SCONVI_c039_0_09 (conv_i_src_c039_0_09 conv_i_c039_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_09 (conv_q_src_c039_0_09 0 conv_bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_0_09 (conv_q_src_c039_0_09 conv_q_c039_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_10 (conv_i_src_c039_0_10 0 conv_bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_0_10 (conv_i_src_c039_0_10 conv_i_c039_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_10 (conv_q_src_c039_0_10 0 conv_bpf_c039_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_0_10 (conv_q_src_c039_0_10 conv_q_c039_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_11 (conv_i_src_c039_0_11 0 conv_bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_0_11 (conv_i_src_c039_0_11 conv_i_c039_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_11 (conv_q_src_c039_0_11 0 conv_bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_0_11 (conv_q_src_c039_0_11 conv_q_c039_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_12 (conv_i_src_c039_0_12 0 conv_bpf_c039_0 0) vcvs gain=1.950903220161e-01
SCONVI_c039_0_12 (conv_i_src_c039_0_12 conv_i_c039_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_12 (conv_q_src_c039_0_12 0 conv_bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_0_12 (conv_q_src_c039_0_12 conv_q_c039_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_13 (conv_i_src_c039_0_13 0 conv_bpf_c039_0 0) vcvs gain=5.555702330196e-01
SCONVI_c039_0_13 (conv_i_src_c039_0_13 conv_i_c039_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_13 (conv_q_src_c039_0_13 0 conv_bpf_c039_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_0_13 (conv_q_src_c039_0_13 conv_q_c039_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_14 (conv_i_src_c039_0_14 0 conv_bpf_c039_0 0) vcvs gain=8.314696123025e-01
SCONVI_c039_0_14 (conv_i_src_c039_0_14 conv_i_c039_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_14 (conv_q_src_c039_0_14 0 conv_bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_0_14 (conv_q_src_c039_0_14 conv_q_c039_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_15 (conv_i_src_c039_0_15 0 conv_bpf_c039_0 0) vcvs gain=9.807852804032e-01
SCONVI_c039_0_15 (conv_i_src_c039_0_15 conv_i_c039_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_15 (conv_q_src_c039_0_15 0 conv_bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_0_15 (conv_q_src_c039_0_15 conv_q_c039_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c039_0 (conv_i_c039_0 0) resistor r=1G
RCONVQ_c039_0 (conv_q_c039_0 0) resistor r=1G
RCONVINTI_c039_0 (conv_i_c039_0 ConvIcar_c039_0) resistor r=1k
CCONVINTI_c039_0 (ConvIcar_c039_0 0) capacitor c=80p
RCONVINTQ_c039_0 (conv_q_c039_0 ConvQcar_c039_0) resistor r=1k
CCONVINTQ_c039_0 (ConvQcar_c039_0 0) capacitor c=80p
save conv_bpf_c039_0 ConvIcar_c039_0 ConvQcar_c039_0

// conventional mixed baseline bl039, carrier_1: 500000000 Hz
CCONVBPF_c039_1 (bl039 n_conv_cbpf_c039_1) capacitor c=1.013211836423e-13
LCONVBPF_c039_1 (n_conv_cbpf_c039_1 conv_bpf_c039_1) inductor l=1.000000000000e-06
RCONVBPF_c039_1 (conv_bpf_c039_1 0) resistor r=1.570796326795e+02
ECONVI_c039_1_00 (conv_i_src_c039_1_00 0 conv_bpf_c039_1 0) vcvs gain=9.807852804032e-01
SCONVI_c039_1_00 (conv_i_src_c039_1_00 conv_i_c039_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_00 (conv_q_src_c039_1_00 0 conv_bpf_c039_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_1_00 (conv_q_src_c039_1_00 conv_q_c039_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_01 (conv_i_src_c039_1_01 0 conv_bpf_c039_1 0) vcvs gain=8.314696123025e-01
SCONVI_c039_1_01 (conv_i_src_c039_1_01 conv_i_c039_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_01 (conv_q_src_c039_1_01 0 conv_bpf_c039_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_1_01 (conv_q_src_c039_1_01 conv_q_c039_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_02 (conv_i_src_c039_1_02 0 conv_bpf_c039_1 0) vcvs gain=5.555702330196e-01
SCONVI_c039_1_02 (conv_i_src_c039_1_02 conv_i_c039_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_02 (conv_q_src_c039_1_02 0 conv_bpf_c039_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_1_02 (conv_q_src_c039_1_02 conv_q_c039_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_03 (conv_i_src_c039_1_03 0 conv_bpf_c039_1 0) vcvs gain=1.950903220161e-01
SCONVI_c039_1_03 (conv_i_src_c039_1_03 conv_i_c039_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_03 (conv_q_src_c039_1_03 0 conv_bpf_c039_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_1_03 (conv_q_src_c039_1_03 conv_q_c039_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_04 (conv_i_src_c039_1_04 0 conv_bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_1_04 (conv_i_src_c039_1_04 conv_i_c039_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_04 (conv_q_src_c039_1_04 0 conv_bpf_c039_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_1_04 (conv_q_src_c039_1_04 conv_q_c039_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_05 (conv_i_src_c039_1_05 0 conv_bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_1_05 (conv_i_src_c039_1_05 conv_i_c039_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_05 (conv_q_src_c039_1_05 0 conv_bpf_c039_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_1_05 (conv_q_src_c039_1_05 conv_q_c039_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_06 (conv_i_src_c039_1_06 0 conv_bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c039_1_06 (conv_i_src_c039_1_06 conv_i_c039_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_06 (conv_q_src_c039_1_06 0 conv_bpf_c039_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_1_06 (conv_q_src_c039_1_06 conv_q_c039_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_07 (conv_i_src_c039_1_07 0 conv_bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_1_07 (conv_i_src_c039_1_07 conv_i_c039_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_07 (conv_q_src_c039_1_07 0 conv_bpf_c039_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_1_07 (conv_q_src_c039_1_07 conv_q_c039_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_08 (conv_i_src_c039_1_08 0 conv_bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_1_08 (conv_i_src_c039_1_08 conv_i_c039_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_08 (conv_q_src_c039_1_08 0 conv_bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_1_08 (conv_q_src_c039_1_08 conv_q_c039_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_09 (conv_i_src_c039_1_09 0 conv_bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c039_1_09 (conv_i_src_c039_1_09 conv_i_c039_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_09 (conv_q_src_c039_1_09 0 conv_bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_1_09 (conv_q_src_c039_1_09 conv_q_c039_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_10 (conv_i_src_c039_1_10 0 conv_bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_1_10 (conv_i_src_c039_1_10 conv_i_c039_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_10 (conv_q_src_c039_1_10 0 conv_bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_1_10 (conv_q_src_c039_1_10 conv_q_c039_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_11 (conv_i_src_c039_1_11 0 conv_bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_1_11 (conv_i_src_c039_1_11 conv_i_c039_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_11 (conv_q_src_c039_1_11 0 conv_bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_1_11 (conv_q_src_c039_1_11 conv_q_c039_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_12 (conv_i_src_c039_1_12 0 conv_bpf_c039_1 0) vcvs gain=1.950903220161e-01
SCONVI_c039_1_12 (conv_i_src_c039_1_12 conv_i_c039_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_12 (conv_q_src_c039_1_12 0 conv_bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_1_12 (conv_q_src_c039_1_12 conv_q_c039_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_13 (conv_i_src_c039_1_13 0 conv_bpf_c039_1 0) vcvs gain=5.555702330196e-01
SCONVI_c039_1_13 (conv_i_src_c039_1_13 conv_i_c039_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_13 (conv_q_src_c039_1_13 0 conv_bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_1_13 (conv_q_src_c039_1_13 conv_q_c039_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_14 (conv_i_src_c039_1_14 0 conv_bpf_c039_1 0) vcvs gain=8.314696123025e-01
SCONVI_c039_1_14 (conv_i_src_c039_1_14 conv_i_c039_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_14 (conv_q_src_c039_1_14 0 conv_bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_1_14 (conv_q_src_c039_1_14 conv_q_c039_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_1_15 (conv_i_src_c039_1_15 0 conv_bpf_c039_1 0) vcvs gain=9.807852804032e-01
SCONVI_c039_1_15 (conv_i_src_c039_1_15 conv_i_c039_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_1_15 (conv_q_src_c039_1_15 0 conv_bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_1_15 (conv_q_src_c039_1_15 conv_q_c039_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c039_1 (conv_i_c039_1 0) resistor r=1G
RCONVQ_c039_1 (conv_q_c039_1 0) resistor r=1G
RCONVINTI_c039_1 (conv_i_c039_1 ConvIcar_c039_1) resistor r=1k
CCONVINTI_c039_1 (ConvIcar_c039_1 0) capacitor c=80p
RCONVINTQ_c039_1 (conv_q_c039_1 ConvQcar_c039_1) resistor r=1k
CCONVINTQ_c039_1 (ConvQcar_c039_1 0) capacitor c=80p
save conv_bpf_c039_1 ConvIcar_c039_1 ConvQcar_c039_1

// conventional mixed baseline bl039, carrier_2: 750000000 Hz
CCONVBPF_c039_2 (bl039 n_conv_cbpf_c039_2) capacitor c=4.503163717437e-14
LCONVBPF_c039_2 (n_conv_cbpf_c039_2 conv_bpf_c039_2) inductor l=1.000000000000e-06
RCONVBPF_c039_2 (conv_bpf_c039_2 0) resistor r=2.356194490192e+02
ECONVI_c039_2_00 (conv_i_src_c039_2_00 0 conv_bpf_c039_2 0) vcvs gain=9.807852804032e-01
SCONVI_c039_2_00 (conv_i_src_c039_2_00 conv_i_c039_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_00 (conv_q_src_c039_2_00 0 conv_bpf_c039_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_2_00 (conv_q_src_c039_2_00 conv_q_c039_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_01 (conv_i_src_c039_2_01 0 conv_bpf_c039_2 0) vcvs gain=8.314696123025e-01
SCONVI_c039_2_01 (conv_i_src_c039_2_01 conv_i_c039_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_01 (conv_q_src_c039_2_01 0 conv_bpf_c039_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_2_01 (conv_q_src_c039_2_01 conv_q_c039_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_02 (conv_i_src_c039_2_02 0 conv_bpf_c039_2 0) vcvs gain=5.555702330196e-01
SCONVI_c039_2_02 (conv_i_src_c039_2_02 conv_i_c039_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_02 (conv_q_src_c039_2_02 0 conv_bpf_c039_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_2_02 (conv_q_src_c039_2_02 conv_q_c039_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_03 (conv_i_src_c039_2_03 0 conv_bpf_c039_2 0) vcvs gain=1.950903220161e-01
SCONVI_c039_2_03 (conv_i_src_c039_2_03 conv_i_c039_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_03 (conv_q_src_c039_2_03 0 conv_bpf_c039_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_2_03 (conv_q_src_c039_2_03 conv_q_c039_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_04 (conv_i_src_c039_2_04 0 conv_bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_2_04 (conv_i_src_c039_2_04 conv_i_c039_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_04 (conv_q_src_c039_2_04 0 conv_bpf_c039_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_2_04 (conv_q_src_c039_2_04 conv_q_c039_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_05 (conv_i_src_c039_2_05 0 conv_bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_2_05 (conv_i_src_c039_2_05 conv_i_c039_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_05 (conv_q_src_c039_2_05 0 conv_bpf_c039_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_2_05 (conv_q_src_c039_2_05 conv_q_c039_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_06 (conv_i_src_c039_2_06 0 conv_bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c039_2_06 (conv_i_src_c039_2_06 conv_i_c039_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_06 (conv_q_src_c039_2_06 0 conv_bpf_c039_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_2_06 (conv_q_src_c039_2_06 conv_q_c039_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_07 (conv_i_src_c039_2_07 0 conv_bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_2_07 (conv_i_src_c039_2_07 conv_i_c039_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_07 (conv_q_src_c039_2_07 0 conv_bpf_c039_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_2_07 (conv_q_src_c039_2_07 conv_q_c039_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_08 (conv_i_src_c039_2_08 0 conv_bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_2_08 (conv_i_src_c039_2_08 conv_i_c039_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_08 (conv_q_src_c039_2_08 0 conv_bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_2_08 (conv_q_src_c039_2_08 conv_q_c039_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_09 (conv_i_src_c039_2_09 0 conv_bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c039_2_09 (conv_i_src_c039_2_09 conv_i_c039_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_09 (conv_q_src_c039_2_09 0 conv_bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_2_09 (conv_q_src_c039_2_09 conv_q_c039_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_10 (conv_i_src_c039_2_10 0 conv_bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_2_10 (conv_i_src_c039_2_10 conv_i_c039_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_10 (conv_q_src_c039_2_10 0 conv_bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_2_10 (conv_q_src_c039_2_10 conv_q_c039_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_11 (conv_i_src_c039_2_11 0 conv_bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_2_11 (conv_i_src_c039_2_11 conv_i_c039_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_11 (conv_q_src_c039_2_11 0 conv_bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_2_11 (conv_q_src_c039_2_11 conv_q_c039_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_12 (conv_i_src_c039_2_12 0 conv_bpf_c039_2 0) vcvs gain=1.950903220161e-01
SCONVI_c039_2_12 (conv_i_src_c039_2_12 conv_i_c039_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_12 (conv_q_src_c039_2_12 0 conv_bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_2_12 (conv_q_src_c039_2_12 conv_q_c039_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_13 (conv_i_src_c039_2_13 0 conv_bpf_c039_2 0) vcvs gain=5.555702330196e-01
SCONVI_c039_2_13 (conv_i_src_c039_2_13 conv_i_c039_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_13 (conv_q_src_c039_2_13 0 conv_bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_2_13 (conv_q_src_c039_2_13 conv_q_c039_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_14 (conv_i_src_c039_2_14 0 conv_bpf_c039_2 0) vcvs gain=8.314696123025e-01
SCONVI_c039_2_14 (conv_i_src_c039_2_14 conv_i_c039_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_14 (conv_q_src_c039_2_14 0 conv_bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_2_14 (conv_q_src_c039_2_14 conv_q_c039_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_2_15 (conv_i_src_c039_2_15 0 conv_bpf_c039_2 0) vcvs gain=9.807852804032e-01
SCONVI_c039_2_15 (conv_i_src_c039_2_15 conv_i_c039_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_2_15 (conv_q_src_c039_2_15 0 conv_bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_2_15 (conv_q_src_c039_2_15 conv_q_c039_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c039_2 (conv_i_c039_2 0) resistor r=1G
RCONVQ_c039_2 (conv_q_c039_2 0) resistor r=1G
RCONVINTI_c039_2 (conv_i_c039_2 ConvIcar_c039_2) resistor r=1k
CCONVINTI_c039_2 (ConvIcar_c039_2 0) capacitor c=80p
RCONVINTQ_c039_2 (conv_q_c039_2 ConvQcar_c039_2) resistor r=1k
CCONVINTQ_c039_2 (ConvQcar_c039_2 0) capacitor c=80p
save conv_bpf_c039_2 ConvIcar_c039_2 ConvQcar_c039_2

// conventional mixed baseline bl039, carrier_3: 1000000000 Hz
CCONVBPF_c039_3 (bl039 n_conv_cbpf_c039_3) capacitor c=2.533029591058e-14
LCONVBPF_c039_3 (n_conv_cbpf_c039_3 conv_bpf_c039_3) inductor l=1.000000000000e-06
RCONVBPF_c039_3 (conv_bpf_c039_3 0) resistor r=3.141592653590e+02
ECONVI_c039_3_00 (conv_i_src_c039_3_00 0 conv_bpf_c039_3 0) vcvs gain=9.807852804032e-01
SCONVI_c039_3_00 (conv_i_src_c039_3_00 conv_i_c039_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_00 (conv_q_src_c039_3_00 0 conv_bpf_c039_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_3_00 (conv_q_src_c039_3_00 conv_q_c039_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_01 (conv_i_src_c039_3_01 0 conv_bpf_c039_3 0) vcvs gain=8.314696123025e-01
SCONVI_c039_3_01 (conv_i_src_c039_3_01 conv_i_c039_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_01 (conv_q_src_c039_3_01 0 conv_bpf_c039_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_3_01 (conv_q_src_c039_3_01 conv_q_c039_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_02 (conv_i_src_c039_3_02 0 conv_bpf_c039_3 0) vcvs gain=5.555702330196e-01
SCONVI_c039_3_02 (conv_i_src_c039_3_02 conv_i_c039_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_02 (conv_q_src_c039_3_02 0 conv_bpf_c039_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_3_02 (conv_q_src_c039_3_02 conv_q_c039_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_03 (conv_i_src_c039_3_03 0 conv_bpf_c039_3 0) vcvs gain=1.950903220161e-01
SCONVI_c039_3_03 (conv_i_src_c039_3_03 conv_i_c039_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_03 (conv_q_src_c039_3_03 0 conv_bpf_c039_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_3_03 (conv_q_src_c039_3_03 conv_q_c039_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_04 (conv_i_src_c039_3_04 0 conv_bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_3_04 (conv_i_src_c039_3_04 conv_i_c039_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_04 (conv_q_src_c039_3_04 0 conv_bpf_c039_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_3_04 (conv_q_src_c039_3_04 conv_q_c039_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_05 (conv_i_src_c039_3_05 0 conv_bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_3_05 (conv_i_src_c039_3_05 conv_i_c039_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_05 (conv_q_src_c039_3_05 0 conv_bpf_c039_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_3_05 (conv_q_src_c039_3_05 conv_q_c039_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_06 (conv_i_src_c039_3_06 0 conv_bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c039_3_06 (conv_i_src_c039_3_06 conv_i_c039_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_06 (conv_q_src_c039_3_06 0 conv_bpf_c039_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_3_06 (conv_q_src_c039_3_06 conv_q_c039_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_07 (conv_i_src_c039_3_07 0 conv_bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_3_07 (conv_i_src_c039_3_07 conv_i_c039_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_07 (conv_q_src_c039_3_07 0 conv_bpf_c039_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_3_07 (conv_q_src_c039_3_07 conv_q_c039_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_08 (conv_i_src_c039_3_08 0 conv_bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_3_08 (conv_i_src_c039_3_08 conv_i_c039_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_08 (conv_q_src_c039_3_08 0 conv_bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_3_08 (conv_q_src_c039_3_08 conv_q_c039_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_09 (conv_i_src_c039_3_09 0 conv_bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c039_3_09 (conv_i_src_c039_3_09 conv_i_c039_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_09 (conv_q_src_c039_3_09 0 conv_bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_3_09 (conv_q_src_c039_3_09 conv_q_c039_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_10 (conv_i_src_c039_3_10 0 conv_bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_3_10 (conv_i_src_c039_3_10 conv_i_c039_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_10 (conv_q_src_c039_3_10 0 conv_bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_3_10 (conv_q_src_c039_3_10 conv_q_c039_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_11 (conv_i_src_c039_3_11 0 conv_bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_3_11 (conv_i_src_c039_3_11 conv_i_c039_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_11 (conv_q_src_c039_3_11 0 conv_bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_3_11 (conv_q_src_c039_3_11 conv_q_c039_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_12 (conv_i_src_c039_3_12 0 conv_bpf_c039_3 0) vcvs gain=1.950903220161e-01
SCONVI_c039_3_12 (conv_i_src_c039_3_12 conv_i_c039_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_12 (conv_q_src_c039_3_12 0 conv_bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c039_3_12 (conv_q_src_c039_3_12 conv_q_c039_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_13 (conv_i_src_c039_3_13 0 conv_bpf_c039_3 0) vcvs gain=5.555702330196e-01
SCONVI_c039_3_13 (conv_i_src_c039_3_13 conv_i_c039_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_13 (conv_q_src_c039_3_13 0 conv_bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c039_3_13 (conv_q_src_c039_3_13 conv_q_c039_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_14 (conv_i_src_c039_3_14 0 conv_bpf_c039_3 0) vcvs gain=8.314696123025e-01
SCONVI_c039_3_14 (conv_i_src_c039_3_14 conv_i_c039_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_14 (conv_q_src_c039_3_14 0 conv_bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c039_3_14 (conv_q_src_c039_3_14 conv_q_c039_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_3_15 (conv_i_src_c039_3_15 0 conv_bpf_c039_3 0) vcvs gain=9.807852804032e-01
SCONVI_c039_3_15 (conv_i_src_c039_3_15 conv_i_c039_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_3_15 (conv_q_src_c039_3_15 0 conv_bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_3_15 (conv_q_src_c039_3_15 conv_q_c039_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c039_3 (conv_i_c039_3 0) resistor r=1G
RCONVQ_c039_3 (conv_q_c039_3 0) resistor r=1G
RCONVINTI_c039_3 (conv_i_c039_3 ConvIcar_c039_3) resistor r=1k
CCONVINTI_c039_3 (ConvIcar_c039_3 0) capacitor c=80p
RCONVINTQ_c039_3 (conv_q_c039_3 ConvQcar_c039_3) resistor r=1k
CCONVINTQ_c039_3 (ConvQcar_c039_3 0) capacitor c=80p
save conv_bpf_c039_3 ConvIcar_c039_3 ConvQcar_c039_3

// conventional mixed baseline bl040, carrier_0: 250000000 Hz
CCONVBPF_c040_0 (bl040 n_conv_cbpf_c040_0) capacitor c=4.052847345694e-13
LCONVBPF_c040_0 (n_conv_cbpf_c040_0 conv_bpf_c040_0) inductor l=1.000000000000e-06
RCONVBPF_c040_0 (conv_bpf_c040_0 0) resistor r=7.853981633974e+01
ECONVI_c040_0_00 (conv_i_src_c040_0_00 0 conv_bpf_c040_0 0) vcvs gain=9.807852804032e-01
SCONVI_c040_0_00 (conv_i_src_c040_0_00 conv_i_c040_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_00 (conv_q_src_c040_0_00 0 conv_bpf_c040_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_0_00 (conv_q_src_c040_0_00 conv_q_c040_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_01 (conv_i_src_c040_0_01 0 conv_bpf_c040_0 0) vcvs gain=8.314696123025e-01
SCONVI_c040_0_01 (conv_i_src_c040_0_01 conv_i_c040_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_01 (conv_q_src_c040_0_01 0 conv_bpf_c040_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_0_01 (conv_q_src_c040_0_01 conv_q_c040_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_02 (conv_i_src_c040_0_02 0 conv_bpf_c040_0 0) vcvs gain=5.555702330196e-01
SCONVI_c040_0_02 (conv_i_src_c040_0_02 conv_i_c040_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_02 (conv_q_src_c040_0_02 0 conv_bpf_c040_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_0_02 (conv_q_src_c040_0_02 conv_q_c040_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_03 (conv_i_src_c040_0_03 0 conv_bpf_c040_0 0) vcvs gain=1.950903220161e-01
SCONVI_c040_0_03 (conv_i_src_c040_0_03 conv_i_c040_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_03 (conv_q_src_c040_0_03 0 conv_bpf_c040_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_0_03 (conv_q_src_c040_0_03 conv_q_c040_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_04 (conv_i_src_c040_0_04 0 conv_bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_0_04 (conv_i_src_c040_0_04 conv_i_c040_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_04 (conv_q_src_c040_0_04 0 conv_bpf_c040_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_0_04 (conv_q_src_c040_0_04 conv_q_c040_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_05 (conv_i_src_c040_0_05 0 conv_bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_0_05 (conv_i_src_c040_0_05 conv_i_c040_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_05 (conv_q_src_c040_0_05 0 conv_bpf_c040_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_0_05 (conv_q_src_c040_0_05 conv_q_c040_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_06 (conv_i_src_c040_0_06 0 conv_bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_0_06 (conv_i_src_c040_0_06 conv_i_c040_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_06 (conv_q_src_c040_0_06 0 conv_bpf_c040_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_0_06 (conv_q_src_c040_0_06 conv_q_c040_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_07 (conv_i_src_c040_0_07 0 conv_bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_0_07 (conv_i_src_c040_0_07 conv_i_c040_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_07 (conv_q_src_c040_0_07 0 conv_bpf_c040_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_0_07 (conv_q_src_c040_0_07 conv_q_c040_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_08 (conv_i_src_c040_0_08 0 conv_bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_0_08 (conv_i_src_c040_0_08 conv_i_c040_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_08 (conv_q_src_c040_0_08 0 conv_bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_0_08 (conv_q_src_c040_0_08 conv_q_c040_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_09 (conv_i_src_c040_0_09 0 conv_bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_0_09 (conv_i_src_c040_0_09 conv_i_c040_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_09 (conv_q_src_c040_0_09 0 conv_bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_0_09 (conv_q_src_c040_0_09 conv_q_c040_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_10 (conv_i_src_c040_0_10 0 conv_bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_0_10 (conv_i_src_c040_0_10 conv_i_c040_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_10 (conv_q_src_c040_0_10 0 conv_bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_0_10 (conv_q_src_c040_0_10 conv_q_c040_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_11 (conv_i_src_c040_0_11 0 conv_bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_0_11 (conv_i_src_c040_0_11 conv_i_c040_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_11 (conv_q_src_c040_0_11 0 conv_bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_0_11 (conv_q_src_c040_0_11 conv_q_c040_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_12 (conv_i_src_c040_0_12 0 conv_bpf_c040_0 0) vcvs gain=1.950903220161e-01
SCONVI_c040_0_12 (conv_i_src_c040_0_12 conv_i_c040_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_12 (conv_q_src_c040_0_12 0 conv_bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_0_12 (conv_q_src_c040_0_12 conv_q_c040_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_13 (conv_i_src_c040_0_13 0 conv_bpf_c040_0 0) vcvs gain=5.555702330196e-01
SCONVI_c040_0_13 (conv_i_src_c040_0_13 conv_i_c040_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_13 (conv_q_src_c040_0_13 0 conv_bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_0_13 (conv_q_src_c040_0_13 conv_q_c040_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_14 (conv_i_src_c040_0_14 0 conv_bpf_c040_0 0) vcvs gain=8.314696123025e-01
SCONVI_c040_0_14 (conv_i_src_c040_0_14 conv_i_c040_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_14 (conv_q_src_c040_0_14 0 conv_bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_0_14 (conv_q_src_c040_0_14 conv_q_c040_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_0_15 (conv_i_src_c040_0_15 0 conv_bpf_c040_0 0) vcvs gain=9.807852804032e-01
SCONVI_c040_0_15 (conv_i_src_c040_0_15 conv_i_c040_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_0_15 (conv_q_src_c040_0_15 0 conv_bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_0_15 (conv_q_src_c040_0_15 conv_q_c040_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c040_0 (conv_i_c040_0 0) resistor r=1G
RCONVQ_c040_0 (conv_q_c040_0 0) resistor r=1G
RCONVINTI_c040_0 (conv_i_c040_0 ConvIcar_c040_0) resistor r=1k
CCONVINTI_c040_0 (ConvIcar_c040_0 0) capacitor c=80p
RCONVINTQ_c040_0 (conv_q_c040_0 ConvQcar_c040_0) resistor r=1k
CCONVINTQ_c040_0 (ConvQcar_c040_0 0) capacitor c=80p
save conv_bpf_c040_0 ConvIcar_c040_0 ConvQcar_c040_0

// conventional mixed baseline bl040, carrier_1: 500000000 Hz
CCONVBPF_c040_1 (bl040 n_conv_cbpf_c040_1) capacitor c=1.013211836423e-13
LCONVBPF_c040_1 (n_conv_cbpf_c040_1 conv_bpf_c040_1) inductor l=1.000000000000e-06
RCONVBPF_c040_1 (conv_bpf_c040_1 0) resistor r=1.570796326795e+02
ECONVI_c040_1_00 (conv_i_src_c040_1_00 0 conv_bpf_c040_1 0) vcvs gain=9.807852804032e-01
SCONVI_c040_1_00 (conv_i_src_c040_1_00 conv_i_c040_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_00 (conv_q_src_c040_1_00 0 conv_bpf_c040_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_1_00 (conv_q_src_c040_1_00 conv_q_c040_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_01 (conv_i_src_c040_1_01 0 conv_bpf_c040_1 0) vcvs gain=8.314696123025e-01
SCONVI_c040_1_01 (conv_i_src_c040_1_01 conv_i_c040_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_01 (conv_q_src_c040_1_01 0 conv_bpf_c040_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_1_01 (conv_q_src_c040_1_01 conv_q_c040_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_02 (conv_i_src_c040_1_02 0 conv_bpf_c040_1 0) vcvs gain=5.555702330196e-01
SCONVI_c040_1_02 (conv_i_src_c040_1_02 conv_i_c040_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_02 (conv_q_src_c040_1_02 0 conv_bpf_c040_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_1_02 (conv_q_src_c040_1_02 conv_q_c040_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_03 (conv_i_src_c040_1_03 0 conv_bpf_c040_1 0) vcvs gain=1.950903220161e-01
SCONVI_c040_1_03 (conv_i_src_c040_1_03 conv_i_c040_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_03 (conv_q_src_c040_1_03 0 conv_bpf_c040_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_1_03 (conv_q_src_c040_1_03 conv_q_c040_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_04 (conv_i_src_c040_1_04 0 conv_bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_1_04 (conv_i_src_c040_1_04 conv_i_c040_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_04 (conv_q_src_c040_1_04 0 conv_bpf_c040_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_1_04 (conv_q_src_c040_1_04 conv_q_c040_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_05 (conv_i_src_c040_1_05 0 conv_bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_1_05 (conv_i_src_c040_1_05 conv_i_c040_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_05 (conv_q_src_c040_1_05 0 conv_bpf_c040_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_1_05 (conv_q_src_c040_1_05 conv_q_c040_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_06 (conv_i_src_c040_1_06 0 conv_bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_1_06 (conv_i_src_c040_1_06 conv_i_c040_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_06 (conv_q_src_c040_1_06 0 conv_bpf_c040_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_1_06 (conv_q_src_c040_1_06 conv_q_c040_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_07 (conv_i_src_c040_1_07 0 conv_bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_1_07 (conv_i_src_c040_1_07 conv_i_c040_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_07 (conv_q_src_c040_1_07 0 conv_bpf_c040_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_1_07 (conv_q_src_c040_1_07 conv_q_c040_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_08 (conv_i_src_c040_1_08 0 conv_bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_1_08 (conv_i_src_c040_1_08 conv_i_c040_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_08 (conv_q_src_c040_1_08 0 conv_bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_1_08 (conv_q_src_c040_1_08 conv_q_c040_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_09 (conv_i_src_c040_1_09 0 conv_bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_1_09 (conv_i_src_c040_1_09 conv_i_c040_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_09 (conv_q_src_c040_1_09 0 conv_bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_1_09 (conv_q_src_c040_1_09 conv_q_c040_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_10 (conv_i_src_c040_1_10 0 conv_bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_1_10 (conv_i_src_c040_1_10 conv_i_c040_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_10 (conv_q_src_c040_1_10 0 conv_bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_1_10 (conv_q_src_c040_1_10 conv_q_c040_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_11 (conv_i_src_c040_1_11 0 conv_bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_1_11 (conv_i_src_c040_1_11 conv_i_c040_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_11 (conv_q_src_c040_1_11 0 conv_bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_1_11 (conv_q_src_c040_1_11 conv_q_c040_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_12 (conv_i_src_c040_1_12 0 conv_bpf_c040_1 0) vcvs gain=1.950903220161e-01
SCONVI_c040_1_12 (conv_i_src_c040_1_12 conv_i_c040_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_12 (conv_q_src_c040_1_12 0 conv_bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_1_12 (conv_q_src_c040_1_12 conv_q_c040_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_13 (conv_i_src_c040_1_13 0 conv_bpf_c040_1 0) vcvs gain=5.555702330196e-01
SCONVI_c040_1_13 (conv_i_src_c040_1_13 conv_i_c040_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_13 (conv_q_src_c040_1_13 0 conv_bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_1_13 (conv_q_src_c040_1_13 conv_q_c040_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_14 (conv_i_src_c040_1_14 0 conv_bpf_c040_1 0) vcvs gain=8.314696123025e-01
SCONVI_c040_1_14 (conv_i_src_c040_1_14 conv_i_c040_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_14 (conv_q_src_c040_1_14 0 conv_bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_1_14 (conv_q_src_c040_1_14 conv_q_c040_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_1_15 (conv_i_src_c040_1_15 0 conv_bpf_c040_1 0) vcvs gain=9.807852804032e-01
SCONVI_c040_1_15 (conv_i_src_c040_1_15 conv_i_c040_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_1_15 (conv_q_src_c040_1_15 0 conv_bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_1_15 (conv_q_src_c040_1_15 conv_q_c040_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c040_1 (conv_i_c040_1 0) resistor r=1G
RCONVQ_c040_1 (conv_q_c040_1 0) resistor r=1G
RCONVINTI_c040_1 (conv_i_c040_1 ConvIcar_c040_1) resistor r=1k
CCONVINTI_c040_1 (ConvIcar_c040_1 0) capacitor c=80p
RCONVINTQ_c040_1 (conv_q_c040_1 ConvQcar_c040_1) resistor r=1k
CCONVINTQ_c040_1 (ConvQcar_c040_1 0) capacitor c=80p
save conv_bpf_c040_1 ConvIcar_c040_1 ConvQcar_c040_1

// conventional mixed baseline bl040, carrier_2: 750000000 Hz
CCONVBPF_c040_2 (bl040 n_conv_cbpf_c040_2) capacitor c=4.503163717437e-14
LCONVBPF_c040_2 (n_conv_cbpf_c040_2 conv_bpf_c040_2) inductor l=1.000000000000e-06
RCONVBPF_c040_2 (conv_bpf_c040_2 0) resistor r=2.356194490192e+02
ECONVI_c040_2_00 (conv_i_src_c040_2_00 0 conv_bpf_c040_2 0) vcvs gain=9.807852804032e-01
SCONVI_c040_2_00 (conv_i_src_c040_2_00 conv_i_c040_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_00 (conv_q_src_c040_2_00 0 conv_bpf_c040_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_2_00 (conv_q_src_c040_2_00 conv_q_c040_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_01 (conv_i_src_c040_2_01 0 conv_bpf_c040_2 0) vcvs gain=8.314696123025e-01
SCONVI_c040_2_01 (conv_i_src_c040_2_01 conv_i_c040_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_01 (conv_q_src_c040_2_01 0 conv_bpf_c040_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_2_01 (conv_q_src_c040_2_01 conv_q_c040_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_02 (conv_i_src_c040_2_02 0 conv_bpf_c040_2 0) vcvs gain=5.555702330196e-01
SCONVI_c040_2_02 (conv_i_src_c040_2_02 conv_i_c040_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_02 (conv_q_src_c040_2_02 0 conv_bpf_c040_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_2_02 (conv_q_src_c040_2_02 conv_q_c040_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_03 (conv_i_src_c040_2_03 0 conv_bpf_c040_2 0) vcvs gain=1.950903220161e-01
SCONVI_c040_2_03 (conv_i_src_c040_2_03 conv_i_c040_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_03 (conv_q_src_c040_2_03 0 conv_bpf_c040_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_2_03 (conv_q_src_c040_2_03 conv_q_c040_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_04 (conv_i_src_c040_2_04 0 conv_bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_2_04 (conv_i_src_c040_2_04 conv_i_c040_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_04 (conv_q_src_c040_2_04 0 conv_bpf_c040_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_2_04 (conv_q_src_c040_2_04 conv_q_c040_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_05 (conv_i_src_c040_2_05 0 conv_bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_2_05 (conv_i_src_c040_2_05 conv_i_c040_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_05 (conv_q_src_c040_2_05 0 conv_bpf_c040_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_2_05 (conv_q_src_c040_2_05 conv_q_c040_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_06 (conv_i_src_c040_2_06 0 conv_bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_2_06 (conv_i_src_c040_2_06 conv_i_c040_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_06 (conv_q_src_c040_2_06 0 conv_bpf_c040_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_2_06 (conv_q_src_c040_2_06 conv_q_c040_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_07 (conv_i_src_c040_2_07 0 conv_bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_2_07 (conv_i_src_c040_2_07 conv_i_c040_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_07 (conv_q_src_c040_2_07 0 conv_bpf_c040_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_2_07 (conv_q_src_c040_2_07 conv_q_c040_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_08 (conv_i_src_c040_2_08 0 conv_bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_2_08 (conv_i_src_c040_2_08 conv_i_c040_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_08 (conv_q_src_c040_2_08 0 conv_bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_2_08 (conv_q_src_c040_2_08 conv_q_c040_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_09 (conv_i_src_c040_2_09 0 conv_bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_2_09 (conv_i_src_c040_2_09 conv_i_c040_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_09 (conv_q_src_c040_2_09 0 conv_bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_2_09 (conv_q_src_c040_2_09 conv_q_c040_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_10 (conv_i_src_c040_2_10 0 conv_bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_2_10 (conv_i_src_c040_2_10 conv_i_c040_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_10 (conv_q_src_c040_2_10 0 conv_bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_2_10 (conv_q_src_c040_2_10 conv_q_c040_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_11 (conv_i_src_c040_2_11 0 conv_bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_2_11 (conv_i_src_c040_2_11 conv_i_c040_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_11 (conv_q_src_c040_2_11 0 conv_bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_2_11 (conv_q_src_c040_2_11 conv_q_c040_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_12 (conv_i_src_c040_2_12 0 conv_bpf_c040_2 0) vcvs gain=1.950903220161e-01
SCONVI_c040_2_12 (conv_i_src_c040_2_12 conv_i_c040_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_12 (conv_q_src_c040_2_12 0 conv_bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_2_12 (conv_q_src_c040_2_12 conv_q_c040_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_13 (conv_i_src_c040_2_13 0 conv_bpf_c040_2 0) vcvs gain=5.555702330196e-01
SCONVI_c040_2_13 (conv_i_src_c040_2_13 conv_i_c040_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_13 (conv_q_src_c040_2_13 0 conv_bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_2_13 (conv_q_src_c040_2_13 conv_q_c040_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_14 (conv_i_src_c040_2_14 0 conv_bpf_c040_2 0) vcvs gain=8.314696123025e-01
SCONVI_c040_2_14 (conv_i_src_c040_2_14 conv_i_c040_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_14 (conv_q_src_c040_2_14 0 conv_bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_2_14 (conv_q_src_c040_2_14 conv_q_c040_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_2_15 (conv_i_src_c040_2_15 0 conv_bpf_c040_2 0) vcvs gain=9.807852804032e-01
SCONVI_c040_2_15 (conv_i_src_c040_2_15 conv_i_c040_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_2_15 (conv_q_src_c040_2_15 0 conv_bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_2_15 (conv_q_src_c040_2_15 conv_q_c040_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c040_2 (conv_i_c040_2 0) resistor r=1G
RCONVQ_c040_2 (conv_q_c040_2 0) resistor r=1G
RCONVINTI_c040_2 (conv_i_c040_2 ConvIcar_c040_2) resistor r=1k
CCONVINTI_c040_2 (ConvIcar_c040_2 0) capacitor c=80p
RCONVINTQ_c040_2 (conv_q_c040_2 ConvQcar_c040_2) resistor r=1k
CCONVINTQ_c040_2 (ConvQcar_c040_2 0) capacitor c=80p
save conv_bpf_c040_2 ConvIcar_c040_2 ConvQcar_c040_2

// conventional mixed baseline bl040, carrier_3: 1000000000 Hz
CCONVBPF_c040_3 (bl040 n_conv_cbpf_c040_3) capacitor c=2.533029591058e-14
LCONVBPF_c040_3 (n_conv_cbpf_c040_3 conv_bpf_c040_3) inductor l=1.000000000000e-06
RCONVBPF_c040_3 (conv_bpf_c040_3 0) resistor r=3.141592653590e+02
ECONVI_c040_3_00 (conv_i_src_c040_3_00 0 conv_bpf_c040_3 0) vcvs gain=9.807852804032e-01
SCONVI_c040_3_00 (conv_i_src_c040_3_00 conv_i_c040_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_00 (conv_q_src_c040_3_00 0 conv_bpf_c040_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_3_00 (conv_q_src_c040_3_00 conv_q_c040_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_01 (conv_i_src_c040_3_01 0 conv_bpf_c040_3 0) vcvs gain=8.314696123025e-01
SCONVI_c040_3_01 (conv_i_src_c040_3_01 conv_i_c040_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_01 (conv_q_src_c040_3_01 0 conv_bpf_c040_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_3_01 (conv_q_src_c040_3_01 conv_q_c040_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_02 (conv_i_src_c040_3_02 0 conv_bpf_c040_3 0) vcvs gain=5.555702330196e-01
SCONVI_c040_3_02 (conv_i_src_c040_3_02 conv_i_c040_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_02 (conv_q_src_c040_3_02 0 conv_bpf_c040_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_3_02 (conv_q_src_c040_3_02 conv_q_c040_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_03 (conv_i_src_c040_3_03 0 conv_bpf_c040_3 0) vcvs gain=1.950903220161e-01
SCONVI_c040_3_03 (conv_i_src_c040_3_03 conv_i_c040_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_03 (conv_q_src_c040_3_03 0 conv_bpf_c040_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_3_03 (conv_q_src_c040_3_03 conv_q_c040_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_04 (conv_i_src_c040_3_04 0 conv_bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_3_04 (conv_i_src_c040_3_04 conv_i_c040_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_04 (conv_q_src_c040_3_04 0 conv_bpf_c040_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c040_3_04 (conv_q_src_c040_3_04 conv_q_c040_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_05 (conv_i_src_c040_3_05 0 conv_bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_3_05 (conv_i_src_c040_3_05 conv_i_c040_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_05 (conv_q_src_c040_3_05 0 conv_bpf_c040_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c040_3_05 (conv_q_src_c040_3_05 conv_q_c040_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_06 (conv_i_src_c040_3_06 0 conv_bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_3_06 (conv_i_src_c040_3_06 conv_i_c040_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_06 (conv_q_src_c040_3_06 0 conv_bpf_c040_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c040_3_06 (conv_q_src_c040_3_06 conv_q_c040_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_07 (conv_i_src_c040_3_07 0 conv_bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_3_07 (conv_i_src_c040_3_07 conv_i_c040_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_07 (conv_q_src_c040_3_07 0 conv_bpf_c040_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c040_3_07 (conv_q_src_c040_3_07 conv_q_c040_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_08 (conv_i_src_c040_3_08 0 conv_bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c040_3_08 (conv_i_src_c040_3_08 conv_i_c040_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_08 (conv_q_src_c040_3_08 0 conv_bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_3_08 (conv_q_src_c040_3_08 conv_q_c040_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_09 (conv_i_src_c040_3_09 0 conv_bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c040_3_09 (conv_i_src_c040_3_09 conv_i_c040_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_09 (conv_q_src_c040_3_09 0 conv_bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_3_09 (conv_q_src_c040_3_09 conv_q_c040_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_10 (conv_i_src_c040_3_10 0 conv_bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c040_3_10 (conv_i_src_c040_3_10 conv_i_c040_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_10 (conv_q_src_c040_3_10 0 conv_bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_3_10 (conv_q_src_c040_3_10 conv_q_c040_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_11 (conv_i_src_c040_3_11 0 conv_bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c040_3_11 (conv_i_src_c040_3_11 conv_i_c040_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_11 (conv_q_src_c040_3_11 0 conv_bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_3_11 (conv_q_src_c040_3_11 conv_q_c040_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_12 (conv_i_src_c040_3_12 0 conv_bpf_c040_3 0) vcvs gain=1.950903220161e-01
SCONVI_c040_3_12 (conv_i_src_c040_3_12 conv_i_c040_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_12 (conv_q_src_c040_3_12 0 conv_bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c040_3_12 (conv_q_src_c040_3_12 conv_q_c040_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_13 (conv_i_src_c040_3_13 0 conv_bpf_c040_3 0) vcvs gain=5.555702330196e-01
SCONVI_c040_3_13 (conv_i_src_c040_3_13 conv_i_c040_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_13 (conv_q_src_c040_3_13 0 conv_bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c040_3_13 (conv_q_src_c040_3_13 conv_q_c040_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_14 (conv_i_src_c040_3_14 0 conv_bpf_c040_3 0) vcvs gain=8.314696123025e-01
SCONVI_c040_3_14 (conv_i_src_c040_3_14 conv_i_c040_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_14 (conv_q_src_c040_3_14 0 conv_bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c040_3_14 (conv_q_src_c040_3_14 conv_q_c040_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c040_3_15 (conv_i_src_c040_3_15 0 conv_bpf_c040_3 0) vcvs gain=9.807852804032e-01
SCONVI_c040_3_15 (conv_i_src_c040_3_15 conv_i_c040_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c040_3_15 (conv_q_src_c040_3_15 0 conv_bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c040_3_15 (conv_q_src_c040_3_15 conv_q_c040_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c040_3 (conv_i_c040_3 0) resistor r=1G
RCONVQ_c040_3 (conv_q_c040_3 0) resistor r=1G
RCONVINTI_c040_3 (conv_i_c040_3 ConvIcar_c040_3) resistor r=1k
CCONVINTI_c040_3 (ConvIcar_c040_3 0) capacitor c=80p
RCONVINTQ_c040_3 (conv_q_c040_3 ConvQcar_c040_3) resistor r=1k
CCONVINTQ_c040_3 (ConvQcar_c040_3 0) capacitor c=80p
save conv_bpf_c040_3 ConvIcar_c040_3 ConvQcar_c040_3

// conventional mixed baseline bl041, carrier_0: 250000000 Hz
CCONVBPF_c041_0 (bl041 n_conv_cbpf_c041_0) capacitor c=4.052847345694e-13
LCONVBPF_c041_0 (n_conv_cbpf_c041_0 conv_bpf_c041_0) inductor l=1.000000000000e-06
RCONVBPF_c041_0 (conv_bpf_c041_0 0) resistor r=7.853981633974e+01
ECONVI_c041_0_00 (conv_i_src_c041_0_00 0 conv_bpf_c041_0 0) vcvs gain=9.807852804032e-01
SCONVI_c041_0_00 (conv_i_src_c041_0_00 conv_i_c041_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_00 (conv_q_src_c041_0_00 0 conv_bpf_c041_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_0_00 (conv_q_src_c041_0_00 conv_q_c041_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_01 (conv_i_src_c041_0_01 0 conv_bpf_c041_0 0) vcvs gain=8.314696123025e-01
SCONVI_c041_0_01 (conv_i_src_c041_0_01 conv_i_c041_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_01 (conv_q_src_c041_0_01 0 conv_bpf_c041_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_0_01 (conv_q_src_c041_0_01 conv_q_c041_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_02 (conv_i_src_c041_0_02 0 conv_bpf_c041_0 0) vcvs gain=5.555702330196e-01
SCONVI_c041_0_02 (conv_i_src_c041_0_02 conv_i_c041_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_02 (conv_q_src_c041_0_02 0 conv_bpf_c041_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_0_02 (conv_q_src_c041_0_02 conv_q_c041_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_03 (conv_i_src_c041_0_03 0 conv_bpf_c041_0 0) vcvs gain=1.950903220161e-01
SCONVI_c041_0_03 (conv_i_src_c041_0_03 conv_i_c041_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_03 (conv_q_src_c041_0_03 0 conv_bpf_c041_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_0_03 (conv_q_src_c041_0_03 conv_q_c041_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_04 (conv_i_src_c041_0_04 0 conv_bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_0_04 (conv_i_src_c041_0_04 conv_i_c041_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_04 (conv_q_src_c041_0_04 0 conv_bpf_c041_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_0_04 (conv_q_src_c041_0_04 conv_q_c041_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_05 (conv_i_src_c041_0_05 0 conv_bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_0_05 (conv_i_src_c041_0_05 conv_i_c041_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_05 (conv_q_src_c041_0_05 0 conv_bpf_c041_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_0_05 (conv_q_src_c041_0_05 conv_q_c041_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_06 (conv_i_src_c041_0_06 0 conv_bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_0_06 (conv_i_src_c041_0_06 conv_i_c041_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_06 (conv_q_src_c041_0_06 0 conv_bpf_c041_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_0_06 (conv_q_src_c041_0_06 conv_q_c041_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_07 (conv_i_src_c041_0_07 0 conv_bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_0_07 (conv_i_src_c041_0_07 conv_i_c041_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_07 (conv_q_src_c041_0_07 0 conv_bpf_c041_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_0_07 (conv_q_src_c041_0_07 conv_q_c041_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_08 (conv_i_src_c041_0_08 0 conv_bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_0_08 (conv_i_src_c041_0_08 conv_i_c041_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_08 (conv_q_src_c041_0_08 0 conv_bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_0_08 (conv_q_src_c041_0_08 conv_q_c041_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_09 (conv_i_src_c041_0_09 0 conv_bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_0_09 (conv_i_src_c041_0_09 conv_i_c041_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_09 (conv_q_src_c041_0_09 0 conv_bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_0_09 (conv_q_src_c041_0_09 conv_q_c041_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_10 (conv_i_src_c041_0_10 0 conv_bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_0_10 (conv_i_src_c041_0_10 conv_i_c041_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_10 (conv_q_src_c041_0_10 0 conv_bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_0_10 (conv_q_src_c041_0_10 conv_q_c041_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_11 (conv_i_src_c041_0_11 0 conv_bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_0_11 (conv_i_src_c041_0_11 conv_i_c041_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_11 (conv_q_src_c041_0_11 0 conv_bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_0_11 (conv_q_src_c041_0_11 conv_q_c041_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_12 (conv_i_src_c041_0_12 0 conv_bpf_c041_0 0) vcvs gain=1.950903220161e-01
SCONVI_c041_0_12 (conv_i_src_c041_0_12 conv_i_c041_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_12 (conv_q_src_c041_0_12 0 conv_bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_0_12 (conv_q_src_c041_0_12 conv_q_c041_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_13 (conv_i_src_c041_0_13 0 conv_bpf_c041_0 0) vcvs gain=5.555702330196e-01
SCONVI_c041_0_13 (conv_i_src_c041_0_13 conv_i_c041_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_13 (conv_q_src_c041_0_13 0 conv_bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_0_13 (conv_q_src_c041_0_13 conv_q_c041_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_14 (conv_i_src_c041_0_14 0 conv_bpf_c041_0 0) vcvs gain=8.314696123025e-01
SCONVI_c041_0_14 (conv_i_src_c041_0_14 conv_i_c041_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_14 (conv_q_src_c041_0_14 0 conv_bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_0_14 (conv_q_src_c041_0_14 conv_q_c041_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_0_15 (conv_i_src_c041_0_15 0 conv_bpf_c041_0 0) vcvs gain=9.807852804032e-01
SCONVI_c041_0_15 (conv_i_src_c041_0_15 conv_i_c041_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_0_15 (conv_q_src_c041_0_15 0 conv_bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_0_15 (conv_q_src_c041_0_15 conv_q_c041_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c041_0 (conv_i_c041_0 0) resistor r=1G
RCONVQ_c041_0 (conv_q_c041_0 0) resistor r=1G
RCONVINTI_c041_0 (conv_i_c041_0 ConvIcar_c041_0) resistor r=1k
CCONVINTI_c041_0 (ConvIcar_c041_0 0) capacitor c=80p
RCONVINTQ_c041_0 (conv_q_c041_0 ConvQcar_c041_0) resistor r=1k
CCONVINTQ_c041_0 (ConvQcar_c041_0 0) capacitor c=80p
save conv_bpf_c041_0 ConvIcar_c041_0 ConvQcar_c041_0

// conventional mixed baseline bl041, carrier_1: 500000000 Hz
CCONVBPF_c041_1 (bl041 n_conv_cbpf_c041_1) capacitor c=1.013211836423e-13
LCONVBPF_c041_1 (n_conv_cbpf_c041_1 conv_bpf_c041_1) inductor l=1.000000000000e-06
RCONVBPF_c041_1 (conv_bpf_c041_1 0) resistor r=1.570796326795e+02
ECONVI_c041_1_00 (conv_i_src_c041_1_00 0 conv_bpf_c041_1 0) vcvs gain=9.807852804032e-01
SCONVI_c041_1_00 (conv_i_src_c041_1_00 conv_i_c041_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_00 (conv_q_src_c041_1_00 0 conv_bpf_c041_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_1_00 (conv_q_src_c041_1_00 conv_q_c041_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_01 (conv_i_src_c041_1_01 0 conv_bpf_c041_1 0) vcvs gain=8.314696123025e-01
SCONVI_c041_1_01 (conv_i_src_c041_1_01 conv_i_c041_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_01 (conv_q_src_c041_1_01 0 conv_bpf_c041_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_1_01 (conv_q_src_c041_1_01 conv_q_c041_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_02 (conv_i_src_c041_1_02 0 conv_bpf_c041_1 0) vcvs gain=5.555702330196e-01
SCONVI_c041_1_02 (conv_i_src_c041_1_02 conv_i_c041_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_02 (conv_q_src_c041_1_02 0 conv_bpf_c041_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_1_02 (conv_q_src_c041_1_02 conv_q_c041_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_03 (conv_i_src_c041_1_03 0 conv_bpf_c041_1 0) vcvs gain=1.950903220161e-01
SCONVI_c041_1_03 (conv_i_src_c041_1_03 conv_i_c041_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_03 (conv_q_src_c041_1_03 0 conv_bpf_c041_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_1_03 (conv_q_src_c041_1_03 conv_q_c041_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_04 (conv_i_src_c041_1_04 0 conv_bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_1_04 (conv_i_src_c041_1_04 conv_i_c041_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_04 (conv_q_src_c041_1_04 0 conv_bpf_c041_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_1_04 (conv_q_src_c041_1_04 conv_q_c041_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_05 (conv_i_src_c041_1_05 0 conv_bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_1_05 (conv_i_src_c041_1_05 conv_i_c041_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_05 (conv_q_src_c041_1_05 0 conv_bpf_c041_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_1_05 (conv_q_src_c041_1_05 conv_q_c041_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_06 (conv_i_src_c041_1_06 0 conv_bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_1_06 (conv_i_src_c041_1_06 conv_i_c041_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_06 (conv_q_src_c041_1_06 0 conv_bpf_c041_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_1_06 (conv_q_src_c041_1_06 conv_q_c041_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_07 (conv_i_src_c041_1_07 0 conv_bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_1_07 (conv_i_src_c041_1_07 conv_i_c041_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_07 (conv_q_src_c041_1_07 0 conv_bpf_c041_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_1_07 (conv_q_src_c041_1_07 conv_q_c041_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_08 (conv_i_src_c041_1_08 0 conv_bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_1_08 (conv_i_src_c041_1_08 conv_i_c041_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_08 (conv_q_src_c041_1_08 0 conv_bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_1_08 (conv_q_src_c041_1_08 conv_q_c041_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_09 (conv_i_src_c041_1_09 0 conv_bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_1_09 (conv_i_src_c041_1_09 conv_i_c041_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_09 (conv_q_src_c041_1_09 0 conv_bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_1_09 (conv_q_src_c041_1_09 conv_q_c041_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_10 (conv_i_src_c041_1_10 0 conv_bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_1_10 (conv_i_src_c041_1_10 conv_i_c041_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_10 (conv_q_src_c041_1_10 0 conv_bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_1_10 (conv_q_src_c041_1_10 conv_q_c041_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_11 (conv_i_src_c041_1_11 0 conv_bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_1_11 (conv_i_src_c041_1_11 conv_i_c041_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_11 (conv_q_src_c041_1_11 0 conv_bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_1_11 (conv_q_src_c041_1_11 conv_q_c041_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_12 (conv_i_src_c041_1_12 0 conv_bpf_c041_1 0) vcvs gain=1.950903220161e-01
SCONVI_c041_1_12 (conv_i_src_c041_1_12 conv_i_c041_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_12 (conv_q_src_c041_1_12 0 conv_bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_1_12 (conv_q_src_c041_1_12 conv_q_c041_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_13 (conv_i_src_c041_1_13 0 conv_bpf_c041_1 0) vcvs gain=5.555702330196e-01
SCONVI_c041_1_13 (conv_i_src_c041_1_13 conv_i_c041_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_13 (conv_q_src_c041_1_13 0 conv_bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_1_13 (conv_q_src_c041_1_13 conv_q_c041_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_14 (conv_i_src_c041_1_14 0 conv_bpf_c041_1 0) vcvs gain=8.314696123025e-01
SCONVI_c041_1_14 (conv_i_src_c041_1_14 conv_i_c041_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_14 (conv_q_src_c041_1_14 0 conv_bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_1_14 (conv_q_src_c041_1_14 conv_q_c041_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_1_15 (conv_i_src_c041_1_15 0 conv_bpf_c041_1 0) vcvs gain=9.807852804032e-01
SCONVI_c041_1_15 (conv_i_src_c041_1_15 conv_i_c041_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_1_15 (conv_q_src_c041_1_15 0 conv_bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_1_15 (conv_q_src_c041_1_15 conv_q_c041_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c041_1 (conv_i_c041_1 0) resistor r=1G
RCONVQ_c041_1 (conv_q_c041_1 0) resistor r=1G
RCONVINTI_c041_1 (conv_i_c041_1 ConvIcar_c041_1) resistor r=1k
CCONVINTI_c041_1 (ConvIcar_c041_1 0) capacitor c=80p
RCONVINTQ_c041_1 (conv_q_c041_1 ConvQcar_c041_1) resistor r=1k
CCONVINTQ_c041_1 (ConvQcar_c041_1 0) capacitor c=80p
save conv_bpf_c041_1 ConvIcar_c041_1 ConvQcar_c041_1

// conventional mixed baseline bl041, carrier_2: 750000000 Hz
CCONVBPF_c041_2 (bl041 n_conv_cbpf_c041_2) capacitor c=4.503163717437e-14
LCONVBPF_c041_2 (n_conv_cbpf_c041_2 conv_bpf_c041_2) inductor l=1.000000000000e-06
RCONVBPF_c041_2 (conv_bpf_c041_2 0) resistor r=2.356194490192e+02
ECONVI_c041_2_00 (conv_i_src_c041_2_00 0 conv_bpf_c041_2 0) vcvs gain=9.807852804032e-01
SCONVI_c041_2_00 (conv_i_src_c041_2_00 conv_i_c041_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_00 (conv_q_src_c041_2_00 0 conv_bpf_c041_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_2_00 (conv_q_src_c041_2_00 conv_q_c041_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_01 (conv_i_src_c041_2_01 0 conv_bpf_c041_2 0) vcvs gain=8.314696123025e-01
SCONVI_c041_2_01 (conv_i_src_c041_2_01 conv_i_c041_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_01 (conv_q_src_c041_2_01 0 conv_bpf_c041_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_2_01 (conv_q_src_c041_2_01 conv_q_c041_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_02 (conv_i_src_c041_2_02 0 conv_bpf_c041_2 0) vcvs gain=5.555702330196e-01
SCONVI_c041_2_02 (conv_i_src_c041_2_02 conv_i_c041_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_02 (conv_q_src_c041_2_02 0 conv_bpf_c041_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_2_02 (conv_q_src_c041_2_02 conv_q_c041_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_03 (conv_i_src_c041_2_03 0 conv_bpf_c041_2 0) vcvs gain=1.950903220161e-01
SCONVI_c041_2_03 (conv_i_src_c041_2_03 conv_i_c041_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_03 (conv_q_src_c041_2_03 0 conv_bpf_c041_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_2_03 (conv_q_src_c041_2_03 conv_q_c041_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_04 (conv_i_src_c041_2_04 0 conv_bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_2_04 (conv_i_src_c041_2_04 conv_i_c041_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_04 (conv_q_src_c041_2_04 0 conv_bpf_c041_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_2_04 (conv_q_src_c041_2_04 conv_q_c041_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_05 (conv_i_src_c041_2_05 0 conv_bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_2_05 (conv_i_src_c041_2_05 conv_i_c041_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_05 (conv_q_src_c041_2_05 0 conv_bpf_c041_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_2_05 (conv_q_src_c041_2_05 conv_q_c041_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_06 (conv_i_src_c041_2_06 0 conv_bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_2_06 (conv_i_src_c041_2_06 conv_i_c041_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_06 (conv_q_src_c041_2_06 0 conv_bpf_c041_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_2_06 (conv_q_src_c041_2_06 conv_q_c041_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_07 (conv_i_src_c041_2_07 0 conv_bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_2_07 (conv_i_src_c041_2_07 conv_i_c041_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_07 (conv_q_src_c041_2_07 0 conv_bpf_c041_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_2_07 (conv_q_src_c041_2_07 conv_q_c041_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_08 (conv_i_src_c041_2_08 0 conv_bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_2_08 (conv_i_src_c041_2_08 conv_i_c041_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_08 (conv_q_src_c041_2_08 0 conv_bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_2_08 (conv_q_src_c041_2_08 conv_q_c041_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_09 (conv_i_src_c041_2_09 0 conv_bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_2_09 (conv_i_src_c041_2_09 conv_i_c041_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_09 (conv_q_src_c041_2_09 0 conv_bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_2_09 (conv_q_src_c041_2_09 conv_q_c041_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_10 (conv_i_src_c041_2_10 0 conv_bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_2_10 (conv_i_src_c041_2_10 conv_i_c041_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_10 (conv_q_src_c041_2_10 0 conv_bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_2_10 (conv_q_src_c041_2_10 conv_q_c041_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_11 (conv_i_src_c041_2_11 0 conv_bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_2_11 (conv_i_src_c041_2_11 conv_i_c041_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_11 (conv_q_src_c041_2_11 0 conv_bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_2_11 (conv_q_src_c041_2_11 conv_q_c041_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_12 (conv_i_src_c041_2_12 0 conv_bpf_c041_2 0) vcvs gain=1.950903220161e-01
SCONVI_c041_2_12 (conv_i_src_c041_2_12 conv_i_c041_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_12 (conv_q_src_c041_2_12 0 conv_bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_2_12 (conv_q_src_c041_2_12 conv_q_c041_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_13 (conv_i_src_c041_2_13 0 conv_bpf_c041_2 0) vcvs gain=5.555702330196e-01
SCONVI_c041_2_13 (conv_i_src_c041_2_13 conv_i_c041_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_13 (conv_q_src_c041_2_13 0 conv_bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_2_13 (conv_q_src_c041_2_13 conv_q_c041_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_14 (conv_i_src_c041_2_14 0 conv_bpf_c041_2 0) vcvs gain=8.314696123025e-01
SCONVI_c041_2_14 (conv_i_src_c041_2_14 conv_i_c041_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_14 (conv_q_src_c041_2_14 0 conv_bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_2_14 (conv_q_src_c041_2_14 conv_q_c041_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_2_15 (conv_i_src_c041_2_15 0 conv_bpf_c041_2 0) vcvs gain=9.807852804032e-01
SCONVI_c041_2_15 (conv_i_src_c041_2_15 conv_i_c041_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_2_15 (conv_q_src_c041_2_15 0 conv_bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_2_15 (conv_q_src_c041_2_15 conv_q_c041_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c041_2 (conv_i_c041_2 0) resistor r=1G
RCONVQ_c041_2 (conv_q_c041_2 0) resistor r=1G
RCONVINTI_c041_2 (conv_i_c041_2 ConvIcar_c041_2) resistor r=1k
CCONVINTI_c041_2 (ConvIcar_c041_2 0) capacitor c=80p
RCONVINTQ_c041_2 (conv_q_c041_2 ConvQcar_c041_2) resistor r=1k
CCONVINTQ_c041_2 (ConvQcar_c041_2 0) capacitor c=80p
save conv_bpf_c041_2 ConvIcar_c041_2 ConvQcar_c041_2

// conventional mixed baseline bl041, carrier_3: 1000000000 Hz
CCONVBPF_c041_3 (bl041 n_conv_cbpf_c041_3) capacitor c=2.533029591058e-14
LCONVBPF_c041_3 (n_conv_cbpf_c041_3 conv_bpf_c041_3) inductor l=1.000000000000e-06
RCONVBPF_c041_3 (conv_bpf_c041_3 0) resistor r=3.141592653590e+02
ECONVI_c041_3_00 (conv_i_src_c041_3_00 0 conv_bpf_c041_3 0) vcvs gain=9.807852804032e-01
SCONVI_c041_3_00 (conv_i_src_c041_3_00 conv_i_c041_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_00 (conv_q_src_c041_3_00 0 conv_bpf_c041_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_3_00 (conv_q_src_c041_3_00 conv_q_c041_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_01 (conv_i_src_c041_3_01 0 conv_bpf_c041_3 0) vcvs gain=8.314696123025e-01
SCONVI_c041_3_01 (conv_i_src_c041_3_01 conv_i_c041_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_01 (conv_q_src_c041_3_01 0 conv_bpf_c041_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_3_01 (conv_q_src_c041_3_01 conv_q_c041_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_02 (conv_i_src_c041_3_02 0 conv_bpf_c041_3 0) vcvs gain=5.555702330196e-01
SCONVI_c041_3_02 (conv_i_src_c041_3_02 conv_i_c041_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_02 (conv_q_src_c041_3_02 0 conv_bpf_c041_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_3_02 (conv_q_src_c041_3_02 conv_q_c041_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_03 (conv_i_src_c041_3_03 0 conv_bpf_c041_3 0) vcvs gain=1.950903220161e-01
SCONVI_c041_3_03 (conv_i_src_c041_3_03 conv_i_c041_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_03 (conv_q_src_c041_3_03 0 conv_bpf_c041_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_3_03 (conv_q_src_c041_3_03 conv_q_c041_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_04 (conv_i_src_c041_3_04 0 conv_bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_3_04 (conv_i_src_c041_3_04 conv_i_c041_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_04 (conv_q_src_c041_3_04 0 conv_bpf_c041_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c041_3_04 (conv_q_src_c041_3_04 conv_q_c041_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_05 (conv_i_src_c041_3_05 0 conv_bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_3_05 (conv_i_src_c041_3_05 conv_i_c041_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_05 (conv_q_src_c041_3_05 0 conv_bpf_c041_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c041_3_05 (conv_q_src_c041_3_05 conv_q_c041_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_06 (conv_i_src_c041_3_06 0 conv_bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_3_06 (conv_i_src_c041_3_06 conv_i_c041_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_06 (conv_q_src_c041_3_06 0 conv_bpf_c041_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c041_3_06 (conv_q_src_c041_3_06 conv_q_c041_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_07 (conv_i_src_c041_3_07 0 conv_bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_3_07 (conv_i_src_c041_3_07 conv_i_c041_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_07 (conv_q_src_c041_3_07 0 conv_bpf_c041_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c041_3_07 (conv_q_src_c041_3_07 conv_q_c041_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_08 (conv_i_src_c041_3_08 0 conv_bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c041_3_08 (conv_i_src_c041_3_08 conv_i_c041_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_08 (conv_q_src_c041_3_08 0 conv_bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_3_08 (conv_q_src_c041_3_08 conv_q_c041_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_09 (conv_i_src_c041_3_09 0 conv_bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c041_3_09 (conv_i_src_c041_3_09 conv_i_c041_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_09 (conv_q_src_c041_3_09 0 conv_bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_3_09 (conv_q_src_c041_3_09 conv_q_c041_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_10 (conv_i_src_c041_3_10 0 conv_bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c041_3_10 (conv_i_src_c041_3_10 conv_i_c041_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_10 (conv_q_src_c041_3_10 0 conv_bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_3_10 (conv_q_src_c041_3_10 conv_q_c041_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_11 (conv_i_src_c041_3_11 0 conv_bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c041_3_11 (conv_i_src_c041_3_11 conv_i_c041_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_11 (conv_q_src_c041_3_11 0 conv_bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_3_11 (conv_q_src_c041_3_11 conv_q_c041_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_12 (conv_i_src_c041_3_12 0 conv_bpf_c041_3 0) vcvs gain=1.950903220161e-01
SCONVI_c041_3_12 (conv_i_src_c041_3_12 conv_i_c041_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_12 (conv_q_src_c041_3_12 0 conv_bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c041_3_12 (conv_q_src_c041_3_12 conv_q_c041_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_13 (conv_i_src_c041_3_13 0 conv_bpf_c041_3 0) vcvs gain=5.555702330196e-01
SCONVI_c041_3_13 (conv_i_src_c041_3_13 conv_i_c041_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_13 (conv_q_src_c041_3_13 0 conv_bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c041_3_13 (conv_q_src_c041_3_13 conv_q_c041_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_14 (conv_i_src_c041_3_14 0 conv_bpf_c041_3 0) vcvs gain=8.314696123025e-01
SCONVI_c041_3_14 (conv_i_src_c041_3_14 conv_i_c041_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_14 (conv_q_src_c041_3_14 0 conv_bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c041_3_14 (conv_q_src_c041_3_14 conv_q_c041_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c041_3_15 (conv_i_src_c041_3_15 0 conv_bpf_c041_3 0) vcvs gain=9.807852804032e-01
SCONVI_c041_3_15 (conv_i_src_c041_3_15 conv_i_c041_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c041_3_15 (conv_q_src_c041_3_15 0 conv_bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c041_3_15 (conv_q_src_c041_3_15 conv_q_c041_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c041_3 (conv_i_c041_3 0) resistor r=1G
RCONVQ_c041_3 (conv_q_c041_3 0) resistor r=1G
RCONVINTI_c041_3 (conv_i_c041_3 ConvIcar_c041_3) resistor r=1k
CCONVINTI_c041_3 (ConvIcar_c041_3 0) capacitor c=80p
RCONVINTQ_c041_3 (conv_q_c041_3 ConvQcar_c041_3) resistor r=1k
CCONVINTQ_c041_3 (ConvQcar_c041_3 0) capacitor c=80p
save conv_bpf_c041_3 ConvIcar_c041_3 ConvQcar_c041_3

// conventional mixed baseline bl042, carrier_0: 250000000 Hz
CCONVBPF_c042_0 (bl042 n_conv_cbpf_c042_0) capacitor c=4.052847345694e-13
LCONVBPF_c042_0 (n_conv_cbpf_c042_0 conv_bpf_c042_0) inductor l=1.000000000000e-06
RCONVBPF_c042_0 (conv_bpf_c042_0 0) resistor r=7.853981633974e+01
ECONVI_c042_0_00 (conv_i_src_c042_0_00 0 conv_bpf_c042_0 0) vcvs gain=9.807852804032e-01
SCONVI_c042_0_00 (conv_i_src_c042_0_00 conv_i_c042_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_00 (conv_q_src_c042_0_00 0 conv_bpf_c042_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_0_00 (conv_q_src_c042_0_00 conv_q_c042_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_01 (conv_i_src_c042_0_01 0 conv_bpf_c042_0 0) vcvs gain=8.314696123025e-01
SCONVI_c042_0_01 (conv_i_src_c042_0_01 conv_i_c042_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_01 (conv_q_src_c042_0_01 0 conv_bpf_c042_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_0_01 (conv_q_src_c042_0_01 conv_q_c042_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_02 (conv_i_src_c042_0_02 0 conv_bpf_c042_0 0) vcvs gain=5.555702330196e-01
SCONVI_c042_0_02 (conv_i_src_c042_0_02 conv_i_c042_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_02 (conv_q_src_c042_0_02 0 conv_bpf_c042_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_0_02 (conv_q_src_c042_0_02 conv_q_c042_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_03 (conv_i_src_c042_0_03 0 conv_bpf_c042_0 0) vcvs gain=1.950903220161e-01
SCONVI_c042_0_03 (conv_i_src_c042_0_03 conv_i_c042_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_03 (conv_q_src_c042_0_03 0 conv_bpf_c042_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_0_03 (conv_q_src_c042_0_03 conv_q_c042_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_04 (conv_i_src_c042_0_04 0 conv_bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_0_04 (conv_i_src_c042_0_04 conv_i_c042_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_04 (conv_q_src_c042_0_04 0 conv_bpf_c042_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_0_04 (conv_q_src_c042_0_04 conv_q_c042_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_05 (conv_i_src_c042_0_05 0 conv_bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_0_05 (conv_i_src_c042_0_05 conv_i_c042_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_05 (conv_q_src_c042_0_05 0 conv_bpf_c042_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_0_05 (conv_q_src_c042_0_05 conv_q_c042_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_06 (conv_i_src_c042_0_06 0 conv_bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_0_06 (conv_i_src_c042_0_06 conv_i_c042_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_06 (conv_q_src_c042_0_06 0 conv_bpf_c042_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_0_06 (conv_q_src_c042_0_06 conv_q_c042_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_07 (conv_i_src_c042_0_07 0 conv_bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_0_07 (conv_i_src_c042_0_07 conv_i_c042_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_07 (conv_q_src_c042_0_07 0 conv_bpf_c042_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_0_07 (conv_q_src_c042_0_07 conv_q_c042_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_08 (conv_i_src_c042_0_08 0 conv_bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_0_08 (conv_i_src_c042_0_08 conv_i_c042_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_08 (conv_q_src_c042_0_08 0 conv_bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_0_08 (conv_q_src_c042_0_08 conv_q_c042_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_09 (conv_i_src_c042_0_09 0 conv_bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_0_09 (conv_i_src_c042_0_09 conv_i_c042_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_09 (conv_q_src_c042_0_09 0 conv_bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_0_09 (conv_q_src_c042_0_09 conv_q_c042_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_10 (conv_i_src_c042_0_10 0 conv_bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_0_10 (conv_i_src_c042_0_10 conv_i_c042_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_10 (conv_q_src_c042_0_10 0 conv_bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_0_10 (conv_q_src_c042_0_10 conv_q_c042_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_11 (conv_i_src_c042_0_11 0 conv_bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_0_11 (conv_i_src_c042_0_11 conv_i_c042_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_11 (conv_q_src_c042_0_11 0 conv_bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_0_11 (conv_q_src_c042_0_11 conv_q_c042_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_12 (conv_i_src_c042_0_12 0 conv_bpf_c042_0 0) vcvs gain=1.950903220161e-01
SCONVI_c042_0_12 (conv_i_src_c042_0_12 conv_i_c042_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_12 (conv_q_src_c042_0_12 0 conv_bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_0_12 (conv_q_src_c042_0_12 conv_q_c042_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_13 (conv_i_src_c042_0_13 0 conv_bpf_c042_0 0) vcvs gain=5.555702330196e-01
SCONVI_c042_0_13 (conv_i_src_c042_0_13 conv_i_c042_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_13 (conv_q_src_c042_0_13 0 conv_bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_0_13 (conv_q_src_c042_0_13 conv_q_c042_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_14 (conv_i_src_c042_0_14 0 conv_bpf_c042_0 0) vcvs gain=8.314696123025e-01
SCONVI_c042_0_14 (conv_i_src_c042_0_14 conv_i_c042_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_14 (conv_q_src_c042_0_14 0 conv_bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_0_14 (conv_q_src_c042_0_14 conv_q_c042_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_0_15 (conv_i_src_c042_0_15 0 conv_bpf_c042_0 0) vcvs gain=9.807852804032e-01
SCONVI_c042_0_15 (conv_i_src_c042_0_15 conv_i_c042_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_0_15 (conv_q_src_c042_0_15 0 conv_bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_0_15 (conv_q_src_c042_0_15 conv_q_c042_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c042_0 (conv_i_c042_0 0) resistor r=1G
RCONVQ_c042_0 (conv_q_c042_0 0) resistor r=1G
RCONVINTI_c042_0 (conv_i_c042_0 ConvIcar_c042_0) resistor r=1k
CCONVINTI_c042_0 (ConvIcar_c042_0 0) capacitor c=80p
RCONVINTQ_c042_0 (conv_q_c042_0 ConvQcar_c042_0) resistor r=1k
CCONVINTQ_c042_0 (ConvQcar_c042_0 0) capacitor c=80p
save conv_bpf_c042_0 ConvIcar_c042_0 ConvQcar_c042_0

// conventional mixed baseline bl042, carrier_1: 500000000 Hz
CCONVBPF_c042_1 (bl042 n_conv_cbpf_c042_1) capacitor c=1.013211836423e-13
LCONVBPF_c042_1 (n_conv_cbpf_c042_1 conv_bpf_c042_1) inductor l=1.000000000000e-06
RCONVBPF_c042_1 (conv_bpf_c042_1 0) resistor r=1.570796326795e+02
ECONVI_c042_1_00 (conv_i_src_c042_1_00 0 conv_bpf_c042_1 0) vcvs gain=9.807852804032e-01
SCONVI_c042_1_00 (conv_i_src_c042_1_00 conv_i_c042_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_00 (conv_q_src_c042_1_00 0 conv_bpf_c042_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_1_00 (conv_q_src_c042_1_00 conv_q_c042_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_01 (conv_i_src_c042_1_01 0 conv_bpf_c042_1 0) vcvs gain=8.314696123025e-01
SCONVI_c042_1_01 (conv_i_src_c042_1_01 conv_i_c042_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_01 (conv_q_src_c042_1_01 0 conv_bpf_c042_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_1_01 (conv_q_src_c042_1_01 conv_q_c042_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_02 (conv_i_src_c042_1_02 0 conv_bpf_c042_1 0) vcvs gain=5.555702330196e-01
SCONVI_c042_1_02 (conv_i_src_c042_1_02 conv_i_c042_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_02 (conv_q_src_c042_1_02 0 conv_bpf_c042_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_1_02 (conv_q_src_c042_1_02 conv_q_c042_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_03 (conv_i_src_c042_1_03 0 conv_bpf_c042_1 0) vcvs gain=1.950903220161e-01
SCONVI_c042_1_03 (conv_i_src_c042_1_03 conv_i_c042_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_03 (conv_q_src_c042_1_03 0 conv_bpf_c042_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_1_03 (conv_q_src_c042_1_03 conv_q_c042_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_04 (conv_i_src_c042_1_04 0 conv_bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_1_04 (conv_i_src_c042_1_04 conv_i_c042_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_04 (conv_q_src_c042_1_04 0 conv_bpf_c042_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_1_04 (conv_q_src_c042_1_04 conv_q_c042_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_05 (conv_i_src_c042_1_05 0 conv_bpf_c042_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_1_05 (conv_i_src_c042_1_05 conv_i_c042_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_05 (conv_q_src_c042_1_05 0 conv_bpf_c042_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_1_05 (conv_q_src_c042_1_05 conv_q_c042_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_06 (conv_i_src_c042_1_06 0 conv_bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_1_06 (conv_i_src_c042_1_06 conv_i_c042_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_06 (conv_q_src_c042_1_06 0 conv_bpf_c042_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_1_06 (conv_q_src_c042_1_06 conv_q_c042_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_07 (conv_i_src_c042_1_07 0 conv_bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_1_07 (conv_i_src_c042_1_07 conv_i_c042_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_07 (conv_q_src_c042_1_07 0 conv_bpf_c042_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_1_07 (conv_q_src_c042_1_07 conv_q_c042_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_08 (conv_i_src_c042_1_08 0 conv_bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_1_08 (conv_i_src_c042_1_08 conv_i_c042_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_08 (conv_q_src_c042_1_08 0 conv_bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_1_08 (conv_q_src_c042_1_08 conv_q_c042_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_09 (conv_i_src_c042_1_09 0 conv_bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_1_09 (conv_i_src_c042_1_09 conv_i_c042_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_09 (conv_q_src_c042_1_09 0 conv_bpf_c042_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_1_09 (conv_q_src_c042_1_09 conv_q_c042_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_10 (conv_i_src_c042_1_10 0 conv_bpf_c042_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_1_10 (conv_i_src_c042_1_10 conv_i_c042_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_10 (conv_q_src_c042_1_10 0 conv_bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_1_10 (conv_q_src_c042_1_10 conv_q_c042_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_11 (conv_i_src_c042_1_11 0 conv_bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_1_11 (conv_i_src_c042_1_11 conv_i_c042_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_11 (conv_q_src_c042_1_11 0 conv_bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_1_11 (conv_q_src_c042_1_11 conv_q_c042_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_12 (conv_i_src_c042_1_12 0 conv_bpf_c042_1 0) vcvs gain=1.950903220161e-01
SCONVI_c042_1_12 (conv_i_src_c042_1_12 conv_i_c042_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_12 (conv_q_src_c042_1_12 0 conv_bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_1_12 (conv_q_src_c042_1_12 conv_q_c042_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_13 (conv_i_src_c042_1_13 0 conv_bpf_c042_1 0) vcvs gain=5.555702330196e-01
SCONVI_c042_1_13 (conv_i_src_c042_1_13 conv_i_c042_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_13 (conv_q_src_c042_1_13 0 conv_bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_1_13 (conv_q_src_c042_1_13 conv_q_c042_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_14 (conv_i_src_c042_1_14 0 conv_bpf_c042_1 0) vcvs gain=8.314696123025e-01
SCONVI_c042_1_14 (conv_i_src_c042_1_14 conv_i_c042_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_14 (conv_q_src_c042_1_14 0 conv_bpf_c042_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_1_14 (conv_q_src_c042_1_14 conv_q_c042_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_1_15 (conv_i_src_c042_1_15 0 conv_bpf_c042_1 0) vcvs gain=9.807852804032e-01
SCONVI_c042_1_15 (conv_i_src_c042_1_15 conv_i_c042_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_1_15 (conv_q_src_c042_1_15 0 conv_bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_1_15 (conv_q_src_c042_1_15 conv_q_c042_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c042_1 (conv_i_c042_1 0) resistor r=1G
RCONVQ_c042_1 (conv_q_c042_1 0) resistor r=1G
RCONVINTI_c042_1 (conv_i_c042_1 ConvIcar_c042_1) resistor r=1k
CCONVINTI_c042_1 (ConvIcar_c042_1 0) capacitor c=80p
RCONVINTQ_c042_1 (conv_q_c042_1 ConvQcar_c042_1) resistor r=1k
CCONVINTQ_c042_1 (ConvQcar_c042_1 0) capacitor c=80p
save conv_bpf_c042_1 ConvIcar_c042_1 ConvQcar_c042_1

// conventional mixed baseline bl042, carrier_2: 750000000 Hz
CCONVBPF_c042_2 (bl042 n_conv_cbpf_c042_2) capacitor c=4.503163717437e-14
LCONVBPF_c042_2 (n_conv_cbpf_c042_2 conv_bpf_c042_2) inductor l=1.000000000000e-06
RCONVBPF_c042_2 (conv_bpf_c042_2 0) resistor r=2.356194490192e+02
ECONVI_c042_2_00 (conv_i_src_c042_2_00 0 conv_bpf_c042_2 0) vcvs gain=9.807852804032e-01
SCONVI_c042_2_00 (conv_i_src_c042_2_00 conv_i_c042_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_00 (conv_q_src_c042_2_00 0 conv_bpf_c042_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_2_00 (conv_q_src_c042_2_00 conv_q_c042_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_01 (conv_i_src_c042_2_01 0 conv_bpf_c042_2 0) vcvs gain=8.314696123025e-01
SCONVI_c042_2_01 (conv_i_src_c042_2_01 conv_i_c042_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_01 (conv_q_src_c042_2_01 0 conv_bpf_c042_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_2_01 (conv_q_src_c042_2_01 conv_q_c042_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_02 (conv_i_src_c042_2_02 0 conv_bpf_c042_2 0) vcvs gain=5.555702330196e-01
SCONVI_c042_2_02 (conv_i_src_c042_2_02 conv_i_c042_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_02 (conv_q_src_c042_2_02 0 conv_bpf_c042_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_2_02 (conv_q_src_c042_2_02 conv_q_c042_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_03 (conv_i_src_c042_2_03 0 conv_bpf_c042_2 0) vcvs gain=1.950903220161e-01
SCONVI_c042_2_03 (conv_i_src_c042_2_03 conv_i_c042_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_03 (conv_q_src_c042_2_03 0 conv_bpf_c042_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_2_03 (conv_q_src_c042_2_03 conv_q_c042_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_04 (conv_i_src_c042_2_04 0 conv_bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_2_04 (conv_i_src_c042_2_04 conv_i_c042_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_04 (conv_q_src_c042_2_04 0 conv_bpf_c042_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_2_04 (conv_q_src_c042_2_04 conv_q_c042_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_05 (conv_i_src_c042_2_05 0 conv_bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_2_05 (conv_i_src_c042_2_05 conv_i_c042_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_05 (conv_q_src_c042_2_05 0 conv_bpf_c042_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_2_05 (conv_q_src_c042_2_05 conv_q_c042_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_06 (conv_i_src_c042_2_06 0 conv_bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_2_06 (conv_i_src_c042_2_06 conv_i_c042_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_06 (conv_q_src_c042_2_06 0 conv_bpf_c042_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_2_06 (conv_q_src_c042_2_06 conv_q_c042_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_07 (conv_i_src_c042_2_07 0 conv_bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_2_07 (conv_i_src_c042_2_07 conv_i_c042_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_07 (conv_q_src_c042_2_07 0 conv_bpf_c042_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_2_07 (conv_q_src_c042_2_07 conv_q_c042_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_08 (conv_i_src_c042_2_08 0 conv_bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_2_08 (conv_i_src_c042_2_08 conv_i_c042_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_08 (conv_q_src_c042_2_08 0 conv_bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_2_08 (conv_q_src_c042_2_08 conv_q_c042_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_09 (conv_i_src_c042_2_09 0 conv_bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_2_09 (conv_i_src_c042_2_09 conv_i_c042_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_09 (conv_q_src_c042_2_09 0 conv_bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_2_09 (conv_q_src_c042_2_09 conv_q_c042_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_10 (conv_i_src_c042_2_10 0 conv_bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_2_10 (conv_i_src_c042_2_10 conv_i_c042_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_10 (conv_q_src_c042_2_10 0 conv_bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_2_10 (conv_q_src_c042_2_10 conv_q_c042_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_11 (conv_i_src_c042_2_11 0 conv_bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_2_11 (conv_i_src_c042_2_11 conv_i_c042_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_11 (conv_q_src_c042_2_11 0 conv_bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_2_11 (conv_q_src_c042_2_11 conv_q_c042_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_12 (conv_i_src_c042_2_12 0 conv_bpf_c042_2 0) vcvs gain=1.950903220161e-01
SCONVI_c042_2_12 (conv_i_src_c042_2_12 conv_i_c042_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_12 (conv_q_src_c042_2_12 0 conv_bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_2_12 (conv_q_src_c042_2_12 conv_q_c042_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_13 (conv_i_src_c042_2_13 0 conv_bpf_c042_2 0) vcvs gain=5.555702330196e-01
SCONVI_c042_2_13 (conv_i_src_c042_2_13 conv_i_c042_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_13 (conv_q_src_c042_2_13 0 conv_bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_2_13 (conv_q_src_c042_2_13 conv_q_c042_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_14 (conv_i_src_c042_2_14 0 conv_bpf_c042_2 0) vcvs gain=8.314696123025e-01
SCONVI_c042_2_14 (conv_i_src_c042_2_14 conv_i_c042_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_14 (conv_q_src_c042_2_14 0 conv_bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_2_14 (conv_q_src_c042_2_14 conv_q_c042_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_2_15 (conv_i_src_c042_2_15 0 conv_bpf_c042_2 0) vcvs gain=9.807852804032e-01
SCONVI_c042_2_15 (conv_i_src_c042_2_15 conv_i_c042_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_2_15 (conv_q_src_c042_2_15 0 conv_bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_2_15 (conv_q_src_c042_2_15 conv_q_c042_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c042_2 (conv_i_c042_2 0) resistor r=1G
RCONVQ_c042_2 (conv_q_c042_2 0) resistor r=1G
RCONVINTI_c042_2 (conv_i_c042_2 ConvIcar_c042_2) resistor r=1k
CCONVINTI_c042_2 (ConvIcar_c042_2 0) capacitor c=80p
RCONVINTQ_c042_2 (conv_q_c042_2 ConvQcar_c042_2) resistor r=1k
CCONVINTQ_c042_2 (ConvQcar_c042_2 0) capacitor c=80p
save conv_bpf_c042_2 ConvIcar_c042_2 ConvQcar_c042_2

// conventional mixed baseline bl042, carrier_3: 1000000000 Hz
CCONVBPF_c042_3 (bl042 n_conv_cbpf_c042_3) capacitor c=2.533029591058e-14
LCONVBPF_c042_3 (n_conv_cbpf_c042_3 conv_bpf_c042_3) inductor l=1.000000000000e-06
RCONVBPF_c042_3 (conv_bpf_c042_3 0) resistor r=3.141592653590e+02
ECONVI_c042_3_00 (conv_i_src_c042_3_00 0 conv_bpf_c042_3 0) vcvs gain=9.807852804032e-01
SCONVI_c042_3_00 (conv_i_src_c042_3_00 conv_i_c042_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_00 (conv_q_src_c042_3_00 0 conv_bpf_c042_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_3_00 (conv_q_src_c042_3_00 conv_q_c042_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_01 (conv_i_src_c042_3_01 0 conv_bpf_c042_3 0) vcvs gain=8.314696123025e-01
SCONVI_c042_3_01 (conv_i_src_c042_3_01 conv_i_c042_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_01 (conv_q_src_c042_3_01 0 conv_bpf_c042_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_3_01 (conv_q_src_c042_3_01 conv_q_c042_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_02 (conv_i_src_c042_3_02 0 conv_bpf_c042_3 0) vcvs gain=5.555702330196e-01
SCONVI_c042_3_02 (conv_i_src_c042_3_02 conv_i_c042_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_02 (conv_q_src_c042_3_02 0 conv_bpf_c042_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_3_02 (conv_q_src_c042_3_02 conv_q_c042_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_03 (conv_i_src_c042_3_03 0 conv_bpf_c042_3 0) vcvs gain=1.950903220161e-01
SCONVI_c042_3_03 (conv_i_src_c042_3_03 conv_i_c042_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_03 (conv_q_src_c042_3_03 0 conv_bpf_c042_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_3_03 (conv_q_src_c042_3_03 conv_q_c042_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_04 (conv_i_src_c042_3_04 0 conv_bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_3_04 (conv_i_src_c042_3_04 conv_i_c042_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_04 (conv_q_src_c042_3_04 0 conv_bpf_c042_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c042_3_04 (conv_q_src_c042_3_04 conv_q_c042_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_05 (conv_i_src_c042_3_05 0 conv_bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_3_05 (conv_i_src_c042_3_05 conv_i_c042_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_05 (conv_q_src_c042_3_05 0 conv_bpf_c042_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c042_3_05 (conv_q_src_c042_3_05 conv_q_c042_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_06 (conv_i_src_c042_3_06 0 conv_bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_3_06 (conv_i_src_c042_3_06 conv_i_c042_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_06 (conv_q_src_c042_3_06 0 conv_bpf_c042_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c042_3_06 (conv_q_src_c042_3_06 conv_q_c042_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_07 (conv_i_src_c042_3_07 0 conv_bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_3_07 (conv_i_src_c042_3_07 conv_i_c042_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_07 (conv_q_src_c042_3_07 0 conv_bpf_c042_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c042_3_07 (conv_q_src_c042_3_07 conv_q_c042_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_08 (conv_i_src_c042_3_08 0 conv_bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c042_3_08 (conv_i_src_c042_3_08 conv_i_c042_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_08 (conv_q_src_c042_3_08 0 conv_bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_3_08 (conv_q_src_c042_3_08 conv_q_c042_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_09 (conv_i_src_c042_3_09 0 conv_bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c042_3_09 (conv_i_src_c042_3_09 conv_i_c042_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_09 (conv_q_src_c042_3_09 0 conv_bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_3_09 (conv_q_src_c042_3_09 conv_q_c042_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_10 (conv_i_src_c042_3_10 0 conv_bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c042_3_10 (conv_i_src_c042_3_10 conv_i_c042_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_10 (conv_q_src_c042_3_10 0 conv_bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_3_10 (conv_q_src_c042_3_10 conv_q_c042_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_11 (conv_i_src_c042_3_11 0 conv_bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c042_3_11 (conv_i_src_c042_3_11 conv_i_c042_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_11 (conv_q_src_c042_3_11 0 conv_bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_3_11 (conv_q_src_c042_3_11 conv_q_c042_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_12 (conv_i_src_c042_3_12 0 conv_bpf_c042_3 0) vcvs gain=1.950903220161e-01
SCONVI_c042_3_12 (conv_i_src_c042_3_12 conv_i_c042_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_12 (conv_q_src_c042_3_12 0 conv_bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c042_3_12 (conv_q_src_c042_3_12 conv_q_c042_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_13 (conv_i_src_c042_3_13 0 conv_bpf_c042_3 0) vcvs gain=5.555702330196e-01
SCONVI_c042_3_13 (conv_i_src_c042_3_13 conv_i_c042_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_13 (conv_q_src_c042_3_13 0 conv_bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c042_3_13 (conv_q_src_c042_3_13 conv_q_c042_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_14 (conv_i_src_c042_3_14 0 conv_bpf_c042_3 0) vcvs gain=8.314696123025e-01
SCONVI_c042_3_14 (conv_i_src_c042_3_14 conv_i_c042_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_14 (conv_q_src_c042_3_14 0 conv_bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c042_3_14 (conv_q_src_c042_3_14 conv_q_c042_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c042_3_15 (conv_i_src_c042_3_15 0 conv_bpf_c042_3 0) vcvs gain=9.807852804032e-01
SCONVI_c042_3_15 (conv_i_src_c042_3_15 conv_i_c042_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c042_3_15 (conv_q_src_c042_3_15 0 conv_bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c042_3_15 (conv_q_src_c042_3_15 conv_q_c042_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c042_3 (conv_i_c042_3 0) resistor r=1G
RCONVQ_c042_3 (conv_q_c042_3 0) resistor r=1G
RCONVINTI_c042_3 (conv_i_c042_3 ConvIcar_c042_3) resistor r=1k
CCONVINTI_c042_3 (ConvIcar_c042_3 0) capacitor c=80p
RCONVINTQ_c042_3 (conv_q_c042_3 ConvQcar_c042_3) resistor r=1k
CCONVINTQ_c042_3 (ConvQcar_c042_3 0) capacitor c=80p
save conv_bpf_c042_3 ConvIcar_c042_3 ConvQcar_c042_3

// conventional mixed baseline bl043, carrier_0: 250000000 Hz
CCONVBPF_c043_0 (bl043 n_conv_cbpf_c043_0) capacitor c=4.052847345694e-13
LCONVBPF_c043_0 (n_conv_cbpf_c043_0 conv_bpf_c043_0) inductor l=1.000000000000e-06
RCONVBPF_c043_0 (conv_bpf_c043_0 0) resistor r=7.853981633974e+01
ECONVI_c043_0_00 (conv_i_src_c043_0_00 0 conv_bpf_c043_0 0) vcvs gain=9.807852804032e-01
SCONVI_c043_0_00 (conv_i_src_c043_0_00 conv_i_c043_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_00 (conv_q_src_c043_0_00 0 conv_bpf_c043_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_0_00 (conv_q_src_c043_0_00 conv_q_c043_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_01 (conv_i_src_c043_0_01 0 conv_bpf_c043_0 0) vcvs gain=8.314696123025e-01
SCONVI_c043_0_01 (conv_i_src_c043_0_01 conv_i_c043_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_01 (conv_q_src_c043_0_01 0 conv_bpf_c043_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_0_01 (conv_q_src_c043_0_01 conv_q_c043_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_02 (conv_i_src_c043_0_02 0 conv_bpf_c043_0 0) vcvs gain=5.555702330196e-01
SCONVI_c043_0_02 (conv_i_src_c043_0_02 conv_i_c043_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_02 (conv_q_src_c043_0_02 0 conv_bpf_c043_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_0_02 (conv_q_src_c043_0_02 conv_q_c043_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_03 (conv_i_src_c043_0_03 0 conv_bpf_c043_0 0) vcvs gain=1.950903220161e-01
SCONVI_c043_0_03 (conv_i_src_c043_0_03 conv_i_c043_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_03 (conv_q_src_c043_0_03 0 conv_bpf_c043_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_0_03 (conv_q_src_c043_0_03 conv_q_c043_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_04 (conv_i_src_c043_0_04 0 conv_bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_0_04 (conv_i_src_c043_0_04 conv_i_c043_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_04 (conv_q_src_c043_0_04 0 conv_bpf_c043_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_0_04 (conv_q_src_c043_0_04 conv_q_c043_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_05 (conv_i_src_c043_0_05 0 conv_bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_0_05 (conv_i_src_c043_0_05 conv_i_c043_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_05 (conv_q_src_c043_0_05 0 conv_bpf_c043_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_0_05 (conv_q_src_c043_0_05 conv_q_c043_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_06 (conv_i_src_c043_0_06 0 conv_bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_0_06 (conv_i_src_c043_0_06 conv_i_c043_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_06 (conv_q_src_c043_0_06 0 conv_bpf_c043_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_0_06 (conv_q_src_c043_0_06 conv_q_c043_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_07 (conv_i_src_c043_0_07 0 conv_bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_0_07 (conv_i_src_c043_0_07 conv_i_c043_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_07 (conv_q_src_c043_0_07 0 conv_bpf_c043_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_0_07 (conv_q_src_c043_0_07 conv_q_c043_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_08 (conv_i_src_c043_0_08 0 conv_bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_0_08 (conv_i_src_c043_0_08 conv_i_c043_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_08 (conv_q_src_c043_0_08 0 conv_bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_0_08 (conv_q_src_c043_0_08 conv_q_c043_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_09 (conv_i_src_c043_0_09 0 conv_bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_0_09 (conv_i_src_c043_0_09 conv_i_c043_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_09 (conv_q_src_c043_0_09 0 conv_bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_0_09 (conv_q_src_c043_0_09 conv_q_c043_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_10 (conv_i_src_c043_0_10 0 conv_bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_0_10 (conv_i_src_c043_0_10 conv_i_c043_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_10 (conv_q_src_c043_0_10 0 conv_bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_0_10 (conv_q_src_c043_0_10 conv_q_c043_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_11 (conv_i_src_c043_0_11 0 conv_bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_0_11 (conv_i_src_c043_0_11 conv_i_c043_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_11 (conv_q_src_c043_0_11 0 conv_bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_0_11 (conv_q_src_c043_0_11 conv_q_c043_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_12 (conv_i_src_c043_0_12 0 conv_bpf_c043_0 0) vcvs gain=1.950903220161e-01
SCONVI_c043_0_12 (conv_i_src_c043_0_12 conv_i_c043_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_12 (conv_q_src_c043_0_12 0 conv_bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_0_12 (conv_q_src_c043_0_12 conv_q_c043_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_13 (conv_i_src_c043_0_13 0 conv_bpf_c043_0 0) vcvs gain=5.555702330196e-01
SCONVI_c043_0_13 (conv_i_src_c043_0_13 conv_i_c043_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_13 (conv_q_src_c043_0_13 0 conv_bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_0_13 (conv_q_src_c043_0_13 conv_q_c043_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_14 (conv_i_src_c043_0_14 0 conv_bpf_c043_0 0) vcvs gain=8.314696123025e-01
SCONVI_c043_0_14 (conv_i_src_c043_0_14 conv_i_c043_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_14 (conv_q_src_c043_0_14 0 conv_bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_0_14 (conv_q_src_c043_0_14 conv_q_c043_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_0_15 (conv_i_src_c043_0_15 0 conv_bpf_c043_0 0) vcvs gain=9.807852804032e-01
SCONVI_c043_0_15 (conv_i_src_c043_0_15 conv_i_c043_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_0_15 (conv_q_src_c043_0_15 0 conv_bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_0_15 (conv_q_src_c043_0_15 conv_q_c043_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c043_0 (conv_i_c043_0 0) resistor r=1G
RCONVQ_c043_0 (conv_q_c043_0 0) resistor r=1G
RCONVINTI_c043_0 (conv_i_c043_0 ConvIcar_c043_0) resistor r=1k
CCONVINTI_c043_0 (ConvIcar_c043_0 0) capacitor c=80p
RCONVINTQ_c043_0 (conv_q_c043_0 ConvQcar_c043_0) resistor r=1k
CCONVINTQ_c043_0 (ConvQcar_c043_0 0) capacitor c=80p
save conv_bpf_c043_0 ConvIcar_c043_0 ConvQcar_c043_0

// conventional mixed baseline bl043, carrier_1: 500000000 Hz
CCONVBPF_c043_1 (bl043 n_conv_cbpf_c043_1) capacitor c=1.013211836423e-13
LCONVBPF_c043_1 (n_conv_cbpf_c043_1 conv_bpf_c043_1) inductor l=1.000000000000e-06
RCONVBPF_c043_1 (conv_bpf_c043_1 0) resistor r=1.570796326795e+02
ECONVI_c043_1_00 (conv_i_src_c043_1_00 0 conv_bpf_c043_1 0) vcvs gain=9.807852804032e-01
SCONVI_c043_1_00 (conv_i_src_c043_1_00 conv_i_c043_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_00 (conv_q_src_c043_1_00 0 conv_bpf_c043_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_1_00 (conv_q_src_c043_1_00 conv_q_c043_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_01 (conv_i_src_c043_1_01 0 conv_bpf_c043_1 0) vcvs gain=8.314696123025e-01
SCONVI_c043_1_01 (conv_i_src_c043_1_01 conv_i_c043_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_01 (conv_q_src_c043_1_01 0 conv_bpf_c043_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_1_01 (conv_q_src_c043_1_01 conv_q_c043_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_02 (conv_i_src_c043_1_02 0 conv_bpf_c043_1 0) vcvs gain=5.555702330196e-01
SCONVI_c043_1_02 (conv_i_src_c043_1_02 conv_i_c043_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_02 (conv_q_src_c043_1_02 0 conv_bpf_c043_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_1_02 (conv_q_src_c043_1_02 conv_q_c043_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_03 (conv_i_src_c043_1_03 0 conv_bpf_c043_1 0) vcvs gain=1.950903220161e-01
SCONVI_c043_1_03 (conv_i_src_c043_1_03 conv_i_c043_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_03 (conv_q_src_c043_1_03 0 conv_bpf_c043_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_1_03 (conv_q_src_c043_1_03 conv_q_c043_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_04 (conv_i_src_c043_1_04 0 conv_bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_1_04 (conv_i_src_c043_1_04 conv_i_c043_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_04 (conv_q_src_c043_1_04 0 conv_bpf_c043_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_1_04 (conv_q_src_c043_1_04 conv_q_c043_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_05 (conv_i_src_c043_1_05 0 conv_bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_1_05 (conv_i_src_c043_1_05 conv_i_c043_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_05 (conv_q_src_c043_1_05 0 conv_bpf_c043_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_1_05 (conv_q_src_c043_1_05 conv_q_c043_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_06 (conv_i_src_c043_1_06 0 conv_bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_1_06 (conv_i_src_c043_1_06 conv_i_c043_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_06 (conv_q_src_c043_1_06 0 conv_bpf_c043_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_1_06 (conv_q_src_c043_1_06 conv_q_c043_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_07 (conv_i_src_c043_1_07 0 conv_bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_1_07 (conv_i_src_c043_1_07 conv_i_c043_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_07 (conv_q_src_c043_1_07 0 conv_bpf_c043_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_1_07 (conv_q_src_c043_1_07 conv_q_c043_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_08 (conv_i_src_c043_1_08 0 conv_bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_1_08 (conv_i_src_c043_1_08 conv_i_c043_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_08 (conv_q_src_c043_1_08 0 conv_bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_1_08 (conv_q_src_c043_1_08 conv_q_c043_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_09 (conv_i_src_c043_1_09 0 conv_bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_1_09 (conv_i_src_c043_1_09 conv_i_c043_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_09 (conv_q_src_c043_1_09 0 conv_bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_1_09 (conv_q_src_c043_1_09 conv_q_c043_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_10 (conv_i_src_c043_1_10 0 conv_bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_1_10 (conv_i_src_c043_1_10 conv_i_c043_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_10 (conv_q_src_c043_1_10 0 conv_bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_1_10 (conv_q_src_c043_1_10 conv_q_c043_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_11 (conv_i_src_c043_1_11 0 conv_bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_1_11 (conv_i_src_c043_1_11 conv_i_c043_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_11 (conv_q_src_c043_1_11 0 conv_bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_1_11 (conv_q_src_c043_1_11 conv_q_c043_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_12 (conv_i_src_c043_1_12 0 conv_bpf_c043_1 0) vcvs gain=1.950903220161e-01
SCONVI_c043_1_12 (conv_i_src_c043_1_12 conv_i_c043_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_12 (conv_q_src_c043_1_12 0 conv_bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_1_12 (conv_q_src_c043_1_12 conv_q_c043_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_13 (conv_i_src_c043_1_13 0 conv_bpf_c043_1 0) vcvs gain=5.555702330196e-01
SCONVI_c043_1_13 (conv_i_src_c043_1_13 conv_i_c043_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_13 (conv_q_src_c043_1_13 0 conv_bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_1_13 (conv_q_src_c043_1_13 conv_q_c043_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_14 (conv_i_src_c043_1_14 0 conv_bpf_c043_1 0) vcvs gain=8.314696123025e-01
SCONVI_c043_1_14 (conv_i_src_c043_1_14 conv_i_c043_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_14 (conv_q_src_c043_1_14 0 conv_bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_1_14 (conv_q_src_c043_1_14 conv_q_c043_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_1_15 (conv_i_src_c043_1_15 0 conv_bpf_c043_1 0) vcvs gain=9.807852804032e-01
SCONVI_c043_1_15 (conv_i_src_c043_1_15 conv_i_c043_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_1_15 (conv_q_src_c043_1_15 0 conv_bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_1_15 (conv_q_src_c043_1_15 conv_q_c043_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c043_1 (conv_i_c043_1 0) resistor r=1G
RCONVQ_c043_1 (conv_q_c043_1 0) resistor r=1G
RCONVINTI_c043_1 (conv_i_c043_1 ConvIcar_c043_1) resistor r=1k
CCONVINTI_c043_1 (ConvIcar_c043_1 0) capacitor c=80p
RCONVINTQ_c043_1 (conv_q_c043_1 ConvQcar_c043_1) resistor r=1k
CCONVINTQ_c043_1 (ConvQcar_c043_1 0) capacitor c=80p
save conv_bpf_c043_1 ConvIcar_c043_1 ConvQcar_c043_1

// conventional mixed baseline bl043, carrier_2: 750000000 Hz
CCONVBPF_c043_2 (bl043 n_conv_cbpf_c043_2) capacitor c=4.503163717437e-14
LCONVBPF_c043_2 (n_conv_cbpf_c043_2 conv_bpf_c043_2) inductor l=1.000000000000e-06
RCONVBPF_c043_2 (conv_bpf_c043_2 0) resistor r=2.356194490192e+02
ECONVI_c043_2_00 (conv_i_src_c043_2_00 0 conv_bpf_c043_2 0) vcvs gain=9.807852804032e-01
SCONVI_c043_2_00 (conv_i_src_c043_2_00 conv_i_c043_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_00 (conv_q_src_c043_2_00 0 conv_bpf_c043_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_2_00 (conv_q_src_c043_2_00 conv_q_c043_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_01 (conv_i_src_c043_2_01 0 conv_bpf_c043_2 0) vcvs gain=8.314696123025e-01
SCONVI_c043_2_01 (conv_i_src_c043_2_01 conv_i_c043_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_01 (conv_q_src_c043_2_01 0 conv_bpf_c043_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_2_01 (conv_q_src_c043_2_01 conv_q_c043_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_02 (conv_i_src_c043_2_02 0 conv_bpf_c043_2 0) vcvs gain=5.555702330196e-01
SCONVI_c043_2_02 (conv_i_src_c043_2_02 conv_i_c043_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_02 (conv_q_src_c043_2_02 0 conv_bpf_c043_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_2_02 (conv_q_src_c043_2_02 conv_q_c043_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_03 (conv_i_src_c043_2_03 0 conv_bpf_c043_2 0) vcvs gain=1.950903220161e-01
SCONVI_c043_2_03 (conv_i_src_c043_2_03 conv_i_c043_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_03 (conv_q_src_c043_2_03 0 conv_bpf_c043_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_2_03 (conv_q_src_c043_2_03 conv_q_c043_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_04 (conv_i_src_c043_2_04 0 conv_bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_2_04 (conv_i_src_c043_2_04 conv_i_c043_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_04 (conv_q_src_c043_2_04 0 conv_bpf_c043_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_2_04 (conv_q_src_c043_2_04 conv_q_c043_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_05 (conv_i_src_c043_2_05 0 conv_bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_2_05 (conv_i_src_c043_2_05 conv_i_c043_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_05 (conv_q_src_c043_2_05 0 conv_bpf_c043_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_2_05 (conv_q_src_c043_2_05 conv_q_c043_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_06 (conv_i_src_c043_2_06 0 conv_bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_2_06 (conv_i_src_c043_2_06 conv_i_c043_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_06 (conv_q_src_c043_2_06 0 conv_bpf_c043_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_2_06 (conv_q_src_c043_2_06 conv_q_c043_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_07 (conv_i_src_c043_2_07 0 conv_bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_2_07 (conv_i_src_c043_2_07 conv_i_c043_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_07 (conv_q_src_c043_2_07 0 conv_bpf_c043_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_2_07 (conv_q_src_c043_2_07 conv_q_c043_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_08 (conv_i_src_c043_2_08 0 conv_bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_2_08 (conv_i_src_c043_2_08 conv_i_c043_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_08 (conv_q_src_c043_2_08 0 conv_bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_2_08 (conv_q_src_c043_2_08 conv_q_c043_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_09 (conv_i_src_c043_2_09 0 conv_bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_2_09 (conv_i_src_c043_2_09 conv_i_c043_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_09 (conv_q_src_c043_2_09 0 conv_bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_2_09 (conv_q_src_c043_2_09 conv_q_c043_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_10 (conv_i_src_c043_2_10 0 conv_bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_2_10 (conv_i_src_c043_2_10 conv_i_c043_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_10 (conv_q_src_c043_2_10 0 conv_bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_2_10 (conv_q_src_c043_2_10 conv_q_c043_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_11 (conv_i_src_c043_2_11 0 conv_bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_2_11 (conv_i_src_c043_2_11 conv_i_c043_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_11 (conv_q_src_c043_2_11 0 conv_bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_2_11 (conv_q_src_c043_2_11 conv_q_c043_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_12 (conv_i_src_c043_2_12 0 conv_bpf_c043_2 0) vcvs gain=1.950903220161e-01
SCONVI_c043_2_12 (conv_i_src_c043_2_12 conv_i_c043_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_12 (conv_q_src_c043_2_12 0 conv_bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_2_12 (conv_q_src_c043_2_12 conv_q_c043_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_13 (conv_i_src_c043_2_13 0 conv_bpf_c043_2 0) vcvs gain=5.555702330196e-01
SCONVI_c043_2_13 (conv_i_src_c043_2_13 conv_i_c043_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_13 (conv_q_src_c043_2_13 0 conv_bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_2_13 (conv_q_src_c043_2_13 conv_q_c043_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_14 (conv_i_src_c043_2_14 0 conv_bpf_c043_2 0) vcvs gain=8.314696123025e-01
SCONVI_c043_2_14 (conv_i_src_c043_2_14 conv_i_c043_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_14 (conv_q_src_c043_2_14 0 conv_bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_2_14 (conv_q_src_c043_2_14 conv_q_c043_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_2_15 (conv_i_src_c043_2_15 0 conv_bpf_c043_2 0) vcvs gain=9.807852804032e-01
SCONVI_c043_2_15 (conv_i_src_c043_2_15 conv_i_c043_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_2_15 (conv_q_src_c043_2_15 0 conv_bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_2_15 (conv_q_src_c043_2_15 conv_q_c043_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c043_2 (conv_i_c043_2 0) resistor r=1G
RCONVQ_c043_2 (conv_q_c043_2 0) resistor r=1G
RCONVINTI_c043_2 (conv_i_c043_2 ConvIcar_c043_2) resistor r=1k
CCONVINTI_c043_2 (ConvIcar_c043_2 0) capacitor c=80p
RCONVINTQ_c043_2 (conv_q_c043_2 ConvQcar_c043_2) resistor r=1k
CCONVINTQ_c043_2 (ConvQcar_c043_2 0) capacitor c=80p
save conv_bpf_c043_2 ConvIcar_c043_2 ConvQcar_c043_2

// conventional mixed baseline bl043, carrier_3: 1000000000 Hz
CCONVBPF_c043_3 (bl043 n_conv_cbpf_c043_3) capacitor c=2.533029591058e-14
LCONVBPF_c043_3 (n_conv_cbpf_c043_3 conv_bpf_c043_3) inductor l=1.000000000000e-06
RCONVBPF_c043_3 (conv_bpf_c043_3 0) resistor r=3.141592653590e+02
ECONVI_c043_3_00 (conv_i_src_c043_3_00 0 conv_bpf_c043_3 0) vcvs gain=9.807852804032e-01
SCONVI_c043_3_00 (conv_i_src_c043_3_00 conv_i_c043_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_00 (conv_q_src_c043_3_00 0 conv_bpf_c043_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_3_00 (conv_q_src_c043_3_00 conv_q_c043_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_01 (conv_i_src_c043_3_01 0 conv_bpf_c043_3 0) vcvs gain=8.314696123025e-01
SCONVI_c043_3_01 (conv_i_src_c043_3_01 conv_i_c043_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_01 (conv_q_src_c043_3_01 0 conv_bpf_c043_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_3_01 (conv_q_src_c043_3_01 conv_q_c043_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_02 (conv_i_src_c043_3_02 0 conv_bpf_c043_3 0) vcvs gain=5.555702330196e-01
SCONVI_c043_3_02 (conv_i_src_c043_3_02 conv_i_c043_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_02 (conv_q_src_c043_3_02 0 conv_bpf_c043_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_3_02 (conv_q_src_c043_3_02 conv_q_c043_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_03 (conv_i_src_c043_3_03 0 conv_bpf_c043_3 0) vcvs gain=1.950903220161e-01
SCONVI_c043_3_03 (conv_i_src_c043_3_03 conv_i_c043_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_03 (conv_q_src_c043_3_03 0 conv_bpf_c043_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_3_03 (conv_q_src_c043_3_03 conv_q_c043_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_04 (conv_i_src_c043_3_04 0 conv_bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_3_04 (conv_i_src_c043_3_04 conv_i_c043_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_04 (conv_q_src_c043_3_04 0 conv_bpf_c043_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c043_3_04 (conv_q_src_c043_3_04 conv_q_c043_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_05 (conv_i_src_c043_3_05 0 conv_bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_3_05 (conv_i_src_c043_3_05 conv_i_c043_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_05 (conv_q_src_c043_3_05 0 conv_bpf_c043_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c043_3_05 (conv_q_src_c043_3_05 conv_q_c043_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_06 (conv_i_src_c043_3_06 0 conv_bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_3_06 (conv_i_src_c043_3_06 conv_i_c043_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_06 (conv_q_src_c043_3_06 0 conv_bpf_c043_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c043_3_06 (conv_q_src_c043_3_06 conv_q_c043_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_07 (conv_i_src_c043_3_07 0 conv_bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_3_07 (conv_i_src_c043_3_07 conv_i_c043_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_07 (conv_q_src_c043_3_07 0 conv_bpf_c043_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c043_3_07 (conv_q_src_c043_3_07 conv_q_c043_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_08 (conv_i_src_c043_3_08 0 conv_bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c043_3_08 (conv_i_src_c043_3_08 conv_i_c043_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_08 (conv_q_src_c043_3_08 0 conv_bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_3_08 (conv_q_src_c043_3_08 conv_q_c043_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_09 (conv_i_src_c043_3_09 0 conv_bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c043_3_09 (conv_i_src_c043_3_09 conv_i_c043_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_09 (conv_q_src_c043_3_09 0 conv_bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_3_09 (conv_q_src_c043_3_09 conv_q_c043_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_10 (conv_i_src_c043_3_10 0 conv_bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c043_3_10 (conv_i_src_c043_3_10 conv_i_c043_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_10 (conv_q_src_c043_3_10 0 conv_bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_3_10 (conv_q_src_c043_3_10 conv_q_c043_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_11 (conv_i_src_c043_3_11 0 conv_bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c043_3_11 (conv_i_src_c043_3_11 conv_i_c043_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_11 (conv_q_src_c043_3_11 0 conv_bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_3_11 (conv_q_src_c043_3_11 conv_q_c043_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_12 (conv_i_src_c043_3_12 0 conv_bpf_c043_3 0) vcvs gain=1.950903220161e-01
SCONVI_c043_3_12 (conv_i_src_c043_3_12 conv_i_c043_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_12 (conv_q_src_c043_3_12 0 conv_bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c043_3_12 (conv_q_src_c043_3_12 conv_q_c043_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_13 (conv_i_src_c043_3_13 0 conv_bpf_c043_3 0) vcvs gain=5.555702330196e-01
SCONVI_c043_3_13 (conv_i_src_c043_3_13 conv_i_c043_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_13 (conv_q_src_c043_3_13 0 conv_bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c043_3_13 (conv_q_src_c043_3_13 conv_q_c043_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_14 (conv_i_src_c043_3_14 0 conv_bpf_c043_3 0) vcvs gain=8.314696123025e-01
SCONVI_c043_3_14 (conv_i_src_c043_3_14 conv_i_c043_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_14 (conv_q_src_c043_3_14 0 conv_bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c043_3_14 (conv_q_src_c043_3_14 conv_q_c043_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c043_3_15 (conv_i_src_c043_3_15 0 conv_bpf_c043_3 0) vcvs gain=9.807852804032e-01
SCONVI_c043_3_15 (conv_i_src_c043_3_15 conv_i_c043_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c043_3_15 (conv_q_src_c043_3_15 0 conv_bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c043_3_15 (conv_q_src_c043_3_15 conv_q_c043_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c043_3 (conv_i_c043_3 0) resistor r=1G
RCONVQ_c043_3 (conv_q_c043_3 0) resistor r=1G
RCONVINTI_c043_3 (conv_i_c043_3 ConvIcar_c043_3) resistor r=1k
CCONVINTI_c043_3 (ConvIcar_c043_3 0) capacitor c=80p
RCONVINTQ_c043_3 (conv_q_c043_3 ConvQcar_c043_3) resistor r=1k
CCONVINTQ_c043_3 (ConvQcar_c043_3 0) capacitor c=80p
save conv_bpf_c043_3 ConvIcar_c043_3 ConvQcar_c043_3

// conventional mixed baseline bl044, carrier_0: 250000000 Hz
CCONVBPF_c044_0 (bl044 n_conv_cbpf_c044_0) capacitor c=4.052847345694e-13
LCONVBPF_c044_0 (n_conv_cbpf_c044_0 conv_bpf_c044_0) inductor l=1.000000000000e-06
RCONVBPF_c044_0 (conv_bpf_c044_0 0) resistor r=7.853981633974e+01
ECONVI_c044_0_00 (conv_i_src_c044_0_00 0 conv_bpf_c044_0 0) vcvs gain=9.807852804032e-01
SCONVI_c044_0_00 (conv_i_src_c044_0_00 conv_i_c044_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_00 (conv_q_src_c044_0_00 0 conv_bpf_c044_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_0_00 (conv_q_src_c044_0_00 conv_q_c044_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_01 (conv_i_src_c044_0_01 0 conv_bpf_c044_0 0) vcvs gain=8.314696123025e-01
SCONVI_c044_0_01 (conv_i_src_c044_0_01 conv_i_c044_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_01 (conv_q_src_c044_0_01 0 conv_bpf_c044_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_0_01 (conv_q_src_c044_0_01 conv_q_c044_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_02 (conv_i_src_c044_0_02 0 conv_bpf_c044_0 0) vcvs gain=5.555702330196e-01
SCONVI_c044_0_02 (conv_i_src_c044_0_02 conv_i_c044_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_02 (conv_q_src_c044_0_02 0 conv_bpf_c044_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_0_02 (conv_q_src_c044_0_02 conv_q_c044_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_03 (conv_i_src_c044_0_03 0 conv_bpf_c044_0 0) vcvs gain=1.950903220161e-01
SCONVI_c044_0_03 (conv_i_src_c044_0_03 conv_i_c044_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_03 (conv_q_src_c044_0_03 0 conv_bpf_c044_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_0_03 (conv_q_src_c044_0_03 conv_q_c044_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_04 (conv_i_src_c044_0_04 0 conv_bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_0_04 (conv_i_src_c044_0_04 conv_i_c044_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_04 (conv_q_src_c044_0_04 0 conv_bpf_c044_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_0_04 (conv_q_src_c044_0_04 conv_q_c044_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_05 (conv_i_src_c044_0_05 0 conv_bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_0_05 (conv_i_src_c044_0_05 conv_i_c044_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_05 (conv_q_src_c044_0_05 0 conv_bpf_c044_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_0_05 (conv_q_src_c044_0_05 conv_q_c044_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_06 (conv_i_src_c044_0_06 0 conv_bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_0_06 (conv_i_src_c044_0_06 conv_i_c044_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_06 (conv_q_src_c044_0_06 0 conv_bpf_c044_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_0_06 (conv_q_src_c044_0_06 conv_q_c044_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_07 (conv_i_src_c044_0_07 0 conv_bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_0_07 (conv_i_src_c044_0_07 conv_i_c044_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_07 (conv_q_src_c044_0_07 0 conv_bpf_c044_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_0_07 (conv_q_src_c044_0_07 conv_q_c044_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_08 (conv_i_src_c044_0_08 0 conv_bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_0_08 (conv_i_src_c044_0_08 conv_i_c044_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_08 (conv_q_src_c044_0_08 0 conv_bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_0_08 (conv_q_src_c044_0_08 conv_q_c044_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_09 (conv_i_src_c044_0_09 0 conv_bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_0_09 (conv_i_src_c044_0_09 conv_i_c044_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_09 (conv_q_src_c044_0_09 0 conv_bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_0_09 (conv_q_src_c044_0_09 conv_q_c044_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_10 (conv_i_src_c044_0_10 0 conv_bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_0_10 (conv_i_src_c044_0_10 conv_i_c044_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_10 (conv_q_src_c044_0_10 0 conv_bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_0_10 (conv_q_src_c044_0_10 conv_q_c044_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_11 (conv_i_src_c044_0_11 0 conv_bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_0_11 (conv_i_src_c044_0_11 conv_i_c044_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_11 (conv_q_src_c044_0_11 0 conv_bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_0_11 (conv_q_src_c044_0_11 conv_q_c044_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_12 (conv_i_src_c044_0_12 0 conv_bpf_c044_0 0) vcvs gain=1.950903220161e-01
SCONVI_c044_0_12 (conv_i_src_c044_0_12 conv_i_c044_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_12 (conv_q_src_c044_0_12 0 conv_bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_0_12 (conv_q_src_c044_0_12 conv_q_c044_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_13 (conv_i_src_c044_0_13 0 conv_bpf_c044_0 0) vcvs gain=5.555702330196e-01
SCONVI_c044_0_13 (conv_i_src_c044_0_13 conv_i_c044_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_13 (conv_q_src_c044_0_13 0 conv_bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_0_13 (conv_q_src_c044_0_13 conv_q_c044_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_14 (conv_i_src_c044_0_14 0 conv_bpf_c044_0 0) vcvs gain=8.314696123025e-01
SCONVI_c044_0_14 (conv_i_src_c044_0_14 conv_i_c044_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_14 (conv_q_src_c044_0_14 0 conv_bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_0_14 (conv_q_src_c044_0_14 conv_q_c044_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_0_15 (conv_i_src_c044_0_15 0 conv_bpf_c044_0 0) vcvs gain=9.807852804032e-01
SCONVI_c044_0_15 (conv_i_src_c044_0_15 conv_i_c044_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_0_15 (conv_q_src_c044_0_15 0 conv_bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_0_15 (conv_q_src_c044_0_15 conv_q_c044_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c044_0 (conv_i_c044_0 0) resistor r=1G
RCONVQ_c044_0 (conv_q_c044_0 0) resistor r=1G
RCONVINTI_c044_0 (conv_i_c044_0 ConvIcar_c044_0) resistor r=1k
CCONVINTI_c044_0 (ConvIcar_c044_0 0) capacitor c=80p
RCONVINTQ_c044_0 (conv_q_c044_0 ConvQcar_c044_0) resistor r=1k
CCONVINTQ_c044_0 (ConvQcar_c044_0 0) capacitor c=80p
save conv_bpf_c044_0 ConvIcar_c044_0 ConvQcar_c044_0

// conventional mixed baseline bl044, carrier_1: 500000000 Hz
CCONVBPF_c044_1 (bl044 n_conv_cbpf_c044_1) capacitor c=1.013211836423e-13
LCONVBPF_c044_1 (n_conv_cbpf_c044_1 conv_bpf_c044_1) inductor l=1.000000000000e-06
RCONVBPF_c044_1 (conv_bpf_c044_1 0) resistor r=1.570796326795e+02
ECONVI_c044_1_00 (conv_i_src_c044_1_00 0 conv_bpf_c044_1 0) vcvs gain=9.807852804032e-01
SCONVI_c044_1_00 (conv_i_src_c044_1_00 conv_i_c044_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_00 (conv_q_src_c044_1_00 0 conv_bpf_c044_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_1_00 (conv_q_src_c044_1_00 conv_q_c044_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_01 (conv_i_src_c044_1_01 0 conv_bpf_c044_1 0) vcvs gain=8.314696123025e-01
SCONVI_c044_1_01 (conv_i_src_c044_1_01 conv_i_c044_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_01 (conv_q_src_c044_1_01 0 conv_bpf_c044_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_1_01 (conv_q_src_c044_1_01 conv_q_c044_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_02 (conv_i_src_c044_1_02 0 conv_bpf_c044_1 0) vcvs gain=5.555702330196e-01
SCONVI_c044_1_02 (conv_i_src_c044_1_02 conv_i_c044_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_02 (conv_q_src_c044_1_02 0 conv_bpf_c044_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_1_02 (conv_q_src_c044_1_02 conv_q_c044_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_03 (conv_i_src_c044_1_03 0 conv_bpf_c044_1 0) vcvs gain=1.950903220161e-01
SCONVI_c044_1_03 (conv_i_src_c044_1_03 conv_i_c044_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_03 (conv_q_src_c044_1_03 0 conv_bpf_c044_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_1_03 (conv_q_src_c044_1_03 conv_q_c044_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_04 (conv_i_src_c044_1_04 0 conv_bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_1_04 (conv_i_src_c044_1_04 conv_i_c044_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_04 (conv_q_src_c044_1_04 0 conv_bpf_c044_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_1_04 (conv_q_src_c044_1_04 conv_q_c044_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_05 (conv_i_src_c044_1_05 0 conv_bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_1_05 (conv_i_src_c044_1_05 conv_i_c044_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_05 (conv_q_src_c044_1_05 0 conv_bpf_c044_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_1_05 (conv_q_src_c044_1_05 conv_q_c044_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_06 (conv_i_src_c044_1_06 0 conv_bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_1_06 (conv_i_src_c044_1_06 conv_i_c044_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_06 (conv_q_src_c044_1_06 0 conv_bpf_c044_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_1_06 (conv_q_src_c044_1_06 conv_q_c044_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_07 (conv_i_src_c044_1_07 0 conv_bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_1_07 (conv_i_src_c044_1_07 conv_i_c044_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_07 (conv_q_src_c044_1_07 0 conv_bpf_c044_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_1_07 (conv_q_src_c044_1_07 conv_q_c044_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_08 (conv_i_src_c044_1_08 0 conv_bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_1_08 (conv_i_src_c044_1_08 conv_i_c044_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_08 (conv_q_src_c044_1_08 0 conv_bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_1_08 (conv_q_src_c044_1_08 conv_q_c044_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_09 (conv_i_src_c044_1_09 0 conv_bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_1_09 (conv_i_src_c044_1_09 conv_i_c044_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_09 (conv_q_src_c044_1_09 0 conv_bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_1_09 (conv_q_src_c044_1_09 conv_q_c044_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_10 (conv_i_src_c044_1_10 0 conv_bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_1_10 (conv_i_src_c044_1_10 conv_i_c044_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_10 (conv_q_src_c044_1_10 0 conv_bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_1_10 (conv_q_src_c044_1_10 conv_q_c044_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_11 (conv_i_src_c044_1_11 0 conv_bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_1_11 (conv_i_src_c044_1_11 conv_i_c044_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_11 (conv_q_src_c044_1_11 0 conv_bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_1_11 (conv_q_src_c044_1_11 conv_q_c044_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_12 (conv_i_src_c044_1_12 0 conv_bpf_c044_1 0) vcvs gain=1.950903220161e-01
SCONVI_c044_1_12 (conv_i_src_c044_1_12 conv_i_c044_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_12 (conv_q_src_c044_1_12 0 conv_bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_1_12 (conv_q_src_c044_1_12 conv_q_c044_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_13 (conv_i_src_c044_1_13 0 conv_bpf_c044_1 0) vcvs gain=5.555702330196e-01
SCONVI_c044_1_13 (conv_i_src_c044_1_13 conv_i_c044_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_13 (conv_q_src_c044_1_13 0 conv_bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_1_13 (conv_q_src_c044_1_13 conv_q_c044_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_14 (conv_i_src_c044_1_14 0 conv_bpf_c044_1 0) vcvs gain=8.314696123025e-01
SCONVI_c044_1_14 (conv_i_src_c044_1_14 conv_i_c044_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_14 (conv_q_src_c044_1_14 0 conv_bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_1_14 (conv_q_src_c044_1_14 conv_q_c044_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_1_15 (conv_i_src_c044_1_15 0 conv_bpf_c044_1 0) vcvs gain=9.807852804032e-01
SCONVI_c044_1_15 (conv_i_src_c044_1_15 conv_i_c044_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_1_15 (conv_q_src_c044_1_15 0 conv_bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_1_15 (conv_q_src_c044_1_15 conv_q_c044_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c044_1 (conv_i_c044_1 0) resistor r=1G
RCONVQ_c044_1 (conv_q_c044_1 0) resistor r=1G
RCONVINTI_c044_1 (conv_i_c044_1 ConvIcar_c044_1) resistor r=1k
CCONVINTI_c044_1 (ConvIcar_c044_1 0) capacitor c=80p
RCONVINTQ_c044_1 (conv_q_c044_1 ConvQcar_c044_1) resistor r=1k
CCONVINTQ_c044_1 (ConvQcar_c044_1 0) capacitor c=80p
save conv_bpf_c044_1 ConvIcar_c044_1 ConvQcar_c044_1

// conventional mixed baseline bl044, carrier_2: 750000000 Hz
CCONVBPF_c044_2 (bl044 n_conv_cbpf_c044_2) capacitor c=4.503163717437e-14
LCONVBPF_c044_2 (n_conv_cbpf_c044_2 conv_bpf_c044_2) inductor l=1.000000000000e-06
RCONVBPF_c044_2 (conv_bpf_c044_2 0) resistor r=2.356194490192e+02
ECONVI_c044_2_00 (conv_i_src_c044_2_00 0 conv_bpf_c044_2 0) vcvs gain=9.807852804032e-01
SCONVI_c044_2_00 (conv_i_src_c044_2_00 conv_i_c044_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_00 (conv_q_src_c044_2_00 0 conv_bpf_c044_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_2_00 (conv_q_src_c044_2_00 conv_q_c044_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_01 (conv_i_src_c044_2_01 0 conv_bpf_c044_2 0) vcvs gain=8.314696123025e-01
SCONVI_c044_2_01 (conv_i_src_c044_2_01 conv_i_c044_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_01 (conv_q_src_c044_2_01 0 conv_bpf_c044_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_2_01 (conv_q_src_c044_2_01 conv_q_c044_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_02 (conv_i_src_c044_2_02 0 conv_bpf_c044_2 0) vcvs gain=5.555702330196e-01
SCONVI_c044_2_02 (conv_i_src_c044_2_02 conv_i_c044_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_02 (conv_q_src_c044_2_02 0 conv_bpf_c044_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_2_02 (conv_q_src_c044_2_02 conv_q_c044_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_03 (conv_i_src_c044_2_03 0 conv_bpf_c044_2 0) vcvs gain=1.950903220161e-01
SCONVI_c044_2_03 (conv_i_src_c044_2_03 conv_i_c044_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_03 (conv_q_src_c044_2_03 0 conv_bpf_c044_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_2_03 (conv_q_src_c044_2_03 conv_q_c044_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_04 (conv_i_src_c044_2_04 0 conv_bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_2_04 (conv_i_src_c044_2_04 conv_i_c044_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_04 (conv_q_src_c044_2_04 0 conv_bpf_c044_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_2_04 (conv_q_src_c044_2_04 conv_q_c044_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_05 (conv_i_src_c044_2_05 0 conv_bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_2_05 (conv_i_src_c044_2_05 conv_i_c044_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_05 (conv_q_src_c044_2_05 0 conv_bpf_c044_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_2_05 (conv_q_src_c044_2_05 conv_q_c044_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_06 (conv_i_src_c044_2_06 0 conv_bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_2_06 (conv_i_src_c044_2_06 conv_i_c044_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_06 (conv_q_src_c044_2_06 0 conv_bpf_c044_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_2_06 (conv_q_src_c044_2_06 conv_q_c044_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_07 (conv_i_src_c044_2_07 0 conv_bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_2_07 (conv_i_src_c044_2_07 conv_i_c044_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_07 (conv_q_src_c044_2_07 0 conv_bpf_c044_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_2_07 (conv_q_src_c044_2_07 conv_q_c044_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_08 (conv_i_src_c044_2_08 0 conv_bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_2_08 (conv_i_src_c044_2_08 conv_i_c044_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_08 (conv_q_src_c044_2_08 0 conv_bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_2_08 (conv_q_src_c044_2_08 conv_q_c044_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_09 (conv_i_src_c044_2_09 0 conv_bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_2_09 (conv_i_src_c044_2_09 conv_i_c044_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_09 (conv_q_src_c044_2_09 0 conv_bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_2_09 (conv_q_src_c044_2_09 conv_q_c044_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_10 (conv_i_src_c044_2_10 0 conv_bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_2_10 (conv_i_src_c044_2_10 conv_i_c044_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_10 (conv_q_src_c044_2_10 0 conv_bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_2_10 (conv_q_src_c044_2_10 conv_q_c044_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_11 (conv_i_src_c044_2_11 0 conv_bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_2_11 (conv_i_src_c044_2_11 conv_i_c044_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_11 (conv_q_src_c044_2_11 0 conv_bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_2_11 (conv_q_src_c044_2_11 conv_q_c044_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_12 (conv_i_src_c044_2_12 0 conv_bpf_c044_2 0) vcvs gain=1.950903220161e-01
SCONVI_c044_2_12 (conv_i_src_c044_2_12 conv_i_c044_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_12 (conv_q_src_c044_2_12 0 conv_bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_2_12 (conv_q_src_c044_2_12 conv_q_c044_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_13 (conv_i_src_c044_2_13 0 conv_bpf_c044_2 0) vcvs gain=5.555702330196e-01
SCONVI_c044_2_13 (conv_i_src_c044_2_13 conv_i_c044_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_13 (conv_q_src_c044_2_13 0 conv_bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_2_13 (conv_q_src_c044_2_13 conv_q_c044_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_14 (conv_i_src_c044_2_14 0 conv_bpf_c044_2 0) vcvs gain=8.314696123025e-01
SCONVI_c044_2_14 (conv_i_src_c044_2_14 conv_i_c044_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_14 (conv_q_src_c044_2_14 0 conv_bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_2_14 (conv_q_src_c044_2_14 conv_q_c044_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_2_15 (conv_i_src_c044_2_15 0 conv_bpf_c044_2 0) vcvs gain=9.807852804032e-01
SCONVI_c044_2_15 (conv_i_src_c044_2_15 conv_i_c044_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_2_15 (conv_q_src_c044_2_15 0 conv_bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_2_15 (conv_q_src_c044_2_15 conv_q_c044_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c044_2 (conv_i_c044_2 0) resistor r=1G
RCONVQ_c044_2 (conv_q_c044_2 0) resistor r=1G
RCONVINTI_c044_2 (conv_i_c044_2 ConvIcar_c044_2) resistor r=1k
CCONVINTI_c044_2 (ConvIcar_c044_2 0) capacitor c=80p
RCONVINTQ_c044_2 (conv_q_c044_2 ConvQcar_c044_2) resistor r=1k
CCONVINTQ_c044_2 (ConvQcar_c044_2 0) capacitor c=80p
save conv_bpf_c044_2 ConvIcar_c044_2 ConvQcar_c044_2

// conventional mixed baseline bl044, carrier_3: 1000000000 Hz
CCONVBPF_c044_3 (bl044 n_conv_cbpf_c044_3) capacitor c=2.533029591058e-14
LCONVBPF_c044_3 (n_conv_cbpf_c044_3 conv_bpf_c044_3) inductor l=1.000000000000e-06
RCONVBPF_c044_3 (conv_bpf_c044_3 0) resistor r=3.141592653590e+02
ECONVI_c044_3_00 (conv_i_src_c044_3_00 0 conv_bpf_c044_3 0) vcvs gain=9.807852804032e-01
SCONVI_c044_3_00 (conv_i_src_c044_3_00 conv_i_c044_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_00 (conv_q_src_c044_3_00 0 conv_bpf_c044_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_3_00 (conv_q_src_c044_3_00 conv_q_c044_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_01 (conv_i_src_c044_3_01 0 conv_bpf_c044_3 0) vcvs gain=8.314696123025e-01
SCONVI_c044_3_01 (conv_i_src_c044_3_01 conv_i_c044_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_01 (conv_q_src_c044_3_01 0 conv_bpf_c044_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_3_01 (conv_q_src_c044_3_01 conv_q_c044_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_02 (conv_i_src_c044_3_02 0 conv_bpf_c044_3 0) vcvs gain=5.555702330196e-01
SCONVI_c044_3_02 (conv_i_src_c044_3_02 conv_i_c044_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_02 (conv_q_src_c044_3_02 0 conv_bpf_c044_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_3_02 (conv_q_src_c044_3_02 conv_q_c044_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_03 (conv_i_src_c044_3_03 0 conv_bpf_c044_3 0) vcvs gain=1.950903220161e-01
SCONVI_c044_3_03 (conv_i_src_c044_3_03 conv_i_c044_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_03 (conv_q_src_c044_3_03 0 conv_bpf_c044_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_3_03 (conv_q_src_c044_3_03 conv_q_c044_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_04 (conv_i_src_c044_3_04 0 conv_bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_3_04 (conv_i_src_c044_3_04 conv_i_c044_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_04 (conv_q_src_c044_3_04 0 conv_bpf_c044_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c044_3_04 (conv_q_src_c044_3_04 conv_q_c044_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_05 (conv_i_src_c044_3_05 0 conv_bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_3_05 (conv_i_src_c044_3_05 conv_i_c044_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_05 (conv_q_src_c044_3_05 0 conv_bpf_c044_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c044_3_05 (conv_q_src_c044_3_05 conv_q_c044_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_06 (conv_i_src_c044_3_06 0 conv_bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_3_06 (conv_i_src_c044_3_06 conv_i_c044_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_06 (conv_q_src_c044_3_06 0 conv_bpf_c044_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c044_3_06 (conv_q_src_c044_3_06 conv_q_c044_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_07 (conv_i_src_c044_3_07 0 conv_bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_3_07 (conv_i_src_c044_3_07 conv_i_c044_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_07 (conv_q_src_c044_3_07 0 conv_bpf_c044_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c044_3_07 (conv_q_src_c044_3_07 conv_q_c044_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_08 (conv_i_src_c044_3_08 0 conv_bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c044_3_08 (conv_i_src_c044_3_08 conv_i_c044_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_08 (conv_q_src_c044_3_08 0 conv_bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_3_08 (conv_q_src_c044_3_08 conv_q_c044_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_09 (conv_i_src_c044_3_09 0 conv_bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c044_3_09 (conv_i_src_c044_3_09 conv_i_c044_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_09 (conv_q_src_c044_3_09 0 conv_bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_3_09 (conv_q_src_c044_3_09 conv_q_c044_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_10 (conv_i_src_c044_3_10 0 conv_bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c044_3_10 (conv_i_src_c044_3_10 conv_i_c044_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_10 (conv_q_src_c044_3_10 0 conv_bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_3_10 (conv_q_src_c044_3_10 conv_q_c044_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_11 (conv_i_src_c044_3_11 0 conv_bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c044_3_11 (conv_i_src_c044_3_11 conv_i_c044_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_11 (conv_q_src_c044_3_11 0 conv_bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_3_11 (conv_q_src_c044_3_11 conv_q_c044_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_12 (conv_i_src_c044_3_12 0 conv_bpf_c044_3 0) vcvs gain=1.950903220161e-01
SCONVI_c044_3_12 (conv_i_src_c044_3_12 conv_i_c044_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_12 (conv_q_src_c044_3_12 0 conv_bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c044_3_12 (conv_q_src_c044_3_12 conv_q_c044_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_13 (conv_i_src_c044_3_13 0 conv_bpf_c044_3 0) vcvs gain=5.555702330196e-01
SCONVI_c044_3_13 (conv_i_src_c044_3_13 conv_i_c044_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_13 (conv_q_src_c044_3_13 0 conv_bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c044_3_13 (conv_q_src_c044_3_13 conv_q_c044_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_14 (conv_i_src_c044_3_14 0 conv_bpf_c044_3 0) vcvs gain=8.314696123025e-01
SCONVI_c044_3_14 (conv_i_src_c044_3_14 conv_i_c044_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_14 (conv_q_src_c044_3_14 0 conv_bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c044_3_14 (conv_q_src_c044_3_14 conv_q_c044_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c044_3_15 (conv_i_src_c044_3_15 0 conv_bpf_c044_3 0) vcvs gain=9.807852804032e-01
SCONVI_c044_3_15 (conv_i_src_c044_3_15 conv_i_c044_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c044_3_15 (conv_q_src_c044_3_15 0 conv_bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c044_3_15 (conv_q_src_c044_3_15 conv_q_c044_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c044_3 (conv_i_c044_3 0) resistor r=1G
RCONVQ_c044_3 (conv_q_c044_3 0) resistor r=1G
RCONVINTI_c044_3 (conv_i_c044_3 ConvIcar_c044_3) resistor r=1k
CCONVINTI_c044_3 (ConvIcar_c044_3 0) capacitor c=80p
RCONVINTQ_c044_3 (conv_q_c044_3 ConvQcar_c044_3) resistor r=1k
CCONVINTQ_c044_3 (ConvQcar_c044_3 0) capacitor c=80p
save conv_bpf_c044_3 ConvIcar_c044_3 ConvQcar_c044_3

// conventional mixed baseline bl045, carrier_0: 250000000 Hz
CCONVBPF_c045_0 (bl045 n_conv_cbpf_c045_0) capacitor c=4.052847345694e-13
LCONVBPF_c045_0 (n_conv_cbpf_c045_0 conv_bpf_c045_0) inductor l=1.000000000000e-06
RCONVBPF_c045_0 (conv_bpf_c045_0 0) resistor r=7.853981633974e+01
ECONVI_c045_0_00 (conv_i_src_c045_0_00 0 conv_bpf_c045_0 0) vcvs gain=9.807852804032e-01
SCONVI_c045_0_00 (conv_i_src_c045_0_00 conv_i_c045_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_00 (conv_q_src_c045_0_00 0 conv_bpf_c045_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_0_00 (conv_q_src_c045_0_00 conv_q_c045_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_01 (conv_i_src_c045_0_01 0 conv_bpf_c045_0 0) vcvs gain=8.314696123025e-01
SCONVI_c045_0_01 (conv_i_src_c045_0_01 conv_i_c045_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_01 (conv_q_src_c045_0_01 0 conv_bpf_c045_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_0_01 (conv_q_src_c045_0_01 conv_q_c045_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_02 (conv_i_src_c045_0_02 0 conv_bpf_c045_0 0) vcvs gain=5.555702330196e-01
SCONVI_c045_0_02 (conv_i_src_c045_0_02 conv_i_c045_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_02 (conv_q_src_c045_0_02 0 conv_bpf_c045_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_0_02 (conv_q_src_c045_0_02 conv_q_c045_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_03 (conv_i_src_c045_0_03 0 conv_bpf_c045_0 0) vcvs gain=1.950903220161e-01
SCONVI_c045_0_03 (conv_i_src_c045_0_03 conv_i_c045_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_03 (conv_q_src_c045_0_03 0 conv_bpf_c045_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_0_03 (conv_q_src_c045_0_03 conv_q_c045_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_04 (conv_i_src_c045_0_04 0 conv_bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_0_04 (conv_i_src_c045_0_04 conv_i_c045_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_04 (conv_q_src_c045_0_04 0 conv_bpf_c045_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_0_04 (conv_q_src_c045_0_04 conv_q_c045_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_05 (conv_i_src_c045_0_05 0 conv_bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_0_05 (conv_i_src_c045_0_05 conv_i_c045_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_05 (conv_q_src_c045_0_05 0 conv_bpf_c045_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_0_05 (conv_q_src_c045_0_05 conv_q_c045_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_06 (conv_i_src_c045_0_06 0 conv_bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_0_06 (conv_i_src_c045_0_06 conv_i_c045_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_06 (conv_q_src_c045_0_06 0 conv_bpf_c045_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_0_06 (conv_q_src_c045_0_06 conv_q_c045_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_07 (conv_i_src_c045_0_07 0 conv_bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_0_07 (conv_i_src_c045_0_07 conv_i_c045_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_07 (conv_q_src_c045_0_07 0 conv_bpf_c045_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_0_07 (conv_q_src_c045_0_07 conv_q_c045_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_08 (conv_i_src_c045_0_08 0 conv_bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_0_08 (conv_i_src_c045_0_08 conv_i_c045_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_08 (conv_q_src_c045_0_08 0 conv_bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_0_08 (conv_q_src_c045_0_08 conv_q_c045_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_09 (conv_i_src_c045_0_09 0 conv_bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_0_09 (conv_i_src_c045_0_09 conv_i_c045_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_09 (conv_q_src_c045_0_09 0 conv_bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_0_09 (conv_q_src_c045_0_09 conv_q_c045_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_10 (conv_i_src_c045_0_10 0 conv_bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_0_10 (conv_i_src_c045_0_10 conv_i_c045_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_10 (conv_q_src_c045_0_10 0 conv_bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_0_10 (conv_q_src_c045_0_10 conv_q_c045_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_11 (conv_i_src_c045_0_11 0 conv_bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_0_11 (conv_i_src_c045_0_11 conv_i_c045_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_11 (conv_q_src_c045_0_11 0 conv_bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_0_11 (conv_q_src_c045_0_11 conv_q_c045_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_12 (conv_i_src_c045_0_12 0 conv_bpf_c045_0 0) vcvs gain=1.950903220161e-01
SCONVI_c045_0_12 (conv_i_src_c045_0_12 conv_i_c045_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_12 (conv_q_src_c045_0_12 0 conv_bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_0_12 (conv_q_src_c045_0_12 conv_q_c045_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_13 (conv_i_src_c045_0_13 0 conv_bpf_c045_0 0) vcvs gain=5.555702330196e-01
SCONVI_c045_0_13 (conv_i_src_c045_0_13 conv_i_c045_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_13 (conv_q_src_c045_0_13 0 conv_bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_0_13 (conv_q_src_c045_0_13 conv_q_c045_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_14 (conv_i_src_c045_0_14 0 conv_bpf_c045_0 0) vcvs gain=8.314696123025e-01
SCONVI_c045_0_14 (conv_i_src_c045_0_14 conv_i_c045_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_14 (conv_q_src_c045_0_14 0 conv_bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_0_14 (conv_q_src_c045_0_14 conv_q_c045_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_0_15 (conv_i_src_c045_0_15 0 conv_bpf_c045_0 0) vcvs gain=9.807852804032e-01
SCONVI_c045_0_15 (conv_i_src_c045_0_15 conv_i_c045_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_0_15 (conv_q_src_c045_0_15 0 conv_bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_0_15 (conv_q_src_c045_0_15 conv_q_c045_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c045_0 (conv_i_c045_0 0) resistor r=1G
RCONVQ_c045_0 (conv_q_c045_0 0) resistor r=1G
RCONVINTI_c045_0 (conv_i_c045_0 ConvIcar_c045_0) resistor r=1k
CCONVINTI_c045_0 (ConvIcar_c045_0 0) capacitor c=80p
RCONVINTQ_c045_0 (conv_q_c045_0 ConvQcar_c045_0) resistor r=1k
CCONVINTQ_c045_0 (ConvQcar_c045_0 0) capacitor c=80p
save conv_bpf_c045_0 ConvIcar_c045_0 ConvQcar_c045_0

// conventional mixed baseline bl045, carrier_1: 500000000 Hz
CCONVBPF_c045_1 (bl045 n_conv_cbpf_c045_1) capacitor c=1.013211836423e-13
LCONVBPF_c045_1 (n_conv_cbpf_c045_1 conv_bpf_c045_1) inductor l=1.000000000000e-06
RCONVBPF_c045_1 (conv_bpf_c045_1 0) resistor r=1.570796326795e+02
ECONVI_c045_1_00 (conv_i_src_c045_1_00 0 conv_bpf_c045_1 0) vcvs gain=9.807852804032e-01
SCONVI_c045_1_00 (conv_i_src_c045_1_00 conv_i_c045_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_00 (conv_q_src_c045_1_00 0 conv_bpf_c045_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_1_00 (conv_q_src_c045_1_00 conv_q_c045_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_01 (conv_i_src_c045_1_01 0 conv_bpf_c045_1 0) vcvs gain=8.314696123025e-01
SCONVI_c045_1_01 (conv_i_src_c045_1_01 conv_i_c045_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_01 (conv_q_src_c045_1_01 0 conv_bpf_c045_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_1_01 (conv_q_src_c045_1_01 conv_q_c045_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_02 (conv_i_src_c045_1_02 0 conv_bpf_c045_1 0) vcvs gain=5.555702330196e-01
SCONVI_c045_1_02 (conv_i_src_c045_1_02 conv_i_c045_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_02 (conv_q_src_c045_1_02 0 conv_bpf_c045_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_1_02 (conv_q_src_c045_1_02 conv_q_c045_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_03 (conv_i_src_c045_1_03 0 conv_bpf_c045_1 0) vcvs gain=1.950903220161e-01
SCONVI_c045_1_03 (conv_i_src_c045_1_03 conv_i_c045_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_03 (conv_q_src_c045_1_03 0 conv_bpf_c045_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_1_03 (conv_q_src_c045_1_03 conv_q_c045_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_04 (conv_i_src_c045_1_04 0 conv_bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_1_04 (conv_i_src_c045_1_04 conv_i_c045_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_04 (conv_q_src_c045_1_04 0 conv_bpf_c045_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_1_04 (conv_q_src_c045_1_04 conv_q_c045_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_05 (conv_i_src_c045_1_05 0 conv_bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_1_05 (conv_i_src_c045_1_05 conv_i_c045_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_05 (conv_q_src_c045_1_05 0 conv_bpf_c045_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_1_05 (conv_q_src_c045_1_05 conv_q_c045_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_06 (conv_i_src_c045_1_06 0 conv_bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_1_06 (conv_i_src_c045_1_06 conv_i_c045_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_06 (conv_q_src_c045_1_06 0 conv_bpf_c045_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_1_06 (conv_q_src_c045_1_06 conv_q_c045_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_07 (conv_i_src_c045_1_07 0 conv_bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_1_07 (conv_i_src_c045_1_07 conv_i_c045_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_07 (conv_q_src_c045_1_07 0 conv_bpf_c045_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_1_07 (conv_q_src_c045_1_07 conv_q_c045_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_08 (conv_i_src_c045_1_08 0 conv_bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_1_08 (conv_i_src_c045_1_08 conv_i_c045_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_08 (conv_q_src_c045_1_08 0 conv_bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_1_08 (conv_q_src_c045_1_08 conv_q_c045_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_09 (conv_i_src_c045_1_09 0 conv_bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_1_09 (conv_i_src_c045_1_09 conv_i_c045_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_09 (conv_q_src_c045_1_09 0 conv_bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_1_09 (conv_q_src_c045_1_09 conv_q_c045_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_10 (conv_i_src_c045_1_10 0 conv_bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_1_10 (conv_i_src_c045_1_10 conv_i_c045_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_10 (conv_q_src_c045_1_10 0 conv_bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_1_10 (conv_q_src_c045_1_10 conv_q_c045_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_11 (conv_i_src_c045_1_11 0 conv_bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_1_11 (conv_i_src_c045_1_11 conv_i_c045_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_11 (conv_q_src_c045_1_11 0 conv_bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_1_11 (conv_q_src_c045_1_11 conv_q_c045_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_12 (conv_i_src_c045_1_12 0 conv_bpf_c045_1 0) vcvs gain=1.950903220161e-01
SCONVI_c045_1_12 (conv_i_src_c045_1_12 conv_i_c045_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_12 (conv_q_src_c045_1_12 0 conv_bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_1_12 (conv_q_src_c045_1_12 conv_q_c045_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_13 (conv_i_src_c045_1_13 0 conv_bpf_c045_1 0) vcvs gain=5.555702330196e-01
SCONVI_c045_1_13 (conv_i_src_c045_1_13 conv_i_c045_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_13 (conv_q_src_c045_1_13 0 conv_bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_1_13 (conv_q_src_c045_1_13 conv_q_c045_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_14 (conv_i_src_c045_1_14 0 conv_bpf_c045_1 0) vcvs gain=8.314696123025e-01
SCONVI_c045_1_14 (conv_i_src_c045_1_14 conv_i_c045_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_14 (conv_q_src_c045_1_14 0 conv_bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_1_14 (conv_q_src_c045_1_14 conv_q_c045_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_1_15 (conv_i_src_c045_1_15 0 conv_bpf_c045_1 0) vcvs gain=9.807852804032e-01
SCONVI_c045_1_15 (conv_i_src_c045_1_15 conv_i_c045_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_1_15 (conv_q_src_c045_1_15 0 conv_bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_1_15 (conv_q_src_c045_1_15 conv_q_c045_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c045_1 (conv_i_c045_1 0) resistor r=1G
RCONVQ_c045_1 (conv_q_c045_1 0) resistor r=1G
RCONVINTI_c045_1 (conv_i_c045_1 ConvIcar_c045_1) resistor r=1k
CCONVINTI_c045_1 (ConvIcar_c045_1 0) capacitor c=80p
RCONVINTQ_c045_1 (conv_q_c045_1 ConvQcar_c045_1) resistor r=1k
CCONVINTQ_c045_1 (ConvQcar_c045_1 0) capacitor c=80p
save conv_bpf_c045_1 ConvIcar_c045_1 ConvQcar_c045_1

// conventional mixed baseline bl045, carrier_2: 750000000 Hz
CCONVBPF_c045_2 (bl045 n_conv_cbpf_c045_2) capacitor c=4.503163717437e-14
LCONVBPF_c045_2 (n_conv_cbpf_c045_2 conv_bpf_c045_2) inductor l=1.000000000000e-06
RCONVBPF_c045_2 (conv_bpf_c045_2 0) resistor r=2.356194490192e+02
ECONVI_c045_2_00 (conv_i_src_c045_2_00 0 conv_bpf_c045_2 0) vcvs gain=9.807852804032e-01
SCONVI_c045_2_00 (conv_i_src_c045_2_00 conv_i_c045_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_00 (conv_q_src_c045_2_00 0 conv_bpf_c045_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_2_00 (conv_q_src_c045_2_00 conv_q_c045_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_01 (conv_i_src_c045_2_01 0 conv_bpf_c045_2 0) vcvs gain=8.314696123025e-01
SCONVI_c045_2_01 (conv_i_src_c045_2_01 conv_i_c045_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_01 (conv_q_src_c045_2_01 0 conv_bpf_c045_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_2_01 (conv_q_src_c045_2_01 conv_q_c045_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_02 (conv_i_src_c045_2_02 0 conv_bpf_c045_2 0) vcvs gain=5.555702330196e-01
SCONVI_c045_2_02 (conv_i_src_c045_2_02 conv_i_c045_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_02 (conv_q_src_c045_2_02 0 conv_bpf_c045_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_2_02 (conv_q_src_c045_2_02 conv_q_c045_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_03 (conv_i_src_c045_2_03 0 conv_bpf_c045_2 0) vcvs gain=1.950903220161e-01
SCONVI_c045_2_03 (conv_i_src_c045_2_03 conv_i_c045_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_03 (conv_q_src_c045_2_03 0 conv_bpf_c045_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_2_03 (conv_q_src_c045_2_03 conv_q_c045_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_04 (conv_i_src_c045_2_04 0 conv_bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_2_04 (conv_i_src_c045_2_04 conv_i_c045_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_04 (conv_q_src_c045_2_04 0 conv_bpf_c045_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_2_04 (conv_q_src_c045_2_04 conv_q_c045_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_05 (conv_i_src_c045_2_05 0 conv_bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_2_05 (conv_i_src_c045_2_05 conv_i_c045_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_05 (conv_q_src_c045_2_05 0 conv_bpf_c045_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_2_05 (conv_q_src_c045_2_05 conv_q_c045_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_06 (conv_i_src_c045_2_06 0 conv_bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_2_06 (conv_i_src_c045_2_06 conv_i_c045_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_06 (conv_q_src_c045_2_06 0 conv_bpf_c045_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_2_06 (conv_q_src_c045_2_06 conv_q_c045_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_07 (conv_i_src_c045_2_07 0 conv_bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_2_07 (conv_i_src_c045_2_07 conv_i_c045_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_07 (conv_q_src_c045_2_07 0 conv_bpf_c045_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_2_07 (conv_q_src_c045_2_07 conv_q_c045_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_08 (conv_i_src_c045_2_08 0 conv_bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_2_08 (conv_i_src_c045_2_08 conv_i_c045_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_08 (conv_q_src_c045_2_08 0 conv_bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_2_08 (conv_q_src_c045_2_08 conv_q_c045_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_09 (conv_i_src_c045_2_09 0 conv_bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_2_09 (conv_i_src_c045_2_09 conv_i_c045_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_09 (conv_q_src_c045_2_09 0 conv_bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_2_09 (conv_q_src_c045_2_09 conv_q_c045_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_10 (conv_i_src_c045_2_10 0 conv_bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_2_10 (conv_i_src_c045_2_10 conv_i_c045_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_10 (conv_q_src_c045_2_10 0 conv_bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_2_10 (conv_q_src_c045_2_10 conv_q_c045_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_11 (conv_i_src_c045_2_11 0 conv_bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_2_11 (conv_i_src_c045_2_11 conv_i_c045_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_11 (conv_q_src_c045_2_11 0 conv_bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_2_11 (conv_q_src_c045_2_11 conv_q_c045_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_12 (conv_i_src_c045_2_12 0 conv_bpf_c045_2 0) vcvs gain=1.950903220161e-01
SCONVI_c045_2_12 (conv_i_src_c045_2_12 conv_i_c045_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_12 (conv_q_src_c045_2_12 0 conv_bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_2_12 (conv_q_src_c045_2_12 conv_q_c045_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_13 (conv_i_src_c045_2_13 0 conv_bpf_c045_2 0) vcvs gain=5.555702330196e-01
SCONVI_c045_2_13 (conv_i_src_c045_2_13 conv_i_c045_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_13 (conv_q_src_c045_2_13 0 conv_bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_2_13 (conv_q_src_c045_2_13 conv_q_c045_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_14 (conv_i_src_c045_2_14 0 conv_bpf_c045_2 0) vcvs gain=8.314696123025e-01
SCONVI_c045_2_14 (conv_i_src_c045_2_14 conv_i_c045_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_14 (conv_q_src_c045_2_14 0 conv_bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_2_14 (conv_q_src_c045_2_14 conv_q_c045_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_2_15 (conv_i_src_c045_2_15 0 conv_bpf_c045_2 0) vcvs gain=9.807852804032e-01
SCONVI_c045_2_15 (conv_i_src_c045_2_15 conv_i_c045_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_2_15 (conv_q_src_c045_2_15 0 conv_bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_2_15 (conv_q_src_c045_2_15 conv_q_c045_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c045_2 (conv_i_c045_2 0) resistor r=1G
RCONVQ_c045_2 (conv_q_c045_2 0) resistor r=1G
RCONVINTI_c045_2 (conv_i_c045_2 ConvIcar_c045_2) resistor r=1k
CCONVINTI_c045_2 (ConvIcar_c045_2 0) capacitor c=80p
RCONVINTQ_c045_2 (conv_q_c045_2 ConvQcar_c045_2) resistor r=1k
CCONVINTQ_c045_2 (ConvQcar_c045_2 0) capacitor c=80p
save conv_bpf_c045_2 ConvIcar_c045_2 ConvQcar_c045_2

// conventional mixed baseline bl045, carrier_3: 1000000000 Hz
CCONVBPF_c045_3 (bl045 n_conv_cbpf_c045_3) capacitor c=2.533029591058e-14
LCONVBPF_c045_3 (n_conv_cbpf_c045_3 conv_bpf_c045_3) inductor l=1.000000000000e-06
RCONVBPF_c045_3 (conv_bpf_c045_3 0) resistor r=3.141592653590e+02
ECONVI_c045_3_00 (conv_i_src_c045_3_00 0 conv_bpf_c045_3 0) vcvs gain=9.807852804032e-01
SCONVI_c045_3_00 (conv_i_src_c045_3_00 conv_i_c045_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_00 (conv_q_src_c045_3_00 0 conv_bpf_c045_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_3_00 (conv_q_src_c045_3_00 conv_q_c045_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_01 (conv_i_src_c045_3_01 0 conv_bpf_c045_3 0) vcvs gain=8.314696123025e-01
SCONVI_c045_3_01 (conv_i_src_c045_3_01 conv_i_c045_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_01 (conv_q_src_c045_3_01 0 conv_bpf_c045_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_3_01 (conv_q_src_c045_3_01 conv_q_c045_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_02 (conv_i_src_c045_3_02 0 conv_bpf_c045_3 0) vcvs gain=5.555702330196e-01
SCONVI_c045_3_02 (conv_i_src_c045_3_02 conv_i_c045_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_02 (conv_q_src_c045_3_02 0 conv_bpf_c045_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_3_02 (conv_q_src_c045_3_02 conv_q_c045_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_03 (conv_i_src_c045_3_03 0 conv_bpf_c045_3 0) vcvs gain=1.950903220161e-01
SCONVI_c045_3_03 (conv_i_src_c045_3_03 conv_i_c045_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_03 (conv_q_src_c045_3_03 0 conv_bpf_c045_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_3_03 (conv_q_src_c045_3_03 conv_q_c045_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_04 (conv_i_src_c045_3_04 0 conv_bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_3_04 (conv_i_src_c045_3_04 conv_i_c045_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_04 (conv_q_src_c045_3_04 0 conv_bpf_c045_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c045_3_04 (conv_q_src_c045_3_04 conv_q_c045_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_05 (conv_i_src_c045_3_05 0 conv_bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_3_05 (conv_i_src_c045_3_05 conv_i_c045_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_05 (conv_q_src_c045_3_05 0 conv_bpf_c045_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c045_3_05 (conv_q_src_c045_3_05 conv_q_c045_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_06 (conv_i_src_c045_3_06 0 conv_bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_3_06 (conv_i_src_c045_3_06 conv_i_c045_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_06 (conv_q_src_c045_3_06 0 conv_bpf_c045_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c045_3_06 (conv_q_src_c045_3_06 conv_q_c045_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_07 (conv_i_src_c045_3_07 0 conv_bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_3_07 (conv_i_src_c045_3_07 conv_i_c045_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_07 (conv_q_src_c045_3_07 0 conv_bpf_c045_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c045_3_07 (conv_q_src_c045_3_07 conv_q_c045_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_08 (conv_i_src_c045_3_08 0 conv_bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c045_3_08 (conv_i_src_c045_3_08 conv_i_c045_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_08 (conv_q_src_c045_3_08 0 conv_bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_3_08 (conv_q_src_c045_3_08 conv_q_c045_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_09 (conv_i_src_c045_3_09 0 conv_bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c045_3_09 (conv_i_src_c045_3_09 conv_i_c045_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_09 (conv_q_src_c045_3_09 0 conv_bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_3_09 (conv_q_src_c045_3_09 conv_q_c045_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_10 (conv_i_src_c045_3_10 0 conv_bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c045_3_10 (conv_i_src_c045_3_10 conv_i_c045_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_10 (conv_q_src_c045_3_10 0 conv_bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_3_10 (conv_q_src_c045_3_10 conv_q_c045_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_11 (conv_i_src_c045_3_11 0 conv_bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c045_3_11 (conv_i_src_c045_3_11 conv_i_c045_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_11 (conv_q_src_c045_3_11 0 conv_bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_3_11 (conv_q_src_c045_3_11 conv_q_c045_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_12 (conv_i_src_c045_3_12 0 conv_bpf_c045_3 0) vcvs gain=1.950903220161e-01
SCONVI_c045_3_12 (conv_i_src_c045_3_12 conv_i_c045_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_12 (conv_q_src_c045_3_12 0 conv_bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c045_3_12 (conv_q_src_c045_3_12 conv_q_c045_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_13 (conv_i_src_c045_3_13 0 conv_bpf_c045_3 0) vcvs gain=5.555702330196e-01
SCONVI_c045_3_13 (conv_i_src_c045_3_13 conv_i_c045_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_13 (conv_q_src_c045_3_13 0 conv_bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c045_3_13 (conv_q_src_c045_3_13 conv_q_c045_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_14 (conv_i_src_c045_3_14 0 conv_bpf_c045_3 0) vcvs gain=8.314696123025e-01
SCONVI_c045_3_14 (conv_i_src_c045_3_14 conv_i_c045_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_14 (conv_q_src_c045_3_14 0 conv_bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c045_3_14 (conv_q_src_c045_3_14 conv_q_c045_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c045_3_15 (conv_i_src_c045_3_15 0 conv_bpf_c045_3 0) vcvs gain=9.807852804032e-01
SCONVI_c045_3_15 (conv_i_src_c045_3_15 conv_i_c045_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c045_3_15 (conv_q_src_c045_3_15 0 conv_bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c045_3_15 (conv_q_src_c045_3_15 conv_q_c045_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c045_3 (conv_i_c045_3 0) resistor r=1G
RCONVQ_c045_3 (conv_q_c045_3 0) resistor r=1G
RCONVINTI_c045_3 (conv_i_c045_3 ConvIcar_c045_3) resistor r=1k
CCONVINTI_c045_3 (ConvIcar_c045_3 0) capacitor c=80p
RCONVINTQ_c045_3 (conv_q_c045_3 ConvQcar_c045_3) resistor r=1k
CCONVINTQ_c045_3 (ConvQcar_c045_3 0) capacitor c=80p
save conv_bpf_c045_3 ConvIcar_c045_3 ConvQcar_c045_3

// conventional mixed baseline bl046, carrier_0: 250000000 Hz
CCONVBPF_c046_0 (bl046 n_conv_cbpf_c046_0) capacitor c=4.052847345694e-13
LCONVBPF_c046_0 (n_conv_cbpf_c046_0 conv_bpf_c046_0) inductor l=1.000000000000e-06
RCONVBPF_c046_0 (conv_bpf_c046_0 0) resistor r=7.853981633974e+01
ECONVI_c046_0_00 (conv_i_src_c046_0_00 0 conv_bpf_c046_0 0) vcvs gain=9.807852804032e-01
SCONVI_c046_0_00 (conv_i_src_c046_0_00 conv_i_c046_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_00 (conv_q_src_c046_0_00 0 conv_bpf_c046_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_0_00 (conv_q_src_c046_0_00 conv_q_c046_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_01 (conv_i_src_c046_0_01 0 conv_bpf_c046_0 0) vcvs gain=8.314696123025e-01
SCONVI_c046_0_01 (conv_i_src_c046_0_01 conv_i_c046_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_01 (conv_q_src_c046_0_01 0 conv_bpf_c046_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_0_01 (conv_q_src_c046_0_01 conv_q_c046_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_02 (conv_i_src_c046_0_02 0 conv_bpf_c046_0 0) vcvs gain=5.555702330196e-01
SCONVI_c046_0_02 (conv_i_src_c046_0_02 conv_i_c046_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_02 (conv_q_src_c046_0_02 0 conv_bpf_c046_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_0_02 (conv_q_src_c046_0_02 conv_q_c046_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_03 (conv_i_src_c046_0_03 0 conv_bpf_c046_0 0) vcvs gain=1.950903220161e-01
SCONVI_c046_0_03 (conv_i_src_c046_0_03 conv_i_c046_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_03 (conv_q_src_c046_0_03 0 conv_bpf_c046_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_0_03 (conv_q_src_c046_0_03 conv_q_c046_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_04 (conv_i_src_c046_0_04 0 conv_bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_0_04 (conv_i_src_c046_0_04 conv_i_c046_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_04 (conv_q_src_c046_0_04 0 conv_bpf_c046_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_0_04 (conv_q_src_c046_0_04 conv_q_c046_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_05 (conv_i_src_c046_0_05 0 conv_bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_0_05 (conv_i_src_c046_0_05 conv_i_c046_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_05 (conv_q_src_c046_0_05 0 conv_bpf_c046_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_0_05 (conv_q_src_c046_0_05 conv_q_c046_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_06 (conv_i_src_c046_0_06 0 conv_bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_0_06 (conv_i_src_c046_0_06 conv_i_c046_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_06 (conv_q_src_c046_0_06 0 conv_bpf_c046_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_0_06 (conv_q_src_c046_0_06 conv_q_c046_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_07 (conv_i_src_c046_0_07 0 conv_bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_0_07 (conv_i_src_c046_0_07 conv_i_c046_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_07 (conv_q_src_c046_0_07 0 conv_bpf_c046_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_0_07 (conv_q_src_c046_0_07 conv_q_c046_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_08 (conv_i_src_c046_0_08 0 conv_bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_0_08 (conv_i_src_c046_0_08 conv_i_c046_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_08 (conv_q_src_c046_0_08 0 conv_bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_0_08 (conv_q_src_c046_0_08 conv_q_c046_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_09 (conv_i_src_c046_0_09 0 conv_bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_0_09 (conv_i_src_c046_0_09 conv_i_c046_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_09 (conv_q_src_c046_0_09 0 conv_bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_0_09 (conv_q_src_c046_0_09 conv_q_c046_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_10 (conv_i_src_c046_0_10 0 conv_bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_0_10 (conv_i_src_c046_0_10 conv_i_c046_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_10 (conv_q_src_c046_0_10 0 conv_bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_0_10 (conv_q_src_c046_0_10 conv_q_c046_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_11 (conv_i_src_c046_0_11 0 conv_bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_0_11 (conv_i_src_c046_0_11 conv_i_c046_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_11 (conv_q_src_c046_0_11 0 conv_bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_0_11 (conv_q_src_c046_0_11 conv_q_c046_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_12 (conv_i_src_c046_0_12 0 conv_bpf_c046_0 0) vcvs gain=1.950903220161e-01
SCONVI_c046_0_12 (conv_i_src_c046_0_12 conv_i_c046_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_12 (conv_q_src_c046_0_12 0 conv_bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_0_12 (conv_q_src_c046_0_12 conv_q_c046_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_13 (conv_i_src_c046_0_13 0 conv_bpf_c046_0 0) vcvs gain=5.555702330196e-01
SCONVI_c046_0_13 (conv_i_src_c046_0_13 conv_i_c046_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_13 (conv_q_src_c046_0_13 0 conv_bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_0_13 (conv_q_src_c046_0_13 conv_q_c046_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_14 (conv_i_src_c046_0_14 0 conv_bpf_c046_0 0) vcvs gain=8.314696123025e-01
SCONVI_c046_0_14 (conv_i_src_c046_0_14 conv_i_c046_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_14 (conv_q_src_c046_0_14 0 conv_bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_0_14 (conv_q_src_c046_0_14 conv_q_c046_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_0_15 (conv_i_src_c046_0_15 0 conv_bpf_c046_0 0) vcvs gain=9.807852804032e-01
SCONVI_c046_0_15 (conv_i_src_c046_0_15 conv_i_c046_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_0_15 (conv_q_src_c046_0_15 0 conv_bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_0_15 (conv_q_src_c046_0_15 conv_q_c046_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c046_0 (conv_i_c046_0 0) resistor r=1G
RCONVQ_c046_0 (conv_q_c046_0 0) resistor r=1G
RCONVINTI_c046_0 (conv_i_c046_0 ConvIcar_c046_0) resistor r=1k
CCONVINTI_c046_0 (ConvIcar_c046_0 0) capacitor c=80p
RCONVINTQ_c046_0 (conv_q_c046_0 ConvQcar_c046_0) resistor r=1k
CCONVINTQ_c046_0 (ConvQcar_c046_0 0) capacitor c=80p
save conv_bpf_c046_0 ConvIcar_c046_0 ConvQcar_c046_0

// conventional mixed baseline bl046, carrier_1: 500000000 Hz
CCONVBPF_c046_1 (bl046 n_conv_cbpf_c046_1) capacitor c=1.013211836423e-13
LCONVBPF_c046_1 (n_conv_cbpf_c046_1 conv_bpf_c046_1) inductor l=1.000000000000e-06
RCONVBPF_c046_1 (conv_bpf_c046_1 0) resistor r=1.570796326795e+02
ECONVI_c046_1_00 (conv_i_src_c046_1_00 0 conv_bpf_c046_1 0) vcvs gain=9.807852804032e-01
SCONVI_c046_1_00 (conv_i_src_c046_1_00 conv_i_c046_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_00 (conv_q_src_c046_1_00 0 conv_bpf_c046_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_1_00 (conv_q_src_c046_1_00 conv_q_c046_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_01 (conv_i_src_c046_1_01 0 conv_bpf_c046_1 0) vcvs gain=8.314696123025e-01
SCONVI_c046_1_01 (conv_i_src_c046_1_01 conv_i_c046_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_01 (conv_q_src_c046_1_01 0 conv_bpf_c046_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_1_01 (conv_q_src_c046_1_01 conv_q_c046_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_02 (conv_i_src_c046_1_02 0 conv_bpf_c046_1 0) vcvs gain=5.555702330196e-01
SCONVI_c046_1_02 (conv_i_src_c046_1_02 conv_i_c046_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_02 (conv_q_src_c046_1_02 0 conv_bpf_c046_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_1_02 (conv_q_src_c046_1_02 conv_q_c046_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_03 (conv_i_src_c046_1_03 0 conv_bpf_c046_1 0) vcvs gain=1.950903220161e-01
SCONVI_c046_1_03 (conv_i_src_c046_1_03 conv_i_c046_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_03 (conv_q_src_c046_1_03 0 conv_bpf_c046_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_1_03 (conv_q_src_c046_1_03 conv_q_c046_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_04 (conv_i_src_c046_1_04 0 conv_bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_1_04 (conv_i_src_c046_1_04 conv_i_c046_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_04 (conv_q_src_c046_1_04 0 conv_bpf_c046_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_1_04 (conv_q_src_c046_1_04 conv_q_c046_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_05 (conv_i_src_c046_1_05 0 conv_bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_1_05 (conv_i_src_c046_1_05 conv_i_c046_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_05 (conv_q_src_c046_1_05 0 conv_bpf_c046_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_1_05 (conv_q_src_c046_1_05 conv_q_c046_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_06 (conv_i_src_c046_1_06 0 conv_bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_1_06 (conv_i_src_c046_1_06 conv_i_c046_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_06 (conv_q_src_c046_1_06 0 conv_bpf_c046_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_1_06 (conv_q_src_c046_1_06 conv_q_c046_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_07 (conv_i_src_c046_1_07 0 conv_bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_1_07 (conv_i_src_c046_1_07 conv_i_c046_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_07 (conv_q_src_c046_1_07 0 conv_bpf_c046_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_1_07 (conv_q_src_c046_1_07 conv_q_c046_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_08 (conv_i_src_c046_1_08 0 conv_bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_1_08 (conv_i_src_c046_1_08 conv_i_c046_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_08 (conv_q_src_c046_1_08 0 conv_bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_1_08 (conv_q_src_c046_1_08 conv_q_c046_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_09 (conv_i_src_c046_1_09 0 conv_bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_1_09 (conv_i_src_c046_1_09 conv_i_c046_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_09 (conv_q_src_c046_1_09 0 conv_bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_1_09 (conv_q_src_c046_1_09 conv_q_c046_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_10 (conv_i_src_c046_1_10 0 conv_bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_1_10 (conv_i_src_c046_1_10 conv_i_c046_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_10 (conv_q_src_c046_1_10 0 conv_bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_1_10 (conv_q_src_c046_1_10 conv_q_c046_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_11 (conv_i_src_c046_1_11 0 conv_bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_1_11 (conv_i_src_c046_1_11 conv_i_c046_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_11 (conv_q_src_c046_1_11 0 conv_bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_1_11 (conv_q_src_c046_1_11 conv_q_c046_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_12 (conv_i_src_c046_1_12 0 conv_bpf_c046_1 0) vcvs gain=1.950903220161e-01
SCONVI_c046_1_12 (conv_i_src_c046_1_12 conv_i_c046_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_12 (conv_q_src_c046_1_12 0 conv_bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_1_12 (conv_q_src_c046_1_12 conv_q_c046_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_13 (conv_i_src_c046_1_13 0 conv_bpf_c046_1 0) vcvs gain=5.555702330196e-01
SCONVI_c046_1_13 (conv_i_src_c046_1_13 conv_i_c046_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_13 (conv_q_src_c046_1_13 0 conv_bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_1_13 (conv_q_src_c046_1_13 conv_q_c046_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_14 (conv_i_src_c046_1_14 0 conv_bpf_c046_1 0) vcvs gain=8.314696123025e-01
SCONVI_c046_1_14 (conv_i_src_c046_1_14 conv_i_c046_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_14 (conv_q_src_c046_1_14 0 conv_bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_1_14 (conv_q_src_c046_1_14 conv_q_c046_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_1_15 (conv_i_src_c046_1_15 0 conv_bpf_c046_1 0) vcvs gain=9.807852804032e-01
SCONVI_c046_1_15 (conv_i_src_c046_1_15 conv_i_c046_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_1_15 (conv_q_src_c046_1_15 0 conv_bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_1_15 (conv_q_src_c046_1_15 conv_q_c046_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c046_1 (conv_i_c046_1 0) resistor r=1G
RCONVQ_c046_1 (conv_q_c046_1 0) resistor r=1G
RCONVINTI_c046_1 (conv_i_c046_1 ConvIcar_c046_1) resistor r=1k
CCONVINTI_c046_1 (ConvIcar_c046_1 0) capacitor c=80p
RCONVINTQ_c046_1 (conv_q_c046_1 ConvQcar_c046_1) resistor r=1k
CCONVINTQ_c046_1 (ConvQcar_c046_1 0) capacitor c=80p
save conv_bpf_c046_1 ConvIcar_c046_1 ConvQcar_c046_1

// conventional mixed baseline bl046, carrier_2: 750000000 Hz
CCONVBPF_c046_2 (bl046 n_conv_cbpf_c046_2) capacitor c=4.503163717437e-14
LCONVBPF_c046_2 (n_conv_cbpf_c046_2 conv_bpf_c046_2) inductor l=1.000000000000e-06
RCONVBPF_c046_2 (conv_bpf_c046_2 0) resistor r=2.356194490192e+02
ECONVI_c046_2_00 (conv_i_src_c046_2_00 0 conv_bpf_c046_2 0) vcvs gain=9.807852804032e-01
SCONVI_c046_2_00 (conv_i_src_c046_2_00 conv_i_c046_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_00 (conv_q_src_c046_2_00 0 conv_bpf_c046_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_2_00 (conv_q_src_c046_2_00 conv_q_c046_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_01 (conv_i_src_c046_2_01 0 conv_bpf_c046_2 0) vcvs gain=8.314696123025e-01
SCONVI_c046_2_01 (conv_i_src_c046_2_01 conv_i_c046_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_01 (conv_q_src_c046_2_01 0 conv_bpf_c046_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_2_01 (conv_q_src_c046_2_01 conv_q_c046_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_02 (conv_i_src_c046_2_02 0 conv_bpf_c046_2 0) vcvs gain=5.555702330196e-01
SCONVI_c046_2_02 (conv_i_src_c046_2_02 conv_i_c046_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_02 (conv_q_src_c046_2_02 0 conv_bpf_c046_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_2_02 (conv_q_src_c046_2_02 conv_q_c046_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_03 (conv_i_src_c046_2_03 0 conv_bpf_c046_2 0) vcvs gain=1.950903220161e-01
SCONVI_c046_2_03 (conv_i_src_c046_2_03 conv_i_c046_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_03 (conv_q_src_c046_2_03 0 conv_bpf_c046_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_2_03 (conv_q_src_c046_2_03 conv_q_c046_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_04 (conv_i_src_c046_2_04 0 conv_bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_2_04 (conv_i_src_c046_2_04 conv_i_c046_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_04 (conv_q_src_c046_2_04 0 conv_bpf_c046_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_2_04 (conv_q_src_c046_2_04 conv_q_c046_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_05 (conv_i_src_c046_2_05 0 conv_bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_2_05 (conv_i_src_c046_2_05 conv_i_c046_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_05 (conv_q_src_c046_2_05 0 conv_bpf_c046_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_2_05 (conv_q_src_c046_2_05 conv_q_c046_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_06 (conv_i_src_c046_2_06 0 conv_bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_2_06 (conv_i_src_c046_2_06 conv_i_c046_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_06 (conv_q_src_c046_2_06 0 conv_bpf_c046_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_2_06 (conv_q_src_c046_2_06 conv_q_c046_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_07 (conv_i_src_c046_2_07 0 conv_bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_2_07 (conv_i_src_c046_2_07 conv_i_c046_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_07 (conv_q_src_c046_2_07 0 conv_bpf_c046_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_2_07 (conv_q_src_c046_2_07 conv_q_c046_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_08 (conv_i_src_c046_2_08 0 conv_bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_2_08 (conv_i_src_c046_2_08 conv_i_c046_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_08 (conv_q_src_c046_2_08 0 conv_bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_2_08 (conv_q_src_c046_2_08 conv_q_c046_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_09 (conv_i_src_c046_2_09 0 conv_bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_2_09 (conv_i_src_c046_2_09 conv_i_c046_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_09 (conv_q_src_c046_2_09 0 conv_bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_2_09 (conv_q_src_c046_2_09 conv_q_c046_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_10 (conv_i_src_c046_2_10 0 conv_bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_2_10 (conv_i_src_c046_2_10 conv_i_c046_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_10 (conv_q_src_c046_2_10 0 conv_bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_2_10 (conv_q_src_c046_2_10 conv_q_c046_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_11 (conv_i_src_c046_2_11 0 conv_bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_2_11 (conv_i_src_c046_2_11 conv_i_c046_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_11 (conv_q_src_c046_2_11 0 conv_bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_2_11 (conv_q_src_c046_2_11 conv_q_c046_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_12 (conv_i_src_c046_2_12 0 conv_bpf_c046_2 0) vcvs gain=1.950903220161e-01
SCONVI_c046_2_12 (conv_i_src_c046_2_12 conv_i_c046_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_12 (conv_q_src_c046_2_12 0 conv_bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_2_12 (conv_q_src_c046_2_12 conv_q_c046_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_13 (conv_i_src_c046_2_13 0 conv_bpf_c046_2 0) vcvs gain=5.555702330196e-01
SCONVI_c046_2_13 (conv_i_src_c046_2_13 conv_i_c046_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_13 (conv_q_src_c046_2_13 0 conv_bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_2_13 (conv_q_src_c046_2_13 conv_q_c046_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_14 (conv_i_src_c046_2_14 0 conv_bpf_c046_2 0) vcvs gain=8.314696123025e-01
SCONVI_c046_2_14 (conv_i_src_c046_2_14 conv_i_c046_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_14 (conv_q_src_c046_2_14 0 conv_bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_2_14 (conv_q_src_c046_2_14 conv_q_c046_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_2_15 (conv_i_src_c046_2_15 0 conv_bpf_c046_2 0) vcvs gain=9.807852804032e-01
SCONVI_c046_2_15 (conv_i_src_c046_2_15 conv_i_c046_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_2_15 (conv_q_src_c046_2_15 0 conv_bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_2_15 (conv_q_src_c046_2_15 conv_q_c046_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c046_2 (conv_i_c046_2 0) resistor r=1G
RCONVQ_c046_2 (conv_q_c046_2 0) resistor r=1G
RCONVINTI_c046_2 (conv_i_c046_2 ConvIcar_c046_2) resistor r=1k
CCONVINTI_c046_2 (ConvIcar_c046_2 0) capacitor c=80p
RCONVINTQ_c046_2 (conv_q_c046_2 ConvQcar_c046_2) resistor r=1k
CCONVINTQ_c046_2 (ConvQcar_c046_2 0) capacitor c=80p
save conv_bpf_c046_2 ConvIcar_c046_2 ConvQcar_c046_2

// conventional mixed baseline bl046, carrier_3: 1000000000 Hz
CCONVBPF_c046_3 (bl046 n_conv_cbpf_c046_3) capacitor c=2.533029591058e-14
LCONVBPF_c046_3 (n_conv_cbpf_c046_3 conv_bpf_c046_3) inductor l=1.000000000000e-06
RCONVBPF_c046_3 (conv_bpf_c046_3 0) resistor r=3.141592653590e+02
ECONVI_c046_3_00 (conv_i_src_c046_3_00 0 conv_bpf_c046_3 0) vcvs gain=9.807852804032e-01
SCONVI_c046_3_00 (conv_i_src_c046_3_00 conv_i_c046_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_00 (conv_q_src_c046_3_00 0 conv_bpf_c046_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_3_00 (conv_q_src_c046_3_00 conv_q_c046_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_01 (conv_i_src_c046_3_01 0 conv_bpf_c046_3 0) vcvs gain=8.314696123025e-01
SCONVI_c046_3_01 (conv_i_src_c046_3_01 conv_i_c046_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_01 (conv_q_src_c046_3_01 0 conv_bpf_c046_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_3_01 (conv_q_src_c046_3_01 conv_q_c046_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_02 (conv_i_src_c046_3_02 0 conv_bpf_c046_3 0) vcvs gain=5.555702330196e-01
SCONVI_c046_3_02 (conv_i_src_c046_3_02 conv_i_c046_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_02 (conv_q_src_c046_3_02 0 conv_bpf_c046_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_3_02 (conv_q_src_c046_3_02 conv_q_c046_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_03 (conv_i_src_c046_3_03 0 conv_bpf_c046_3 0) vcvs gain=1.950903220161e-01
SCONVI_c046_3_03 (conv_i_src_c046_3_03 conv_i_c046_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_03 (conv_q_src_c046_3_03 0 conv_bpf_c046_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_3_03 (conv_q_src_c046_3_03 conv_q_c046_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_04 (conv_i_src_c046_3_04 0 conv_bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_3_04 (conv_i_src_c046_3_04 conv_i_c046_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_04 (conv_q_src_c046_3_04 0 conv_bpf_c046_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c046_3_04 (conv_q_src_c046_3_04 conv_q_c046_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_05 (conv_i_src_c046_3_05 0 conv_bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_3_05 (conv_i_src_c046_3_05 conv_i_c046_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_05 (conv_q_src_c046_3_05 0 conv_bpf_c046_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c046_3_05 (conv_q_src_c046_3_05 conv_q_c046_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_06 (conv_i_src_c046_3_06 0 conv_bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_3_06 (conv_i_src_c046_3_06 conv_i_c046_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_06 (conv_q_src_c046_3_06 0 conv_bpf_c046_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c046_3_06 (conv_q_src_c046_3_06 conv_q_c046_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_07 (conv_i_src_c046_3_07 0 conv_bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_3_07 (conv_i_src_c046_3_07 conv_i_c046_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_07 (conv_q_src_c046_3_07 0 conv_bpf_c046_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c046_3_07 (conv_q_src_c046_3_07 conv_q_c046_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_08 (conv_i_src_c046_3_08 0 conv_bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c046_3_08 (conv_i_src_c046_3_08 conv_i_c046_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_08 (conv_q_src_c046_3_08 0 conv_bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_3_08 (conv_q_src_c046_3_08 conv_q_c046_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_09 (conv_i_src_c046_3_09 0 conv_bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c046_3_09 (conv_i_src_c046_3_09 conv_i_c046_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_09 (conv_q_src_c046_3_09 0 conv_bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_3_09 (conv_q_src_c046_3_09 conv_q_c046_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_10 (conv_i_src_c046_3_10 0 conv_bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c046_3_10 (conv_i_src_c046_3_10 conv_i_c046_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_10 (conv_q_src_c046_3_10 0 conv_bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_3_10 (conv_q_src_c046_3_10 conv_q_c046_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_11 (conv_i_src_c046_3_11 0 conv_bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c046_3_11 (conv_i_src_c046_3_11 conv_i_c046_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_11 (conv_q_src_c046_3_11 0 conv_bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_3_11 (conv_q_src_c046_3_11 conv_q_c046_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_12 (conv_i_src_c046_3_12 0 conv_bpf_c046_3 0) vcvs gain=1.950903220161e-01
SCONVI_c046_3_12 (conv_i_src_c046_3_12 conv_i_c046_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_12 (conv_q_src_c046_3_12 0 conv_bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c046_3_12 (conv_q_src_c046_3_12 conv_q_c046_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_13 (conv_i_src_c046_3_13 0 conv_bpf_c046_3 0) vcvs gain=5.555702330196e-01
SCONVI_c046_3_13 (conv_i_src_c046_3_13 conv_i_c046_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_13 (conv_q_src_c046_3_13 0 conv_bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c046_3_13 (conv_q_src_c046_3_13 conv_q_c046_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_14 (conv_i_src_c046_3_14 0 conv_bpf_c046_3 0) vcvs gain=8.314696123025e-01
SCONVI_c046_3_14 (conv_i_src_c046_3_14 conv_i_c046_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_14 (conv_q_src_c046_3_14 0 conv_bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c046_3_14 (conv_q_src_c046_3_14 conv_q_c046_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c046_3_15 (conv_i_src_c046_3_15 0 conv_bpf_c046_3 0) vcvs gain=9.807852804032e-01
SCONVI_c046_3_15 (conv_i_src_c046_3_15 conv_i_c046_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c046_3_15 (conv_q_src_c046_3_15 0 conv_bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c046_3_15 (conv_q_src_c046_3_15 conv_q_c046_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c046_3 (conv_i_c046_3 0) resistor r=1G
RCONVQ_c046_3 (conv_q_c046_3 0) resistor r=1G
RCONVINTI_c046_3 (conv_i_c046_3 ConvIcar_c046_3) resistor r=1k
CCONVINTI_c046_3 (ConvIcar_c046_3 0) capacitor c=80p
RCONVINTQ_c046_3 (conv_q_c046_3 ConvQcar_c046_3) resistor r=1k
CCONVINTQ_c046_3 (ConvQcar_c046_3 0) capacitor c=80p
save conv_bpf_c046_3 ConvIcar_c046_3 ConvQcar_c046_3

// conventional mixed baseline bl047, carrier_0: 250000000 Hz
CCONVBPF_c047_0 (bl047 n_conv_cbpf_c047_0) capacitor c=4.052847345694e-13
LCONVBPF_c047_0 (n_conv_cbpf_c047_0 conv_bpf_c047_0) inductor l=1.000000000000e-06
RCONVBPF_c047_0 (conv_bpf_c047_0 0) resistor r=7.853981633974e+01
ECONVI_c047_0_00 (conv_i_src_c047_0_00 0 conv_bpf_c047_0 0) vcvs gain=9.807852804032e-01
SCONVI_c047_0_00 (conv_i_src_c047_0_00 conv_i_c047_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_00 (conv_q_src_c047_0_00 0 conv_bpf_c047_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_0_00 (conv_q_src_c047_0_00 conv_q_c047_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_01 (conv_i_src_c047_0_01 0 conv_bpf_c047_0 0) vcvs gain=8.314696123025e-01
SCONVI_c047_0_01 (conv_i_src_c047_0_01 conv_i_c047_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_01 (conv_q_src_c047_0_01 0 conv_bpf_c047_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_0_01 (conv_q_src_c047_0_01 conv_q_c047_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_02 (conv_i_src_c047_0_02 0 conv_bpf_c047_0 0) vcvs gain=5.555702330196e-01
SCONVI_c047_0_02 (conv_i_src_c047_0_02 conv_i_c047_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_02 (conv_q_src_c047_0_02 0 conv_bpf_c047_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_0_02 (conv_q_src_c047_0_02 conv_q_c047_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_03 (conv_i_src_c047_0_03 0 conv_bpf_c047_0 0) vcvs gain=1.950903220161e-01
SCONVI_c047_0_03 (conv_i_src_c047_0_03 conv_i_c047_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_03 (conv_q_src_c047_0_03 0 conv_bpf_c047_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_0_03 (conv_q_src_c047_0_03 conv_q_c047_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_04 (conv_i_src_c047_0_04 0 conv_bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_0_04 (conv_i_src_c047_0_04 conv_i_c047_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_04 (conv_q_src_c047_0_04 0 conv_bpf_c047_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_0_04 (conv_q_src_c047_0_04 conv_q_c047_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_05 (conv_i_src_c047_0_05 0 conv_bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_0_05 (conv_i_src_c047_0_05 conv_i_c047_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_05 (conv_q_src_c047_0_05 0 conv_bpf_c047_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_0_05 (conv_q_src_c047_0_05 conv_q_c047_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_06 (conv_i_src_c047_0_06 0 conv_bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_0_06 (conv_i_src_c047_0_06 conv_i_c047_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_06 (conv_q_src_c047_0_06 0 conv_bpf_c047_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_0_06 (conv_q_src_c047_0_06 conv_q_c047_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_07 (conv_i_src_c047_0_07 0 conv_bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_0_07 (conv_i_src_c047_0_07 conv_i_c047_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_07 (conv_q_src_c047_0_07 0 conv_bpf_c047_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_0_07 (conv_q_src_c047_0_07 conv_q_c047_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_08 (conv_i_src_c047_0_08 0 conv_bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_0_08 (conv_i_src_c047_0_08 conv_i_c047_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_08 (conv_q_src_c047_0_08 0 conv_bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_0_08 (conv_q_src_c047_0_08 conv_q_c047_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_09 (conv_i_src_c047_0_09 0 conv_bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_0_09 (conv_i_src_c047_0_09 conv_i_c047_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_09 (conv_q_src_c047_0_09 0 conv_bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_0_09 (conv_q_src_c047_0_09 conv_q_c047_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_10 (conv_i_src_c047_0_10 0 conv_bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_0_10 (conv_i_src_c047_0_10 conv_i_c047_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_10 (conv_q_src_c047_0_10 0 conv_bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_0_10 (conv_q_src_c047_0_10 conv_q_c047_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_11 (conv_i_src_c047_0_11 0 conv_bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_0_11 (conv_i_src_c047_0_11 conv_i_c047_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_11 (conv_q_src_c047_0_11 0 conv_bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_0_11 (conv_q_src_c047_0_11 conv_q_c047_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_12 (conv_i_src_c047_0_12 0 conv_bpf_c047_0 0) vcvs gain=1.950903220161e-01
SCONVI_c047_0_12 (conv_i_src_c047_0_12 conv_i_c047_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_12 (conv_q_src_c047_0_12 0 conv_bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_0_12 (conv_q_src_c047_0_12 conv_q_c047_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_13 (conv_i_src_c047_0_13 0 conv_bpf_c047_0 0) vcvs gain=5.555702330196e-01
SCONVI_c047_0_13 (conv_i_src_c047_0_13 conv_i_c047_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_13 (conv_q_src_c047_0_13 0 conv_bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_0_13 (conv_q_src_c047_0_13 conv_q_c047_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_14 (conv_i_src_c047_0_14 0 conv_bpf_c047_0 0) vcvs gain=8.314696123025e-01
SCONVI_c047_0_14 (conv_i_src_c047_0_14 conv_i_c047_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_14 (conv_q_src_c047_0_14 0 conv_bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_0_14 (conv_q_src_c047_0_14 conv_q_c047_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_0_15 (conv_i_src_c047_0_15 0 conv_bpf_c047_0 0) vcvs gain=9.807852804032e-01
SCONVI_c047_0_15 (conv_i_src_c047_0_15 conv_i_c047_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_0_15 (conv_q_src_c047_0_15 0 conv_bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_0_15 (conv_q_src_c047_0_15 conv_q_c047_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c047_0 (conv_i_c047_0 0) resistor r=1G
RCONVQ_c047_0 (conv_q_c047_0 0) resistor r=1G
RCONVINTI_c047_0 (conv_i_c047_0 ConvIcar_c047_0) resistor r=1k
CCONVINTI_c047_0 (ConvIcar_c047_0 0) capacitor c=80p
RCONVINTQ_c047_0 (conv_q_c047_0 ConvQcar_c047_0) resistor r=1k
CCONVINTQ_c047_0 (ConvQcar_c047_0 0) capacitor c=80p
save conv_bpf_c047_0 ConvIcar_c047_0 ConvQcar_c047_0

// conventional mixed baseline bl047, carrier_1: 500000000 Hz
CCONVBPF_c047_1 (bl047 n_conv_cbpf_c047_1) capacitor c=1.013211836423e-13
LCONVBPF_c047_1 (n_conv_cbpf_c047_1 conv_bpf_c047_1) inductor l=1.000000000000e-06
RCONVBPF_c047_1 (conv_bpf_c047_1 0) resistor r=1.570796326795e+02
ECONVI_c047_1_00 (conv_i_src_c047_1_00 0 conv_bpf_c047_1 0) vcvs gain=9.807852804032e-01
SCONVI_c047_1_00 (conv_i_src_c047_1_00 conv_i_c047_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_00 (conv_q_src_c047_1_00 0 conv_bpf_c047_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_1_00 (conv_q_src_c047_1_00 conv_q_c047_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_01 (conv_i_src_c047_1_01 0 conv_bpf_c047_1 0) vcvs gain=8.314696123025e-01
SCONVI_c047_1_01 (conv_i_src_c047_1_01 conv_i_c047_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_01 (conv_q_src_c047_1_01 0 conv_bpf_c047_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_1_01 (conv_q_src_c047_1_01 conv_q_c047_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_02 (conv_i_src_c047_1_02 0 conv_bpf_c047_1 0) vcvs gain=5.555702330196e-01
SCONVI_c047_1_02 (conv_i_src_c047_1_02 conv_i_c047_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_02 (conv_q_src_c047_1_02 0 conv_bpf_c047_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_1_02 (conv_q_src_c047_1_02 conv_q_c047_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_03 (conv_i_src_c047_1_03 0 conv_bpf_c047_1 0) vcvs gain=1.950903220161e-01
SCONVI_c047_1_03 (conv_i_src_c047_1_03 conv_i_c047_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_03 (conv_q_src_c047_1_03 0 conv_bpf_c047_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_1_03 (conv_q_src_c047_1_03 conv_q_c047_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_04 (conv_i_src_c047_1_04 0 conv_bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_1_04 (conv_i_src_c047_1_04 conv_i_c047_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_04 (conv_q_src_c047_1_04 0 conv_bpf_c047_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_1_04 (conv_q_src_c047_1_04 conv_q_c047_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_05 (conv_i_src_c047_1_05 0 conv_bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_1_05 (conv_i_src_c047_1_05 conv_i_c047_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_05 (conv_q_src_c047_1_05 0 conv_bpf_c047_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_1_05 (conv_q_src_c047_1_05 conv_q_c047_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_06 (conv_i_src_c047_1_06 0 conv_bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_1_06 (conv_i_src_c047_1_06 conv_i_c047_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_06 (conv_q_src_c047_1_06 0 conv_bpf_c047_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_1_06 (conv_q_src_c047_1_06 conv_q_c047_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_07 (conv_i_src_c047_1_07 0 conv_bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_1_07 (conv_i_src_c047_1_07 conv_i_c047_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_07 (conv_q_src_c047_1_07 0 conv_bpf_c047_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_1_07 (conv_q_src_c047_1_07 conv_q_c047_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_08 (conv_i_src_c047_1_08 0 conv_bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_1_08 (conv_i_src_c047_1_08 conv_i_c047_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_08 (conv_q_src_c047_1_08 0 conv_bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_1_08 (conv_q_src_c047_1_08 conv_q_c047_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_09 (conv_i_src_c047_1_09 0 conv_bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_1_09 (conv_i_src_c047_1_09 conv_i_c047_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_09 (conv_q_src_c047_1_09 0 conv_bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_1_09 (conv_q_src_c047_1_09 conv_q_c047_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_10 (conv_i_src_c047_1_10 0 conv_bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_1_10 (conv_i_src_c047_1_10 conv_i_c047_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_10 (conv_q_src_c047_1_10 0 conv_bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_1_10 (conv_q_src_c047_1_10 conv_q_c047_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_11 (conv_i_src_c047_1_11 0 conv_bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_1_11 (conv_i_src_c047_1_11 conv_i_c047_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_11 (conv_q_src_c047_1_11 0 conv_bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_1_11 (conv_q_src_c047_1_11 conv_q_c047_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_12 (conv_i_src_c047_1_12 0 conv_bpf_c047_1 0) vcvs gain=1.950903220161e-01
SCONVI_c047_1_12 (conv_i_src_c047_1_12 conv_i_c047_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_12 (conv_q_src_c047_1_12 0 conv_bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_1_12 (conv_q_src_c047_1_12 conv_q_c047_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_13 (conv_i_src_c047_1_13 0 conv_bpf_c047_1 0) vcvs gain=5.555702330196e-01
SCONVI_c047_1_13 (conv_i_src_c047_1_13 conv_i_c047_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_13 (conv_q_src_c047_1_13 0 conv_bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_1_13 (conv_q_src_c047_1_13 conv_q_c047_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_14 (conv_i_src_c047_1_14 0 conv_bpf_c047_1 0) vcvs gain=8.314696123025e-01
SCONVI_c047_1_14 (conv_i_src_c047_1_14 conv_i_c047_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_14 (conv_q_src_c047_1_14 0 conv_bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_1_14 (conv_q_src_c047_1_14 conv_q_c047_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_1_15 (conv_i_src_c047_1_15 0 conv_bpf_c047_1 0) vcvs gain=9.807852804032e-01
SCONVI_c047_1_15 (conv_i_src_c047_1_15 conv_i_c047_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_1_15 (conv_q_src_c047_1_15 0 conv_bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_1_15 (conv_q_src_c047_1_15 conv_q_c047_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c047_1 (conv_i_c047_1 0) resistor r=1G
RCONVQ_c047_1 (conv_q_c047_1 0) resistor r=1G
RCONVINTI_c047_1 (conv_i_c047_1 ConvIcar_c047_1) resistor r=1k
CCONVINTI_c047_1 (ConvIcar_c047_1 0) capacitor c=80p
RCONVINTQ_c047_1 (conv_q_c047_1 ConvQcar_c047_1) resistor r=1k
CCONVINTQ_c047_1 (ConvQcar_c047_1 0) capacitor c=80p
save conv_bpf_c047_1 ConvIcar_c047_1 ConvQcar_c047_1

// conventional mixed baseline bl047, carrier_2: 750000000 Hz
CCONVBPF_c047_2 (bl047 n_conv_cbpf_c047_2) capacitor c=4.503163717437e-14
LCONVBPF_c047_2 (n_conv_cbpf_c047_2 conv_bpf_c047_2) inductor l=1.000000000000e-06
RCONVBPF_c047_2 (conv_bpf_c047_2 0) resistor r=2.356194490192e+02
ECONVI_c047_2_00 (conv_i_src_c047_2_00 0 conv_bpf_c047_2 0) vcvs gain=9.807852804032e-01
SCONVI_c047_2_00 (conv_i_src_c047_2_00 conv_i_c047_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_00 (conv_q_src_c047_2_00 0 conv_bpf_c047_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_2_00 (conv_q_src_c047_2_00 conv_q_c047_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_01 (conv_i_src_c047_2_01 0 conv_bpf_c047_2 0) vcvs gain=8.314696123025e-01
SCONVI_c047_2_01 (conv_i_src_c047_2_01 conv_i_c047_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_01 (conv_q_src_c047_2_01 0 conv_bpf_c047_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_2_01 (conv_q_src_c047_2_01 conv_q_c047_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_02 (conv_i_src_c047_2_02 0 conv_bpf_c047_2 0) vcvs gain=5.555702330196e-01
SCONVI_c047_2_02 (conv_i_src_c047_2_02 conv_i_c047_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_02 (conv_q_src_c047_2_02 0 conv_bpf_c047_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_2_02 (conv_q_src_c047_2_02 conv_q_c047_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_03 (conv_i_src_c047_2_03 0 conv_bpf_c047_2 0) vcvs gain=1.950903220161e-01
SCONVI_c047_2_03 (conv_i_src_c047_2_03 conv_i_c047_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_03 (conv_q_src_c047_2_03 0 conv_bpf_c047_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_2_03 (conv_q_src_c047_2_03 conv_q_c047_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_04 (conv_i_src_c047_2_04 0 conv_bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_2_04 (conv_i_src_c047_2_04 conv_i_c047_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_04 (conv_q_src_c047_2_04 0 conv_bpf_c047_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_2_04 (conv_q_src_c047_2_04 conv_q_c047_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_05 (conv_i_src_c047_2_05 0 conv_bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_2_05 (conv_i_src_c047_2_05 conv_i_c047_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_05 (conv_q_src_c047_2_05 0 conv_bpf_c047_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_2_05 (conv_q_src_c047_2_05 conv_q_c047_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_06 (conv_i_src_c047_2_06 0 conv_bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_2_06 (conv_i_src_c047_2_06 conv_i_c047_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_06 (conv_q_src_c047_2_06 0 conv_bpf_c047_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_2_06 (conv_q_src_c047_2_06 conv_q_c047_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_07 (conv_i_src_c047_2_07 0 conv_bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_2_07 (conv_i_src_c047_2_07 conv_i_c047_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_07 (conv_q_src_c047_2_07 0 conv_bpf_c047_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_2_07 (conv_q_src_c047_2_07 conv_q_c047_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_08 (conv_i_src_c047_2_08 0 conv_bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_2_08 (conv_i_src_c047_2_08 conv_i_c047_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_08 (conv_q_src_c047_2_08 0 conv_bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_2_08 (conv_q_src_c047_2_08 conv_q_c047_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_09 (conv_i_src_c047_2_09 0 conv_bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_2_09 (conv_i_src_c047_2_09 conv_i_c047_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_09 (conv_q_src_c047_2_09 0 conv_bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_2_09 (conv_q_src_c047_2_09 conv_q_c047_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_10 (conv_i_src_c047_2_10 0 conv_bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_2_10 (conv_i_src_c047_2_10 conv_i_c047_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_10 (conv_q_src_c047_2_10 0 conv_bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_2_10 (conv_q_src_c047_2_10 conv_q_c047_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_11 (conv_i_src_c047_2_11 0 conv_bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_2_11 (conv_i_src_c047_2_11 conv_i_c047_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_11 (conv_q_src_c047_2_11 0 conv_bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_2_11 (conv_q_src_c047_2_11 conv_q_c047_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_12 (conv_i_src_c047_2_12 0 conv_bpf_c047_2 0) vcvs gain=1.950903220161e-01
SCONVI_c047_2_12 (conv_i_src_c047_2_12 conv_i_c047_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_12 (conv_q_src_c047_2_12 0 conv_bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_2_12 (conv_q_src_c047_2_12 conv_q_c047_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_13 (conv_i_src_c047_2_13 0 conv_bpf_c047_2 0) vcvs gain=5.555702330196e-01
SCONVI_c047_2_13 (conv_i_src_c047_2_13 conv_i_c047_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_13 (conv_q_src_c047_2_13 0 conv_bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_2_13 (conv_q_src_c047_2_13 conv_q_c047_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_14 (conv_i_src_c047_2_14 0 conv_bpf_c047_2 0) vcvs gain=8.314696123025e-01
SCONVI_c047_2_14 (conv_i_src_c047_2_14 conv_i_c047_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_14 (conv_q_src_c047_2_14 0 conv_bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_2_14 (conv_q_src_c047_2_14 conv_q_c047_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_2_15 (conv_i_src_c047_2_15 0 conv_bpf_c047_2 0) vcvs gain=9.807852804032e-01
SCONVI_c047_2_15 (conv_i_src_c047_2_15 conv_i_c047_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_2_15 (conv_q_src_c047_2_15 0 conv_bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_2_15 (conv_q_src_c047_2_15 conv_q_c047_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c047_2 (conv_i_c047_2 0) resistor r=1G
RCONVQ_c047_2 (conv_q_c047_2 0) resistor r=1G
RCONVINTI_c047_2 (conv_i_c047_2 ConvIcar_c047_2) resistor r=1k
CCONVINTI_c047_2 (ConvIcar_c047_2 0) capacitor c=80p
RCONVINTQ_c047_2 (conv_q_c047_2 ConvQcar_c047_2) resistor r=1k
CCONVINTQ_c047_2 (ConvQcar_c047_2 0) capacitor c=80p
save conv_bpf_c047_2 ConvIcar_c047_2 ConvQcar_c047_2

// conventional mixed baseline bl047, carrier_3: 1000000000 Hz
CCONVBPF_c047_3 (bl047 n_conv_cbpf_c047_3) capacitor c=2.533029591058e-14
LCONVBPF_c047_3 (n_conv_cbpf_c047_3 conv_bpf_c047_3) inductor l=1.000000000000e-06
RCONVBPF_c047_3 (conv_bpf_c047_3 0) resistor r=3.141592653590e+02
ECONVI_c047_3_00 (conv_i_src_c047_3_00 0 conv_bpf_c047_3 0) vcvs gain=9.807852804032e-01
SCONVI_c047_3_00 (conv_i_src_c047_3_00 conv_i_c047_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_00 (conv_q_src_c047_3_00 0 conv_bpf_c047_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_3_00 (conv_q_src_c047_3_00 conv_q_c047_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_01 (conv_i_src_c047_3_01 0 conv_bpf_c047_3 0) vcvs gain=8.314696123025e-01
SCONVI_c047_3_01 (conv_i_src_c047_3_01 conv_i_c047_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_01 (conv_q_src_c047_3_01 0 conv_bpf_c047_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_3_01 (conv_q_src_c047_3_01 conv_q_c047_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_02 (conv_i_src_c047_3_02 0 conv_bpf_c047_3 0) vcvs gain=5.555702330196e-01
SCONVI_c047_3_02 (conv_i_src_c047_3_02 conv_i_c047_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_02 (conv_q_src_c047_3_02 0 conv_bpf_c047_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_3_02 (conv_q_src_c047_3_02 conv_q_c047_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_03 (conv_i_src_c047_3_03 0 conv_bpf_c047_3 0) vcvs gain=1.950903220161e-01
SCONVI_c047_3_03 (conv_i_src_c047_3_03 conv_i_c047_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_03 (conv_q_src_c047_3_03 0 conv_bpf_c047_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_3_03 (conv_q_src_c047_3_03 conv_q_c047_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_04 (conv_i_src_c047_3_04 0 conv_bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_3_04 (conv_i_src_c047_3_04 conv_i_c047_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_04 (conv_q_src_c047_3_04 0 conv_bpf_c047_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c047_3_04 (conv_q_src_c047_3_04 conv_q_c047_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_05 (conv_i_src_c047_3_05 0 conv_bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_3_05 (conv_i_src_c047_3_05 conv_i_c047_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_05 (conv_q_src_c047_3_05 0 conv_bpf_c047_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c047_3_05 (conv_q_src_c047_3_05 conv_q_c047_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_06 (conv_i_src_c047_3_06 0 conv_bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_3_06 (conv_i_src_c047_3_06 conv_i_c047_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_06 (conv_q_src_c047_3_06 0 conv_bpf_c047_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c047_3_06 (conv_q_src_c047_3_06 conv_q_c047_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_07 (conv_i_src_c047_3_07 0 conv_bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_3_07 (conv_i_src_c047_3_07 conv_i_c047_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_07 (conv_q_src_c047_3_07 0 conv_bpf_c047_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c047_3_07 (conv_q_src_c047_3_07 conv_q_c047_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_08 (conv_i_src_c047_3_08 0 conv_bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c047_3_08 (conv_i_src_c047_3_08 conv_i_c047_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_08 (conv_q_src_c047_3_08 0 conv_bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_3_08 (conv_q_src_c047_3_08 conv_q_c047_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_09 (conv_i_src_c047_3_09 0 conv_bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c047_3_09 (conv_i_src_c047_3_09 conv_i_c047_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_09 (conv_q_src_c047_3_09 0 conv_bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_3_09 (conv_q_src_c047_3_09 conv_q_c047_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_10 (conv_i_src_c047_3_10 0 conv_bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c047_3_10 (conv_i_src_c047_3_10 conv_i_c047_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_10 (conv_q_src_c047_3_10 0 conv_bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_3_10 (conv_q_src_c047_3_10 conv_q_c047_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_11 (conv_i_src_c047_3_11 0 conv_bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c047_3_11 (conv_i_src_c047_3_11 conv_i_c047_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_11 (conv_q_src_c047_3_11 0 conv_bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_3_11 (conv_q_src_c047_3_11 conv_q_c047_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_12 (conv_i_src_c047_3_12 0 conv_bpf_c047_3 0) vcvs gain=1.950903220161e-01
SCONVI_c047_3_12 (conv_i_src_c047_3_12 conv_i_c047_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_12 (conv_q_src_c047_3_12 0 conv_bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c047_3_12 (conv_q_src_c047_3_12 conv_q_c047_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_13 (conv_i_src_c047_3_13 0 conv_bpf_c047_3 0) vcvs gain=5.555702330196e-01
SCONVI_c047_3_13 (conv_i_src_c047_3_13 conv_i_c047_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_13 (conv_q_src_c047_3_13 0 conv_bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c047_3_13 (conv_q_src_c047_3_13 conv_q_c047_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_14 (conv_i_src_c047_3_14 0 conv_bpf_c047_3 0) vcvs gain=8.314696123025e-01
SCONVI_c047_3_14 (conv_i_src_c047_3_14 conv_i_c047_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_14 (conv_q_src_c047_3_14 0 conv_bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c047_3_14 (conv_q_src_c047_3_14 conv_q_c047_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c047_3_15 (conv_i_src_c047_3_15 0 conv_bpf_c047_3 0) vcvs gain=9.807852804032e-01
SCONVI_c047_3_15 (conv_i_src_c047_3_15 conv_i_c047_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c047_3_15 (conv_q_src_c047_3_15 0 conv_bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c047_3_15 (conv_q_src_c047_3_15 conv_q_c047_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c047_3 (conv_i_c047_3 0) resistor r=1G
RCONVQ_c047_3 (conv_q_c047_3 0) resistor r=1G
RCONVINTI_c047_3 (conv_i_c047_3 ConvIcar_c047_3) resistor r=1k
CCONVINTI_c047_3 (ConvIcar_c047_3 0) capacitor c=80p
RCONVINTQ_c047_3 (conv_q_c047_3 ConvQcar_c047_3) resistor r=1k
CCONVINTQ_c047_3 (ConvQcar_c047_3 0) capacitor c=80p
save conv_bpf_c047_3 ConvIcar_c047_3 ConvQcar_c047_3

// conventional mixed baseline bl048, carrier_0: 250000000 Hz
CCONVBPF_c048_0 (bl048 n_conv_cbpf_c048_0) capacitor c=4.052847345694e-13
LCONVBPF_c048_0 (n_conv_cbpf_c048_0 conv_bpf_c048_0) inductor l=1.000000000000e-06
RCONVBPF_c048_0 (conv_bpf_c048_0 0) resistor r=7.853981633974e+01
ECONVI_c048_0_00 (conv_i_src_c048_0_00 0 conv_bpf_c048_0 0) vcvs gain=9.807852804032e-01
SCONVI_c048_0_00 (conv_i_src_c048_0_00 conv_i_c048_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_00 (conv_q_src_c048_0_00 0 conv_bpf_c048_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_0_00 (conv_q_src_c048_0_00 conv_q_c048_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_01 (conv_i_src_c048_0_01 0 conv_bpf_c048_0 0) vcvs gain=8.314696123025e-01
SCONVI_c048_0_01 (conv_i_src_c048_0_01 conv_i_c048_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_01 (conv_q_src_c048_0_01 0 conv_bpf_c048_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_0_01 (conv_q_src_c048_0_01 conv_q_c048_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_02 (conv_i_src_c048_0_02 0 conv_bpf_c048_0 0) vcvs gain=5.555702330196e-01
SCONVI_c048_0_02 (conv_i_src_c048_0_02 conv_i_c048_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_02 (conv_q_src_c048_0_02 0 conv_bpf_c048_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_0_02 (conv_q_src_c048_0_02 conv_q_c048_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_03 (conv_i_src_c048_0_03 0 conv_bpf_c048_0 0) vcvs gain=1.950903220161e-01
SCONVI_c048_0_03 (conv_i_src_c048_0_03 conv_i_c048_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_03 (conv_q_src_c048_0_03 0 conv_bpf_c048_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_0_03 (conv_q_src_c048_0_03 conv_q_c048_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_04 (conv_i_src_c048_0_04 0 conv_bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_0_04 (conv_i_src_c048_0_04 conv_i_c048_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_04 (conv_q_src_c048_0_04 0 conv_bpf_c048_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_0_04 (conv_q_src_c048_0_04 conv_q_c048_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_05 (conv_i_src_c048_0_05 0 conv_bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_0_05 (conv_i_src_c048_0_05 conv_i_c048_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_05 (conv_q_src_c048_0_05 0 conv_bpf_c048_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_0_05 (conv_q_src_c048_0_05 conv_q_c048_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_06 (conv_i_src_c048_0_06 0 conv_bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_0_06 (conv_i_src_c048_0_06 conv_i_c048_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_06 (conv_q_src_c048_0_06 0 conv_bpf_c048_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_0_06 (conv_q_src_c048_0_06 conv_q_c048_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_07 (conv_i_src_c048_0_07 0 conv_bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_0_07 (conv_i_src_c048_0_07 conv_i_c048_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_07 (conv_q_src_c048_0_07 0 conv_bpf_c048_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_0_07 (conv_q_src_c048_0_07 conv_q_c048_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_08 (conv_i_src_c048_0_08 0 conv_bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_0_08 (conv_i_src_c048_0_08 conv_i_c048_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_08 (conv_q_src_c048_0_08 0 conv_bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_0_08 (conv_q_src_c048_0_08 conv_q_c048_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_09 (conv_i_src_c048_0_09 0 conv_bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_0_09 (conv_i_src_c048_0_09 conv_i_c048_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_09 (conv_q_src_c048_0_09 0 conv_bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_0_09 (conv_q_src_c048_0_09 conv_q_c048_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_10 (conv_i_src_c048_0_10 0 conv_bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_0_10 (conv_i_src_c048_0_10 conv_i_c048_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_10 (conv_q_src_c048_0_10 0 conv_bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_0_10 (conv_q_src_c048_0_10 conv_q_c048_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_11 (conv_i_src_c048_0_11 0 conv_bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_0_11 (conv_i_src_c048_0_11 conv_i_c048_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_11 (conv_q_src_c048_0_11 0 conv_bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_0_11 (conv_q_src_c048_0_11 conv_q_c048_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_12 (conv_i_src_c048_0_12 0 conv_bpf_c048_0 0) vcvs gain=1.950903220161e-01
SCONVI_c048_0_12 (conv_i_src_c048_0_12 conv_i_c048_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_12 (conv_q_src_c048_0_12 0 conv_bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_0_12 (conv_q_src_c048_0_12 conv_q_c048_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_13 (conv_i_src_c048_0_13 0 conv_bpf_c048_0 0) vcvs gain=5.555702330196e-01
SCONVI_c048_0_13 (conv_i_src_c048_0_13 conv_i_c048_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_13 (conv_q_src_c048_0_13 0 conv_bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_0_13 (conv_q_src_c048_0_13 conv_q_c048_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_14 (conv_i_src_c048_0_14 0 conv_bpf_c048_0 0) vcvs gain=8.314696123025e-01
SCONVI_c048_0_14 (conv_i_src_c048_0_14 conv_i_c048_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_14 (conv_q_src_c048_0_14 0 conv_bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_0_14 (conv_q_src_c048_0_14 conv_q_c048_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_0_15 (conv_i_src_c048_0_15 0 conv_bpf_c048_0 0) vcvs gain=9.807852804032e-01
SCONVI_c048_0_15 (conv_i_src_c048_0_15 conv_i_c048_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_0_15 (conv_q_src_c048_0_15 0 conv_bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_0_15 (conv_q_src_c048_0_15 conv_q_c048_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c048_0 (conv_i_c048_0 0) resistor r=1G
RCONVQ_c048_0 (conv_q_c048_0 0) resistor r=1G
RCONVINTI_c048_0 (conv_i_c048_0 ConvIcar_c048_0) resistor r=1k
CCONVINTI_c048_0 (ConvIcar_c048_0 0) capacitor c=80p
RCONVINTQ_c048_0 (conv_q_c048_0 ConvQcar_c048_0) resistor r=1k
CCONVINTQ_c048_0 (ConvQcar_c048_0 0) capacitor c=80p
save conv_bpf_c048_0 ConvIcar_c048_0 ConvQcar_c048_0

// conventional mixed baseline bl048, carrier_1: 500000000 Hz
CCONVBPF_c048_1 (bl048 n_conv_cbpf_c048_1) capacitor c=1.013211836423e-13
LCONVBPF_c048_1 (n_conv_cbpf_c048_1 conv_bpf_c048_1) inductor l=1.000000000000e-06
RCONVBPF_c048_1 (conv_bpf_c048_1 0) resistor r=1.570796326795e+02
ECONVI_c048_1_00 (conv_i_src_c048_1_00 0 conv_bpf_c048_1 0) vcvs gain=9.807852804032e-01
SCONVI_c048_1_00 (conv_i_src_c048_1_00 conv_i_c048_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_00 (conv_q_src_c048_1_00 0 conv_bpf_c048_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_1_00 (conv_q_src_c048_1_00 conv_q_c048_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_01 (conv_i_src_c048_1_01 0 conv_bpf_c048_1 0) vcvs gain=8.314696123025e-01
SCONVI_c048_1_01 (conv_i_src_c048_1_01 conv_i_c048_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_01 (conv_q_src_c048_1_01 0 conv_bpf_c048_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_1_01 (conv_q_src_c048_1_01 conv_q_c048_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_02 (conv_i_src_c048_1_02 0 conv_bpf_c048_1 0) vcvs gain=5.555702330196e-01
SCONVI_c048_1_02 (conv_i_src_c048_1_02 conv_i_c048_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_02 (conv_q_src_c048_1_02 0 conv_bpf_c048_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_1_02 (conv_q_src_c048_1_02 conv_q_c048_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_03 (conv_i_src_c048_1_03 0 conv_bpf_c048_1 0) vcvs gain=1.950903220161e-01
SCONVI_c048_1_03 (conv_i_src_c048_1_03 conv_i_c048_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_03 (conv_q_src_c048_1_03 0 conv_bpf_c048_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_1_03 (conv_q_src_c048_1_03 conv_q_c048_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_04 (conv_i_src_c048_1_04 0 conv_bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_1_04 (conv_i_src_c048_1_04 conv_i_c048_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_04 (conv_q_src_c048_1_04 0 conv_bpf_c048_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_1_04 (conv_q_src_c048_1_04 conv_q_c048_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_05 (conv_i_src_c048_1_05 0 conv_bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_1_05 (conv_i_src_c048_1_05 conv_i_c048_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_05 (conv_q_src_c048_1_05 0 conv_bpf_c048_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_1_05 (conv_q_src_c048_1_05 conv_q_c048_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_06 (conv_i_src_c048_1_06 0 conv_bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_1_06 (conv_i_src_c048_1_06 conv_i_c048_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_06 (conv_q_src_c048_1_06 0 conv_bpf_c048_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_1_06 (conv_q_src_c048_1_06 conv_q_c048_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_07 (conv_i_src_c048_1_07 0 conv_bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_1_07 (conv_i_src_c048_1_07 conv_i_c048_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_07 (conv_q_src_c048_1_07 0 conv_bpf_c048_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_1_07 (conv_q_src_c048_1_07 conv_q_c048_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_08 (conv_i_src_c048_1_08 0 conv_bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_1_08 (conv_i_src_c048_1_08 conv_i_c048_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_08 (conv_q_src_c048_1_08 0 conv_bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_1_08 (conv_q_src_c048_1_08 conv_q_c048_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_09 (conv_i_src_c048_1_09 0 conv_bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_1_09 (conv_i_src_c048_1_09 conv_i_c048_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_09 (conv_q_src_c048_1_09 0 conv_bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_1_09 (conv_q_src_c048_1_09 conv_q_c048_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_10 (conv_i_src_c048_1_10 0 conv_bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_1_10 (conv_i_src_c048_1_10 conv_i_c048_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_10 (conv_q_src_c048_1_10 0 conv_bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_1_10 (conv_q_src_c048_1_10 conv_q_c048_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_11 (conv_i_src_c048_1_11 0 conv_bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_1_11 (conv_i_src_c048_1_11 conv_i_c048_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_11 (conv_q_src_c048_1_11 0 conv_bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_1_11 (conv_q_src_c048_1_11 conv_q_c048_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_12 (conv_i_src_c048_1_12 0 conv_bpf_c048_1 0) vcvs gain=1.950903220161e-01
SCONVI_c048_1_12 (conv_i_src_c048_1_12 conv_i_c048_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_12 (conv_q_src_c048_1_12 0 conv_bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_1_12 (conv_q_src_c048_1_12 conv_q_c048_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_13 (conv_i_src_c048_1_13 0 conv_bpf_c048_1 0) vcvs gain=5.555702330196e-01
SCONVI_c048_1_13 (conv_i_src_c048_1_13 conv_i_c048_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_13 (conv_q_src_c048_1_13 0 conv_bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_1_13 (conv_q_src_c048_1_13 conv_q_c048_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_14 (conv_i_src_c048_1_14 0 conv_bpf_c048_1 0) vcvs gain=8.314696123025e-01
SCONVI_c048_1_14 (conv_i_src_c048_1_14 conv_i_c048_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_14 (conv_q_src_c048_1_14 0 conv_bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_1_14 (conv_q_src_c048_1_14 conv_q_c048_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_1_15 (conv_i_src_c048_1_15 0 conv_bpf_c048_1 0) vcvs gain=9.807852804032e-01
SCONVI_c048_1_15 (conv_i_src_c048_1_15 conv_i_c048_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_1_15 (conv_q_src_c048_1_15 0 conv_bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_1_15 (conv_q_src_c048_1_15 conv_q_c048_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c048_1 (conv_i_c048_1 0) resistor r=1G
RCONVQ_c048_1 (conv_q_c048_1 0) resistor r=1G
RCONVINTI_c048_1 (conv_i_c048_1 ConvIcar_c048_1) resistor r=1k
CCONVINTI_c048_1 (ConvIcar_c048_1 0) capacitor c=80p
RCONVINTQ_c048_1 (conv_q_c048_1 ConvQcar_c048_1) resistor r=1k
CCONVINTQ_c048_1 (ConvQcar_c048_1 0) capacitor c=80p
save conv_bpf_c048_1 ConvIcar_c048_1 ConvQcar_c048_1

// conventional mixed baseline bl048, carrier_2: 750000000 Hz
CCONVBPF_c048_2 (bl048 n_conv_cbpf_c048_2) capacitor c=4.503163717437e-14
LCONVBPF_c048_2 (n_conv_cbpf_c048_2 conv_bpf_c048_2) inductor l=1.000000000000e-06
RCONVBPF_c048_2 (conv_bpf_c048_2 0) resistor r=2.356194490192e+02
ECONVI_c048_2_00 (conv_i_src_c048_2_00 0 conv_bpf_c048_2 0) vcvs gain=9.807852804032e-01
SCONVI_c048_2_00 (conv_i_src_c048_2_00 conv_i_c048_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_00 (conv_q_src_c048_2_00 0 conv_bpf_c048_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_2_00 (conv_q_src_c048_2_00 conv_q_c048_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_01 (conv_i_src_c048_2_01 0 conv_bpf_c048_2 0) vcvs gain=8.314696123025e-01
SCONVI_c048_2_01 (conv_i_src_c048_2_01 conv_i_c048_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_01 (conv_q_src_c048_2_01 0 conv_bpf_c048_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_2_01 (conv_q_src_c048_2_01 conv_q_c048_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_02 (conv_i_src_c048_2_02 0 conv_bpf_c048_2 0) vcvs gain=5.555702330196e-01
SCONVI_c048_2_02 (conv_i_src_c048_2_02 conv_i_c048_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_02 (conv_q_src_c048_2_02 0 conv_bpf_c048_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_2_02 (conv_q_src_c048_2_02 conv_q_c048_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_03 (conv_i_src_c048_2_03 0 conv_bpf_c048_2 0) vcvs gain=1.950903220161e-01
SCONVI_c048_2_03 (conv_i_src_c048_2_03 conv_i_c048_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_03 (conv_q_src_c048_2_03 0 conv_bpf_c048_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_2_03 (conv_q_src_c048_2_03 conv_q_c048_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_04 (conv_i_src_c048_2_04 0 conv_bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_2_04 (conv_i_src_c048_2_04 conv_i_c048_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_04 (conv_q_src_c048_2_04 0 conv_bpf_c048_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_2_04 (conv_q_src_c048_2_04 conv_q_c048_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_05 (conv_i_src_c048_2_05 0 conv_bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_2_05 (conv_i_src_c048_2_05 conv_i_c048_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_05 (conv_q_src_c048_2_05 0 conv_bpf_c048_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_2_05 (conv_q_src_c048_2_05 conv_q_c048_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_06 (conv_i_src_c048_2_06 0 conv_bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_2_06 (conv_i_src_c048_2_06 conv_i_c048_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_06 (conv_q_src_c048_2_06 0 conv_bpf_c048_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_2_06 (conv_q_src_c048_2_06 conv_q_c048_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_07 (conv_i_src_c048_2_07 0 conv_bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_2_07 (conv_i_src_c048_2_07 conv_i_c048_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_07 (conv_q_src_c048_2_07 0 conv_bpf_c048_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_2_07 (conv_q_src_c048_2_07 conv_q_c048_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_08 (conv_i_src_c048_2_08 0 conv_bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_2_08 (conv_i_src_c048_2_08 conv_i_c048_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_08 (conv_q_src_c048_2_08 0 conv_bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_2_08 (conv_q_src_c048_2_08 conv_q_c048_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_09 (conv_i_src_c048_2_09 0 conv_bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_2_09 (conv_i_src_c048_2_09 conv_i_c048_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_09 (conv_q_src_c048_2_09 0 conv_bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_2_09 (conv_q_src_c048_2_09 conv_q_c048_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_10 (conv_i_src_c048_2_10 0 conv_bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_2_10 (conv_i_src_c048_2_10 conv_i_c048_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_10 (conv_q_src_c048_2_10 0 conv_bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_2_10 (conv_q_src_c048_2_10 conv_q_c048_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_11 (conv_i_src_c048_2_11 0 conv_bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_2_11 (conv_i_src_c048_2_11 conv_i_c048_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_11 (conv_q_src_c048_2_11 0 conv_bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_2_11 (conv_q_src_c048_2_11 conv_q_c048_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_12 (conv_i_src_c048_2_12 0 conv_bpf_c048_2 0) vcvs gain=1.950903220161e-01
SCONVI_c048_2_12 (conv_i_src_c048_2_12 conv_i_c048_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_12 (conv_q_src_c048_2_12 0 conv_bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_2_12 (conv_q_src_c048_2_12 conv_q_c048_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_13 (conv_i_src_c048_2_13 0 conv_bpf_c048_2 0) vcvs gain=5.555702330196e-01
SCONVI_c048_2_13 (conv_i_src_c048_2_13 conv_i_c048_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_13 (conv_q_src_c048_2_13 0 conv_bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_2_13 (conv_q_src_c048_2_13 conv_q_c048_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_14 (conv_i_src_c048_2_14 0 conv_bpf_c048_2 0) vcvs gain=8.314696123025e-01
SCONVI_c048_2_14 (conv_i_src_c048_2_14 conv_i_c048_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_14 (conv_q_src_c048_2_14 0 conv_bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_2_14 (conv_q_src_c048_2_14 conv_q_c048_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_2_15 (conv_i_src_c048_2_15 0 conv_bpf_c048_2 0) vcvs gain=9.807852804032e-01
SCONVI_c048_2_15 (conv_i_src_c048_2_15 conv_i_c048_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_2_15 (conv_q_src_c048_2_15 0 conv_bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_2_15 (conv_q_src_c048_2_15 conv_q_c048_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c048_2 (conv_i_c048_2 0) resistor r=1G
RCONVQ_c048_2 (conv_q_c048_2 0) resistor r=1G
RCONVINTI_c048_2 (conv_i_c048_2 ConvIcar_c048_2) resistor r=1k
CCONVINTI_c048_2 (ConvIcar_c048_2 0) capacitor c=80p
RCONVINTQ_c048_2 (conv_q_c048_2 ConvQcar_c048_2) resistor r=1k
CCONVINTQ_c048_2 (ConvQcar_c048_2 0) capacitor c=80p
save conv_bpf_c048_2 ConvIcar_c048_2 ConvQcar_c048_2

// conventional mixed baseline bl048, carrier_3: 1000000000 Hz
CCONVBPF_c048_3 (bl048 n_conv_cbpf_c048_3) capacitor c=2.533029591058e-14
LCONVBPF_c048_3 (n_conv_cbpf_c048_3 conv_bpf_c048_3) inductor l=1.000000000000e-06
RCONVBPF_c048_3 (conv_bpf_c048_3 0) resistor r=3.141592653590e+02
ECONVI_c048_3_00 (conv_i_src_c048_3_00 0 conv_bpf_c048_3 0) vcvs gain=9.807852804032e-01
SCONVI_c048_3_00 (conv_i_src_c048_3_00 conv_i_c048_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_00 (conv_q_src_c048_3_00 0 conv_bpf_c048_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_3_00 (conv_q_src_c048_3_00 conv_q_c048_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_01 (conv_i_src_c048_3_01 0 conv_bpf_c048_3 0) vcvs gain=8.314696123025e-01
SCONVI_c048_3_01 (conv_i_src_c048_3_01 conv_i_c048_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_01 (conv_q_src_c048_3_01 0 conv_bpf_c048_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_3_01 (conv_q_src_c048_3_01 conv_q_c048_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_02 (conv_i_src_c048_3_02 0 conv_bpf_c048_3 0) vcvs gain=5.555702330196e-01
SCONVI_c048_3_02 (conv_i_src_c048_3_02 conv_i_c048_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_02 (conv_q_src_c048_3_02 0 conv_bpf_c048_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_3_02 (conv_q_src_c048_3_02 conv_q_c048_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_03 (conv_i_src_c048_3_03 0 conv_bpf_c048_3 0) vcvs gain=1.950903220161e-01
SCONVI_c048_3_03 (conv_i_src_c048_3_03 conv_i_c048_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_03 (conv_q_src_c048_3_03 0 conv_bpf_c048_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_3_03 (conv_q_src_c048_3_03 conv_q_c048_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_04 (conv_i_src_c048_3_04 0 conv_bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_3_04 (conv_i_src_c048_3_04 conv_i_c048_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_04 (conv_q_src_c048_3_04 0 conv_bpf_c048_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c048_3_04 (conv_q_src_c048_3_04 conv_q_c048_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_05 (conv_i_src_c048_3_05 0 conv_bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_3_05 (conv_i_src_c048_3_05 conv_i_c048_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_05 (conv_q_src_c048_3_05 0 conv_bpf_c048_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c048_3_05 (conv_q_src_c048_3_05 conv_q_c048_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_06 (conv_i_src_c048_3_06 0 conv_bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_3_06 (conv_i_src_c048_3_06 conv_i_c048_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_06 (conv_q_src_c048_3_06 0 conv_bpf_c048_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c048_3_06 (conv_q_src_c048_3_06 conv_q_c048_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_07 (conv_i_src_c048_3_07 0 conv_bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_3_07 (conv_i_src_c048_3_07 conv_i_c048_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_07 (conv_q_src_c048_3_07 0 conv_bpf_c048_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c048_3_07 (conv_q_src_c048_3_07 conv_q_c048_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_08 (conv_i_src_c048_3_08 0 conv_bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c048_3_08 (conv_i_src_c048_3_08 conv_i_c048_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_08 (conv_q_src_c048_3_08 0 conv_bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_3_08 (conv_q_src_c048_3_08 conv_q_c048_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_09 (conv_i_src_c048_3_09 0 conv_bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c048_3_09 (conv_i_src_c048_3_09 conv_i_c048_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_09 (conv_q_src_c048_3_09 0 conv_bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_3_09 (conv_q_src_c048_3_09 conv_q_c048_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_10 (conv_i_src_c048_3_10 0 conv_bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c048_3_10 (conv_i_src_c048_3_10 conv_i_c048_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_10 (conv_q_src_c048_3_10 0 conv_bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_3_10 (conv_q_src_c048_3_10 conv_q_c048_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_11 (conv_i_src_c048_3_11 0 conv_bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c048_3_11 (conv_i_src_c048_3_11 conv_i_c048_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_11 (conv_q_src_c048_3_11 0 conv_bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_3_11 (conv_q_src_c048_3_11 conv_q_c048_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_12 (conv_i_src_c048_3_12 0 conv_bpf_c048_3 0) vcvs gain=1.950903220161e-01
SCONVI_c048_3_12 (conv_i_src_c048_3_12 conv_i_c048_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_12 (conv_q_src_c048_3_12 0 conv_bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c048_3_12 (conv_q_src_c048_3_12 conv_q_c048_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_13 (conv_i_src_c048_3_13 0 conv_bpf_c048_3 0) vcvs gain=5.555702330196e-01
SCONVI_c048_3_13 (conv_i_src_c048_3_13 conv_i_c048_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_13 (conv_q_src_c048_3_13 0 conv_bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c048_3_13 (conv_q_src_c048_3_13 conv_q_c048_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_14 (conv_i_src_c048_3_14 0 conv_bpf_c048_3 0) vcvs gain=8.314696123025e-01
SCONVI_c048_3_14 (conv_i_src_c048_3_14 conv_i_c048_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_14 (conv_q_src_c048_3_14 0 conv_bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c048_3_14 (conv_q_src_c048_3_14 conv_q_c048_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c048_3_15 (conv_i_src_c048_3_15 0 conv_bpf_c048_3 0) vcvs gain=9.807852804032e-01
SCONVI_c048_3_15 (conv_i_src_c048_3_15 conv_i_c048_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c048_3_15 (conv_q_src_c048_3_15 0 conv_bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c048_3_15 (conv_q_src_c048_3_15 conv_q_c048_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c048_3 (conv_i_c048_3 0) resistor r=1G
RCONVQ_c048_3 (conv_q_c048_3 0) resistor r=1G
RCONVINTI_c048_3 (conv_i_c048_3 ConvIcar_c048_3) resistor r=1k
CCONVINTI_c048_3 (ConvIcar_c048_3 0) capacitor c=80p
RCONVINTQ_c048_3 (conv_q_c048_3 ConvQcar_c048_3) resistor r=1k
CCONVINTQ_c048_3 (ConvQcar_c048_3 0) capacitor c=80p
save conv_bpf_c048_3 ConvIcar_c048_3 ConvQcar_c048_3

// conventional mixed baseline bl049, carrier_0: 250000000 Hz
CCONVBPF_c049_0 (bl049 n_conv_cbpf_c049_0) capacitor c=4.052847345694e-13
LCONVBPF_c049_0 (n_conv_cbpf_c049_0 conv_bpf_c049_0) inductor l=1.000000000000e-06
RCONVBPF_c049_0 (conv_bpf_c049_0 0) resistor r=7.853981633974e+01
ECONVI_c049_0_00 (conv_i_src_c049_0_00 0 conv_bpf_c049_0 0) vcvs gain=9.807852804032e-01
SCONVI_c049_0_00 (conv_i_src_c049_0_00 conv_i_c049_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_00 (conv_q_src_c049_0_00 0 conv_bpf_c049_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_0_00 (conv_q_src_c049_0_00 conv_q_c049_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_01 (conv_i_src_c049_0_01 0 conv_bpf_c049_0 0) vcvs gain=8.314696123025e-01
SCONVI_c049_0_01 (conv_i_src_c049_0_01 conv_i_c049_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_01 (conv_q_src_c049_0_01 0 conv_bpf_c049_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_0_01 (conv_q_src_c049_0_01 conv_q_c049_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_02 (conv_i_src_c049_0_02 0 conv_bpf_c049_0 0) vcvs gain=5.555702330196e-01
SCONVI_c049_0_02 (conv_i_src_c049_0_02 conv_i_c049_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_02 (conv_q_src_c049_0_02 0 conv_bpf_c049_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_0_02 (conv_q_src_c049_0_02 conv_q_c049_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_03 (conv_i_src_c049_0_03 0 conv_bpf_c049_0 0) vcvs gain=1.950903220161e-01
SCONVI_c049_0_03 (conv_i_src_c049_0_03 conv_i_c049_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_03 (conv_q_src_c049_0_03 0 conv_bpf_c049_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_0_03 (conv_q_src_c049_0_03 conv_q_c049_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_04 (conv_i_src_c049_0_04 0 conv_bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_0_04 (conv_i_src_c049_0_04 conv_i_c049_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_04 (conv_q_src_c049_0_04 0 conv_bpf_c049_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_0_04 (conv_q_src_c049_0_04 conv_q_c049_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_05 (conv_i_src_c049_0_05 0 conv_bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_0_05 (conv_i_src_c049_0_05 conv_i_c049_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_05 (conv_q_src_c049_0_05 0 conv_bpf_c049_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_0_05 (conv_q_src_c049_0_05 conv_q_c049_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_06 (conv_i_src_c049_0_06 0 conv_bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_0_06 (conv_i_src_c049_0_06 conv_i_c049_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_06 (conv_q_src_c049_0_06 0 conv_bpf_c049_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_0_06 (conv_q_src_c049_0_06 conv_q_c049_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_07 (conv_i_src_c049_0_07 0 conv_bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_0_07 (conv_i_src_c049_0_07 conv_i_c049_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_07 (conv_q_src_c049_0_07 0 conv_bpf_c049_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_0_07 (conv_q_src_c049_0_07 conv_q_c049_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_08 (conv_i_src_c049_0_08 0 conv_bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_0_08 (conv_i_src_c049_0_08 conv_i_c049_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_08 (conv_q_src_c049_0_08 0 conv_bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_0_08 (conv_q_src_c049_0_08 conv_q_c049_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_09 (conv_i_src_c049_0_09 0 conv_bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_0_09 (conv_i_src_c049_0_09 conv_i_c049_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_09 (conv_q_src_c049_0_09 0 conv_bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_0_09 (conv_q_src_c049_0_09 conv_q_c049_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_10 (conv_i_src_c049_0_10 0 conv_bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_0_10 (conv_i_src_c049_0_10 conv_i_c049_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_10 (conv_q_src_c049_0_10 0 conv_bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_0_10 (conv_q_src_c049_0_10 conv_q_c049_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_11 (conv_i_src_c049_0_11 0 conv_bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_0_11 (conv_i_src_c049_0_11 conv_i_c049_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_11 (conv_q_src_c049_0_11 0 conv_bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_0_11 (conv_q_src_c049_0_11 conv_q_c049_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_12 (conv_i_src_c049_0_12 0 conv_bpf_c049_0 0) vcvs gain=1.950903220161e-01
SCONVI_c049_0_12 (conv_i_src_c049_0_12 conv_i_c049_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_12 (conv_q_src_c049_0_12 0 conv_bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_0_12 (conv_q_src_c049_0_12 conv_q_c049_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_13 (conv_i_src_c049_0_13 0 conv_bpf_c049_0 0) vcvs gain=5.555702330196e-01
SCONVI_c049_0_13 (conv_i_src_c049_0_13 conv_i_c049_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_13 (conv_q_src_c049_0_13 0 conv_bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_0_13 (conv_q_src_c049_0_13 conv_q_c049_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_14 (conv_i_src_c049_0_14 0 conv_bpf_c049_0 0) vcvs gain=8.314696123025e-01
SCONVI_c049_0_14 (conv_i_src_c049_0_14 conv_i_c049_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_14 (conv_q_src_c049_0_14 0 conv_bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_0_14 (conv_q_src_c049_0_14 conv_q_c049_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_0_15 (conv_i_src_c049_0_15 0 conv_bpf_c049_0 0) vcvs gain=9.807852804032e-01
SCONVI_c049_0_15 (conv_i_src_c049_0_15 conv_i_c049_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_0_15 (conv_q_src_c049_0_15 0 conv_bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_0_15 (conv_q_src_c049_0_15 conv_q_c049_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c049_0 (conv_i_c049_0 0) resistor r=1G
RCONVQ_c049_0 (conv_q_c049_0 0) resistor r=1G
RCONVINTI_c049_0 (conv_i_c049_0 ConvIcar_c049_0) resistor r=1k
CCONVINTI_c049_0 (ConvIcar_c049_0 0) capacitor c=80p
RCONVINTQ_c049_0 (conv_q_c049_0 ConvQcar_c049_0) resistor r=1k
CCONVINTQ_c049_0 (ConvQcar_c049_0 0) capacitor c=80p
save conv_bpf_c049_0 ConvIcar_c049_0 ConvQcar_c049_0

// conventional mixed baseline bl049, carrier_1: 500000000 Hz
CCONVBPF_c049_1 (bl049 n_conv_cbpf_c049_1) capacitor c=1.013211836423e-13
LCONVBPF_c049_1 (n_conv_cbpf_c049_1 conv_bpf_c049_1) inductor l=1.000000000000e-06
RCONVBPF_c049_1 (conv_bpf_c049_1 0) resistor r=1.570796326795e+02
ECONVI_c049_1_00 (conv_i_src_c049_1_00 0 conv_bpf_c049_1 0) vcvs gain=9.807852804032e-01
SCONVI_c049_1_00 (conv_i_src_c049_1_00 conv_i_c049_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_00 (conv_q_src_c049_1_00 0 conv_bpf_c049_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_1_00 (conv_q_src_c049_1_00 conv_q_c049_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_01 (conv_i_src_c049_1_01 0 conv_bpf_c049_1 0) vcvs gain=8.314696123025e-01
SCONVI_c049_1_01 (conv_i_src_c049_1_01 conv_i_c049_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_01 (conv_q_src_c049_1_01 0 conv_bpf_c049_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_1_01 (conv_q_src_c049_1_01 conv_q_c049_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_02 (conv_i_src_c049_1_02 0 conv_bpf_c049_1 0) vcvs gain=5.555702330196e-01
SCONVI_c049_1_02 (conv_i_src_c049_1_02 conv_i_c049_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_02 (conv_q_src_c049_1_02 0 conv_bpf_c049_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_1_02 (conv_q_src_c049_1_02 conv_q_c049_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_03 (conv_i_src_c049_1_03 0 conv_bpf_c049_1 0) vcvs gain=1.950903220161e-01
SCONVI_c049_1_03 (conv_i_src_c049_1_03 conv_i_c049_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_03 (conv_q_src_c049_1_03 0 conv_bpf_c049_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_1_03 (conv_q_src_c049_1_03 conv_q_c049_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_04 (conv_i_src_c049_1_04 0 conv_bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_1_04 (conv_i_src_c049_1_04 conv_i_c049_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_04 (conv_q_src_c049_1_04 0 conv_bpf_c049_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_1_04 (conv_q_src_c049_1_04 conv_q_c049_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_05 (conv_i_src_c049_1_05 0 conv_bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_1_05 (conv_i_src_c049_1_05 conv_i_c049_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_05 (conv_q_src_c049_1_05 0 conv_bpf_c049_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_1_05 (conv_q_src_c049_1_05 conv_q_c049_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_06 (conv_i_src_c049_1_06 0 conv_bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_1_06 (conv_i_src_c049_1_06 conv_i_c049_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_06 (conv_q_src_c049_1_06 0 conv_bpf_c049_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_1_06 (conv_q_src_c049_1_06 conv_q_c049_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_07 (conv_i_src_c049_1_07 0 conv_bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_1_07 (conv_i_src_c049_1_07 conv_i_c049_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_07 (conv_q_src_c049_1_07 0 conv_bpf_c049_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_1_07 (conv_q_src_c049_1_07 conv_q_c049_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_08 (conv_i_src_c049_1_08 0 conv_bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_1_08 (conv_i_src_c049_1_08 conv_i_c049_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_08 (conv_q_src_c049_1_08 0 conv_bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_1_08 (conv_q_src_c049_1_08 conv_q_c049_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_09 (conv_i_src_c049_1_09 0 conv_bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_1_09 (conv_i_src_c049_1_09 conv_i_c049_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_09 (conv_q_src_c049_1_09 0 conv_bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_1_09 (conv_q_src_c049_1_09 conv_q_c049_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_10 (conv_i_src_c049_1_10 0 conv_bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_1_10 (conv_i_src_c049_1_10 conv_i_c049_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_10 (conv_q_src_c049_1_10 0 conv_bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_1_10 (conv_q_src_c049_1_10 conv_q_c049_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_11 (conv_i_src_c049_1_11 0 conv_bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_1_11 (conv_i_src_c049_1_11 conv_i_c049_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_11 (conv_q_src_c049_1_11 0 conv_bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_1_11 (conv_q_src_c049_1_11 conv_q_c049_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_12 (conv_i_src_c049_1_12 0 conv_bpf_c049_1 0) vcvs gain=1.950903220161e-01
SCONVI_c049_1_12 (conv_i_src_c049_1_12 conv_i_c049_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_12 (conv_q_src_c049_1_12 0 conv_bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_1_12 (conv_q_src_c049_1_12 conv_q_c049_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_13 (conv_i_src_c049_1_13 0 conv_bpf_c049_1 0) vcvs gain=5.555702330196e-01
SCONVI_c049_1_13 (conv_i_src_c049_1_13 conv_i_c049_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_13 (conv_q_src_c049_1_13 0 conv_bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_1_13 (conv_q_src_c049_1_13 conv_q_c049_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_14 (conv_i_src_c049_1_14 0 conv_bpf_c049_1 0) vcvs gain=8.314696123025e-01
SCONVI_c049_1_14 (conv_i_src_c049_1_14 conv_i_c049_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_14 (conv_q_src_c049_1_14 0 conv_bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_1_14 (conv_q_src_c049_1_14 conv_q_c049_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_1_15 (conv_i_src_c049_1_15 0 conv_bpf_c049_1 0) vcvs gain=9.807852804032e-01
SCONVI_c049_1_15 (conv_i_src_c049_1_15 conv_i_c049_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_1_15 (conv_q_src_c049_1_15 0 conv_bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_1_15 (conv_q_src_c049_1_15 conv_q_c049_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c049_1 (conv_i_c049_1 0) resistor r=1G
RCONVQ_c049_1 (conv_q_c049_1 0) resistor r=1G
RCONVINTI_c049_1 (conv_i_c049_1 ConvIcar_c049_1) resistor r=1k
CCONVINTI_c049_1 (ConvIcar_c049_1 0) capacitor c=80p
RCONVINTQ_c049_1 (conv_q_c049_1 ConvQcar_c049_1) resistor r=1k
CCONVINTQ_c049_1 (ConvQcar_c049_1 0) capacitor c=80p
save conv_bpf_c049_1 ConvIcar_c049_1 ConvQcar_c049_1

// conventional mixed baseline bl049, carrier_2: 750000000 Hz
CCONVBPF_c049_2 (bl049 n_conv_cbpf_c049_2) capacitor c=4.503163717437e-14
LCONVBPF_c049_2 (n_conv_cbpf_c049_2 conv_bpf_c049_2) inductor l=1.000000000000e-06
RCONVBPF_c049_2 (conv_bpf_c049_2 0) resistor r=2.356194490192e+02
ECONVI_c049_2_00 (conv_i_src_c049_2_00 0 conv_bpf_c049_2 0) vcvs gain=9.807852804032e-01
SCONVI_c049_2_00 (conv_i_src_c049_2_00 conv_i_c049_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_00 (conv_q_src_c049_2_00 0 conv_bpf_c049_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_2_00 (conv_q_src_c049_2_00 conv_q_c049_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_01 (conv_i_src_c049_2_01 0 conv_bpf_c049_2 0) vcvs gain=8.314696123025e-01
SCONVI_c049_2_01 (conv_i_src_c049_2_01 conv_i_c049_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_01 (conv_q_src_c049_2_01 0 conv_bpf_c049_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_2_01 (conv_q_src_c049_2_01 conv_q_c049_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_02 (conv_i_src_c049_2_02 0 conv_bpf_c049_2 0) vcvs gain=5.555702330196e-01
SCONVI_c049_2_02 (conv_i_src_c049_2_02 conv_i_c049_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_02 (conv_q_src_c049_2_02 0 conv_bpf_c049_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_2_02 (conv_q_src_c049_2_02 conv_q_c049_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_03 (conv_i_src_c049_2_03 0 conv_bpf_c049_2 0) vcvs gain=1.950903220161e-01
SCONVI_c049_2_03 (conv_i_src_c049_2_03 conv_i_c049_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_03 (conv_q_src_c049_2_03 0 conv_bpf_c049_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_2_03 (conv_q_src_c049_2_03 conv_q_c049_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_04 (conv_i_src_c049_2_04 0 conv_bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_2_04 (conv_i_src_c049_2_04 conv_i_c049_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_04 (conv_q_src_c049_2_04 0 conv_bpf_c049_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_2_04 (conv_q_src_c049_2_04 conv_q_c049_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_05 (conv_i_src_c049_2_05 0 conv_bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_2_05 (conv_i_src_c049_2_05 conv_i_c049_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_05 (conv_q_src_c049_2_05 0 conv_bpf_c049_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_2_05 (conv_q_src_c049_2_05 conv_q_c049_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_06 (conv_i_src_c049_2_06 0 conv_bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_2_06 (conv_i_src_c049_2_06 conv_i_c049_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_06 (conv_q_src_c049_2_06 0 conv_bpf_c049_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_2_06 (conv_q_src_c049_2_06 conv_q_c049_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_07 (conv_i_src_c049_2_07 0 conv_bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_2_07 (conv_i_src_c049_2_07 conv_i_c049_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_07 (conv_q_src_c049_2_07 0 conv_bpf_c049_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_2_07 (conv_q_src_c049_2_07 conv_q_c049_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_08 (conv_i_src_c049_2_08 0 conv_bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_2_08 (conv_i_src_c049_2_08 conv_i_c049_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_08 (conv_q_src_c049_2_08 0 conv_bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_2_08 (conv_q_src_c049_2_08 conv_q_c049_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_09 (conv_i_src_c049_2_09 0 conv_bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_2_09 (conv_i_src_c049_2_09 conv_i_c049_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_09 (conv_q_src_c049_2_09 0 conv_bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_2_09 (conv_q_src_c049_2_09 conv_q_c049_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_10 (conv_i_src_c049_2_10 0 conv_bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_2_10 (conv_i_src_c049_2_10 conv_i_c049_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_10 (conv_q_src_c049_2_10 0 conv_bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_2_10 (conv_q_src_c049_2_10 conv_q_c049_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_11 (conv_i_src_c049_2_11 0 conv_bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_2_11 (conv_i_src_c049_2_11 conv_i_c049_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_11 (conv_q_src_c049_2_11 0 conv_bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_2_11 (conv_q_src_c049_2_11 conv_q_c049_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_12 (conv_i_src_c049_2_12 0 conv_bpf_c049_2 0) vcvs gain=1.950903220161e-01
SCONVI_c049_2_12 (conv_i_src_c049_2_12 conv_i_c049_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_12 (conv_q_src_c049_2_12 0 conv_bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_2_12 (conv_q_src_c049_2_12 conv_q_c049_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_13 (conv_i_src_c049_2_13 0 conv_bpf_c049_2 0) vcvs gain=5.555702330196e-01
SCONVI_c049_2_13 (conv_i_src_c049_2_13 conv_i_c049_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_13 (conv_q_src_c049_2_13 0 conv_bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_2_13 (conv_q_src_c049_2_13 conv_q_c049_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_14 (conv_i_src_c049_2_14 0 conv_bpf_c049_2 0) vcvs gain=8.314696123025e-01
SCONVI_c049_2_14 (conv_i_src_c049_2_14 conv_i_c049_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_14 (conv_q_src_c049_2_14 0 conv_bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_2_14 (conv_q_src_c049_2_14 conv_q_c049_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_2_15 (conv_i_src_c049_2_15 0 conv_bpf_c049_2 0) vcvs gain=9.807852804032e-01
SCONVI_c049_2_15 (conv_i_src_c049_2_15 conv_i_c049_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_2_15 (conv_q_src_c049_2_15 0 conv_bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_2_15 (conv_q_src_c049_2_15 conv_q_c049_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c049_2 (conv_i_c049_2 0) resistor r=1G
RCONVQ_c049_2 (conv_q_c049_2 0) resistor r=1G
RCONVINTI_c049_2 (conv_i_c049_2 ConvIcar_c049_2) resistor r=1k
CCONVINTI_c049_2 (ConvIcar_c049_2 0) capacitor c=80p
RCONVINTQ_c049_2 (conv_q_c049_2 ConvQcar_c049_2) resistor r=1k
CCONVINTQ_c049_2 (ConvQcar_c049_2 0) capacitor c=80p
save conv_bpf_c049_2 ConvIcar_c049_2 ConvQcar_c049_2

// conventional mixed baseline bl049, carrier_3: 1000000000 Hz
CCONVBPF_c049_3 (bl049 n_conv_cbpf_c049_3) capacitor c=2.533029591058e-14
LCONVBPF_c049_3 (n_conv_cbpf_c049_3 conv_bpf_c049_3) inductor l=1.000000000000e-06
RCONVBPF_c049_3 (conv_bpf_c049_3 0) resistor r=3.141592653590e+02
ECONVI_c049_3_00 (conv_i_src_c049_3_00 0 conv_bpf_c049_3 0) vcvs gain=9.807852804032e-01
SCONVI_c049_3_00 (conv_i_src_c049_3_00 conv_i_c049_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_00 (conv_q_src_c049_3_00 0 conv_bpf_c049_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_3_00 (conv_q_src_c049_3_00 conv_q_c049_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_01 (conv_i_src_c049_3_01 0 conv_bpf_c049_3 0) vcvs gain=8.314696123025e-01
SCONVI_c049_3_01 (conv_i_src_c049_3_01 conv_i_c049_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_01 (conv_q_src_c049_3_01 0 conv_bpf_c049_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_3_01 (conv_q_src_c049_3_01 conv_q_c049_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_02 (conv_i_src_c049_3_02 0 conv_bpf_c049_3 0) vcvs gain=5.555702330196e-01
SCONVI_c049_3_02 (conv_i_src_c049_3_02 conv_i_c049_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_02 (conv_q_src_c049_3_02 0 conv_bpf_c049_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_3_02 (conv_q_src_c049_3_02 conv_q_c049_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_03 (conv_i_src_c049_3_03 0 conv_bpf_c049_3 0) vcvs gain=1.950903220161e-01
SCONVI_c049_3_03 (conv_i_src_c049_3_03 conv_i_c049_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_03 (conv_q_src_c049_3_03 0 conv_bpf_c049_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_3_03 (conv_q_src_c049_3_03 conv_q_c049_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_04 (conv_i_src_c049_3_04 0 conv_bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_3_04 (conv_i_src_c049_3_04 conv_i_c049_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_04 (conv_q_src_c049_3_04 0 conv_bpf_c049_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c049_3_04 (conv_q_src_c049_3_04 conv_q_c049_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_05 (conv_i_src_c049_3_05 0 conv_bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_3_05 (conv_i_src_c049_3_05 conv_i_c049_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_05 (conv_q_src_c049_3_05 0 conv_bpf_c049_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c049_3_05 (conv_q_src_c049_3_05 conv_q_c049_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_06 (conv_i_src_c049_3_06 0 conv_bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_3_06 (conv_i_src_c049_3_06 conv_i_c049_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_06 (conv_q_src_c049_3_06 0 conv_bpf_c049_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c049_3_06 (conv_q_src_c049_3_06 conv_q_c049_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_07 (conv_i_src_c049_3_07 0 conv_bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_3_07 (conv_i_src_c049_3_07 conv_i_c049_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_07 (conv_q_src_c049_3_07 0 conv_bpf_c049_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c049_3_07 (conv_q_src_c049_3_07 conv_q_c049_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_08 (conv_i_src_c049_3_08 0 conv_bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c049_3_08 (conv_i_src_c049_3_08 conv_i_c049_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_08 (conv_q_src_c049_3_08 0 conv_bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_3_08 (conv_q_src_c049_3_08 conv_q_c049_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_09 (conv_i_src_c049_3_09 0 conv_bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c049_3_09 (conv_i_src_c049_3_09 conv_i_c049_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_09 (conv_q_src_c049_3_09 0 conv_bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_3_09 (conv_q_src_c049_3_09 conv_q_c049_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_10 (conv_i_src_c049_3_10 0 conv_bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c049_3_10 (conv_i_src_c049_3_10 conv_i_c049_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_10 (conv_q_src_c049_3_10 0 conv_bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_3_10 (conv_q_src_c049_3_10 conv_q_c049_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_11 (conv_i_src_c049_3_11 0 conv_bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c049_3_11 (conv_i_src_c049_3_11 conv_i_c049_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_11 (conv_q_src_c049_3_11 0 conv_bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_3_11 (conv_q_src_c049_3_11 conv_q_c049_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_12 (conv_i_src_c049_3_12 0 conv_bpf_c049_3 0) vcvs gain=1.950903220161e-01
SCONVI_c049_3_12 (conv_i_src_c049_3_12 conv_i_c049_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_12 (conv_q_src_c049_3_12 0 conv_bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c049_3_12 (conv_q_src_c049_3_12 conv_q_c049_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_13 (conv_i_src_c049_3_13 0 conv_bpf_c049_3 0) vcvs gain=5.555702330196e-01
SCONVI_c049_3_13 (conv_i_src_c049_3_13 conv_i_c049_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_13 (conv_q_src_c049_3_13 0 conv_bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c049_3_13 (conv_q_src_c049_3_13 conv_q_c049_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_14 (conv_i_src_c049_3_14 0 conv_bpf_c049_3 0) vcvs gain=8.314696123025e-01
SCONVI_c049_3_14 (conv_i_src_c049_3_14 conv_i_c049_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_14 (conv_q_src_c049_3_14 0 conv_bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c049_3_14 (conv_q_src_c049_3_14 conv_q_c049_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c049_3_15 (conv_i_src_c049_3_15 0 conv_bpf_c049_3 0) vcvs gain=9.807852804032e-01
SCONVI_c049_3_15 (conv_i_src_c049_3_15 conv_i_c049_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c049_3_15 (conv_q_src_c049_3_15 0 conv_bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c049_3_15 (conv_q_src_c049_3_15 conv_q_c049_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c049_3 (conv_i_c049_3 0) resistor r=1G
RCONVQ_c049_3 (conv_q_c049_3 0) resistor r=1G
RCONVINTI_c049_3 (conv_i_c049_3 ConvIcar_c049_3) resistor r=1k
CCONVINTI_c049_3 (ConvIcar_c049_3 0) capacitor c=80p
RCONVINTQ_c049_3 (conv_q_c049_3 ConvQcar_c049_3) resistor r=1k
CCONVINTQ_c049_3 (ConvQcar_c049_3 0) capacitor c=80p
save conv_bpf_c049_3 ConvIcar_c049_3 ConvQcar_c049_3

// conventional mixed baseline bl050, carrier_0: 250000000 Hz
CCONVBPF_c050_0 (bl050 n_conv_cbpf_c050_0) capacitor c=4.052847345694e-13
LCONVBPF_c050_0 (n_conv_cbpf_c050_0 conv_bpf_c050_0) inductor l=1.000000000000e-06
RCONVBPF_c050_0 (conv_bpf_c050_0 0) resistor r=7.853981633974e+01
ECONVI_c050_0_00 (conv_i_src_c050_0_00 0 conv_bpf_c050_0 0) vcvs gain=9.807852804032e-01
SCONVI_c050_0_00 (conv_i_src_c050_0_00 conv_i_c050_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_00 (conv_q_src_c050_0_00 0 conv_bpf_c050_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_0_00 (conv_q_src_c050_0_00 conv_q_c050_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_01 (conv_i_src_c050_0_01 0 conv_bpf_c050_0 0) vcvs gain=8.314696123025e-01
SCONVI_c050_0_01 (conv_i_src_c050_0_01 conv_i_c050_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_01 (conv_q_src_c050_0_01 0 conv_bpf_c050_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_0_01 (conv_q_src_c050_0_01 conv_q_c050_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_02 (conv_i_src_c050_0_02 0 conv_bpf_c050_0 0) vcvs gain=5.555702330196e-01
SCONVI_c050_0_02 (conv_i_src_c050_0_02 conv_i_c050_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_02 (conv_q_src_c050_0_02 0 conv_bpf_c050_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_0_02 (conv_q_src_c050_0_02 conv_q_c050_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_03 (conv_i_src_c050_0_03 0 conv_bpf_c050_0 0) vcvs gain=1.950903220161e-01
SCONVI_c050_0_03 (conv_i_src_c050_0_03 conv_i_c050_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_03 (conv_q_src_c050_0_03 0 conv_bpf_c050_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_0_03 (conv_q_src_c050_0_03 conv_q_c050_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_04 (conv_i_src_c050_0_04 0 conv_bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_0_04 (conv_i_src_c050_0_04 conv_i_c050_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_04 (conv_q_src_c050_0_04 0 conv_bpf_c050_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_0_04 (conv_q_src_c050_0_04 conv_q_c050_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_05 (conv_i_src_c050_0_05 0 conv_bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_0_05 (conv_i_src_c050_0_05 conv_i_c050_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_05 (conv_q_src_c050_0_05 0 conv_bpf_c050_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_0_05 (conv_q_src_c050_0_05 conv_q_c050_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_06 (conv_i_src_c050_0_06 0 conv_bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_0_06 (conv_i_src_c050_0_06 conv_i_c050_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_06 (conv_q_src_c050_0_06 0 conv_bpf_c050_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_0_06 (conv_q_src_c050_0_06 conv_q_c050_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_07 (conv_i_src_c050_0_07 0 conv_bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_0_07 (conv_i_src_c050_0_07 conv_i_c050_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_07 (conv_q_src_c050_0_07 0 conv_bpf_c050_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_0_07 (conv_q_src_c050_0_07 conv_q_c050_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_08 (conv_i_src_c050_0_08 0 conv_bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_0_08 (conv_i_src_c050_0_08 conv_i_c050_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_08 (conv_q_src_c050_0_08 0 conv_bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_0_08 (conv_q_src_c050_0_08 conv_q_c050_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_09 (conv_i_src_c050_0_09 0 conv_bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_0_09 (conv_i_src_c050_0_09 conv_i_c050_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_09 (conv_q_src_c050_0_09 0 conv_bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_0_09 (conv_q_src_c050_0_09 conv_q_c050_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_10 (conv_i_src_c050_0_10 0 conv_bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_0_10 (conv_i_src_c050_0_10 conv_i_c050_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_10 (conv_q_src_c050_0_10 0 conv_bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_0_10 (conv_q_src_c050_0_10 conv_q_c050_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_11 (conv_i_src_c050_0_11 0 conv_bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_0_11 (conv_i_src_c050_0_11 conv_i_c050_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_11 (conv_q_src_c050_0_11 0 conv_bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_0_11 (conv_q_src_c050_0_11 conv_q_c050_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_12 (conv_i_src_c050_0_12 0 conv_bpf_c050_0 0) vcvs gain=1.950903220161e-01
SCONVI_c050_0_12 (conv_i_src_c050_0_12 conv_i_c050_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_12 (conv_q_src_c050_0_12 0 conv_bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_0_12 (conv_q_src_c050_0_12 conv_q_c050_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_13 (conv_i_src_c050_0_13 0 conv_bpf_c050_0 0) vcvs gain=5.555702330196e-01
SCONVI_c050_0_13 (conv_i_src_c050_0_13 conv_i_c050_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_13 (conv_q_src_c050_0_13 0 conv_bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_0_13 (conv_q_src_c050_0_13 conv_q_c050_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_14 (conv_i_src_c050_0_14 0 conv_bpf_c050_0 0) vcvs gain=8.314696123025e-01
SCONVI_c050_0_14 (conv_i_src_c050_0_14 conv_i_c050_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_14 (conv_q_src_c050_0_14 0 conv_bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_0_14 (conv_q_src_c050_0_14 conv_q_c050_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_0_15 (conv_i_src_c050_0_15 0 conv_bpf_c050_0 0) vcvs gain=9.807852804032e-01
SCONVI_c050_0_15 (conv_i_src_c050_0_15 conv_i_c050_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_0_15 (conv_q_src_c050_0_15 0 conv_bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_0_15 (conv_q_src_c050_0_15 conv_q_c050_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c050_0 (conv_i_c050_0 0) resistor r=1G
RCONVQ_c050_0 (conv_q_c050_0 0) resistor r=1G
RCONVINTI_c050_0 (conv_i_c050_0 ConvIcar_c050_0) resistor r=1k
CCONVINTI_c050_0 (ConvIcar_c050_0 0) capacitor c=80p
RCONVINTQ_c050_0 (conv_q_c050_0 ConvQcar_c050_0) resistor r=1k
CCONVINTQ_c050_0 (ConvQcar_c050_0 0) capacitor c=80p
save conv_bpf_c050_0 ConvIcar_c050_0 ConvQcar_c050_0

// conventional mixed baseline bl050, carrier_1: 500000000 Hz
CCONVBPF_c050_1 (bl050 n_conv_cbpf_c050_1) capacitor c=1.013211836423e-13
LCONVBPF_c050_1 (n_conv_cbpf_c050_1 conv_bpf_c050_1) inductor l=1.000000000000e-06
RCONVBPF_c050_1 (conv_bpf_c050_1 0) resistor r=1.570796326795e+02
ECONVI_c050_1_00 (conv_i_src_c050_1_00 0 conv_bpf_c050_1 0) vcvs gain=9.807852804032e-01
SCONVI_c050_1_00 (conv_i_src_c050_1_00 conv_i_c050_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_00 (conv_q_src_c050_1_00 0 conv_bpf_c050_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_1_00 (conv_q_src_c050_1_00 conv_q_c050_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_01 (conv_i_src_c050_1_01 0 conv_bpf_c050_1 0) vcvs gain=8.314696123025e-01
SCONVI_c050_1_01 (conv_i_src_c050_1_01 conv_i_c050_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_01 (conv_q_src_c050_1_01 0 conv_bpf_c050_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_1_01 (conv_q_src_c050_1_01 conv_q_c050_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_02 (conv_i_src_c050_1_02 0 conv_bpf_c050_1 0) vcvs gain=5.555702330196e-01
SCONVI_c050_1_02 (conv_i_src_c050_1_02 conv_i_c050_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_02 (conv_q_src_c050_1_02 0 conv_bpf_c050_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_1_02 (conv_q_src_c050_1_02 conv_q_c050_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_03 (conv_i_src_c050_1_03 0 conv_bpf_c050_1 0) vcvs gain=1.950903220161e-01
SCONVI_c050_1_03 (conv_i_src_c050_1_03 conv_i_c050_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_03 (conv_q_src_c050_1_03 0 conv_bpf_c050_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_1_03 (conv_q_src_c050_1_03 conv_q_c050_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_04 (conv_i_src_c050_1_04 0 conv_bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_1_04 (conv_i_src_c050_1_04 conv_i_c050_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_04 (conv_q_src_c050_1_04 0 conv_bpf_c050_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_1_04 (conv_q_src_c050_1_04 conv_q_c050_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_05 (conv_i_src_c050_1_05 0 conv_bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_1_05 (conv_i_src_c050_1_05 conv_i_c050_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_05 (conv_q_src_c050_1_05 0 conv_bpf_c050_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_1_05 (conv_q_src_c050_1_05 conv_q_c050_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_06 (conv_i_src_c050_1_06 0 conv_bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_1_06 (conv_i_src_c050_1_06 conv_i_c050_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_06 (conv_q_src_c050_1_06 0 conv_bpf_c050_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_1_06 (conv_q_src_c050_1_06 conv_q_c050_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_07 (conv_i_src_c050_1_07 0 conv_bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_1_07 (conv_i_src_c050_1_07 conv_i_c050_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_07 (conv_q_src_c050_1_07 0 conv_bpf_c050_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_1_07 (conv_q_src_c050_1_07 conv_q_c050_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_08 (conv_i_src_c050_1_08 0 conv_bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_1_08 (conv_i_src_c050_1_08 conv_i_c050_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_08 (conv_q_src_c050_1_08 0 conv_bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_1_08 (conv_q_src_c050_1_08 conv_q_c050_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_09 (conv_i_src_c050_1_09 0 conv_bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_1_09 (conv_i_src_c050_1_09 conv_i_c050_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_09 (conv_q_src_c050_1_09 0 conv_bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_1_09 (conv_q_src_c050_1_09 conv_q_c050_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_10 (conv_i_src_c050_1_10 0 conv_bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_1_10 (conv_i_src_c050_1_10 conv_i_c050_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_10 (conv_q_src_c050_1_10 0 conv_bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_1_10 (conv_q_src_c050_1_10 conv_q_c050_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_11 (conv_i_src_c050_1_11 0 conv_bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_1_11 (conv_i_src_c050_1_11 conv_i_c050_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_11 (conv_q_src_c050_1_11 0 conv_bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_1_11 (conv_q_src_c050_1_11 conv_q_c050_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_12 (conv_i_src_c050_1_12 0 conv_bpf_c050_1 0) vcvs gain=1.950903220161e-01
SCONVI_c050_1_12 (conv_i_src_c050_1_12 conv_i_c050_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_12 (conv_q_src_c050_1_12 0 conv_bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_1_12 (conv_q_src_c050_1_12 conv_q_c050_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_13 (conv_i_src_c050_1_13 0 conv_bpf_c050_1 0) vcvs gain=5.555702330196e-01
SCONVI_c050_1_13 (conv_i_src_c050_1_13 conv_i_c050_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_13 (conv_q_src_c050_1_13 0 conv_bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_1_13 (conv_q_src_c050_1_13 conv_q_c050_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_14 (conv_i_src_c050_1_14 0 conv_bpf_c050_1 0) vcvs gain=8.314696123025e-01
SCONVI_c050_1_14 (conv_i_src_c050_1_14 conv_i_c050_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_14 (conv_q_src_c050_1_14 0 conv_bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_1_14 (conv_q_src_c050_1_14 conv_q_c050_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_1_15 (conv_i_src_c050_1_15 0 conv_bpf_c050_1 0) vcvs gain=9.807852804032e-01
SCONVI_c050_1_15 (conv_i_src_c050_1_15 conv_i_c050_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_1_15 (conv_q_src_c050_1_15 0 conv_bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_1_15 (conv_q_src_c050_1_15 conv_q_c050_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c050_1 (conv_i_c050_1 0) resistor r=1G
RCONVQ_c050_1 (conv_q_c050_1 0) resistor r=1G
RCONVINTI_c050_1 (conv_i_c050_1 ConvIcar_c050_1) resistor r=1k
CCONVINTI_c050_1 (ConvIcar_c050_1 0) capacitor c=80p
RCONVINTQ_c050_1 (conv_q_c050_1 ConvQcar_c050_1) resistor r=1k
CCONVINTQ_c050_1 (ConvQcar_c050_1 0) capacitor c=80p
save conv_bpf_c050_1 ConvIcar_c050_1 ConvQcar_c050_1

// conventional mixed baseline bl050, carrier_2: 750000000 Hz
CCONVBPF_c050_2 (bl050 n_conv_cbpf_c050_2) capacitor c=4.503163717437e-14
LCONVBPF_c050_2 (n_conv_cbpf_c050_2 conv_bpf_c050_2) inductor l=1.000000000000e-06
RCONVBPF_c050_2 (conv_bpf_c050_2 0) resistor r=2.356194490192e+02
ECONVI_c050_2_00 (conv_i_src_c050_2_00 0 conv_bpf_c050_2 0) vcvs gain=9.807852804032e-01
SCONVI_c050_2_00 (conv_i_src_c050_2_00 conv_i_c050_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_00 (conv_q_src_c050_2_00 0 conv_bpf_c050_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_2_00 (conv_q_src_c050_2_00 conv_q_c050_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_01 (conv_i_src_c050_2_01 0 conv_bpf_c050_2 0) vcvs gain=8.314696123025e-01
SCONVI_c050_2_01 (conv_i_src_c050_2_01 conv_i_c050_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_01 (conv_q_src_c050_2_01 0 conv_bpf_c050_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_2_01 (conv_q_src_c050_2_01 conv_q_c050_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_02 (conv_i_src_c050_2_02 0 conv_bpf_c050_2 0) vcvs gain=5.555702330196e-01
SCONVI_c050_2_02 (conv_i_src_c050_2_02 conv_i_c050_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_02 (conv_q_src_c050_2_02 0 conv_bpf_c050_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_2_02 (conv_q_src_c050_2_02 conv_q_c050_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_03 (conv_i_src_c050_2_03 0 conv_bpf_c050_2 0) vcvs gain=1.950903220161e-01
SCONVI_c050_2_03 (conv_i_src_c050_2_03 conv_i_c050_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_03 (conv_q_src_c050_2_03 0 conv_bpf_c050_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_2_03 (conv_q_src_c050_2_03 conv_q_c050_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_04 (conv_i_src_c050_2_04 0 conv_bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_2_04 (conv_i_src_c050_2_04 conv_i_c050_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_04 (conv_q_src_c050_2_04 0 conv_bpf_c050_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_2_04 (conv_q_src_c050_2_04 conv_q_c050_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_05 (conv_i_src_c050_2_05 0 conv_bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_2_05 (conv_i_src_c050_2_05 conv_i_c050_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_05 (conv_q_src_c050_2_05 0 conv_bpf_c050_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_2_05 (conv_q_src_c050_2_05 conv_q_c050_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_06 (conv_i_src_c050_2_06 0 conv_bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_2_06 (conv_i_src_c050_2_06 conv_i_c050_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_06 (conv_q_src_c050_2_06 0 conv_bpf_c050_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_2_06 (conv_q_src_c050_2_06 conv_q_c050_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_07 (conv_i_src_c050_2_07 0 conv_bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_2_07 (conv_i_src_c050_2_07 conv_i_c050_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_07 (conv_q_src_c050_2_07 0 conv_bpf_c050_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_2_07 (conv_q_src_c050_2_07 conv_q_c050_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_08 (conv_i_src_c050_2_08 0 conv_bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_2_08 (conv_i_src_c050_2_08 conv_i_c050_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_08 (conv_q_src_c050_2_08 0 conv_bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_2_08 (conv_q_src_c050_2_08 conv_q_c050_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_09 (conv_i_src_c050_2_09 0 conv_bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_2_09 (conv_i_src_c050_2_09 conv_i_c050_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_09 (conv_q_src_c050_2_09 0 conv_bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_2_09 (conv_q_src_c050_2_09 conv_q_c050_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_10 (conv_i_src_c050_2_10 0 conv_bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_2_10 (conv_i_src_c050_2_10 conv_i_c050_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_10 (conv_q_src_c050_2_10 0 conv_bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_2_10 (conv_q_src_c050_2_10 conv_q_c050_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_11 (conv_i_src_c050_2_11 0 conv_bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_2_11 (conv_i_src_c050_2_11 conv_i_c050_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_11 (conv_q_src_c050_2_11 0 conv_bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_2_11 (conv_q_src_c050_2_11 conv_q_c050_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_12 (conv_i_src_c050_2_12 0 conv_bpf_c050_2 0) vcvs gain=1.950903220161e-01
SCONVI_c050_2_12 (conv_i_src_c050_2_12 conv_i_c050_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_12 (conv_q_src_c050_2_12 0 conv_bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_2_12 (conv_q_src_c050_2_12 conv_q_c050_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_13 (conv_i_src_c050_2_13 0 conv_bpf_c050_2 0) vcvs gain=5.555702330196e-01
SCONVI_c050_2_13 (conv_i_src_c050_2_13 conv_i_c050_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_13 (conv_q_src_c050_2_13 0 conv_bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_2_13 (conv_q_src_c050_2_13 conv_q_c050_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_14 (conv_i_src_c050_2_14 0 conv_bpf_c050_2 0) vcvs gain=8.314696123025e-01
SCONVI_c050_2_14 (conv_i_src_c050_2_14 conv_i_c050_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_14 (conv_q_src_c050_2_14 0 conv_bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_2_14 (conv_q_src_c050_2_14 conv_q_c050_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_2_15 (conv_i_src_c050_2_15 0 conv_bpf_c050_2 0) vcvs gain=9.807852804032e-01
SCONVI_c050_2_15 (conv_i_src_c050_2_15 conv_i_c050_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_2_15 (conv_q_src_c050_2_15 0 conv_bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_2_15 (conv_q_src_c050_2_15 conv_q_c050_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c050_2 (conv_i_c050_2 0) resistor r=1G
RCONVQ_c050_2 (conv_q_c050_2 0) resistor r=1G
RCONVINTI_c050_2 (conv_i_c050_2 ConvIcar_c050_2) resistor r=1k
CCONVINTI_c050_2 (ConvIcar_c050_2 0) capacitor c=80p
RCONVINTQ_c050_2 (conv_q_c050_2 ConvQcar_c050_2) resistor r=1k
CCONVINTQ_c050_2 (ConvQcar_c050_2 0) capacitor c=80p
save conv_bpf_c050_2 ConvIcar_c050_2 ConvQcar_c050_2

// conventional mixed baseline bl050, carrier_3: 1000000000 Hz
CCONVBPF_c050_3 (bl050 n_conv_cbpf_c050_3) capacitor c=2.533029591058e-14
LCONVBPF_c050_3 (n_conv_cbpf_c050_3 conv_bpf_c050_3) inductor l=1.000000000000e-06
RCONVBPF_c050_3 (conv_bpf_c050_3 0) resistor r=3.141592653590e+02
ECONVI_c050_3_00 (conv_i_src_c050_3_00 0 conv_bpf_c050_3 0) vcvs gain=9.807852804032e-01
SCONVI_c050_3_00 (conv_i_src_c050_3_00 conv_i_c050_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_00 (conv_q_src_c050_3_00 0 conv_bpf_c050_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_3_00 (conv_q_src_c050_3_00 conv_q_c050_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_01 (conv_i_src_c050_3_01 0 conv_bpf_c050_3 0) vcvs gain=8.314696123025e-01
SCONVI_c050_3_01 (conv_i_src_c050_3_01 conv_i_c050_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_01 (conv_q_src_c050_3_01 0 conv_bpf_c050_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_3_01 (conv_q_src_c050_3_01 conv_q_c050_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_02 (conv_i_src_c050_3_02 0 conv_bpf_c050_3 0) vcvs gain=5.555702330196e-01
SCONVI_c050_3_02 (conv_i_src_c050_3_02 conv_i_c050_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_02 (conv_q_src_c050_3_02 0 conv_bpf_c050_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_3_02 (conv_q_src_c050_3_02 conv_q_c050_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_03 (conv_i_src_c050_3_03 0 conv_bpf_c050_3 0) vcvs gain=1.950903220161e-01
SCONVI_c050_3_03 (conv_i_src_c050_3_03 conv_i_c050_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_03 (conv_q_src_c050_3_03 0 conv_bpf_c050_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_3_03 (conv_q_src_c050_3_03 conv_q_c050_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_04 (conv_i_src_c050_3_04 0 conv_bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_3_04 (conv_i_src_c050_3_04 conv_i_c050_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_04 (conv_q_src_c050_3_04 0 conv_bpf_c050_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c050_3_04 (conv_q_src_c050_3_04 conv_q_c050_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_05 (conv_i_src_c050_3_05 0 conv_bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_3_05 (conv_i_src_c050_3_05 conv_i_c050_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_05 (conv_q_src_c050_3_05 0 conv_bpf_c050_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c050_3_05 (conv_q_src_c050_3_05 conv_q_c050_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_06 (conv_i_src_c050_3_06 0 conv_bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_3_06 (conv_i_src_c050_3_06 conv_i_c050_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_06 (conv_q_src_c050_3_06 0 conv_bpf_c050_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c050_3_06 (conv_q_src_c050_3_06 conv_q_c050_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_07 (conv_i_src_c050_3_07 0 conv_bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_3_07 (conv_i_src_c050_3_07 conv_i_c050_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_07 (conv_q_src_c050_3_07 0 conv_bpf_c050_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c050_3_07 (conv_q_src_c050_3_07 conv_q_c050_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_08 (conv_i_src_c050_3_08 0 conv_bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c050_3_08 (conv_i_src_c050_3_08 conv_i_c050_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_08 (conv_q_src_c050_3_08 0 conv_bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_3_08 (conv_q_src_c050_3_08 conv_q_c050_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_09 (conv_i_src_c050_3_09 0 conv_bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c050_3_09 (conv_i_src_c050_3_09 conv_i_c050_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_09 (conv_q_src_c050_3_09 0 conv_bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_3_09 (conv_q_src_c050_3_09 conv_q_c050_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_10 (conv_i_src_c050_3_10 0 conv_bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c050_3_10 (conv_i_src_c050_3_10 conv_i_c050_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_10 (conv_q_src_c050_3_10 0 conv_bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_3_10 (conv_q_src_c050_3_10 conv_q_c050_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_11 (conv_i_src_c050_3_11 0 conv_bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c050_3_11 (conv_i_src_c050_3_11 conv_i_c050_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_11 (conv_q_src_c050_3_11 0 conv_bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_3_11 (conv_q_src_c050_3_11 conv_q_c050_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_12 (conv_i_src_c050_3_12 0 conv_bpf_c050_3 0) vcvs gain=1.950903220161e-01
SCONVI_c050_3_12 (conv_i_src_c050_3_12 conv_i_c050_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_12 (conv_q_src_c050_3_12 0 conv_bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c050_3_12 (conv_q_src_c050_3_12 conv_q_c050_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_13 (conv_i_src_c050_3_13 0 conv_bpf_c050_3 0) vcvs gain=5.555702330196e-01
SCONVI_c050_3_13 (conv_i_src_c050_3_13 conv_i_c050_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_13 (conv_q_src_c050_3_13 0 conv_bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c050_3_13 (conv_q_src_c050_3_13 conv_q_c050_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_14 (conv_i_src_c050_3_14 0 conv_bpf_c050_3 0) vcvs gain=8.314696123025e-01
SCONVI_c050_3_14 (conv_i_src_c050_3_14 conv_i_c050_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_14 (conv_q_src_c050_3_14 0 conv_bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c050_3_14 (conv_q_src_c050_3_14 conv_q_c050_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c050_3_15 (conv_i_src_c050_3_15 0 conv_bpf_c050_3 0) vcvs gain=9.807852804032e-01
SCONVI_c050_3_15 (conv_i_src_c050_3_15 conv_i_c050_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c050_3_15 (conv_q_src_c050_3_15 0 conv_bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c050_3_15 (conv_q_src_c050_3_15 conv_q_c050_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c050_3 (conv_i_c050_3 0) resistor r=1G
RCONVQ_c050_3 (conv_q_c050_3 0) resistor r=1G
RCONVINTI_c050_3 (conv_i_c050_3 ConvIcar_c050_3) resistor r=1k
CCONVINTI_c050_3 (ConvIcar_c050_3 0) capacitor c=80p
RCONVINTQ_c050_3 (conv_q_c050_3 ConvQcar_c050_3) resistor r=1k
CCONVINTQ_c050_3 (ConvQcar_c050_3 0) capacitor c=80p
save conv_bpf_c050_3 ConvIcar_c050_3 ConvQcar_c050_3

// conventional mixed baseline bl051, carrier_0: 250000000 Hz
CCONVBPF_c051_0 (bl051 n_conv_cbpf_c051_0) capacitor c=4.052847345694e-13
LCONVBPF_c051_0 (n_conv_cbpf_c051_0 conv_bpf_c051_0) inductor l=1.000000000000e-06
RCONVBPF_c051_0 (conv_bpf_c051_0 0) resistor r=7.853981633974e+01
ECONVI_c051_0_00 (conv_i_src_c051_0_00 0 conv_bpf_c051_0 0) vcvs gain=9.807852804032e-01
SCONVI_c051_0_00 (conv_i_src_c051_0_00 conv_i_c051_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_00 (conv_q_src_c051_0_00 0 conv_bpf_c051_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_0_00 (conv_q_src_c051_0_00 conv_q_c051_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_01 (conv_i_src_c051_0_01 0 conv_bpf_c051_0 0) vcvs gain=8.314696123025e-01
SCONVI_c051_0_01 (conv_i_src_c051_0_01 conv_i_c051_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_01 (conv_q_src_c051_0_01 0 conv_bpf_c051_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_0_01 (conv_q_src_c051_0_01 conv_q_c051_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_02 (conv_i_src_c051_0_02 0 conv_bpf_c051_0 0) vcvs gain=5.555702330196e-01
SCONVI_c051_0_02 (conv_i_src_c051_0_02 conv_i_c051_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_02 (conv_q_src_c051_0_02 0 conv_bpf_c051_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_0_02 (conv_q_src_c051_0_02 conv_q_c051_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_03 (conv_i_src_c051_0_03 0 conv_bpf_c051_0 0) vcvs gain=1.950903220161e-01
SCONVI_c051_0_03 (conv_i_src_c051_0_03 conv_i_c051_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_03 (conv_q_src_c051_0_03 0 conv_bpf_c051_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_0_03 (conv_q_src_c051_0_03 conv_q_c051_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_04 (conv_i_src_c051_0_04 0 conv_bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_0_04 (conv_i_src_c051_0_04 conv_i_c051_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_04 (conv_q_src_c051_0_04 0 conv_bpf_c051_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_0_04 (conv_q_src_c051_0_04 conv_q_c051_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_05 (conv_i_src_c051_0_05 0 conv_bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_0_05 (conv_i_src_c051_0_05 conv_i_c051_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_05 (conv_q_src_c051_0_05 0 conv_bpf_c051_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_0_05 (conv_q_src_c051_0_05 conv_q_c051_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_06 (conv_i_src_c051_0_06 0 conv_bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_0_06 (conv_i_src_c051_0_06 conv_i_c051_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_06 (conv_q_src_c051_0_06 0 conv_bpf_c051_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_0_06 (conv_q_src_c051_0_06 conv_q_c051_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_07 (conv_i_src_c051_0_07 0 conv_bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_0_07 (conv_i_src_c051_0_07 conv_i_c051_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_07 (conv_q_src_c051_0_07 0 conv_bpf_c051_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_0_07 (conv_q_src_c051_0_07 conv_q_c051_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_08 (conv_i_src_c051_0_08 0 conv_bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_0_08 (conv_i_src_c051_0_08 conv_i_c051_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_08 (conv_q_src_c051_0_08 0 conv_bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_0_08 (conv_q_src_c051_0_08 conv_q_c051_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_09 (conv_i_src_c051_0_09 0 conv_bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_0_09 (conv_i_src_c051_0_09 conv_i_c051_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_09 (conv_q_src_c051_0_09 0 conv_bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_0_09 (conv_q_src_c051_0_09 conv_q_c051_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_10 (conv_i_src_c051_0_10 0 conv_bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_0_10 (conv_i_src_c051_0_10 conv_i_c051_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_10 (conv_q_src_c051_0_10 0 conv_bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_0_10 (conv_q_src_c051_0_10 conv_q_c051_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_11 (conv_i_src_c051_0_11 0 conv_bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_0_11 (conv_i_src_c051_0_11 conv_i_c051_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_11 (conv_q_src_c051_0_11 0 conv_bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_0_11 (conv_q_src_c051_0_11 conv_q_c051_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_12 (conv_i_src_c051_0_12 0 conv_bpf_c051_0 0) vcvs gain=1.950903220161e-01
SCONVI_c051_0_12 (conv_i_src_c051_0_12 conv_i_c051_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_12 (conv_q_src_c051_0_12 0 conv_bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_0_12 (conv_q_src_c051_0_12 conv_q_c051_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_13 (conv_i_src_c051_0_13 0 conv_bpf_c051_0 0) vcvs gain=5.555702330196e-01
SCONVI_c051_0_13 (conv_i_src_c051_0_13 conv_i_c051_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_13 (conv_q_src_c051_0_13 0 conv_bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_0_13 (conv_q_src_c051_0_13 conv_q_c051_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_14 (conv_i_src_c051_0_14 0 conv_bpf_c051_0 0) vcvs gain=8.314696123025e-01
SCONVI_c051_0_14 (conv_i_src_c051_0_14 conv_i_c051_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_14 (conv_q_src_c051_0_14 0 conv_bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_0_14 (conv_q_src_c051_0_14 conv_q_c051_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_0_15 (conv_i_src_c051_0_15 0 conv_bpf_c051_0 0) vcvs gain=9.807852804032e-01
SCONVI_c051_0_15 (conv_i_src_c051_0_15 conv_i_c051_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_0_15 (conv_q_src_c051_0_15 0 conv_bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_0_15 (conv_q_src_c051_0_15 conv_q_c051_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c051_0 (conv_i_c051_0 0) resistor r=1G
RCONVQ_c051_0 (conv_q_c051_0 0) resistor r=1G
RCONVINTI_c051_0 (conv_i_c051_0 ConvIcar_c051_0) resistor r=1k
CCONVINTI_c051_0 (ConvIcar_c051_0 0) capacitor c=80p
RCONVINTQ_c051_0 (conv_q_c051_0 ConvQcar_c051_0) resistor r=1k
CCONVINTQ_c051_0 (ConvQcar_c051_0 0) capacitor c=80p
save conv_bpf_c051_0 ConvIcar_c051_0 ConvQcar_c051_0

// conventional mixed baseline bl051, carrier_1: 500000000 Hz
CCONVBPF_c051_1 (bl051 n_conv_cbpf_c051_1) capacitor c=1.013211836423e-13
LCONVBPF_c051_1 (n_conv_cbpf_c051_1 conv_bpf_c051_1) inductor l=1.000000000000e-06
RCONVBPF_c051_1 (conv_bpf_c051_1 0) resistor r=1.570796326795e+02
ECONVI_c051_1_00 (conv_i_src_c051_1_00 0 conv_bpf_c051_1 0) vcvs gain=9.807852804032e-01
SCONVI_c051_1_00 (conv_i_src_c051_1_00 conv_i_c051_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_00 (conv_q_src_c051_1_00 0 conv_bpf_c051_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_1_00 (conv_q_src_c051_1_00 conv_q_c051_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_01 (conv_i_src_c051_1_01 0 conv_bpf_c051_1 0) vcvs gain=8.314696123025e-01
SCONVI_c051_1_01 (conv_i_src_c051_1_01 conv_i_c051_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_01 (conv_q_src_c051_1_01 0 conv_bpf_c051_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_1_01 (conv_q_src_c051_1_01 conv_q_c051_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_02 (conv_i_src_c051_1_02 0 conv_bpf_c051_1 0) vcvs gain=5.555702330196e-01
SCONVI_c051_1_02 (conv_i_src_c051_1_02 conv_i_c051_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_02 (conv_q_src_c051_1_02 0 conv_bpf_c051_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_1_02 (conv_q_src_c051_1_02 conv_q_c051_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_03 (conv_i_src_c051_1_03 0 conv_bpf_c051_1 0) vcvs gain=1.950903220161e-01
SCONVI_c051_1_03 (conv_i_src_c051_1_03 conv_i_c051_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_03 (conv_q_src_c051_1_03 0 conv_bpf_c051_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_1_03 (conv_q_src_c051_1_03 conv_q_c051_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_04 (conv_i_src_c051_1_04 0 conv_bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_1_04 (conv_i_src_c051_1_04 conv_i_c051_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_04 (conv_q_src_c051_1_04 0 conv_bpf_c051_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_1_04 (conv_q_src_c051_1_04 conv_q_c051_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_05 (conv_i_src_c051_1_05 0 conv_bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_1_05 (conv_i_src_c051_1_05 conv_i_c051_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_05 (conv_q_src_c051_1_05 0 conv_bpf_c051_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_1_05 (conv_q_src_c051_1_05 conv_q_c051_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_06 (conv_i_src_c051_1_06 0 conv_bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_1_06 (conv_i_src_c051_1_06 conv_i_c051_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_06 (conv_q_src_c051_1_06 0 conv_bpf_c051_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_1_06 (conv_q_src_c051_1_06 conv_q_c051_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_07 (conv_i_src_c051_1_07 0 conv_bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_1_07 (conv_i_src_c051_1_07 conv_i_c051_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_07 (conv_q_src_c051_1_07 0 conv_bpf_c051_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_1_07 (conv_q_src_c051_1_07 conv_q_c051_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_08 (conv_i_src_c051_1_08 0 conv_bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_1_08 (conv_i_src_c051_1_08 conv_i_c051_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_08 (conv_q_src_c051_1_08 0 conv_bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_1_08 (conv_q_src_c051_1_08 conv_q_c051_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_09 (conv_i_src_c051_1_09 0 conv_bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_1_09 (conv_i_src_c051_1_09 conv_i_c051_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_09 (conv_q_src_c051_1_09 0 conv_bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_1_09 (conv_q_src_c051_1_09 conv_q_c051_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_10 (conv_i_src_c051_1_10 0 conv_bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_1_10 (conv_i_src_c051_1_10 conv_i_c051_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_10 (conv_q_src_c051_1_10 0 conv_bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_1_10 (conv_q_src_c051_1_10 conv_q_c051_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_11 (conv_i_src_c051_1_11 0 conv_bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_1_11 (conv_i_src_c051_1_11 conv_i_c051_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_11 (conv_q_src_c051_1_11 0 conv_bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_1_11 (conv_q_src_c051_1_11 conv_q_c051_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_12 (conv_i_src_c051_1_12 0 conv_bpf_c051_1 0) vcvs gain=1.950903220161e-01
SCONVI_c051_1_12 (conv_i_src_c051_1_12 conv_i_c051_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_12 (conv_q_src_c051_1_12 0 conv_bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_1_12 (conv_q_src_c051_1_12 conv_q_c051_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_13 (conv_i_src_c051_1_13 0 conv_bpf_c051_1 0) vcvs gain=5.555702330196e-01
SCONVI_c051_1_13 (conv_i_src_c051_1_13 conv_i_c051_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_13 (conv_q_src_c051_1_13 0 conv_bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_1_13 (conv_q_src_c051_1_13 conv_q_c051_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_14 (conv_i_src_c051_1_14 0 conv_bpf_c051_1 0) vcvs gain=8.314696123025e-01
SCONVI_c051_1_14 (conv_i_src_c051_1_14 conv_i_c051_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_14 (conv_q_src_c051_1_14 0 conv_bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_1_14 (conv_q_src_c051_1_14 conv_q_c051_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_1_15 (conv_i_src_c051_1_15 0 conv_bpf_c051_1 0) vcvs gain=9.807852804032e-01
SCONVI_c051_1_15 (conv_i_src_c051_1_15 conv_i_c051_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_1_15 (conv_q_src_c051_1_15 0 conv_bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_1_15 (conv_q_src_c051_1_15 conv_q_c051_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c051_1 (conv_i_c051_1 0) resistor r=1G
RCONVQ_c051_1 (conv_q_c051_1 0) resistor r=1G
RCONVINTI_c051_1 (conv_i_c051_1 ConvIcar_c051_1) resistor r=1k
CCONVINTI_c051_1 (ConvIcar_c051_1 0) capacitor c=80p
RCONVINTQ_c051_1 (conv_q_c051_1 ConvQcar_c051_1) resistor r=1k
CCONVINTQ_c051_1 (ConvQcar_c051_1 0) capacitor c=80p
save conv_bpf_c051_1 ConvIcar_c051_1 ConvQcar_c051_1

// conventional mixed baseline bl051, carrier_2: 750000000 Hz
CCONVBPF_c051_2 (bl051 n_conv_cbpf_c051_2) capacitor c=4.503163717437e-14
LCONVBPF_c051_2 (n_conv_cbpf_c051_2 conv_bpf_c051_2) inductor l=1.000000000000e-06
RCONVBPF_c051_2 (conv_bpf_c051_2 0) resistor r=2.356194490192e+02
ECONVI_c051_2_00 (conv_i_src_c051_2_00 0 conv_bpf_c051_2 0) vcvs gain=9.807852804032e-01
SCONVI_c051_2_00 (conv_i_src_c051_2_00 conv_i_c051_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_00 (conv_q_src_c051_2_00 0 conv_bpf_c051_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_2_00 (conv_q_src_c051_2_00 conv_q_c051_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_01 (conv_i_src_c051_2_01 0 conv_bpf_c051_2 0) vcvs gain=8.314696123025e-01
SCONVI_c051_2_01 (conv_i_src_c051_2_01 conv_i_c051_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_01 (conv_q_src_c051_2_01 0 conv_bpf_c051_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_2_01 (conv_q_src_c051_2_01 conv_q_c051_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_02 (conv_i_src_c051_2_02 0 conv_bpf_c051_2 0) vcvs gain=5.555702330196e-01
SCONVI_c051_2_02 (conv_i_src_c051_2_02 conv_i_c051_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_02 (conv_q_src_c051_2_02 0 conv_bpf_c051_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_2_02 (conv_q_src_c051_2_02 conv_q_c051_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_03 (conv_i_src_c051_2_03 0 conv_bpf_c051_2 0) vcvs gain=1.950903220161e-01
SCONVI_c051_2_03 (conv_i_src_c051_2_03 conv_i_c051_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_03 (conv_q_src_c051_2_03 0 conv_bpf_c051_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_2_03 (conv_q_src_c051_2_03 conv_q_c051_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_04 (conv_i_src_c051_2_04 0 conv_bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_2_04 (conv_i_src_c051_2_04 conv_i_c051_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_04 (conv_q_src_c051_2_04 0 conv_bpf_c051_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_2_04 (conv_q_src_c051_2_04 conv_q_c051_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_05 (conv_i_src_c051_2_05 0 conv_bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_2_05 (conv_i_src_c051_2_05 conv_i_c051_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_05 (conv_q_src_c051_2_05 0 conv_bpf_c051_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_2_05 (conv_q_src_c051_2_05 conv_q_c051_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_06 (conv_i_src_c051_2_06 0 conv_bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_2_06 (conv_i_src_c051_2_06 conv_i_c051_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_06 (conv_q_src_c051_2_06 0 conv_bpf_c051_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_2_06 (conv_q_src_c051_2_06 conv_q_c051_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_07 (conv_i_src_c051_2_07 0 conv_bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_2_07 (conv_i_src_c051_2_07 conv_i_c051_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_07 (conv_q_src_c051_2_07 0 conv_bpf_c051_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_2_07 (conv_q_src_c051_2_07 conv_q_c051_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_08 (conv_i_src_c051_2_08 0 conv_bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_2_08 (conv_i_src_c051_2_08 conv_i_c051_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_08 (conv_q_src_c051_2_08 0 conv_bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_2_08 (conv_q_src_c051_2_08 conv_q_c051_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_09 (conv_i_src_c051_2_09 0 conv_bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_2_09 (conv_i_src_c051_2_09 conv_i_c051_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_09 (conv_q_src_c051_2_09 0 conv_bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_2_09 (conv_q_src_c051_2_09 conv_q_c051_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_10 (conv_i_src_c051_2_10 0 conv_bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_2_10 (conv_i_src_c051_2_10 conv_i_c051_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_10 (conv_q_src_c051_2_10 0 conv_bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_2_10 (conv_q_src_c051_2_10 conv_q_c051_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_11 (conv_i_src_c051_2_11 0 conv_bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_2_11 (conv_i_src_c051_2_11 conv_i_c051_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_11 (conv_q_src_c051_2_11 0 conv_bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_2_11 (conv_q_src_c051_2_11 conv_q_c051_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_12 (conv_i_src_c051_2_12 0 conv_bpf_c051_2 0) vcvs gain=1.950903220161e-01
SCONVI_c051_2_12 (conv_i_src_c051_2_12 conv_i_c051_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_12 (conv_q_src_c051_2_12 0 conv_bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_2_12 (conv_q_src_c051_2_12 conv_q_c051_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_13 (conv_i_src_c051_2_13 0 conv_bpf_c051_2 0) vcvs gain=5.555702330196e-01
SCONVI_c051_2_13 (conv_i_src_c051_2_13 conv_i_c051_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_13 (conv_q_src_c051_2_13 0 conv_bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_2_13 (conv_q_src_c051_2_13 conv_q_c051_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_14 (conv_i_src_c051_2_14 0 conv_bpf_c051_2 0) vcvs gain=8.314696123025e-01
SCONVI_c051_2_14 (conv_i_src_c051_2_14 conv_i_c051_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_14 (conv_q_src_c051_2_14 0 conv_bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_2_14 (conv_q_src_c051_2_14 conv_q_c051_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_2_15 (conv_i_src_c051_2_15 0 conv_bpf_c051_2 0) vcvs gain=9.807852804032e-01
SCONVI_c051_2_15 (conv_i_src_c051_2_15 conv_i_c051_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_2_15 (conv_q_src_c051_2_15 0 conv_bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_2_15 (conv_q_src_c051_2_15 conv_q_c051_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c051_2 (conv_i_c051_2 0) resistor r=1G
RCONVQ_c051_2 (conv_q_c051_2 0) resistor r=1G
RCONVINTI_c051_2 (conv_i_c051_2 ConvIcar_c051_2) resistor r=1k
CCONVINTI_c051_2 (ConvIcar_c051_2 0) capacitor c=80p
RCONVINTQ_c051_2 (conv_q_c051_2 ConvQcar_c051_2) resistor r=1k
CCONVINTQ_c051_2 (ConvQcar_c051_2 0) capacitor c=80p
save conv_bpf_c051_2 ConvIcar_c051_2 ConvQcar_c051_2

// conventional mixed baseline bl051, carrier_3: 1000000000 Hz
CCONVBPF_c051_3 (bl051 n_conv_cbpf_c051_3) capacitor c=2.533029591058e-14
LCONVBPF_c051_3 (n_conv_cbpf_c051_3 conv_bpf_c051_3) inductor l=1.000000000000e-06
RCONVBPF_c051_3 (conv_bpf_c051_3 0) resistor r=3.141592653590e+02
ECONVI_c051_3_00 (conv_i_src_c051_3_00 0 conv_bpf_c051_3 0) vcvs gain=9.807852804032e-01
SCONVI_c051_3_00 (conv_i_src_c051_3_00 conv_i_c051_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_00 (conv_q_src_c051_3_00 0 conv_bpf_c051_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_3_00 (conv_q_src_c051_3_00 conv_q_c051_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_01 (conv_i_src_c051_3_01 0 conv_bpf_c051_3 0) vcvs gain=8.314696123025e-01
SCONVI_c051_3_01 (conv_i_src_c051_3_01 conv_i_c051_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_01 (conv_q_src_c051_3_01 0 conv_bpf_c051_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_3_01 (conv_q_src_c051_3_01 conv_q_c051_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_02 (conv_i_src_c051_3_02 0 conv_bpf_c051_3 0) vcvs gain=5.555702330196e-01
SCONVI_c051_3_02 (conv_i_src_c051_3_02 conv_i_c051_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_02 (conv_q_src_c051_3_02 0 conv_bpf_c051_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_3_02 (conv_q_src_c051_3_02 conv_q_c051_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_03 (conv_i_src_c051_3_03 0 conv_bpf_c051_3 0) vcvs gain=1.950903220161e-01
SCONVI_c051_3_03 (conv_i_src_c051_3_03 conv_i_c051_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_03 (conv_q_src_c051_3_03 0 conv_bpf_c051_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_3_03 (conv_q_src_c051_3_03 conv_q_c051_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_04 (conv_i_src_c051_3_04 0 conv_bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_3_04 (conv_i_src_c051_3_04 conv_i_c051_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_04 (conv_q_src_c051_3_04 0 conv_bpf_c051_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c051_3_04 (conv_q_src_c051_3_04 conv_q_c051_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_05 (conv_i_src_c051_3_05 0 conv_bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_3_05 (conv_i_src_c051_3_05 conv_i_c051_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_05 (conv_q_src_c051_3_05 0 conv_bpf_c051_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c051_3_05 (conv_q_src_c051_3_05 conv_q_c051_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_06 (conv_i_src_c051_3_06 0 conv_bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_3_06 (conv_i_src_c051_3_06 conv_i_c051_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_06 (conv_q_src_c051_3_06 0 conv_bpf_c051_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c051_3_06 (conv_q_src_c051_3_06 conv_q_c051_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_07 (conv_i_src_c051_3_07 0 conv_bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_3_07 (conv_i_src_c051_3_07 conv_i_c051_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_07 (conv_q_src_c051_3_07 0 conv_bpf_c051_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c051_3_07 (conv_q_src_c051_3_07 conv_q_c051_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_08 (conv_i_src_c051_3_08 0 conv_bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c051_3_08 (conv_i_src_c051_3_08 conv_i_c051_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_08 (conv_q_src_c051_3_08 0 conv_bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_3_08 (conv_q_src_c051_3_08 conv_q_c051_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_09 (conv_i_src_c051_3_09 0 conv_bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c051_3_09 (conv_i_src_c051_3_09 conv_i_c051_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_09 (conv_q_src_c051_3_09 0 conv_bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_3_09 (conv_q_src_c051_3_09 conv_q_c051_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_10 (conv_i_src_c051_3_10 0 conv_bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c051_3_10 (conv_i_src_c051_3_10 conv_i_c051_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_10 (conv_q_src_c051_3_10 0 conv_bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_3_10 (conv_q_src_c051_3_10 conv_q_c051_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_11 (conv_i_src_c051_3_11 0 conv_bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c051_3_11 (conv_i_src_c051_3_11 conv_i_c051_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_11 (conv_q_src_c051_3_11 0 conv_bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_3_11 (conv_q_src_c051_3_11 conv_q_c051_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_12 (conv_i_src_c051_3_12 0 conv_bpf_c051_3 0) vcvs gain=1.950903220161e-01
SCONVI_c051_3_12 (conv_i_src_c051_3_12 conv_i_c051_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_12 (conv_q_src_c051_3_12 0 conv_bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c051_3_12 (conv_q_src_c051_3_12 conv_q_c051_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_13 (conv_i_src_c051_3_13 0 conv_bpf_c051_3 0) vcvs gain=5.555702330196e-01
SCONVI_c051_3_13 (conv_i_src_c051_3_13 conv_i_c051_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_13 (conv_q_src_c051_3_13 0 conv_bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c051_3_13 (conv_q_src_c051_3_13 conv_q_c051_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_14 (conv_i_src_c051_3_14 0 conv_bpf_c051_3 0) vcvs gain=8.314696123025e-01
SCONVI_c051_3_14 (conv_i_src_c051_3_14 conv_i_c051_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_14 (conv_q_src_c051_3_14 0 conv_bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c051_3_14 (conv_q_src_c051_3_14 conv_q_c051_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c051_3_15 (conv_i_src_c051_3_15 0 conv_bpf_c051_3 0) vcvs gain=9.807852804032e-01
SCONVI_c051_3_15 (conv_i_src_c051_3_15 conv_i_c051_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c051_3_15 (conv_q_src_c051_3_15 0 conv_bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c051_3_15 (conv_q_src_c051_3_15 conv_q_c051_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c051_3 (conv_i_c051_3 0) resistor r=1G
RCONVQ_c051_3 (conv_q_c051_3 0) resistor r=1G
RCONVINTI_c051_3 (conv_i_c051_3 ConvIcar_c051_3) resistor r=1k
CCONVINTI_c051_3 (ConvIcar_c051_3 0) capacitor c=80p
RCONVINTQ_c051_3 (conv_q_c051_3 ConvQcar_c051_3) resistor r=1k
CCONVINTQ_c051_3 (ConvQcar_c051_3 0) capacitor c=80p
save conv_bpf_c051_3 ConvIcar_c051_3 ConvQcar_c051_3

// conventional mixed baseline bl052, carrier_0: 250000000 Hz
CCONVBPF_c052_0 (bl052 n_conv_cbpf_c052_0) capacitor c=4.052847345694e-13
LCONVBPF_c052_0 (n_conv_cbpf_c052_0 conv_bpf_c052_0) inductor l=1.000000000000e-06
RCONVBPF_c052_0 (conv_bpf_c052_0 0) resistor r=7.853981633974e+01
ECONVI_c052_0_00 (conv_i_src_c052_0_00 0 conv_bpf_c052_0 0) vcvs gain=9.807852804032e-01
SCONVI_c052_0_00 (conv_i_src_c052_0_00 conv_i_c052_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_00 (conv_q_src_c052_0_00 0 conv_bpf_c052_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_0_00 (conv_q_src_c052_0_00 conv_q_c052_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_01 (conv_i_src_c052_0_01 0 conv_bpf_c052_0 0) vcvs gain=8.314696123025e-01
SCONVI_c052_0_01 (conv_i_src_c052_0_01 conv_i_c052_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_01 (conv_q_src_c052_0_01 0 conv_bpf_c052_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_0_01 (conv_q_src_c052_0_01 conv_q_c052_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_02 (conv_i_src_c052_0_02 0 conv_bpf_c052_0 0) vcvs gain=5.555702330196e-01
SCONVI_c052_0_02 (conv_i_src_c052_0_02 conv_i_c052_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_02 (conv_q_src_c052_0_02 0 conv_bpf_c052_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_0_02 (conv_q_src_c052_0_02 conv_q_c052_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_03 (conv_i_src_c052_0_03 0 conv_bpf_c052_0 0) vcvs gain=1.950903220161e-01
SCONVI_c052_0_03 (conv_i_src_c052_0_03 conv_i_c052_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_03 (conv_q_src_c052_0_03 0 conv_bpf_c052_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c052_0_03 (conv_q_src_c052_0_03 conv_q_c052_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_04 (conv_i_src_c052_0_04 0 conv_bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_0_04 (conv_i_src_c052_0_04 conv_i_c052_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_04 (conv_q_src_c052_0_04 0 conv_bpf_c052_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c052_0_04 (conv_q_src_c052_0_04 conv_q_c052_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_05 (conv_i_src_c052_0_05 0 conv_bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_0_05 (conv_i_src_c052_0_05 conv_i_c052_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_05 (conv_q_src_c052_0_05 0 conv_bpf_c052_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_0_05 (conv_q_src_c052_0_05 conv_q_c052_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_06 (conv_i_src_c052_0_06 0 conv_bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_0_06 (conv_i_src_c052_0_06 conv_i_c052_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_06 (conv_q_src_c052_0_06 0 conv_bpf_c052_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_0_06 (conv_q_src_c052_0_06 conv_q_c052_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_07 (conv_i_src_c052_0_07 0 conv_bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_0_07 (conv_i_src_c052_0_07 conv_i_c052_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_07 (conv_q_src_c052_0_07 0 conv_bpf_c052_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_0_07 (conv_q_src_c052_0_07 conv_q_c052_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_08 (conv_i_src_c052_0_08 0 conv_bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_0_08 (conv_i_src_c052_0_08 conv_i_c052_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_08 (conv_q_src_c052_0_08 0 conv_bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_0_08 (conv_q_src_c052_0_08 conv_q_c052_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_09 (conv_i_src_c052_0_09 0 conv_bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_0_09 (conv_i_src_c052_0_09 conv_i_c052_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_09 (conv_q_src_c052_0_09 0 conv_bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_0_09 (conv_q_src_c052_0_09 conv_q_c052_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_10 (conv_i_src_c052_0_10 0 conv_bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_0_10 (conv_i_src_c052_0_10 conv_i_c052_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_10 (conv_q_src_c052_0_10 0 conv_bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_0_10 (conv_q_src_c052_0_10 conv_q_c052_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_11 (conv_i_src_c052_0_11 0 conv_bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_0_11 (conv_i_src_c052_0_11 conv_i_c052_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_11 (conv_q_src_c052_0_11 0 conv_bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_0_11 (conv_q_src_c052_0_11 conv_q_c052_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_12 (conv_i_src_c052_0_12 0 conv_bpf_c052_0 0) vcvs gain=1.950903220161e-01
SCONVI_c052_0_12 (conv_i_src_c052_0_12 conv_i_c052_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_12 (conv_q_src_c052_0_12 0 conv_bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_0_12 (conv_q_src_c052_0_12 conv_q_c052_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_13 (conv_i_src_c052_0_13 0 conv_bpf_c052_0 0) vcvs gain=5.555702330196e-01
SCONVI_c052_0_13 (conv_i_src_c052_0_13 conv_i_c052_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_13 (conv_q_src_c052_0_13 0 conv_bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_0_13 (conv_q_src_c052_0_13 conv_q_c052_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_14 (conv_i_src_c052_0_14 0 conv_bpf_c052_0 0) vcvs gain=8.314696123025e-01
SCONVI_c052_0_14 (conv_i_src_c052_0_14 conv_i_c052_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_14 (conv_q_src_c052_0_14 0 conv_bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_0_14 (conv_q_src_c052_0_14 conv_q_c052_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_0_15 (conv_i_src_c052_0_15 0 conv_bpf_c052_0 0) vcvs gain=9.807852804032e-01
SCONVI_c052_0_15 (conv_i_src_c052_0_15 conv_i_c052_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_0_15 (conv_q_src_c052_0_15 0 conv_bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_0_15 (conv_q_src_c052_0_15 conv_q_c052_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c052_0 (conv_i_c052_0 0) resistor r=1G
RCONVQ_c052_0 (conv_q_c052_0 0) resistor r=1G
RCONVINTI_c052_0 (conv_i_c052_0 ConvIcar_c052_0) resistor r=1k
CCONVINTI_c052_0 (ConvIcar_c052_0 0) capacitor c=80p
RCONVINTQ_c052_0 (conv_q_c052_0 ConvQcar_c052_0) resistor r=1k
CCONVINTQ_c052_0 (ConvQcar_c052_0 0) capacitor c=80p
save conv_bpf_c052_0 ConvIcar_c052_0 ConvQcar_c052_0

// conventional mixed baseline bl052, carrier_1: 500000000 Hz
CCONVBPF_c052_1 (bl052 n_conv_cbpf_c052_1) capacitor c=1.013211836423e-13
LCONVBPF_c052_1 (n_conv_cbpf_c052_1 conv_bpf_c052_1) inductor l=1.000000000000e-06
RCONVBPF_c052_1 (conv_bpf_c052_1 0) resistor r=1.570796326795e+02
ECONVI_c052_1_00 (conv_i_src_c052_1_00 0 conv_bpf_c052_1 0) vcvs gain=9.807852804032e-01
SCONVI_c052_1_00 (conv_i_src_c052_1_00 conv_i_c052_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_00 (conv_q_src_c052_1_00 0 conv_bpf_c052_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_1_00 (conv_q_src_c052_1_00 conv_q_c052_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_01 (conv_i_src_c052_1_01 0 conv_bpf_c052_1 0) vcvs gain=8.314696123025e-01
SCONVI_c052_1_01 (conv_i_src_c052_1_01 conv_i_c052_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_01 (conv_q_src_c052_1_01 0 conv_bpf_c052_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_1_01 (conv_q_src_c052_1_01 conv_q_c052_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_02 (conv_i_src_c052_1_02 0 conv_bpf_c052_1 0) vcvs gain=5.555702330196e-01
SCONVI_c052_1_02 (conv_i_src_c052_1_02 conv_i_c052_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_02 (conv_q_src_c052_1_02 0 conv_bpf_c052_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_1_02 (conv_q_src_c052_1_02 conv_q_c052_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_03 (conv_i_src_c052_1_03 0 conv_bpf_c052_1 0) vcvs gain=1.950903220161e-01
SCONVI_c052_1_03 (conv_i_src_c052_1_03 conv_i_c052_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_03 (conv_q_src_c052_1_03 0 conv_bpf_c052_1 0) vcvs gain=9.807852804032e-01
