SCONVQ_c091_3_04 (conv_q_src_c091_3_04 conv_q_c091_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_05 (conv_i_src_c091_3_05 0 conv_bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_3_05 (conv_i_src_c091_3_05 conv_i_c091_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_05 (conv_q_src_c091_3_05 0 conv_bpf_c091_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_3_05 (conv_q_src_c091_3_05 conv_q_c091_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_06 (conv_i_src_c091_3_06 0 conv_bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_3_06 (conv_i_src_c091_3_06 conv_i_c091_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_06 (conv_q_src_c091_3_06 0 conv_bpf_c091_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_3_06 (conv_q_src_c091_3_06 conv_q_c091_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_07 (conv_i_src_c091_3_07 0 conv_bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_3_07 (conv_i_src_c091_3_07 conv_i_c091_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_07 (conv_q_src_c091_3_07 0 conv_bpf_c091_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_3_07 (conv_q_src_c091_3_07 conv_q_c091_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_08 (conv_i_src_c091_3_08 0 conv_bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_3_08 (conv_i_src_c091_3_08 conv_i_c091_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_08 (conv_q_src_c091_3_08 0 conv_bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_3_08 (conv_q_src_c091_3_08 conv_q_c091_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_09 (conv_i_src_c091_3_09 0 conv_bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_3_09 (conv_i_src_c091_3_09 conv_i_c091_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_09 (conv_q_src_c091_3_09 0 conv_bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_3_09 (conv_q_src_c091_3_09 conv_q_c091_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_10 (conv_i_src_c091_3_10 0 conv_bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_3_10 (conv_i_src_c091_3_10 conv_i_c091_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_10 (conv_q_src_c091_3_10 0 conv_bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_3_10 (conv_q_src_c091_3_10 conv_q_c091_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_11 (conv_i_src_c091_3_11 0 conv_bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_3_11 (conv_i_src_c091_3_11 conv_i_c091_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_11 (conv_q_src_c091_3_11 0 conv_bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_3_11 (conv_q_src_c091_3_11 conv_q_c091_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_12 (conv_i_src_c091_3_12 0 conv_bpf_c091_3 0) vcvs gain=1.950903220161e-01
SCONVI_c091_3_12 (conv_i_src_c091_3_12 conv_i_c091_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_12 (conv_q_src_c091_3_12 0 conv_bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_3_12 (conv_q_src_c091_3_12 conv_q_c091_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_13 (conv_i_src_c091_3_13 0 conv_bpf_c091_3 0) vcvs gain=5.555702330196e-01
SCONVI_c091_3_13 (conv_i_src_c091_3_13 conv_i_c091_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_13 (conv_q_src_c091_3_13 0 conv_bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_3_13 (conv_q_src_c091_3_13 conv_q_c091_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_14 (conv_i_src_c091_3_14 0 conv_bpf_c091_3 0) vcvs gain=8.314696123025e-01
SCONVI_c091_3_14 (conv_i_src_c091_3_14 conv_i_c091_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_14 (conv_q_src_c091_3_14 0 conv_bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_3_14 (conv_q_src_c091_3_14 conv_q_c091_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_15 (conv_i_src_c091_3_15 0 conv_bpf_c091_3 0) vcvs gain=9.807852804032e-01
SCONVI_c091_3_15 (conv_i_src_c091_3_15 conv_i_c091_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_15 (conv_q_src_c091_3_15 0 conv_bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_3_15 (conv_q_src_c091_3_15 conv_q_c091_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c091_3 (conv_i_c091_3 0) resistor r=1G
RCONVQ_c091_3 (conv_q_c091_3 0) resistor r=1G
RCONVINTI_c091_3 (conv_i_c091_3 ConvIcar_c091_3) resistor r=1k
CCONVINTI_c091_3 (ConvIcar_c091_3 0) capacitor c=80p
RCONVINTQ_c091_3 (conv_q_c091_3 ConvQcar_c091_3) resistor r=1k
CCONVINTQ_c091_3 (ConvQcar_c091_3 0) capacitor c=80p
save conv_bpf_c091_3 ConvIcar_c091_3 ConvQcar_c091_3

// conventional mixed baseline bl092, carrier_0: 250000000 Hz
CCONVBPF_c092_0 (bl092 n_conv_cbpf_c092_0) capacitor c=4.052847345694e-13
LCONVBPF_c092_0 (n_conv_cbpf_c092_0 conv_bpf_c092_0) inductor l=1.000000000000e-06
RCONVBPF_c092_0 (conv_bpf_c092_0 0) resistor r=7.853981633974e+01
ECONVI_c092_0_00 (conv_i_src_c092_0_00 0 conv_bpf_c092_0 0) vcvs gain=9.807852804032e-01
SCONVI_c092_0_00 (conv_i_src_c092_0_00 conv_i_c092_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_00 (conv_q_src_c092_0_00 0 conv_bpf_c092_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_0_00 (conv_q_src_c092_0_00 conv_q_c092_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_01 (conv_i_src_c092_0_01 0 conv_bpf_c092_0 0) vcvs gain=8.314696123025e-01
SCONVI_c092_0_01 (conv_i_src_c092_0_01 conv_i_c092_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_01 (conv_q_src_c092_0_01 0 conv_bpf_c092_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_0_01 (conv_q_src_c092_0_01 conv_q_c092_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_02 (conv_i_src_c092_0_02 0 conv_bpf_c092_0 0) vcvs gain=5.555702330196e-01
SCONVI_c092_0_02 (conv_i_src_c092_0_02 conv_i_c092_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_02 (conv_q_src_c092_0_02 0 conv_bpf_c092_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_0_02 (conv_q_src_c092_0_02 conv_q_c092_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_03 (conv_i_src_c092_0_03 0 conv_bpf_c092_0 0) vcvs gain=1.950903220161e-01
SCONVI_c092_0_03 (conv_i_src_c092_0_03 conv_i_c092_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_03 (conv_q_src_c092_0_03 0 conv_bpf_c092_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_0_03 (conv_q_src_c092_0_03 conv_q_c092_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_04 (conv_i_src_c092_0_04 0 conv_bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_0_04 (conv_i_src_c092_0_04 conv_i_c092_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_04 (conv_q_src_c092_0_04 0 conv_bpf_c092_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_0_04 (conv_q_src_c092_0_04 conv_q_c092_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_05 (conv_i_src_c092_0_05 0 conv_bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_0_05 (conv_i_src_c092_0_05 conv_i_c092_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_05 (conv_q_src_c092_0_05 0 conv_bpf_c092_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_0_05 (conv_q_src_c092_0_05 conv_q_c092_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_06 (conv_i_src_c092_0_06 0 conv_bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_0_06 (conv_i_src_c092_0_06 conv_i_c092_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_06 (conv_q_src_c092_0_06 0 conv_bpf_c092_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_0_06 (conv_q_src_c092_0_06 conv_q_c092_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_07 (conv_i_src_c092_0_07 0 conv_bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_0_07 (conv_i_src_c092_0_07 conv_i_c092_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_07 (conv_q_src_c092_0_07 0 conv_bpf_c092_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_0_07 (conv_q_src_c092_0_07 conv_q_c092_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_08 (conv_i_src_c092_0_08 0 conv_bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_0_08 (conv_i_src_c092_0_08 conv_i_c092_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_08 (conv_q_src_c092_0_08 0 conv_bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_0_08 (conv_q_src_c092_0_08 conv_q_c092_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_09 (conv_i_src_c092_0_09 0 conv_bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_0_09 (conv_i_src_c092_0_09 conv_i_c092_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_09 (conv_q_src_c092_0_09 0 conv_bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_0_09 (conv_q_src_c092_0_09 conv_q_c092_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_10 (conv_i_src_c092_0_10 0 conv_bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_0_10 (conv_i_src_c092_0_10 conv_i_c092_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_10 (conv_q_src_c092_0_10 0 conv_bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_0_10 (conv_q_src_c092_0_10 conv_q_c092_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_11 (conv_i_src_c092_0_11 0 conv_bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_0_11 (conv_i_src_c092_0_11 conv_i_c092_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_11 (conv_q_src_c092_0_11 0 conv_bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_0_11 (conv_q_src_c092_0_11 conv_q_c092_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_12 (conv_i_src_c092_0_12 0 conv_bpf_c092_0 0) vcvs gain=1.950903220161e-01
SCONVI_c092_0_12 (conv_i_src_c092_0_12 conv_i_c092_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_12 (conv_q_src_c092_0_12 0 conv_bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_0_12 (conv_q_src_c092_0_12 conv_q_c092_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_13 (conv_i_src_c092_0_13 0 conv_bpf_c092_0 0) vcvs gain=5.555702330196e-01
SCONVI_c092_0_13 (conv_i_src_c092_0_13 conv_i_c092_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_13 (conv_q_src_c092_0_13 0 conv_bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_0_13 (conv_q_src_c092_0_13 conv_q_c092_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_14 (conv_i_src_c092_0_14 0 conv_bpf_c092_0 0) vcvs gain=8.314696123025e-01
SCONVI_c092_0_14 (conv_i_src_c092_0_14 conv_i_c092_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_14 (conv_q_src_c092_0_14 0 conv_bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_0_14 (conv_q_src_c092_0_14 conv_q_c092_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_0_15 (conv_i_src_c092_0_15 0 conv_bpf_c092_0 0) vcvs gain=9.807852804032e-01
SCONVI_c092_0_15 (conv_i_src_c092_0_15 conv_i_c092_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_0_15 (conv_q_src_c092_0_15 0 conv_bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_0_15 (conv_q_src_c092_0_15 conv_q_c092_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c092_0 (conv_i_c092_0 0) resistor r=1G
RCONVQ_c092_0 (conv_q_c092_0 0) resistor r=1G
RCONVINTI_c092_0 (conv_i_c092_0 ConvIcar_c092_0) resistor r=1k
CCONVINTI_c092_0 (ConvIcar_c092_0 0) capacitor c=80p
RCONVINTQ_c092_0 (conv_q_c092_0 ConvQcar_c092_0) resistor r=1k
CCONVINTQ_c092_0 (ConvQcar_c092_0 0) capacitor c=80p
save conv_bpf_c092_0 ConvIcar_c092_0 ConvQcar_c092_0

// conventional mixed baseline bl092, carrier_1: 500000000 Hz
CCONVBPF_c092_1 (bl092 n_conv_cbpf_c092_1) capacitor c=1.013211836423e-13
LCONVBPF_c092_1 (n_conv_cbpf_c092_1 conv_bpf_c092_1) inductor l=1.000000000000e-06
RCONVBPF_c092_1 (conv_bpf_c092_1 0) resistor r=1.570796326795e+02
ECONVI_c092_1_00 (conv_i_src_c092_1_00 0 conv_bpf_c092_1 0) vcvs gain=9.807852804032e-01
SCONVI_c092_1_00 (conv_i_src_c092_1_00 conv_i_c092_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_00 (conv_q_src_c092_1_00 0 conv_bpf_c092_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_1_00 (conv_q_src_c092_1_00 conv_q_c092_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_01 (conv_i_src_c092_1_01 0 conv_bpf_c092_1 0) vcvs gain=8.314696123025e-01
SCONVI_c092_1_01 (conv_i_src_c092_1_01 conv_i_c092_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_01 (conv_q_src_c092_1_01 0 conv_bpf_c092_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_1_01 (conv_q_src_c092_1_01 conv_q_c092_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_02 (conv_i_src_c092_1_02 0 conv_bpf_c092_1 0) vcvs gain=5.555702330196e-01
SCONVI_c092_1_02 (conv_i_src_c092_1_02 conv_i_c092_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_02 (conv_q_src_c092_1_02 0 conv_bpf_c092_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_1_02 (conv_q_src_c092_1_02 conv_q_c092_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_03 (conv_i_src_c092_1_03 0 conv_bpf_c092_1 0) vcvs gain=1.950903220161e-01
SCONVI_c092_1_03 (conv_i_src_c092_1_03 conv_i_c092_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_03 (conv_q_src_c092_1_03 0 conv_bpf_c092_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_1_03 (conv_q_src_c092_1_03 conv_q_c092_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_04 (conv_i_src_c092_1_04 0 conv_bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_1_04 (conv_i_src_c092_1_04 conv_i_c092_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_04 (conv_q_src_c092_1_04 0 conv_bpf_c092_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_1_04 (conv_q_src_c092_1_04 conv_q_c092_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_05 (conv_i_src_c092_1_05 0 conv_bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_1_05 (conv_i_src_c092_1_05 conv_i_c092_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_05 (conv_q_src_c092_1_05 0 conv_bpf_c092_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_1_05 (conv_q_src_c092_1_05 conv_q_c092_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_06 (conv_i_src_c092_1_06 0 conv_bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_1_06 (conv_i_src_c092_1_06 conv_i_c092_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_06 (conv_q_src_c092_1_06 0 conv_bpf_c092_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_1_06 (conv_q_src_c092_1_06 conv_q_c092_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_07 (conv_i_src_c092_1_07 0 conv_bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_1_07 (conv_i_src_c092_1_07 conv_i_c092_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_07 (conv_q_src_c092_1_07 0 conv_bpf_c092_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_1_07 (conv_q_src_c092_1_07 conv_q_c092_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_08 (conv_i_src_c092_1_08 0 conv_bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_1_08 (conv_i_src_c092_1_08 conv_i_c092_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_08 (conv_q_src_c092_1_08 0 conv_bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_1_08 (conv_q_src_c092_1_08 conv_q_c092_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_09 (conv_i_src_c092_1_09 0 conv_bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_1_09 (conv_i_src_c092_1_09 conv_i_c092_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_09 (conv_q_src_c092_1_09 0 conv_bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_1_09 (conv_q_src_c092_1_09 conv_q_c092_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_10 (conv_i_src_c092_1_10 0 conv_bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_1_10 (conv_i_src_c092_1_10 conv_i_c092_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_10 (conv_q_src_c092_1_10 0 conv_bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_1_10 (conv_q_src_c092_1_10 conv_q_c092_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_11 (conv_i_src_c092_1_11 0 conv_bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_1_11 (conv_i_src_c092_1_11 conv_i_c092_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_11 (conv_q_src_c092_1_11 0 conv_bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_1_11 (conv_q_src_c092_1_11 conv_q_c092_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_12 (conv_i_src_c092_1_12 0 conv_bpf_c092_1 0) vcvs gain=1.950903220161e-01
SCONVI_c092_1_12 (conv_i_src_c092_1_12 conv_i_c092_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_12 (conv_q_src_c092_1_12 0 conv_bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_1_12 (conv_q_src_c092_1_12 conv_q_c092_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_13 (conv_i_src_c092_1_13 0 conv_bpf_c092_1 0) vcvs gain=5.555702330196e-01
SCONVI_c092_1_13 (conv_i_src_c092_1_13 conv_i_c092_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_13 (conv_q_src_c092_1_13 0 conv_bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_1_13 (conv_q_src_c092_1_13 conv_q_c092_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_14 (conv_i_src_c092_1_14 0 conv_bpf_c092_1 0) vcvs gain=8.314696123025e-01
SCONVI_c092_1_14 (conv_i_src_c092_1_14 conv_i_c092_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_14 (conv_q_src_c092_1_14 0 conv_bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_1_14 (conv_q_src_c092_1_14 conv_q_c092_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_1_15 (conv_i_src_c092_1_15 0 conv_bpf_c092_1 0) vcvs gain=9.807852804032e-01
SCONVI_c092_1_15 (conv_i_src_c092_1_15 conv_i_c092_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_1_15 (conv_q_src_c092_1_15 0 conv_bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_1_15 (conv_q_src_c092_1_15 conv_q_c092_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c092_1 (conv_i_c092_1 0) resistor r=1G
RCONVQ_c092_1 (conv_q_c092_1 0) resistor r=1G
RCONVINTI_c092_1 (conv_i_c092_1 ConvIcar_c092_1) resistor r=1k
CCONVINTI_c092_1 (ConvIcar_c092_1 0) capacitor c=80p
RCONVINTQ_c092_1 (conv_q_c092_1 ConvQcar_c092_1) resistor r=1k
CCONVINTQ_c092_1 (ConvQcar_c092_1 0) capacitor c=80p
save conv_bpf_c092_1 ConvIcar_c092_1 ConvQcar_c092_1

// conventional mixed baseline bl092, carrier_2: 750000000 Hz
CCONVBPF_c092_2 (bl092 n_conv_cbpf_c092_2) capacitor c=4.503163717437e-14
LCONVBPF_c092_2 (n_conv_cbpf_c092_2 conv_bpf_c092_2) inductor l=1.000000000000e-06
RCONVBPF_c092_2 (conv_bpf_c092_2 0) resistor r=2.356194490192e+02
ECONVI_c092_2_00 (conv_i_src_c092_2_00 0 conv_bpf_c092_2 0) vcvs gain=9.807852804032e-01
SCONVI_c092_2_00 (conv_i_src_c092_2_00 conv_i_c092_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_00 (conv_q_src_c092_2_00 0 conv_bpf_c092_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_2_00 (conv_q_src_c092_2_00 conv_q_c092_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_01 (conv_i_src_c092_2_01 0 conv_bpf_c092_2 0) vcvs gain=8.314696123025e-01
SCONVI_c092_2_01 (conv_i_src_c092_2_01 conv_i_c092_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_01 (conv_q_src_c092_2_01 0 conv_bpf_c092_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_2_01 (conv_q_src_c092_2_01 conv_q_c092_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_02 (conv_i_src_c092_2_02 0 conv_bpf_c092_2 0) vcvs gain=5.555702330196e-01
SCONVI_c092_2_02 (conv_i_src_c092_2_02 conv_i_c092_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_02 (conv_q_src_c092_2_02 0 conv_bpf_c092_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_2_02 (conv_q_src_c092_2_02 conv_q_c092_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_03 (conv_i_src_c092_2_03 0 conv_bpf_c092_2 0) vcvs gain=1.950903220161e-01
SCONVI_c092_2_03 (conv_i_src_c092_2_03 conv_i_c092_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_03 (conv_q_src_c092_2_03 0 conv_bpf_c092_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_2_03 (conv_q_src_c092_2_03 conv_q_c092_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_04 (conv_i_src_c092_2_04 0 conv_bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_2_04 (conv_i_src_c092_2_04 conv_i_c092_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_04 (conv_q_src_c092_2_04 0 conv_bpf_c092_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_2_04 (conv_q_src_c092_2_04 conv_q_c092_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_05 (conv_i_src_c092_2_05 0 conv_bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_2_05 (conv_i_src_c092_2_05 conv_i_c092_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_05 (conv_q_src_c092_2_05 0 conv_bpf_c092_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_2_05 (conv_q_src_c092_2_05 conv_q_c092_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_06 (conv_i_src_c092_2_06 0 conv_bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_2_06 (conv_i_src_c092_2_06 conv_i_c092_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_06 (conv_q_src_c092_2_06 0 conv_bpf_c092_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_2_06 (conv_q_src_c092_2_06 conv_q_c092_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_07 (conv_i_src_c092_2_07 0 conv_bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_2_07 (conv_i_src_c092_2_07 conv_i_c092_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_07 (conv_q_src_c092_2_07 0 conv_bpf_c092_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_2_07 (conv_q_src_c092_2_07 conv_q_c092_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_08 (conv_i_src_c092_2_08 0 conv_bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_2_08 (conv_i_src_c092_2_08 conv_i_c092_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_08 (conv_q_src_c092_2_08 0 conv_bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_2_08 (conv_q_src_c092_2_08 conv_q_c092_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_09 (conv_i_src_c092_2_09 0 conv_bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_2_09 (conv_i_src_c092_2_09 conv_i_c092_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_09 (conv_q_src_c092_2_09 0 conv_bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_2_09 (conv_q_src_c092_2_09 conv_q_c092_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_10 (conv_i_src_c092_2_10 0 conv_bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_2_10 (conv_i_src_c092_2_10 conv_i_c092_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_10 (conv_q_src_c092_2_10 0 conv_bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_2_10 (conv_q_src_c092_2_10 conv_q_c092_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_11 (conv_i_src_c092_2_11 0 conv_bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_2_11 (conv_i_src_c092_2_11 conv_i_c092_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_11 (conv_q_src_c092_2_11 0 conv_bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_2_11 (conv_q_src_c092_2_11 conv_q_c092_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_12 (conv_i_src_c092_2_12 0 conv_bpf_c092_2 0) vcvs gain=1.950903220161e-01
SCONVI_c092_2_12 (conv_i_src_c092_2_12 conv_i_c092_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_12 (conv_q_src_c092_2_12 0 conv_bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_2_12 (conv_q_src_c092_2_12 conv_q_c092_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_13 (conv_i_src_c092_2_13 0 conv_bpf_c092_2 0) vcvs gain=5.555702330196e-01
SCONVI_c092_2_13 (conv_i_src_c092_2_13 conv_i_c092_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_13 (conv_q_src_c092_2_13 0 conv_bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_2_13 (conv_q_src_c092_2_13 conv_q_c092_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_14 (conv_i_src_c092_2_14 0 conv_bpf_c092_2 0) vcvs gain=8.314696123025e-01
SCONVI_c092_2_14 (conv_i_src_c092_2_14 conv_i_c092_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_14 (conv_q_src_c092_2_14 0 conv_bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_2_14 (conv_q_src_c092_2_14 conv_q_c092_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_2_15 (conv_i_src_c092_2_15 0 conv_bpf_c092_2 0) vcvs gain=9.807852804032e-01
SCONVI_c092_2_15 (conv_i_src_c092_2_15 conv_i_c092_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_2_15 (conv_q_src_c092_2_15 0 conv_bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_2_15 (conv_q_src_c092_2_15 conv_q_c092_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c092_2 (conv_i_c092_2 0) resistor r=1G
RCONVQ_c092_2 (conv_q_c092_2 0) resistor r=1G
RCONVINTI_c092_2 (conv_i_c092_2 ConvIcar_c092_2) resistor r=1k
CCONVINTI_c092_2 (ConvIcar_c092_2 0) capacitor c=80p
RCONVINTQ_c092_2 (conv_q_c092_2 ConvQcar_c092_2) resistor r=1k
CCONVINTQ_c092_2 (ConvQcar_c092_2 0) capacitor c=80p
save conv_bpf_c092_2 ConvIcar_c092_2 ConvQcar_c092_2

// conventional mixed baseline bl092, carrier_3: 1000000000 Hz
CCONVBPF_c092_3 (bl092 n_conv_cbpf_c092_3) capacitor c=2.533029591058e-14
LCONVBPF_c092_3 (n_conv_cbpf_c092_3 conv_bpf_c092_3) inductor l=1.000000000000e-06
RCONVBPF_c092_3 (conv_bpf_c092_3 0) resistor r=3.141592653590e+02
ECONVI_c092_3_00 (conv_i_src_c092_3_00 0 conv_bpf_c092_3 0) vcvs gain=9.807852804032e-01
SCONVI_c092_3_00 (conv_i_src_c092_3_00 conv_i_c092_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_00 (conv_q_src_c092_3_00 0 conv_bpf_c092_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_3_00 (conv_q_src_c092_3_00 conv_q_c092_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_01 (conv_i_src_c092_3_01 0 conv_bpf_c092_3 0) vcvs gain=8.314696123025e-01
SCONVI_c092_3_01 (conv_i_src_c092_3_01 conv_i_c092_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_01 (conv_q_src_c092_3_01 0 conv_bpf_c092_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_3_01 (conv_q_src_c092_3_01 conv_q_c092_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_02 (conv_i_src_c092_3_02 0 conv_bpf_c092_3 0) vcvs gain=5.555702330196e-01
SCONVI_c092_3_02 (conv_i_src_c092_3_02 conv_i_c092_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_02 (conv_q_src_c092_3_02 0 conv_bpf_c092_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_3_02 (conv_q_src_c092_3_02 conv_q_c092_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_03 (conv_i_src_c092_3_03 0 conv_bpf_c092_3 0) vcvs gain=1.950903220161e-01
SCONVI_c092_3_03 (conv_i_src_c092_3_03 conv_i_c092_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_03 (conv_q_src_c092_3_03 0 conv_bpf_c092_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_3_03 (conv_q_src_c092_3_03 conv_q_c092_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_04 (conv_i_src_c092_3_04 0 conv_bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_3_04 (conv_i_src_c092_3_04 conv_i_c092_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_04 (conv_q_src_c092_3_04 0 conv_bpf_c092_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c092_3_04 (conv_q_src_c092_3_04 conv_q_c092_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_05 (conv_i_src_c092_3_05 0 conv_bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_3_05 (conv_i_src_c092_3_05 conv_i_c092_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_05 (conv_q_src_c092_3_05 0 conv_bpf_c092_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c092_3_05 (conv_q_src_c092_3_05 conv_q_c092_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_06 (conv_i_src_c092_3_06 0 conv_bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_3_06 (conv_i_src_c092_3_06 conv_i_c092_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_06 (conv_q_src_c092_3_06 0 conv_bpf_c092_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c092_3_06 (conv_q_src_c092_3_06 conv_q_c092_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_07 (conv_i_src_c092_3_07 0 conv_bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_3_07 (conv_i_src_c092_3_07 conv_i_c092_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_07 (conv_q_src_c092_3_07 0 conv_bpf_c092_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c092_3_07 (conv_q_src_c092_3_07 conv_q_c092_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_08 (conv_i_src_c092_3_08 0 conv_bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c092_3_08 (conv_i_src_c092_3_08 conv_i_c092_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_08 (conv_q_src_c092_3_08 0 conv_bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_3_08 (conv_q_src_c092_3_08 conv_q_c092_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_09 (conv_i_src_c092_3_09 0 conv_bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c092_3_09 (conv_i_src_c092_3_09 conv_i_c092_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_09 (conv_q_src_c092_3_09 0 conv_bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_3_09 (conv_q_src_c092_3_09 conv_q_c092_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_10 (conv_i_src_c092_3_10 0 conv_bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c092_3_10 (conv_i_src_c092_3_10 conv_i_c092_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_10 (conv_q_src_c092_3_10 0 conv_bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_3_10 (conv_q_src_c092_3_10 conv_q_c092_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_11 (conv_i_src_c092_3_11 0 conv_bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c092_3_11 (conv_i_src_c092_3_11 conv_i_c092_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_11 (conv_q_src_c092_3_11 0 conv_bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_3_11 (conv_q_src_c092_3_11 conv_q_c092_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_12 (conv_i_src_c092_3_12 0 conv_bpf_c092_3 0) vcvs gain=1.950903220161e-01
SCONVI_c092_3_12 (conv_i_src_c092_3_12 conv_i_c092_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_12 (conv_q_src_c092_3_12 0 conv_bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c092_3_12 (conv_q_src_c092_3_12 conv_q_c092_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_13 (conv_i_src_c092_3_13 0 conv_bpf_c092_3 0) vcvs gain=5.555702330196e-01
SCONVI_c092_3_13 (conv_i_src_c092_3_13 conv_i_c092_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_13 (conv_q_src_c092_3_13 0 conv_bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c092_3_13 (conv_q_src_c092_3_13 conv_q_c092_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_14 (conv_i_src_c092_3_14 0 conv_bpf_c092_3 0) vcvs gain=8.314696123025e-01
SCONVI_c092_3_14 (conv_i_src_c092_3_14 conv_i_c092_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_14 (conv_q_src_c092_3_14 0 conv_bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c092_3_14 (conv_q_src_c092_3_14 conv_q_c092_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c092_3_15 (conv_i_src_c092_3_15 0 conv_bpf_c092_3 0) vcvs gain=9.807852804032e-01
SCONVI_c092_3_15 (conv_i_src_c092_3_15 conv_i_c092_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c092_3_15 (conv_q_src_c092_3_15 0 conv_bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c092_3_15 (conv_q_src_c092_3_15 conv_q_c092_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c092_3 (conv_i_c092_3 0) resistor r=1G
RCONVQ_c092_3 (conv_q_c092_3 0) resistor r=1G
RCONVINTI_c092_3 (conv_i_c092_3 ConvIcar_c092_3) resistor r=1k
CCONVINTI_c092_3 (ConvIcar_c092_3 0) capacitor c=80p
RCONVINTQ_c092_3 (conv_q_c092_3 ConvQcar_c092_3) resistor r=1k
CCONVINTQ_c092_3 (ConvQcar_c092_3 0) capacitor c=80p
save conv_bpf_c092_3 ConvIcar_c092_3 ConvQcar_c092_3

// conventional mixed baseline bl093, carrier_0: 250000000 Hz
CCONVBPF_c093_0 (bl093 n_conv_cbpf_c093_0) capacitor c=4.052847345694e-13
LCONVBPF_c093_0 (n_conv_cbpf_c093_0 conv_bpf_c093_0) inductor l=1.000000000000e-06
RCONVBPF_c093_0 (conv_bpf_c093_0 0) resistor r=7.853981633974e+01
ECONVI_c093_0_00 (conv_i_src_c093_0_00 0 conv_bpf_c093_0 0) vcvs gain=9.807852804032e-01
SCONVI_c093_0_00 (conv_i_src_c093_0_00 conv_i_c093_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_00 (conv_q_src_c093_0_00 0 conv_bpf_c093_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_0_00 (conv_q_src_c093_0_00 conv_q_c093_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_01 (conv_i_src_c093_0_01 0 conv_bpf_c093_0 0) vcvs gain=8.314696123025e-01
SCONVI_c093_0_01 (conv_i_src_c093_0_01 conv_i_c093_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_01 (conv_q_src_c093_0_01 0 conv_bpf_c093_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_0_01 (conv_q_src_c093_0_01 conv_q_c093_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_02 (conv_i_src_c093_0_02 0 conv_bpf_c093_0 0) vcvs gain=5.555702330196e-01
SCONVI_c093_0_02 (conv_i_src_c093_0_02 conv_i_c093_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_02 (conv_q_src_c093_0_02 0 conv_bpf_c093_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_0_02 (conv_q_src_c093_0_02 conv_q_c093_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_03 (conv_i_src_c093_0_03 0 conv_bpf_c093_0 0) vcvs gain=1.950903220161e-01
SCONVI_c093_0_03 (conv_i_src_c093_0_03 conv_i_c093_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_03 (conv_q_src_c093_0_03 0 conv_bpf_c093_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_0_03 (conv_q_src_c093_0_03 conv_q_c093_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_04 (conv_i_src_c093_0_04 0 conv_bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_0_04 (conv_i_src_c093_0_04 conv_i_c093_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_04 (conv_q_src_c093_0_04 0 conv_bpf_c093_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_0_04 (conv_q_src_c093_0_04 conv_q_c093_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_05 (conv_i_src_c093_0_05 0 conv_bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_0_05 (conv_i_src_c093_0_05 conv_i_c093_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_05 (conv_q_src_c093_0_05 0 conv_bpf_c093_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_0_05 (conv_q_src_c093_0_05 conv_q_c093_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_06 (conv_i_src_c093_0_06 0 conv_bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_0_06 (conv_i_src_c093_0_06 conv_i_c093_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_06 (conv_q_src_c093_0_06 0 conv_bpf_c093_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_0_06 (conv_q_src_c093_0_06 conv_q_c093_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_07 (conv_i_src_c093_0_07 0 conv_bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_0_07 (conv_i_src_c093_0_07 conv_i_c093_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_07 (conv_q_src_c093_0_07 0 conv_bpf_c093_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_0_07 (conv_q_src_c093_0_07 conv_q_c093_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_08 (conv_i_src_c093_0_08 0 conv_bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_0_08 (conv_i_src_c093_0_08 conv_i_c093_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_08 (conv_q_src_c093_0_08 0 conv_bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_0_08 (conv_q_src_c093_0_08 conv_q_c093_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_09 (conv_i_src_c093_0_09 0 conv_bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_0_09 (conv_i_src_c093_0_09 conv_i_c093_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_09 (conv_q_src_c093_0_09 0 conv_bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_0_09 (conv_q_src_c093_0_09 conv_q_c093_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_10 (conv_i_src_c093_0_10 0 conv_bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_0_10 (conv_i_src_c093_0_10 conv_i_c093_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_10 (conv_q_src_c093_0_10 0 conv_bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_0_10 (conv_q_src_c093_0_10 conv_q_c093_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_11 (conv_i_src_c093_0_11 0 conv_bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_0_11 (conv_i_src_c093_0_11 conv_i_c093_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_11 (conv_q_src_c093_0_11 0 conv_bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_0_11 (conv_q_src_c093_0_11 conv_q_c093_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_12 (conv_i_src_c093_0_12 0 conv_bpf_c093_0 0) vcvs gain=1.950903220161e-01
SCONVI_c093_0_12 (conv_i_src_c093_0_12 conv_i_c093_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_12 (conv_q_src_c093_0_12 0 conv_bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_0_12 (conv_q_src_c093_0_12 conv_q_c093_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_13 (conv_i_src_c093_0_13 0 conv_bpf_c093_0 0) vcvs gain=5.555702330196e-01
SCONVI_c093_0_13 (conv_i_src_c093_0_13 conv_i_c093_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_13 (conv_q_src_c093_0_13 0 conv_bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_0_13 (conv_q_src_c093_0_13 conv_q_c093_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_14 (conv_i_src_c093_0_14 0 conv_bpf_c093_0 0) vcvs gain=8.314696123025e-01
SCONVI_c093_0_14 (conv_i_src_c093_0_14 conv_i_c093_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_14 (conv_q_src_c093_0_14 0 conv_bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_0_14 (conv_q_src_c093_0_14 conv_q_c093_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_0_15 (conv_i_src_c093_0_15 0 conv_bpf_c093_0 0) vcvs gain=9.807852804032e-01
SCONVI_c093_0_15 (conv_i_src_c093_0_15 conv_i_c093_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_0_15 (conv_q_src_c093_0_15 0 conv_bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_0_15 (conv_q_src_c093_0_15 conv_q_c093_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c093_0 (conv_i_c093_0 0) resistor r=1G
RCONVQ_c093_0 (conv_q_c093_0 0) resistor r=1G
RCONVINTI_c093_0 (conv_i_c093_0 ConvIcar_c093_0) resistor r=1k
CCONVINTI_c093_0 (ConvIcar_c093_0 0) capacitor c=80p
RCONVINTQ_c093_0 (conv_q_c093_0 ConvQcar_c093_0) resistor r=1k
CCONVINTQ_c093_0 (ConvQcar_c093_0 0) capacitor c=80p
save conv_bpf_c093_0 ConvIcar_c093_0 ConvQcar_c093_0

// conventional mixed baseline bl093, carrier_1: 500000000 Hz
CCONVBPF_c093_1 (bl093 n_conv_cbpf_c093_1) capacitor c=1.013211836423e-13
LCONVBPF_c093_1 (n_conv_cbpf_c093_1 conv_bpf_c093_1) inductor l=1.000000000000e-06
RCONVBPF_c093_1 (conv_bpf_c093_1 0) resistor r=1.570796326795e+02
ECONVI_c093_1_00 (conv_i_src_c093_1_00 0 conv_bpf_c093_1 0) vcvs gain=9.807852804032e-01
SCONVI_c093_1_00 (conv_i_src_c093_1_00 conv_i_c093_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_00 (conv_q_src_c093_1_00 0 conv_bpf_c093_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_1_00 (conv_q_src_c093_1_00 conv_q_c093_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_01 (conv_i_src_c093_1_01 0 conv_bpf_c093_1 0) vcvs gain=8.314696123025e-01
SCONVI_c093_1_01 (conv_i_src_c093_1_01 conv_i_c093_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_01 (conv_q_src_c093_1_01 0 conv_bpf_c093_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_1_01 (conv_q_src_c093_1_01 conv_q_c093_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_02 (conv_i_src_c093_1_02 0 conv_bpf_c093_1 0) vcvs gain=5.555702330196e-01
SCONVI_c093_1_02 (conv_i_src_c093_1_02 conv_i_c093_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_02 (conv_q_src_c093_1_02 0 conv_bpf_c093_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_1_02 (conv_q_src_c093_1_02 conv_q_c093_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_03 (conv_i_src_c093_1_03 0 conv_bpf_c093_1 0) vcvs gain=1.950903220161e-01
SCONVI_c093_1_03 (conv_i_src_c093_1_03 conv_i_c093_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_03 (conv_q_src_c093_1_03 0 conv_bpf_c093_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_1_03 (conv_q_src_c093_1_03 conv_q_c093_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_04 (conv_i_src_c093_1_04 0 conv_bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_1_04 (conv_i_src_c093_1_04 conv_i_c093_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_04 (conv_q_src_c093_1_04 0 conv_bpf_c093_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_1_04 (conv_q_src_c093_1_04 conv_q_c093_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_05 (conv_i_src_c093_1_05 0 conv_bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_1_05 (conv_i_src_c093_1_05 conv_i_c093_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_05 (conv_q_src_c093_1_05 0 conv_bpf_c093_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_1_05 (conv_q_src_c093_1_05 conv_q_c093_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_06 (conv_i_src_c093_1_06 0 conv_bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_1_06 (conv_i_src_c093_1_06 conv_i_c093_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_06 (conv_q_src_c093_1_06 0 conv_bpf_c093_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_1_06 (conv_q_src_c093_1_06 conv_q_c093_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_07 (conv_i_src_c093_1_07 0 conv_bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_1_07 (conv_i_src_c093_1_07 conv_i_c093_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_07 (conv_q_src_c093_1_07 0 conv_bpf_c093_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_1_07 (conv_q_src_c093_1_07 conv_q_c093_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_08 (conv_i_src_c093_1_08 0 conv_bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_1_08 (conv_i_src_c093_1_08 conv_i_c093_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_08 (conv_q_src_c093_1_08 0 conv_bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_1_08 (conv_q_src_c093_1_08 conv_q_c093_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_09 (conv_i_src_c093_1_09 0 conv_bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_1_09 (conv_i_src_c093_1_09 conv_i_c093_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_09 (conv_q_src_c093_1_09 0 conv_bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_1_09 (conv_q_src_c093_1_09 conv_q_c093_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_10 (conv_i_src_c093_1_10 0 conv_bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_1_10 (conv_i_src_c093_1_10 conv_i_c093_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_10 (conv_q_src_c093_1_10 0 conv_bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_1_10 (conv_q_src_c093_1_10 conv_q_c093_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_11 (conv_i_src_c093_1_11 0 conv_bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_1_11 (conv_i_src_c093_1_11 conv_i_c093_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_11 (conv_q_src_c093_1_11 0 conv_bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_1_11 (conv_q_src_c093_1_11 conv_q_c093_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_12 (conv_i_src_c093_1_12 0 conv_bpf_c093_1 0) vcvs gain=1.950903220161e-01
SCONVI_c093_1_12 (conv_i_src_c093_1_12 conv_i_c093_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_12 (conv_q_src_c093_1_12 0 conv_bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_1_12 (conv_q_src_c093_1_12 conv_q_c093_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_13 (conv_i_src_c093_1_13 0 conv_bpf_c093_1 0) vcvs gain=5.555702330196e-01
SCONVI_c093_1_13 (conv_i_src_c093_1_13 conv_i_c093_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_13 (conv_q_src_c093_1_13 0 conv_bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_1_13 (conv_q_src_c093_1_13 conv_q_c093_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_14 (conv_i_src_c093_1_14 0 conv_bpf_c093_1 0) vcvs gain=8.314696123025e-01
SCONVI_c093_1_14 (conv_i_src_c093_1_14 conv_i_c093_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_14 (conv_q_src_c093_1_14 0 conv_bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_1_14 (conv_q_src_c093_1_14 conv_q_c093_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_1_15 (conv_i_src_c093_1_15 0 conv_bpf_c093_1 0) vcvs gain=9.807852804032e-01
SCONVI_c093_1_15 (conv_i_src_c093_1_15 conv_i_c093_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_1_15 (conv_q_src_c093_1_15 0 conv_bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_1_15 (conv_q_src_c093_1_15 conv_q_c093_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c093_1 (conv_i_c093_1 0) resistor r=1G
RCONVQ_c093_1 (conv_q_c093_1 0) resistor r=1G
RCONVINTI_c093_1 (conv_i_c093_1 ConvIcar_c093_1) resistor r=1k
CCONVINTI_c093_1 (ConvIcar_c093_1 0) capacitor c=80p
RCONVINTQ_c093_1 (conv_q_c093_1 ConvQcar_c093_1) resistor r=1k
CCONVINTQ_c093_1 (ConvQcar_c093_1 0) capacitor c=80p
save conv_bpf_c093_1 ConvIcar_c093_1 ConvQcar_c093_1

// conventional mixed baseline bl093, carrier_2: 750000000 Hz
CCONVBPF_c093_2 (bl093 n_conv_cbpf_c093_2) capacitor c=4.503163717437e-14
LCONVBPF_c093_2 (n_conv_cbpf_c093_2 conv_bpf_c093_2) inductor l=1.000000000000e-06
RCONVBPF_c093_2 (conv_bpf_c093_2 0) resistor r=2.356194490192e+02
ECONVI_c093_2_00 (conv_i_src_c093_2_00 0 conv_bpf_c093_2 0) vcvs gain=9.807852804032e-01
SCONVI_c093_2_00 (conv_i_src_c093_2_00 conv_i_c093_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_00 (conv_q_src_c093_2_00 0 conv_bpf_c093_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_2_00 (conv_q_src_c093_2_00 conv_q_c093_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_01 (conv_i_src_c093_2_01 0 conv_bpf_c093_2 0) vcvs gain=8.314696123025e-01
SCONVI_c093_2_01 (conv_i_src_c093_2_01 conv_i_c093_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_01 (conv_q_src_c093_2_01 0 conv_bpf_c093_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_2_01 (conv_q_src_c093_2_01 conv_q_c093_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_02 (conv_i_src_c093_2_02 0 conv_bpf_c093_2 0) vcvs gain=5.555702330196e-01
SCONVI_c093_2_02 (conv_i_src_c093_2_02 conv_i_c093_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_02 (conv_q_src_c093_2_02 0 conv_bpf_c093_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_2_02 (conv_q_src_c093_2_02 conv_q_c093_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_03 (conv_i_src_c093_2_03 0 conv_bpf_c093_2 0) vcvs gain=1.950903220161e-01
SCONVI_c093_2_03 (conv_i_src_c093_2_03 conv_i_c093_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_03 (conv_q_src_c093_2_03 0 conv_bpf_c093_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_2_03 (conv_q_src_c093_2_03 conv_q_c093_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_04 (conv_i_src_c093_2_04 0 conv_bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_2_04 (conv_i_src_c093_2_04 conv_i_c093_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_04 (conv_q_src_c093_2_04 0 conv_bpf_c093_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_2_04 (conv_q_src_c093_2_04 conv_q_c093_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_05 (conv_i_src_c093_2_05 0 conv_bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_2_05 (conv_i_src_c093_2_05 conv_i_c093_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_05 (conv_q_src_c093_2_05 0 conv_bpf_c093_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_2_05 (conv_q_src_c093_2_05 conv_q_c093_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_06 (conv_i_src_c093_2_06 0 conv_bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_2_06 (conv_i_src_c093_2_06 conv_i_c093_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_06 (conv_q_src_c093_2_06 0 conv_bpf_c093_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_2_06 (conv_q_src_c093_2_06 conv_q_c093_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_07 (conv_i_src_c093_2_07 0 conv_bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_2_07 (conv_i_src_c093_2_07 conv_i_c093_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_07 (conv_q_src_c093_2_07 0 conv_bpf_c093_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_2_07 (conv_q_src_c093_2_07 conv_q_c093_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_08 (conv_i_src_c093_2_08 0 conv_bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_2_08 (conv_i_src_c093_2_08 conv_i_c093_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_08 (conv_q_src_c093_2_08 0 conv_bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_2_08 (conv_q_src_c093_2_08 conv_q_c093_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_09 (conv_i_src_c093_2_09 0 conv_bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_2_09 (conv_i_src_c093_2_09 conv_i_c093_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_09 (conv_q_src_c093_2_09 0 conv_bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_2_09 (conv_q_src_c093_2_09 conv_q_c093_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_10 (conv_i_src_c093_2_10 0 conv_bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_2_10 (conv_i_src_c093_2_10 conv_i_c093_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_10 (conv_q_src_c093_2_10 0 conv_bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_2_10 (conv_q_src_c093_2_10 conv_q_c093_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_11 (conv_i_src_c093_2_11 0 conv_bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_2_11 (conv_i_src_c093_2_11 conv_i_c093_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_11 (conv_q_src_c093_2_11 0 conv_bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_2_11 (conv_q_src_c093_2_11 conv_q_c093_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_12 (conv_i_src_c093_2_12 0 conv_bpf_c093_2 0) vcvs gain=1.950903220161e-01
SCONVI_c093_2_12 (conv_i_src_c093_2_12 conv_i_c093_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_12 (conv_q_src_c093_2_12 0 conv_bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_2_12 (conv_q_src_c093_2_12 conv_q_c093_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_13 (conv_i_src_c093_2_13 0 conv_bpf_c093_2 0) vcvs gain=5.555702330196e-01
SCONVI_c093_2_13 (conv_i_src_c093_2_13 conv_i_c093_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_13 (conv_q_src_c093_2_13 0 conv_bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_2_13 (conv_q_src_c093_2_13 conv_q_c093_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_14 (conv_i_src_c093_2_14 0 conv_bpf_c093_2 0) vcvs gain=8.314696123025e-01
SCONVI_c093_2_14 (conv_i_src_c093_2_14 conv_i_c093_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_14 (conv_q_src_c093_2_14 0 conv_bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_2_14 (conv_q_src_c093_2_14 conv_q_c093_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_2_15 (conv_i_src_c093_2_15 0 conv_bpf_c093_2 0) vcvs gain=9.807852804032e-01
SCONVI_c093_2_15 (conv_i_src_c093_2_15 conv_i_c093_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_2_15 (conv_q_src_c093_2_15 0 conv_bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_2_15 (conv_q_src_c093_2_15 conv_q_c093_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c093_2 (conv_i_c093_2 0) resistor r=1G
RCONVQ_c093_2 (conv_q_c093_2 0) resistor r=1G
RCONVINTI_c093_2 (conv_i_c093_2 ConvIcar_c093_2) resistor r=1k
CCONVINTI_c093_2 (ConvIcar_c093_2 0) capacitor c=80p
RCONVINTQ_c093_2 (conv_q_c093_2 ConvQcar_c093_2) resistor r=1k
CCONVINTQ_c093_2 (ConvQcar_c093_2 0) capacitor c=80p
save conv_bpf_c093_2 ConvIcar_c093_2 ConvQcar_c093_2

// conventional mixed baseline bl093, carrier_3: 1000000000 Hz
CCONVBPF_c093_3 (bl093 n_conv_cbpf_c093_3) capacitor c=2.533029591058e-14
LCONVBPF_c093_3 (n_conv_cbpf_c093_3 conv_bpf_c093_3) inductor l=1.000000000000e-06
RCONVBPF_c093_3 (conv_bpf_c093_3 0) resistor r=3.141592653590e+02
ECONVI_c093_3_00 (conv_i_src_c093_3_00 0 conv_bpf_c093_3 0) vcvs gain=9.807852804032e-01
SCONVI_c093_3_00 (conv_i_src_c093_3_00 conv_i_c093_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_00 (conv_q_src_c093_3_00 0 conv_bpf_c093_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_3_00 (conv_q_src_c093_3_00 conv_q_c093_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_01 (conv_i_src_c093_3_01 0 conv_bpf_c093_3 0) vcvs gain=8.314696123025e-01
SCONVI_c093_3_01 (conv_i_src_c093_3_01 conv_i_c093_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_01 (conv_q_src_c093_3_01 0 conv_bpf_c093_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_3_01 (conv_q_src_c093_3_01 conv_q_c093_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_02 (conv_i_src_c093_3_02 0 conv_bpf_c093_3 0) vcvs gain=5.555702330196e-01
SCONVI_c093_3_02 (conv_i_src_c093_3_02 conv_i_c093_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_02 (conv_q_src_c093_3_02 0 conv_bpf_c093_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_3_02 (conv_q_src_c093_3_02 conv_q_c093_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_03 (conv_i_src_c093_3_03 0 conv_bpf_c093_3 0) vcvs gain=1.950903220161e-01
SCONVI_c093_3_03 (conv_i_src_c093_3_03 conv_i_c093_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_03 (conv_q_src_c093_3_03 0 conv_bpf_c093_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_3_03 (conv_q_src_c093_3_03 conv_q_c093_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_04 (conv_i_src_c093_3_04 0 conv_bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_3_04 (conv_i_src_c093_3_04 conv_i_c093_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_04 (conv_q_src_c093_3_04 0 conv_bpf_c093_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c093_3_04 (conv_q_src_c093_3_04 conv_q_c093_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_05 (conv_i_src_c093_3_05 0 conv_bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_3_05 (conv_i_src_c093_3_05 conv_i_c093_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_05 (conv_q_src_c093_3_05 0 conv_bpf_c093_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c093_3_05 (conv_q_src_c093_3_05 conv_q_c093_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_06 (conv_i_src_c093_3_06 0 conv_bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_3_06 (conv_i_src_c093_3_06 conv_i_c093_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_06 (conv_q_src_c093_3_06 0 conv_bpf_c093_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c093_3_06 (conv_q_src_c093_3_06 conv_q_c093_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_07 (conv_i_src_c093_3_07 0 conv_bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_3_07 (conv_i_src_c093_3_07 conv_i_c093_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_07 (conv_q_src_c093_3_07 0 conv_bpf_c093_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c093_3_07 (conv_q_src_c093_3_07 conv_q_c093_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_08 (conv_i_src_c093_3_08 0 conv_bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c093_3_08 (conv_i_src_c093_3_08 conv_i_c093_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_08 (conv_q_src_c093_3_08 0 conv_bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_3_08 (conv_q_src_c093_3_08 conv_q_c093_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_09 (conv_i_src_c093_3_09 0 conv_bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c093_3_09 (conv_i_src_c093_3_09 conv_i_c093_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_09 (conv_q_src_c093_3_09 0 conv_bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_3_09 (conv_q_src_c093_3_09 conv_q_c093_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_10 (conv_i_src_c093_3_10 0 conv_bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c093_3_10 (conv_i_src_c093_3_10 conv_i_c093_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_10 (conv_q_src_c093_3_10 0 conv_bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_3_10 (conv_q_src_c093_3_10 conv_q_c093_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_11 (conv_i_src_c093_3_11 0 conv_bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c093_3_11 (conv_i_src_c093_3_11 conv_i_c093_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_11 (conv_q_src_c093_3_11 0 conv_bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_3_11 (conv_q_src_c093_3_11 conv_q_c093_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_12 (conv_i_src_c093_3_12 0 conv_bpf_c093_3 0) vcvs gain=1.950903220161e-01
SCONVI_c093_3_12 (conv_i_src_c093_3_12 conv_i_c093_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_12 (conv_q_src_c093_3_12 0 conv_bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c093_3_12 (conv_q_src_c093_3_12 conv_q_c093_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_13 (conv_i_src_c093_3_13 0 conv_bpf_c093_3 0) vcvs gain=5.555702330196e-01
SCONVI_c093_3_13 (conv_i_src_c093_3_13 conv_i_c093_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_13 (conv_q_src_c093_3_13 0 conv_bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c093_3_13 (conv_q_src_c093_3_13 conv_q_c093_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_14 (conv_i_src_c093_3_14 0 conv_bpf_c093_3 0) vcvs gain=8.314696123025e-01
SCONVI_c093_3_14 (conv_i_src_c093_3_14 conv_i_c093_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_14 (conv_q_src_c093_3_14 0 conv_bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c093_3_14 (conv_q_src_c093_3_14 conv_q_c093_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c093_3_15 (conv_i_src_c093_3_15 0 conv_bpf_c093_3 0) vcvs gain=9.807852804032e-01
SCONVI_c093_3_15 (conv_i_src_c093_3_15 conv_i_c093_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c093_3_15 (conv_q_src_c093_3_15 0 conv_bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c093_3_15 (conv_q_src_c093_3_15 conv_q_c093_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c093_3 (conv_i_c093_3 0) resistor r=1G
RCONVQ_c093_3 (conv_q_c093_3 0) resistor r=1G
RCONVINTI_c093_3 (conv_i_c093_3 ConvIcar_c093_3) resistor r=1k
CCONVINTI_c093_3 (ConvIcar_c093_3 0) capacitor c=80p
RCONVINTQ_c093_3 (conv_q_c093_3 ConvQcar_c093_3) resistor r=1k
CCONVINTQ_c093_3 (ConvQcar_c093_3 0) capacitor c=80p
save conv_bpf_c093_3 ConvIcar_c093_3 ConvQcar_c093_3

// conventional mixed baseline bl094, carrier_0: 250000000 Hz
CCONVBPF_c094_0 (bl094 n_conv_cbpf_c094_0) capacitor c=4.052847345694e-13
LCONVBPF_c094_0 (n_conv_cbpf_c094_0 conv_bpf_c094_0) inductor l=1.000000000000e-06
RCONVBPF_c094_0 (conv_bpf_c094_0 0) resistor r=7.853981633974e+01
ECONVI_c094_0_00 (conv_i_src_c094_0_00 0 conv_bpf_c094_0 0) vcvs gain=9.807852804032e-01
SCONVI_c094_0_00 (conv_i_src_c094_0_00 conv_i_c094_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_00 (conv_q_src_c094_0_00 0 conv_bpf_c094_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_0_00 (conv_q_src_c094_0_00 conv_q_c094_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_01 (conv_i_src_c094_0_01 0 conv_bpf_c094_0 0) vcvs gain=8.314696123025e-01
SCONVI_c094_0_01 (conv_i_src_c094_0_01 conv_i_c094_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_01 (conv_q_src_c094_0_01 0 conv_bpf_c094_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_0_01 (conv_q_src_c094_0_01 conv_q_c094_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_02 (conv_i_src_c094_0_02 0 conv_bpf_c094_0 0) vcvs gain=5.555702330196e-01
SCONVI_c094_0_02 (conv_i_src_c094_0_02 conv_i_c094_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_02 (conv_q_src_c094_0_02 0 conv_bpf_c094_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_0_02 (conv_q_src_c094_0_02 conv_q_c094_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_03 (conv_i_src_c094_0_03 0 conv_bpf_c094_0 0) vcvs gain=1.950903220161e-01
SCONVI_c094_0_03 (conv_i_src_c094_0_03 conv_i_c094_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_03 (conv_q_src_c094_0_03 0 conv_bpf_c094_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_0_03 (conv_q_src_c094_0_03 conv_q_c094_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_04 (conv_i_src_c094_0_04 0 conv_bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_0_04 (conv_i_src_c094_0_04 conv_i_c094_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_04 (conv_q_src_c094_0_04 0 conv_bpf_c094_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_0_04 (conv_q_src_c094_0_04 conv_q_c094_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_05 (conv_i_src_c094_0_05 0 conv_bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_0_05 (conv_i_src_c094_0_05 conv_i_c094_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_05 (conv_q_src_c094_0_05 0 conv_bpf_c094_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_0_05 (conv_q_src_c094_0_05 conv_q_c094_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_06 (conv_i_src_c094_0_06 0 conv_bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_0_06 (conv_i_src_c094_0_06 conv_i_c094_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_06 (conv_q_src_c094_0_06 0 conv_bpf_c094_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_0_06 (conv_q_src_c094_0_06 conv_q_c094_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_07 (conv_i_src_c094_0_07 0 conv_bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_0_07 (conv_i_src_c094_0_07 conv_i_c094_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_07 (conv_q_src_c094_0_07 0 conv_bpf_c094_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_0_07 (conv_q_src_c094_0_07 conv_q_c094_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_08 (conv_i_src_c094_0_08 0 conv_bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_0_08 (conv_i_src_c094_0_08 conv_i_c094_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_08 (conv_q_src_c094_0_08 0 conv_bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_0_08 (conv_q_src_c094_0_08 conv_q_c094_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_09 (conv_i_src_c094_0_09 0 conv_bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_0_09 (conv_i_src_c094_0_09 conv_i_c094_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_09 (conv_q_src_c094_0_09 0 conv_bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_0_09 (conv_q_src_c094_0_09 conv_q_c094_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_10 (conv_i_src_c094_0_10 0 conv_bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_0_10 (conv_i_src_c094_0_10 conv_i_c094_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_10 (conv_q_src_c094_0_10 0 conv_bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_0_10 (conv_q_src_c094_0_10 conv_q_c094_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_11 (conv_i_src_c094_0_11 0 conv_bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_0_11 (conv_i_src_c094_0_11 conv_i_c094_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_11 (conv_q_src_c094_0_11 0 conv_bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_0_11 (conv_q_src_c094_0_11 conv_q_c094_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_12 (conv_i_src_c094_0_12 0 conv_bpf_c094_0 0) vcvs gain=1.950903220161e-01
SCONVI_c094_0_12 (conv_i_src_c094_0_12 conv_i_c094_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_12 (conv_q_src_c094_0_12 0 conv_bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_0_12 (conv_q_src_c094_0_12 conv_q_c094_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_13 (conv_i_src_c094_0_13 0 conv_bpf_c094_0 0) vcvs gain=5.555702330196e-01
SCONVI_c094_0_13 (conv_i_src_c094_0_13 conv_i_c094_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_13 (conv_q_src_c094_0_13 0 conv_bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_0_13 (conv_q_src_c094_0_13 conv_q_c094_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_14 (conv_i_src_c094_0_14 0 conv_bpf_c094_0 0) vcvs gain=8.314696123025e-01
SCONVI_c094_0_14 (conv_i_src_c094_0_14 conv_i_c094_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_14 (conv_q_src_c094_0_14 0 conv_bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_0_14 (conv_q_src_c094_0_14 conv_q_c094_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_0_15 (conv_i_src_c094_0_15 0 conv_bpf_c094_0 0) vcvs gain=9.807852804032e-01
SCONVI_c094_0_15 (conv_i_src_c094_0_15 conv_i_c094_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_0_15 (conv_q_src_c094_0_15 0 conv_bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_0_15 (conv_q_src_c094_0_15 conv_q_c094_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c094_0 (conv_i_c094_0 0) resistor r=1G
RCONVQ_c094_0 (conv_q_c094_0 0) resistor r=1G
RCONVINTI_c094_0 (conv_i_c094_0 ConvIcar_c094_0) resistor r=1k
CCONVINTI_c094_0 (ConvIcar_c094_0 0) capacitor c=80p
RCONVINTQ_c094_0 (conv_q_c094_0 ConvQcar_c094_0) resistor r=1k
CCONVINTQ_c094_0 (ConvQcar_c094_0 0) capacitor c=80p
save conv_bpf_c094_0 ConvIcar_c094_0 ConvQcar_c094_0

// conventional mixed baseline bl094, carrier_1: 500000000 Hz
CCONVBPF_c094_1 (bl094 n_conv_cbpf_c094_1) capacitor c=1.013211836423e-13
LCONVBPF_c094_1 (n_conv_cbpf_c094_1 conv_bpf_c094_1) inductor l=1.000000000000e-06
RCONVBPF_c094_1 (conv_bpf_c094_1 0) resistor r=1.570796326795e+02
ECONVI_c094_1_00 (conv_i_src_c094_1_00 0 conv_bpf_c094_1 0) vcvs gain=9.807852804032e-01
SCONVI_c094_1_00 (conv_i_src_c094_1_00 conv_i_c094_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_00 (conv_q_src_c094_1_00 0 conv_bpf_c094_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_1_00 (conv_q_src_c094_1_00 conv_q_c094_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_01 (conv_i_src_c094_1_01 0 conv_bpf_c094_1 0) vcvs gain=8.314696123025e-01
SCONVI_c094_1_01 (conv_i_src_c094_1_01 conv_i_c094_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_01 (conv_q_src_c094_1_01 0 conv_bpf_c094_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_1_01 (conv_q_src_c094_1_01 conv_q_c094_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_02 (conv_i_src_c094_1_02 0 conv_bpf_c094_1 0) vcvs gain=5.555702330196e-01
SCONVI_c094_1_02 (conv_i_src_c094_1_02 conv_i_c094_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_02 (conv_q_src_c094_1_02 0 conv_bpf_c094_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_1_02 (conv_q_src_c094_1_02 conv_q_c094_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_03 (conv_i_src_c094_1_03 0 conv_bpf_c094_1 0) vcvs gain=1.950903220161e-01
SCONVI_c094_1_03 (conv_i_src_c094_1_03 conv_i_c094_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_03 (conv_q_src_c094_1_03 0 conv_bpf_c094_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_1_03 (conv_q_src_c094_1_03 conv_q_c094_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_04 (conv_i_src_c094_1_04 0 conv_bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_1_04 (conv_i_src_c094_1_04 conv_i_c094_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_04 (conv_q_src_c094_1_04 0 conv_bpf_c094_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_1_04 (conv_q_src_c094_1_04 conv_q_c094_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_05 (conv_i_src_c094_1_05 0 conv_bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_1_05 (conv_i_src_c094_1_05 conv_i_c094_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_05 (conv_q_src_c094_1_05 0 conv_bpf_c094_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_1_05 (conv_q_src_c094_1_05 conv_q_c094_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_06 (conv_i_src_c094_1_06 0 conv_bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_1_06 (conv_i_src_c094_1_06 conv_i_c094_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_06 (conv_q_src_c094_1_06 0 conv_bpf_c094_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_1_06 (conv_q_src_c094_1_06 conv_q_c094_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_07 (conv_i_src_c094_1_07 0 conv_bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_1_07 (conv_i_src_c094_1_07 conv_i_c094_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_07 (conv_q_src_c094_1_07 0 conv_bpf_c094_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_1_07 (conv_q_src_c094_1_07 conv_q_c094_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_08 (conv_i_src_c094_1_08 0 conv_bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_1_08 (conv_i_src_c094_1_08 conv_i_c094_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_08 (conv_q_src_c094_1_08 0 conv_bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_1_08 (conv_q_src_c094_1_08 conv_q_c094_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_09 (conv_i_src_c094_1_09 0 conv_bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_1_09 (conv_i_src_c094_1_09 conv_i_c094_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_09 (conv_q_src_c094_1_09 0 conv_bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_1_09 (conv_q_src_c094_1_09 conv_q_c094_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_10 (conv_i_src_c094_1_10 0 conv_bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_1_10 (conv_i_src_c094_1_10 conv_i_c094_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_10 (conv_q_src_c094_1_10 0 conv_bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_1_10 (conv_q_src_c094_1_10 conv_q_c094_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_11 (conv_i_src_c094_1_11 0 conv_bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_1_11 (conv_i_src_c094_1_11 conv_i_c094_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_11 (conv_q_src_c094_1_11 0 conv_bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_1_11 (conv_q_src_c094_1_11 conv_q_c094_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_12 (conv_i_src_c094_1_12 0 conv_bpf_c094_1 0) vcvs gain=1.950903220161e-01
SCONVI_c094_1_12 (conv_i_src_c094_1_12 conv_i_c094_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_12 (conv_q_src_c094_1_12 0 conv_bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_1_12 (conv_q_src_c094_1_12 conv_q_c094_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_13 (conv_i_src_c094_1_13 0 conv_bpf_c094_1 0) vcvs gain=5.555702330196e-01
SCONVI_c094_1_13 (conv_i_src_c094_1_13 conv_i_c094_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_13 (conv_q_src_c094_1_13 0 conv_bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_1_13 (conv_q_src_c094_1_13 conv_q_c094_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_14 (conv_i_src_c094_1_14 0 conv_bpf_c094_1 0) vcvs gain=8.314696123025e-01
SCONVI_c094_1_14 (conv_i_src_c094_1_14 conv_i_c094_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_14 (conv_q_src_c094_1_14 0 conv_bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_1_14 (conv_q_src_c094_1_14 conv_q_c094_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_1_15 (conv_i_src_c094_1_15 0 conv_bpf_c094_1 0) vcvs gain=9.807852804032e-01
SCONVI_c094_1_15 (conv_i_src_c094_1_15 conv_i_c094_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_1_15 (conv_q_src_c094_1_15 0 conv_bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_1_15 (conv_q_src_c094_1_15 conv_q_c094_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c094_1 (conv_i_c094_1 0) resistor r=1G
RCONVQ_c094_1 (conv_q_c094_1 0) resistor r=1G
RCONVINTI_c094_1 (conv_i_c094_1 ConvIcar_c094_1) resistor r=1k
CCONVINTI_c094_1 (ConvIcar_c094_1 0) capacitor c=80p
RCONVINTQ_c094_1 (conv_q_c094_1 ConvQcar_c094_1) resistor r=1k
CCONVINTQ_c094_1 (ConvQcar_c094_1 0) capacitor c=80p
save conv_bpf_c094_1 ConvIcar_c094_1 ConvQcar_c094_1

// conventional mixed baseline bl094, carrier_2: 750000000 Hz
CCONVBPF_c094_2 (bl094 n_conv_cbpf_c094_2) capacitor c=4.503163717437e-14
LCONVBPF_c094_2 (n_conv_cbpf_c094_2 conv_bpf_c094_2) inductor l=1.000000000000e-06
RCONVBPF_c094_2 (conv_bpf_c094_2 0) resistor r=2.356194490192e+02
ECONVI_c094_2_00 (conv_i_src_c094_2_00 0 conv_bpf_c094_2 0) vcvs gain=9.807852804032e-01
SCONVI_c094_2_00 (conv_i_src_c094_2_00 conv_i_c094_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_00 (conv_q_src_c094_2_00 0 conv_bpf_c094_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_2_00 (conv_q_src_c094_2_00 conv_q_c094_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_01 (conv_i_src_c094_2_01 0 conv_bpf_c094_2 0) vcvs gain=8.314696123025e-01
SCONVI_c094_2_01 (conv_i_src_c094_2_01 conv_i_c094_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_01 (conv_q_src_c094_2_01 0 conv_bpf_c094_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_2_01 (conv_q_src_c094_2_01 conv_q_c094_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_02 (conv_i_src_c094_2_02 0 conv_bpf_c094_2 0) vcvs gain=5.555702330196e-01
SCONVI_c094_2_02 (conv_i_src_c094_2_02 conv_i_c094_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_02 (conv_q_src_c094_2_02 0 conv_bpf_c094_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_2_02 (conv_q_src_c094_2_02 conv_q_c094_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_03 (conv_i_src_c094_2_03 0 conv_bpf_c094_2 0) vcvs gain=1.950903220161e-01
SCONVI_c094_2_03 (conv_i_src_c094_2_03 conv_i_c094_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_03 (conv_q_src_c094_2_03 0 conv_bpf_c094_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_2_03 (conv_q_src_c094_2_03 conv_q_c094_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_04 (conv_i_src_c094_2_04 0 conv_bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_2_04 (conv_i_src_c094_2_04 conv_i_c094_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_04 (conv_q_src_c094_2_04 0 conv_bpf_c094_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_2_04 (conv_q_src_c094_2_04 conv_q_c094_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_05 (conv_i_src_c094_2_05 0 conv_bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_2_05 (conv_i_src_c094_2_05 conv_i_c094_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_05 (conv_q_src_c094_2_05 0 conv_bpf_c094_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_2_05 (conv_q_src_c094_2_05 conv_q_c094_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_06 (conv_i_src_c094_2_06 0 conv_bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_2_06 (conv_i_src_c094_2_06 conv_i_c094_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_06 (conv_q_src_c094_2_06 0 conv_bpf_c094_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_2_06 (conv_q_src_c094_2_06 conv_q_c094_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_07 (conv_i_src_c094_2_07 0 conv_bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_2_07 (conv_i_src_c094_2_07 conv_i_c094_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_07 (conv_q_src_c094_2_07 0 conv_bpf_c094_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_2_07 (conv_q_src_c094_2_07 conv_q_c094_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_08 (conv_i_src_c094_2_08 0 conv_bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_2_08 (conv_i_src_c094_2_08 conv_i_c094_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_08 (conv_q_src_c094_2_08 0 conv_bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_2_08 (conv_q_src_c094_2_08 conv_q_c094_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_09 (conv_i_src_c094_2_09 0 conv_bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_2_09 (conv_i_src_c094_2_09 conv_i_c094_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_09 (conv_q_src_c094_2_09 0 conv_bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_2_09 (conv_q_src_c094_2_09 conv_q_c094_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_10 (conv_i_src_c094_2_10 0 conv_bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_2_10 (conv_i_src_c094_2_10 conv_i_c094_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_10 (conv_q_src_c094_2_10 0 conv_bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_2_10 (conv_q_src_c094_2_10 conv_q_c094_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_11 (conv_i_src_c094_2_11 0 conv_bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_2_11 (conv_i_src_c094_2_11 conv_i_c094_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_11 (conv_q_src_c094_2_11 0 conv_bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_2_11 (conv_q_src_c094_2_11 conv_q_c094_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_12 (conv_i_src_c094_2_12 0 conv_bpf_c094_2 0) vcvs gain=1.950903220161e-01
SCONVI_c094_2_12 (conv_i_src_c094_2_12 conv_i_c094_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_12 (conv_q_src_c094_2_12 0 conv_bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_2_12 (conv_q_src_c094_2_12 conv_q_c094_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_13 (conv_i_src_c094_2_13 0 conv_bpf_c094_2 0) vcvs gain=5.555702330196e-01
SCONVI_c094_2_13 (conv_i_src_c094_2_13 conv_i_c094_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_13 (conv_q_src_c094_2_13 0 conv_bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_2_13 (conv_q_src_c094_2_13 conv_q_c094_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_14 (conv_i_src_c094_2_14 0 conv_bpf_c094_2 0) vcvs gain=8.314696123025e-01
SCONVI_c094_2_14 (conv_i_src_c094_2_14 conv_i_c094_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_14 (conv_q_src_c094_2_14 0 conv_bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_2_14 (conv_q_src_c094_2_14 conv_q_c094_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_2_15 (conv_i_src_c094_2_15 0 conv_bpf_c094_2 0) vcvs gain=9.807852804032e-01
SCONVI_c094_2_15 (conv_i_src_c094_2_15 conv_i_c094_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_2_15 (conv_q_src_c094_2_15 0 conv_bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_2_15 (conv_q_src_c094_2_15 conv_q_c094_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c094_2 (conv_i_c094_2 0) resistor r=1G
RCONVQ_c094_2 (conv_q_c094_2 0) resistor r=1G
RCONVINTI_c094_2 (conv_i_c094_2 ConvIcar_c094_2) resistor r=1k
CCONVINTI_c094_2 (ConvIcar_c094_2 0) capacitor c=80p
RCONVINTQ_c094_2 (conv_q_c094_2 ConvQcar_c094_2) resistor r=1k
CCONVINTQ_c094_2 (ConvQcar_c094_2 0) capacitor c=80p
save conv_bpf_c094_2 ConvIcar_c094_2 ConvQcar_c094_2

// conventional mixed baseline bl094, carrier_3: 1000000000 Hz
CCONVBPF_c094_3 (bl094 n_conv_cbpf_c094_3) capacitor c=2.533029591058e-14
LCONVBPF_c094_3 (n_conv_cbpf_c094_3 conv_bpf_c094_3) inductor l=1.000000000000e-06
RCONVBPF_c094_3 (conv_bpf_c094_3 0) resistor r=3.141592653590e+02
ECONVI_c094_3_00 (conv_i_src_c094_3_00 0 conv_bpf_c094_3 0) vcvs gain=9.807852804032e-01
SCONVI_c094_3_00 (conv_i_src_c094_3_00 conv_i_c094_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_00 (conv_q_src_c094_3_00 0 conv_bpf_c094_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_3_00 (conv_q_src_c094_3_00 conv_q_c094_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_01 (conv_i_src_c094_3_01 0 conv_bpf_c094_3 0) vcvs gain=8.314696123025e-01
SCONVI_c094_3_01 (conv_i_src_c094_3_01 conv_i_c094_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_01 (conv_q_src_c094_3_01 0 conv_bpf_c094_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_3_01 (conv_q_src_c094_3_01 conv_q_c094_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_02 (conv_i_src_c094_3_02 0 conv_bpf_c094_3 0) vcvs gain=5.555702330196e-01
SCONVI_c094_3_02 (conv_i_src_c094_3_02 conv_i_c094_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_02 (conv_q_src_c094_3_02 0 conv_bpf_c094_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_3_02 (conv_q_src_c094_3_02 conv_q_c094_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_03 (conv_i_src_c094_3_03 0 conv_bpf_c094_3 0) vcvs gain=1.950903220161e-01
SCONVI_c094_3_03 (conv_i_src_c094_3_03 conv_i_c094_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_03 (conv_q_src_c094_3_03 0 conv_bpf_c094_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_3_03 (conv_q_src_c094_3_03 conv_q_c094_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_04 (conv_i_src_c094_3_04 0 conv_bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_3_04 (conv_i_src_c094_3_04 conv_i_c094_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_04 (conv_q_src_c094_3_04 0 conv_bpf_c094_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c094_3_04 (conv_q_src_c094_3_04 conv_q_c094_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_05 (conv_i_src_c094_3_05 0 conv_bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_3_05 (conv_i_src_c094_3_05 conv_i_c094_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_05 (conv_q_src_c094_3_05 0 conv_bpf_c094_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c094_3_05 (conv_q_src_c094_3_05 conv_q_c094_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_06 (conv_i_src_c094_3_06 0 conv_bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_3_06 (conv_i_src_c094_3_06 conv_i_c094_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_06 (conv_q_src_c094_3_06 0 conv_bpf_c094_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c094_3_06 (conv_q_src_c094_3_06 conv_q_c094_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_07 (conv_i_src_c094_3_07 0 conv_bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_3_07 (conv_i_src_c094_3_07 conv_i_c094_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_07 (conv_q_src_c094_3_07 0 conv_bpf_c094_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c094_3_07 (conv_q_src_c094_3_07 conv_q_c094_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_08 (conv_i_src_c094_3_08 0 conv_bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c094_3_08 (conv_i_src_c094_3_08 conv_i_c094_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_08 (conv_q_src_c094_3_08 0 conv_bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_3_08 (conv_q_src_c094_3_08 conv_q_c094_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_09 (conv_i_src_c094_3_09 0 conv_bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c094_3_09 (conv_i_src_c094_3_09 conv_i_c094_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_09 (conv_q_src_c094_3_09 0 conv_bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_3_09 (conv_q_src_c094_3_09 conv_q_c094_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_10 (conv_i_src_c094_3_10 0 conv_bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c094_3_10 (conv_i_src_c094_3_10 conv_i_c094_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_10 (conv_q_src_c094_3_10 0 conv_bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_3_10 (conv_q_src_c094_3_10 conv_q_c094_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_11 (conv_i_src_c094_3_11 0 conv_bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c094_3_11 (conv_i_src_c094_3_11 conv_i_c094_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_11 (conv_q_src_c094_3_11 0 conv_bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_3_11 (conv_q_src_c094_3_11 conv_q_c094_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_12 (conv_i_src_c094_3_12 0 conv_bpf_c094_3 0) vcvs gain=1.950903220161e-01
SCONVI_c094_3_12 (conv_i_src_c094_3_12 conv_i_c094_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_12 (conv_q_src_c094_3_12 0 conv_bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c094_3_12 (conv_q_src_c094_3_12 conv_q_c094_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_13 (conv_i_src_c094_3_13 0 conv_bpf_c094_3 0) vcvs gain=5.555702330196e-01
SCONVI_c094_3_13 (conv_i_src_c094_3_13 conv_i_c094_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_13 (conv_q_src_c094_3_13 0 conv_bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c094_3_13 (conv_q_src_c094_3_13 conv_q_c094_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_14 (conv_i_src_c094_3_14 0 conv_bpf_c094_3 0) vcvs gain=8.314696123025e-01
SCONVI_c094_3_14 (conv_i_src_c094_3_14 conv_i_c094_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_14 (conv_q_src_c094_3_14 0 conv_bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c094_3_14 (conv_q_src_c094_3_14 conv_q_c094_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c094_3_15 (conv_i_src_c094_3_15 0 conv_bpf_c094_3 0) vcvs gain=9.807852804032e-01
SCONVI_c094_3_15 (conv_i_src_c094_3_15 conv_i_c094_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c094_3_15 (conv_q_src_c094_3_15 0 conv_bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c094_3_15 (conv_q_src_c094_3_15 conv_q_c094_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c094_3 (conv_i_c094_3 0) resistor r=1G
RCONVQ_c094_3 (conv_q_c094_3 0) resistor r=1G
RCONVINTI_c094_3 (conv_i_c094_3 ConvIcar_c094_3) resistor r=1k
CCONVINTI_c094_3 (ConvIcar_c094_3 0) capacitor c=80p
RCONVINTQ_c094_3 (conv_q_c094_3 ConvQcar_c094_3) resistor r=1k
CCONVINTQ_c094_3 (ConvQcar_c094_3 0) capacitor c=80p
save conv_bpf_c094_3 ConvIcar_c094_3 ConvQcar_c094_3

// conventional mixed baseline bl095, carrier_0: 250000000 Hz
CCONVBPF_c095_0 (bl095 n_conv_cbpf_c095_0) capacitor c=4.052847345694e-13
LCONVBPF_c095_0 (n_conv_cbpf_c095_0 conv_bpf_c095_0) inductor l=1.000000000000e-06
RCONVBPF_c095_0 (conv_bpf_c095_0 0) resistor r=7.853981633974e+01
ECONVI_c095_0_00 (conv_i_src_c095_0_00 0 conv_bpf_c095_0 0) vcvs gain=9.807852804032e-01
SCONVI_c095_0_00 (conv_i_src_c095_0_00 conv_i_c095_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_00 (conv_q_src_c095_0_00 0 conv_bpf_c095_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_0_00 (conv_q_src_c095_0_00 conv_q_c095_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_01 (conv_i_src_c095_0_01 0 conv_bpf_c095_0 0) vcvs gain=8.314696123025e-01
SCONVI_c095_0_01 (conv_i_src_c095_0_01 conv_i_c095_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_01 (conv_q_src_c095_0_01 0 conv_bpf_c095_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_0_01 (conv_q_src_c095_0_01 conv_q_c095_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_02 (conv_i_src_c095_0_02 0 conv_bpf_c095_0 0) vcvs gain=5.555702330196e-01
SCONVI_c095_0_02 (conv_i_src_c095_0_02 conv_i_c095_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_02 (conv_q_src_c095_0_02 0 conv_bpf_c095_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_0_02 (conv_q_src_c095_0_02 conv_q_c095_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_03 (conv_i_src_c095_0_03 0 conv_bpf_c095_0 0) vcvs gain=1.950903220161e-01
SCONVI_c095_0_03 (conv_i_src_c095_0_03 conv_i_c095_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_03 (conv_q_src_c095_0_03 0 conv_bpf_c095_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_0_03 (conv_q_src_c095_0_03 conv_q_c095_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_04 (conv_i_src_c095_0_04 0 conv_bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_0_04 (conv_i_src_c095_0_04 conv_i_c095_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_04 (conv_q_src_c095_0_04 0 conv_bpf_c095_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_0_04 (conv_q_src_c095_0_04 conv_q_c095_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_05 (conv_i_src_c095_0_05 0 conv_bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_0_05 (conv_i_src_c095_0_05 conv_i_c095_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_05 (conv_q_src_c095_0_05 0 conv_bpf_c095_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_0_05 (conv_q_src_c095_0_05 conv_q_c095_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_06 (conv_i_src_c095_0_06 0 conv_bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_0_06 (conv_i_src_c095_0_06 conv_i_c095_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_06 (conv_q_src_c095_0_06 0 conv_bpf_c095_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_0_06 (conv_q_src_c095_0_06 conv_q_c095_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_07 (conv_i_src_c095_0_07 0 conv_bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_0_07 (conv_i_src_c095_0_07 conv_i_c095_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_07 (conv_q_src_c095_0_07 0 conv_bpf_c095_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_0_07 (conv_q_src_c095_0_07 conv_q_c095_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_08 (conv_i_src_c095_0_08 0 conv_bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_0_08 (conv_i_src_c095_0_08 conv_i_c095_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_08 (conv_q_src_c095_0_08 0 conv_bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_0_08 (conv_q_src_c095_0_08 conv_q_c095_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_09 (conv_i_src_c095_0_09 0 conv_bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_0_09 (conv_i_src_c095_0_09 conv_i_c095_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_09 (conv_q_src_c095_0_09 0 conv_bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_0_09 (conv_q_src_c095_0_09 conv_q_c095_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_10 (conv_i_src_c095_0_10 0 conv_bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_0_10 (conv_i_src_c095_0_10 conv_i_c095_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_10 (conv_q_src_c095_0_10 0 conv_bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_0_10 (conv_q_src_c095_0_10 conv_q_c095_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_11 (conv_i_src_c095_0_11 0 conv_bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_0_11 (conv_i_src_c095_0_11 conv_i_c095_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_11 (conv_q_src_c095_0_11 0 conv_bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_0_11 (conv_q_src_c095_0_11 conv_q_c095_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_12 (conv_i_src_c095_0_12 0 conv_bpf_c095_0 0) vcvs gain=1.950903220161e-01
SCONVI_c095_0_12 (conv_i_src_c095_0_12 conv_i_c095_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_12 (conv_q_src_c095_0_12 0 conv_bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_0_12 (conv_q_src_c095_0_12 conv_q_c095_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_13 (conv_i_src_c095_0_13 0 conv_bpf_c095_0 0) vcvs gain=5.555702330196e-01
SCONVI_c095_0_13 (conv_i_src_c095_0_13 conv_i_c095_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_13 (conv_q_src_c095_0_13 0 conv_bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_0_13 (conv_q_src_c095_0_13 conv_q_c095_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_14 (conv_i_src_c095_0_14 0 conv_bpf_c095_0 0) vcvs gain=8.314696123025e-01
SCONVI_c095_0_14 (conv_i_src_c095_0_14 conv_i_c095_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_14 (conv_q_src_c095_0_14 0 conv_bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_0_14 (conv_q_src_c095_0_14 conv_q_c095_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_0_15 (conv_i_src_c095_0_15 0 conv_bpf_c095_0 0) vcvs gain=9.807852804032e-01
SCONVI_c095_0_15 (conv_i_src_c095_0_15 conv_i_c095_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_0_15 (conv_q_src_c095_0_15 0 conv_bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_0_15 (conv_q_src_c095_0_15 conv_q_c095_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c095_0 (conv_i_c095_0 0) resistor r=1G
RCONVQ_c095_0 (conv_q_c095_0 0) resistor r=1G
RCONVINTI_c095_0 (conv_i_c095_0 ConvIcar_c095_0) resistor r=1k
CCONVINTI_c095_0 (ConvIcar_c095_0 0) capacitor c=80p
RCONVINTQ_c095_0 (conv_q_c095_0 ConvQcar_c095_0) resistor r=1k
CCONVINTQ_c095_0 (ConvQcar_c095_0 0) capacitor c=80p
save conv_bpf_c095_0 ConvIcar_c095_0 ConvQcar_c095_0

// conventional mixed baseline bl095, carrier_1: 500000000 Hz
CCONVBPF_c095_1 (bl095 n_conv_cbpf_c095_1) capacitor c=1.013211836423e-13
LCONVBPF_c095_1 (n_conv_cbpf_c095_1 conv_bpf_c095_1) inductor l=1.000000000000e-06
RCONVBPF_c095_1 (conv_bpf_c095_1 0) resistor r=1.570796326795e+02
ECONVI_c095_1_00 (conv_i_src_c095_1_00 0 conv_bpf_c095_1 0) vcvs gain=9.807852804032e-01
SCONVI_c095_1_00 (conv_i_src_c095_1_00 conv_i_c095_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_00 (conv_q_src_c095_1_00 0 conv_bpf_c095_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_1_00 (conv_q_src_c095_1_00 conv_q_c095_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_01 (conv_i_src_c095_1_01 0 conv_bpf_c095_1 0) vcvs gain=8.314696123025e-01
SCONVI_c095_1_01 (conv_i_src_c095_1_01 conv_i_c095_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_01 (conv_q_src_c095_1_01 0 conv_bpf_c095_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_1_01 (conv_q_src_c095_1_01 conv_q_c095_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_02 (conv_i_src_c095_1_02 0 conv_bpf_c095_1 0) vcvs gain=5.555702330196e-01
SCONVI_c095_1_02 (conv_i_src_c095_1_02 conv_i_c095_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_02 (conv_q_src_c095_1_02 0 conv_bpf_c095_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_1_02 (conv_q_src_c095_1_02 conv_q_c095_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_03 (conv_i_src_c095_1_03 0 conv_bpf_c095_1 0) vcvs gain=1.950903220161e-01
SCONVI_c095_1_03 (conv_i_src_c095_1_03 conv_i_c095_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_03 (conv_q_src_c095_1_03 0 conv_bpf_c095_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_1_03 (conv_q_src_c095_1_03 conv_q_c095_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_04 (conv_i_src_c095_1_04 0 conv_bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_1_04 (conv_i_src_c095_1_04 conv_i_c095_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_04 (conv_q_src_c095_1_04 0 conv_bpf_c095_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_1_04 (conv_q_src_c095_1_04 conv_q_c095_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_05 (conv_i_src_c095_1_05 0 conv_bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_1_05 (conv_i_src_c095_1_05 conv_i_c095_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_05 (conv_q_src_c095_1_05 0 conv_bpf_c095_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_1_05 (conv_q_src_c095_1_05 conv_q_c095_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_06 (conv_i_src_c095_1_06 0 conv_bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_1_06 (conv_i_src_c095_1_06 conv_i_c095_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_06 (conv_q_src_c095_1_06 0 conv_bpf_c095_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_1_06 (conv_q_src_c095_1_06 conv_q_c095_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_07 (conv_i_src_c095_1_07 0 conv_bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_1_07 (conv_i_src_c095_1_07 conv_i_c095_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_07 (conv_q_src_c095_1_07 0 conv_bpf_c095_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_1_07 (conv_q_src_c095_1_07 conv_q_c095_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_08 (conv_i_src_c095_1_08 0 conv_bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_1_08 (conv_i_src_c095_1_08 conv_i_c095_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_08 (conv_q_src_c095_1_08 0 conv_bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_1_08 (conv_q_src_c095_1_08 conv_q_c095_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_09 (conv_i_src_c095_1_09 0 conv_bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_1_09 (conv_i_src_c095_1_09 conv_i_c095_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_09 (conv_q_src_c095_1_09 0 conv_bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_1_09 (conv_q_src_c095_1_09 conv_q_c095_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_10 (conv_i_src_c095_1_10 0 conv_bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_1_10 (conv_i_src_c095_1_10 conv_i_c095_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_10 (conv_q_src_c095_1_10 0 conv_bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_1_10 (conv_q_src_c095_1_10 conv_q_c095_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_11 (conv_i_src_c095_1_11 0 conv_bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_1_11 (conv_i_src_c095_1_11 conv_i_c095_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_11 (conv_q_src_c095_1_11 0 conv_bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_1_11 (conv_q_src_c095_1_11 conv_q_c095_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_12 (conv_i_src_c095_1_12 0 conv_bpf_c095_1 0) vcvs gain=1.950903220161e-01
SCONVI_c095_1_12 (conv_i_src_c095_1_12 conv_i_c095_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_12 (conv_q_src_c095_1_12 0 conv_bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_1_12 (conv_q_src_c095_1_12 conv_q_c095_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_13 (conv_i_src_c095_1_13 0 conv_bpf_c095_1 0) vcvs gain=5.555702330196e-01
SCONVI_c095_1_13 (conv_i_src_c095_1_13 conv_i_c095_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_13 (conv_q_src_c095_1_13 0 conv_bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_1_13 (conv_q_src_c095_1_13 conv_q_c095_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_14 (conv_i_src_c095_1_14 0 conv_bpf_c095_1 0) vcvs gain=8.314696123025e-01
SCONVI_c095_1_14 (conv_i_src_c095_1_14 conv_i_c095_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_14 (conv_q_src_c095_1_14 0 conv_bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_1_14 (conv_q_src_c095_1_14 conv_q_c095_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_1_15 (conv_i_src_c095_1_15 0 conv_bpf_c095_1 0) vcvs gain=9.807852804032e-01
SCONVI_c095_1_15 (conv_i_src_c095_1_15 conv_i_c095_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_1_15 (conv_q_src_c095_1_15 0 conv_bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_1_15 (conv_q_src_c095_1_15 conv_q_c095_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c095_1 (conv_i_c095_1 0) resistor r=1G
RCONVQ_c095_1 (conv_q_c095_1 0) resistor r=1G
RCONVINTI_c095_1 (conv_i_c095_1 ConvIcar_c095_1) resistor r=1k
CCONVINTI_c095_1 (ConvIcar_c095_1 0) capacitor c=80p
RCONVINTQ_c095_1 (conv_q_c095_1 ConvQcar_c095_1) resistor r=1k
CCONVINTQ_c095_1 (ConvQcar_c095_1 0) capacitor c=80p
save conv_bpf_c095_1 ConvIcar_c095_1 ConvQcar_c095_1

// conventional mixed baseline bl095, carrier_2: 750000000 Hz
CCONVBPF_c095_2 (bl095 n_conv_cbpf_c095_2) capacitor c=4.503163717437e-14
LCONVBPF_c095_2 (n_conv_cbpf_c095_2 conv_bpf_c095_2) inductor l=1.000000000000e-06
RCONVBPF_c095_2 (conv_bpf_c095_2 0) resistor r=2.356194490192e+02
ECONVI_c095_2_00 (conv_i_src_c095_2_00 0 conv_bpf_c095_2 0) vcvs gain=9.807852804032e-01
SCONVI_c095_2_00 (conv_i_src_c095_2_00 conv_i_c095_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_00 (conv_q_src_c095_2_00 0 conv_bpf_c095_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_2_00 (conv_q_src_c095_2_00 conv_q_c095_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_01 (conv_i_src_c095_2_01 0 conv_bpf_c095_2 0) vcvs gain=8.314696123025e-01
SCONVI_c095_2_01 (conv_i_src_c095_2_01 conv_i_c095_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_01 (conv_q_src_c095_2_01 0 conv_bpf_c095_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_2_01 (conv_q_src_c095_2_01 conv_q_c095_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_02 (conv_i_src_c095_2_02 0 conv_bpf_c095_2 0) vcvs gain=5.555702330196e-01
SCONVI_c095_2_02 (conv_i_src_c095_2_02 conv_i_c095_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_02 (conv_q_src_c095_2_02 0 conv_bpf_c095_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_2_02 (conv_q_src_c095_2_02 conv_q_c095_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_03 (conv_i_src_c095_2_03 0 conv_bpf_c095_2 0) vcvs gain=1.950903220161e-01
SCONVI_c095_2_03 (conv_i_src_c095_2_03 conv_i_c095_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_03 (conv_q_src_c095_2_03 0 conv_bpf_c095_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_2_03 (conv_q_src_c095_2_03 conv_q_c095_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_04 (conv_i_src_c095_2_04 0 conv_bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_2_04 (conv_i_src_c095_2_04 conv_i_c095_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_04 (conv_q_src_c095_2_04 0 conv_bpf_c095_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_2_04 (conv_q_src_c095_2_04 conv_q_c095_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_05 (conv_i_src_c095_2_05 0 conv_bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_2_05 (conv_i_src_c095_2_05 conv_i_c095_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_05 (conv_q_src_c095_2_05 0 conv_bpf_c095_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_2_05 (conv_q_src_c095_2_05 conv_q_c095_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_06 (conv_i_src_c095_2_06 0 conv_bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_2_06 (conv_i_src_c095_2_06 conv_i_c095_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_06 (conv_q_src_c095_2_06 0 conv_bpf_c095_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_2_06 (conv_q_src_c095_2_06 conv_q_c095_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_07 (conv_i_src_c095_2_07 0 conv_bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_2_07 (conv_i_src_c095_2_07 conv_i_c095_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_07 (conv_q_src_c095_2_07 0 conv_bpf_c095_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_2_07 (conv_q_src_c095_2_07 conv_q_c095_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_08 (conv_i_src_c095_2_08 0 conv_bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_2_08 (conv_i_src_c095_2_08 conv_i_c095_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_08 (conv_q_src_c095_2_08 0 conv_bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_2_08 (conv_q_src_c095_2_08 conv_q_c095_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_09 (conv_i_src_c095_2_09 0 conv_bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_2_09 (conv_i_src_c095_2_09 conv_i_c095_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_09 (conv_q_src_c095_2_09 0 conv_bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_2_09 (conv_q_src_c095_2_09 conv_q_c095_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_10 (conv_i_src_c095_2_10 0 conv_bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_2_10 (conv_i_src_c095_2_10 conv_i_c095_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_10 (conv_q_src_c095_2_10 0 conv_bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_2_10 (conv_q_src_c095_2_10 conv_q_c095_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_11 (conv_i_src_c095_2_11 0 conv_bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_2_11 (conv_i_src_c095_2_11 conv_i_c095_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_11 (conv_q_src_c095_2_11 0 conv_bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_2_11 (conv_q_src_c095_2_11 conv_q_c095_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_12 (conv_i_src_c095_2_12 0 conv_bpf_c095_2 0) vcvs gain=1.950903220161e-01
SCONVI_c095_2_12 (conv_i_src_c095_2_12 conv_i_c095_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_12 (conv_q_src_c095_2_12 0 conv_bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_2_12 (conv_q_src_c095_2_12 conv_q_c095_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_13 (conv_i_src_c095_2_13 0 conv_bpf_c095_2 0) vcvs gain=5.555702330196e-01
SCONVI_c095_2_13 (conv_i_src_c095_2_13 conv_i_c095_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_13 (conv_q_src_c095_2_13 0 conv_bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_2_13 (conv_q_src_c095_2_13 conv_q_c095_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_14 (conv_i_src_c095_2_14 0 conv_bpf_c095_2 0) vcvs gain=8.314696123025e-01
SCONVI_c095_2_14 (conv_i_src_c095_2_14 conv_i_c095_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_14 (conv_q_src_c095_2_14 0 conv_bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_2_14 (conv_q_src_c095_2_14 conv_q_c095_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_2_15 (conv_i_src_c095_2_15 0 conv_bpf_c095_2 0) vcvs gain=9.807852804032e-01
SCONVI_c095_2_15 (conv_i_src_c095_2_15 conv_i_c095_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_2_15 (conv_q_src_c095_2_15 0 conv_bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_2_15 (conv_q_src_c095_2_15 conv_q_c095_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c095_2 (conv_i_c095_2 0) resistor r=1G
RCONVQ_c095_2 (conv_q_c095_2 0) resistor r=1G
RCONVINTI_c095_2 (conv_i_c095_2 ConvIcar_c095_2) resistor r=1k
CCONVINTI_c095_2 (ConvIcar_c095_2 0) capacitor c=80p
RCONVINTQ_c095_2 (conv_q_c095_2 ConvQcar_c095_2) resistor r=1k
CCONVINTQ_c095_2 (ConvQcar_c095_2 0) capacitor c=80p
save conv_bpf_c095_2 ConvIcar_c095_2 ConvQcar_c095_2

// conventional mixed baseline bl095, carrier_3: 1000000000 Hz
CCONVBPF_c095_3 (bl095 n_conv_cbpf_c095_3) capacitor c=2.533029591058e-14
LCONVBPF_c095_3 (n_conv_cbpf_c095_3 conv_bpf_c095_3) inductor l=1.000000000000e-06
RCONVBPF_c095_3 (conv_bpf_c095_3 0) resistor r=3.141592653590e+02
ECONVI_c095_3_00 (conv_i_src_c095_3_00 0 conv_bpf_c095_3 0) vcvs gain=9.807852804032e-01
SCONVI_c095_3_00 (conv_i_src_c095_3_00 conv_i_c095_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_00 (conv_q_src_c095_3_00 0 conv_bpf_c095_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_3_00 (conv_q_src_c095_3_00 conv_q_c095_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_01 (conv_i_src_c095_3_01 0 conv_bpf_c095_3 0) vcvs gain=8.314696123025e-01
SCONVI_c095_3_01 (conv_i_src_c095_3_01 conv_i_c095_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_01 (conv_q_src_c095_3_01 0 conv_bpf_c095_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_3_01 (conv_q_src_c095_3_01 conv_q_c095_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_02 (conv_i_src_c095_3_02 0 conv_bpf_c095_3 0) vcvs gain=5.555702330196e-01
SCONVI_c095_3_02 (conv_i_src_c095_3_02 conv_i_c095_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_02 (conv_q_src_c095_3_02 0 conv_bpf_c095_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_3_02 (conv_q_src_c095_3_02 conv_q_c095_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_03 (conv_i_src_c095_3_03 0 conv_bpf_c095_3 0) vcvs gain=1.950903220161e-01
SCONVI_c095_3_03 (conv_i_src_c095_3_03 conv_i_c095_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_03 (conv_q_src_c095_3_03 0 conv_bpf_c095_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_3_03 (conv_q_src_c095_3_03 conv_q_c095_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_04 (conv_i_src_c095_3_04 0 conv_bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_3_04 (conv_i_src_c095_3_04 conv_i_c095_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_04 (conv_q_src_c095_3_04 0 conv_bpf_c095_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c095_3_04 (conv_q_src_c095_3_04 conv_q_c095_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_05 (conv_i_src_c095_3_05 0 conv_bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_3_05 (conv_i_src_c095_3_05 conv_i_c095_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_05 (conv_q_src_c095_3_05 0 conv_bpf_c095_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c095_3_05 (conv_q_src_c095_3_05 conv_q_c095_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_06 (conv_i_src_c095_3_06 0 conv_bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_3_06 (conv_i_src_c095_3_06 conv_i_c095_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_06 (conv_q_src_c095_3_06 0 conv_bpf_c095_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c095_3_06 (conv_q_src_c095_3_06 conv_q_c095_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_07 (conv_i_src_c095_3_07 0 conv_bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_3_07 (conv_i_src_c095_3_07 conv_i_c095_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_07 (conv_q_src_c095_3_07 0 conv_bpf_c095_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c095_3_07 (conv_q_src_c095_3_07 conv_q_c095_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_08 (conv_i_src_c095_3_08 0 conv_bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c095_3_08 (conv_i_src_c095_3_08 conv_i_c095_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_08 (conv_q_src_c095_3_08 0 conv_bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_3_08 (conv_q_src_c095_3_08 conv_q_c095_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_09 (conv_i_src_c095_3_09 0 conv_bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c095_3_09 (conv_i_src_c095_3_09 conv_i_c095_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_09 (conv_q_src_c095_3_09 0 conv_bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_3_09 (conv_q_src_c095_3_09 conv_q_c095_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_10 (conv_i_src_c095_3_10 0 conv_bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c095_3_10 (conv_i_src_c095_3_10 conv_i_c095_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_10 (conv_q_src_c095_3_10 0 conv_bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_3_10 (conv_q_src_c095_3_10 conv_q_c095_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_11 (conv_i_src_c095_3_11 0 conv_bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c095_3_11 (conv_i_src_c095_3_11 conv_i_c095_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_11 (conv_q_src_c095_3_11 0 conv_bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_3_11 (conv_q_src_c095_3_11 conv_q_c095_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_12 (conv_i_src_c095_3_12 0 conv_bpf_c095_3 0) vcvs gain=1.950903220161e-01
SCONVI_c095_3_12 (conv_i_src_c095_3_12 conv_i_c095_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_12 (conv_q_src_c095_3_12 0 conv_bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c095_3_12 (conv_q_src_c095_3_12 conv_q_c095_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_13 (conv_i_src_c095_3_13 0 conv_bpf_c095_3 0) vcvs gain=5.555702330196e-01
SCONVI_c095_3_13 (conv_i_src_c095_3_13 conv_i_c095_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_13 (conv_q_src_c095_3_13 0 conv_bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c095_3_13 (conv_q_src_c095_3_13 conv_q_c095_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_14 (conv_i_src_c095_3_14 0 conv_bpf_c095_3 0) vcvs gain=8.314696123025e-01
SCONVI_c095_3_14 (conv_i_src_c095_3_14 conv_i_c095_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_14 (conv_q_src_c095_3_14 0 conv_bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c095_3_14 (conv_q_src_c095_3_14 conv_q_c095_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c095_3_15 (conv_i_src_c095_3_15 0 conv_bpf_c095_3 0) vcvs gain=9.807852804032e-01
SCONVI_c095_3_15 (conv_i_src_c095_3_15 conv_i_c095_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c095_3_15 (conv_q_src_c095_3_15 0 conv_bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c095_3_15 (conv_q_src_c095_3_15 conv_q_c095_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c095_3 (conv_i_c095_3 0) resistor r=1G
RCONVQ_c095_3 (conv_q_c095_3 0) resistor r=1G
RCONVINTI_c095_3 (conv_i_c095_3 ConvIcar_c095_3) resistor r=1k
CCONVINTI_c095_3 (ConvIcar_c095_3 0) capacitor c=80p
RCONVINTQ_c095_3 (conv_q_c095_3 ConvQcar_c095_3) resistor r=1k
CCONVINTQ_c095_3 (ConvQcar_c095_3 0) capacitor c=80p
save conv_bpf_c095_3 ConvIcar_c095_3 ConvQcar_c095_3

// conventional mixed baseline bl096, carrier_0: 250000000 Hz
CCONVBPF_c096_0 (bl096 n_conv_cbpf_c096_0) capacitor c=4.052847345694e-13
LCONVBPF_c096_0 (n_conv_cbpf_c096_0 conv_bpf_c096_0) inductor l=1.000000000000e-06
RCONVBPF_c096_0 (conv_bpf_c096_0 0) resistor r=7.853981633974e+01
ECONVI_c096_0_00 (conv_i_src_c096_0_00 0 conv_bpf_c096_0 0) vcvs gain=9.807852804032e-01
SCONVI_c096_0_00 (conv_i_src_c096_0_00 conv_i_c096_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_00 (conv_q_src_c096_0_00 0 conv_bpf_c096_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_0_00 (conv_q_src_c096_0_00 conv_q_c096_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_01 (conv_i_src_c096_0_01 0 conv_bpf_c096_0 0) vcvs gain=8.314696123025e-01
SCONVI_c096_0_01 (conv_i_src_c096_0_01 conv_i_c096_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_01 (conv_q_src_c096_0_01 0 conv_bpf_c096_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_0_01 (conv_q_src_c096_0_01 conv_q_c096_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_02 (conv_i_src_c096_0_02 0 conv_bpf_c096_0 0) vcvs gain=5.555702330196e-01
SCONVI_c096_0_02 (conv_i_src_c096_0_02 conv_i_c096_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_02 (conv_q_src_c096_0_02 0 conv_bpf_c096_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_0_02 (conv_q_src_c096_0_02 conv_q_c096_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_03 (conv_i_src_c096_0_03 0 conv_bpf_c096_0 0) vcvs gain=1.950903220161e-01
SCONVI_c096_0_03 (conv_i_src_c096_0_03 conv_i_c096_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_03 (conv_q_src_c096_0_03 0 conv_bpf_c096_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_0_03 (conv_q_src_c096_0_03 conv_q_c096_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_04 (conv_i_src_c096_0_04 0 conv_bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_0_04 (conv_i_src_c096_0_04 conv_i_c096_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_04 (conv_q_src_c096_0_04 0 conv_bpf_c096_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_0_04 (conv_q_src_c096_0_04 conv_q_c096_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_05 (conv_i_src_c096_0_05 0 conv_bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_0_05 (conv_i_src_c096_0_05 conv_i_c096_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_05 (conv_q_src_c096_0_05 0 conv_bpf_c096_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_0_05 (conv_q_src_c096_0_05 conv_q_c096_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_06 (conv_i_src_c096_0_06 0 conv_bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_0_06 (conv_i_src_c096_0_06 conv_i_c096_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_06 (conv_q_src_c096_0_06 0 conv_bpf_c096_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_0_06 (conv_q_src_c096_0_06 conv_q_c096_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_07 (conv_i_src_c096_0_07 0 conv_bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_0_07 (conv_i_src_c096_0_07 conv_i_c096_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_07 (conv_q_src_c096_0_07 0 conv_bpf_c096_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_0_07 (conv_q_src_c096_0_07 conv_q_c096_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_08 (conv_i_src_c096_0_08 0 conv_bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_0_08 (conv_i_src_c096_0_08 conv_i_c096_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_08 (conv_q_src_c096_0_08 0 conv_bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_0_08 (conv_q_src_c096_0_08 conv_q_c096_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_09 (conv_i_src_c096_0_09 0 conv_bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_0_09 (conv_i_src_c096_0_09 conv_i_c096_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_09 (conv_q_src_c096_0_09 0 conv_bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_0_09 (conv_q_src_c096_0_09 conv_q_c096_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_10 (conv_i_src_c096_0_10 0 conv_bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_0_10 (conv_i_src_c096_0_10 conv_i_c096_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_10 (conv_q_src_c096_0_10 0 conv_bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_0_10 (conv_q_src_c096_0_10 conv_q_c096_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_11 (conv_i_src_c096_0_11 0 conv_bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_0_11 (conv_i_src_c096_0_11 conv_i_c096_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_11 (conv_q_src_c096_0_11 0 conv_bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_0_11 (conv_q_src_c096_0_11 conv_q_c096_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_12 (conv_i_src_c096_0_12 0 conv_bpf_c096_0 0) vcvs gain=1.950903220161e-01
SCONVI_c096_0_12 (conv_i_src_c096_0_12 conv_i_c096_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_12 (conv_q_src_c096_0_12 0 conv_bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_0_12 (conv_q_src_c096_0_12 conv_q_c096_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_13 (conv_i_src_c096_0_13 0 conv_bpf_c096_0 0) vcvs gain=5.555702330196e-01
SCONVI_c096_0_13 (conv_i_src_c096_0_13 conv_i_c096_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_13 (conv_q_src_c096_0_13 0 conv_bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_0_13 (conv_q_src_c096_0_13 conv_q_c096_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_14 (conv_i_src_c096_0_14 0 conv_bpf_c096_0 0) vcvs gain=8.314696123025e-01
SCONVI_c096_0_14 (conv_i_src_c096_0_14 conv_i_c096_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_14 (conv_q_src_c096_0_14 0 conv_bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_0_14 (conv_q_src_c096_0_14 conv_q_c096_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_0_15 (conv_i_src_c096_0_15 0 conv_bpf_c096_0 0) vcvs gain=9.807852804032e-01
SCONVI_c096_0_15 (conv_i_src_c096_0_15 conv_i_c096_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_0_15 (conv_q_src_c096_0_15 0 conv_bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_0_15 (conv_q_src_c096_0_15 conv_q_c096_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c096_0 (conv_i_c096_0 0) resistor r=1G
RCONVQ_c096_0 (conv_q_c096_0 0) resistor r=1G
RCONVINTI_c096_0 (conv_i_c096_0 ConvIcar_c096_0) resistor r=1k
CCONVINTI_c096_0 (ConvIcar_c096_0 0) capacitor c=80p
RCONVINTQ_c096_0 (conv_q_c096_0 ConvQcar_c096_0) resistor r=1k
CCONVINTQ_c096_0 (ConvQcar_c096_0 0) capacitor c=80p
save conv_bpf_c096_0 ConvIcar_c096_0 ConvQcar_c096_0

// conventional mixed baseline bl096, carrier_1: 500000000 Hz
CCONVBPF_c096_1 (bl096 n_conv_cbpf_c096_1) capacitor c=1.013211836423e-13
LCONVBPF_c096_1 (n_conv_cbpf_c096_1 conv_bpf_c096_1) inductor l=1.000000000000e-06
RCONVBPF_c096_1 (conv_bpf_c096_1 0) resistor r=1.570796326795e+02
ECONVI_c096_1_00 (conv_i_src_c096_1_00 0 conv_bpf_c096_1 0) vcvs gain=9.807852804032e-01
SCONVI_c096_1_00 (conv_i_src_c096_1_00 conv_i_c096_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_00 (conv_q_src_c096_1_00 0 conv_bpf_c096_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_1_00 (conv_q_src_c096_1_00 conv_q_c096_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_01 (conv_i_src_c096_1_01 0 conv_bpf_c096_1 0) vcvs gain=8.314696123025e-01
SCONVI_c096_1_01 (conv_i_src_c096_1_01 conv_i_c096_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_01 (conv_q_src_c096_1_01 0 conv_bpf_c096_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_1_01 (conv_q_src_c096_1_01 conv_q_c096_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_02 (conv_i_src_c096_1_02 0 conv_bpf_c096_1 0) vcvs gain=5.555702330196e-01
SCONVI_c096_1_02 (conv_i_src_c096_1_02 conv_i_c096_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_02 (conv_q_src_c096_1_02 0 conv_bpf_c096_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_1_02 (conv_q_src_c096_1_02 conv_q_c096_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_03 (conv_i_src_c096_1_03 0 conv_bpf_c096_1 0) vcvs gain=1.950903220161e-01
SCONVI_c096_1_03 (conv_i_src_c096_1_03 conv_i_c096_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_03 (conv_q_src_c096_1_03 0 conv_bpf_c096_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_1_03 (conv_q_src_c096_1_03 conv_q_c096_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_04 (conv_i_src_c096_1_04 0 conv_bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_1_04 (conv_i_src_c096_1_04 conv_i_c096_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_04 (conv_q_src_c096_1_04 0 conv_bpf_c096_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_1_04 (conv_q_src_c096_1_04 conv_q_c096_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_05 (conv_i_src_c096_1_05 0 conv_bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_1_05 (conv_i_src_c096_1_05 conv_i_c096_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_05 (conv_q_src_c096_1_05 0 conv_bpf_c096_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_1_05 (conv_q_src_c096_1_05 conv_q_c096_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_06 (conv_i_src_c096_1_06 0 conv_bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_1_06 (conv_i_src_c096_1_06 conv_i_c096_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_06 (conv_q_src_c096_1_06 0 conv_bpf_c096_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_1_06 (conv_q_src_c096_1_06 conv_q_c096_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_07 (conv_i_src_c096_1_07 0 conv_bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_1_07 (conv_i_src_c096_1_07 conv_i_c096_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_07 (conv_q_src_c096_1_07 0 conv_bpf_c096_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_1_07 (conv_q_src_c096_1_07 conv_q_c096_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_08 (conv_i_src_c096_1_08 0 conv_bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_1_08 (conv_i_src_c096_1_08 conv_i_c096_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_08 (conv_q_src_c096_1_08 0 conv_bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_1_08 (conv_q_src_c096_1_08 conv_q_c096_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_09 (conv_i_src_c096_1_09 0 conv_bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_1_09 (conv_i_src_c096_1_09 conv_i_c096_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_09 (conv_q_src_c096_1_09 0 conv_bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_1_09 (conv_q_src_c096_1_09 conv_q_c096_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_10 (conv_i_src_c096_1_10 0 conv_bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_1_10 (conv_i_src_c096_1_10 conv_i_c096_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_10 (conv_q_src_c096_1_10 0 conv_bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_1_10 (conv_q_src_c096_1_10 conv_q_c096_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_11 (conv_i_src_c096_1_11 0 conv_bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_1_11 (conv_i_src_c096_1_11 conv_i_c096_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_11 (conv_q_src_c096_1_11 0 conv_bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_1_11 (conv_q_src_c096_1_11 conv_q_c096_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_12 (conv_i_src_c096_1_12 0 conv_bpf_c096_1 0) vcvs gain=1.950903220161e-01
SCONVI_c096_1_12 (conv_i_src_c096_1_12 conv_i_c096_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_12 (conv_q_src_c096_1_12 0 conv_bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_1_12 (conv_q_src_c096_1_12 conv_q_c096_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_13 (conv_i_src_c096_1_13 0 conv_bpf_c096_1 0) vcvs gain=5.555702330196e-01
SCONVI_c096_1_13 (conv_i_src_c096_1_13 conv_i_c096_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_13 (conv_q_src_c096_1_13 0 conv_bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_1_13 (conv_q_src_c096_1_13 conv_q_c096_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_14 (conv_i_src_c096_1_14 0 conv_bpf_c096_1 0) vcvs gain=8.314696123025e-01
SCONVI_c096_1_14 (conv_i_src_c096_1_14 conv_i_c096_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_14 (conv_q_src_c096_1_14 0 conv_bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_1_14 (conv_q_src_c096_1_14 conv_q_c096_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_1_15 (conv_i_src_c096_1_15 0 conv_bpf_c096_1 0) vcvs gain=9.807852804032e-01
SCONVI_c096_1_15 (conv_i_src_c096_1_15 conv_i_c096_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_1_15 (conv_q_src_c096_1_15 0 conv_bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_1_15 (conv_q_src_c096_1_15 conv_q_c096_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c096_1 (conv_i_c096_1 0) resistor r=1G
RCONVQ_c096_1 (conv_q_c096_1 0) resistor r=1G
RCONVINTI_c096_1 (conv_i_c096_1 ConvIcar_c096_1) resistor r=1k
CCONVINTI_c096_1 (ConvIcar_c096_1 0) capacitor c=80p
RCONVINTQ_c096_1 (conv_q_c096_1 ConvQcar_c096_1) resistor r=1k
CCONVINTQ_c096_1 (ConvQcar_c096_1 0) capacitor c=80p
save conv_bpf_c096_1 ConvIcar_c096_1 ConvQcar_c096_1

// conventional mixed baseline bl096, carrier_2: 750000000 Hz
CCONVBPF_c096_2 (bl096 n_conv_cbpf_c096_2) capacitor c=4.503163717437e-14
LCONVBPF_c096_2 (n_conv_cbpf_c096_2 conv_bpf_c096_2) inductor l=1.000000000000e-06
RCONVBPF_c096_2 (conv_bpf_c096_2 0) resistor r=2.356194490192e+02
ECONVI_c096_2_00 (conv_i_src_c096_2_00 0 conv_bpf_c096_2 0) vcvs gain=9.807852804032e-01
SCONVI_c096_2_00 (conv_i_src_c096_2_00 conv_i_c096_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_00 (conv_q_src_c096_2_00 0 conv_bpf_c096_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_2_00 (conv_q_src_c096_2_00 conv_q_c096_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_01 (conv_i_src_c096_2_01 0 conv_bpf_c096_2 0) vcvs gain=8.314696123025e-01
SCONVI_c096_2_01 (conv_i_src_c096_2_01 conv_i_c096_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_01 (conv_q_src_c096_2_01 0 conv_bpf_c096_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_2_01 (conv_q_src_c096_2_01 conv_q_c096_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_02 (conv_i_src_c096_2_02 0 conv_bpf_c096_2 0) vcvs gain=5.555702330196e-01
SCONVI_c096_2_02 (conv_i_src_c096_2_02 conv_i_c096_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_02 (conv_q_src_c096_2_02 0 conv_bpf_c096_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_2_02 (conv_q_src_c096_2_02 conv_q_c096_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_03 (conv_i_src_c096_2_03 0 conv_bpf_c096_2 0) vcvs gain=1.950903220161e-01
SCONVI_c096_2_03 (conv_i_src_c096_2_03 conv_i_c096_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_03 (conv_q_src_c096_2_03 0 conv_bpf_c096_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_2_03 (conv_q_src_c096_2_03 conv_q_c096_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_04 (conv_i_src_c096_2_04 0 conv_bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_2_04 (conv_i_src_c096_2_04 conv_i_c096_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_04 (conv_q_src_c096_2_04 0 conv_bpf_c096_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_2_04 (conv_q_src_c096_2_04 conv_q_c096_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_05 (conv_i_src_c096_2_05 0 conv_bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_2_05 (conv_i_src_c096_2_05 conv_i_c096_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_05 (conv_q_src_c096_2_05 0 conv_bpf_c096_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_2_05 (conv_q_src_c096_2_05 conv_q_c096_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_06 (conv_i_src_c096_2_06 0 conv_bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_2_06 (conv_i_src_c096_2_06 conv_i_c096_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_06 (conv_q_src_c096_2_06 0 conv_bpf_c096_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_2_06 (conv_q_src_c096_2_06 conv_q_c096_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_07 (conv_i_src_c096_2_07 0 conv_bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_2_07 (conv_i_src_c096_2_07 conv_i_c096_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_07 (conv_q_src_c096_2_07 0 conv_bpf_c096_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_2_07 (conv_q_src_c096_2_07 conv_q_c096_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_08 (conv_i_src_c096_2_08 0 conv_bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_2_08 (conv_i_src_c096_2_08 conv_i_c096_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_08 (conv_q_src_c096_2_08 0 conv_bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_2_08 (conv_q_src_c096_2_08 conv_q_c096_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_09 (conv_i_src_c096_2_09 0 conv_bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_2_09 (conv_i_src_c096_2_09 conv_i_c096_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_09 (conv_q_src_c096_2_09 0 conv_bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_2_09 (conv_q_src_c096_2_09 conv_q_c096_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_10 (conv_i_src_c096_2_10 0 conv_bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_2_10 (conv_i_src_c096_2_10 conv_i_c096_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_10 (conv_q_src_c096_2_10 0 conv_bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_2_10 (conv_q_src_c096_2_10 conv_q_c096_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_11 (conv_i_src_c096_2_11 0 conv_bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_2_11 (conv_i_src_c096_2_11 conv_i_c096_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_11 (conv_q_src_c096_2_11 0 conv_bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_2_11 (conv_q_src_c096_2_11 conv_q_c096_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_12 (conv_i_src_c096_2_12 0 conv_bpf_c096_2 0) vcvs gain=1.950903220161e-01
SCONVI_c096_2_12 (conv_i_src_c096_2_12 conv_i_c096_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_12 (conv_q_src_c096_2_12 0 conv_bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_2_12 (conv_q_src_c096_2_12 conv_q_c096_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_13 (conv_i_src_c096_2_13 0 conv_bpf_c096_2 0) vcvs gain=5.555702330196e-01
SCONVI_c096_2_13 (conv_i_src_c096_2_13 conv_i_c096_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_13 (conv_q_src_c096_2_13 0 conv_bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_2_13 (conv_q_src_c096_2_13 conv_q_c096_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_14 (conv_i_src_c096_2_14 0 conv_bpf_c096_2 0) vcvs gain=8.314696123025e-01
SCONVI_c096_2_14 (conv_i_src_c096_2_14 conv_i_c096_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_14 (conv_q_src_c096_2_14 0 conv_bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_2_14 (conv_q_src_c096_2_14 conv_q_c096_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_2_15 (conv_i_src_c096_2_15 0 conv_bpf_c096_2 0) vcvs gain=9.807852804032e-01
SCONVI_c096_2_15 (conv_i_src_c096_2_15 conv_i_c096_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_2_15 (conv_q_src_c096_2_15 0 conv_bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_2_15 (conv_q_src_c096_2_15 conv_q_c096_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c096_2 (conv_i_c096_2 0) resistor r=1G
RCONVQ_c096_2 (conv_q_c096_2 0) resistor r=1G
RCONVINTI_c096_2 (conv_i_c096_2 ConvIcar_c096_2) resistor r=1k
CCONVINTI_c096_2 (ConvIcar_c096_2 0) capacitor c=80p
RCONVINTQ_c096_2 (conv_q_c096_2 ConvQcar_c096_2) resistor r=1k
CCONVINTQ_c096_2 (ConvQcar_c096_2 0) capacitor c=80p
save conv_bpf_c096_2 ConvIcar_c096_2 ConvQcar_c096_2

// conventional mixed baseline bl096, carrier_3: 1000000000 Hz
CCONVBPF_c096_3 (bl096 n_conv_cbpf_c096_3) capacitor c=2.533029591058e-14
LCONVBPF_c096_3 (n_conv_cbpf_c096_3 conv_bpf_c096_3) inductor l=1.000000000000e-06
RCONVBPF_c096_3 (conv_bpf_c096_3 0) resistor r=3.141592653590e+02
ECONVI_c096_3_00 (conv_i_src_c096_3_00 0 conv_bpf_c096_3 0) vcvs gain=9.807852804032e-01
SCONVI_c096_3_00 (conv_i_src_c096_3_00 conv_i_c096_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_00 (conv_q_src_c096_3_00 0 conv_bpf_c096_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_3_00 (conv_q_src_c096_3_00 conv_q_c096_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_01 (conv_i_src_c096_3_01 0 conv_bpf_c096_3 0) vcvs gain=8.314696123025e-01
SCONVI_c096_3_01 (conv_i_src_c096_3_01 conv_i_c096_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_01 (conv_q_src_c096_3_01 0 conv_bpf_c096_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_3_01 (conv_q_src_c096_3_01 conv_q_c096_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_02 (conv_i_src_c096_3_02 0 conv_bpf_c096_3 0) vcvs gain=5.555702330196e-01
SCONVI_c096_3_02 (conv_i_src_c096_3_02 conv_i_c096_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_02 (conv_q_src_c096_3_02 0 conv_bpf_c096_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_3_02 (conv_q_src_c096_3_02 conv_q_c096_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_03 (conv_i_src_c096_3_03 0 conv_bpf_c096_3 0) vcvs gain=1.950903220161e-01
SCONVI_c096_3_03 (conv_i_src_c096_3_03 conv_i_c096_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_03 (conv_q_src_c096_3_03 0 conv_bpf_c096_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_3_03 (conv_q_src_c096_3_03 conv_q_c096_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_04 (conv_i_src_c096_3_04 0 conv_bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_3_04 (conv_i_src_c096_3_04 conv_i_c096_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_04 (conv_q_src_c096_3_04 0 conv_bpf_c096_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c096_3_04 (conv_q_src_c096_3_04 conv_q_c096_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_05 (conv_i_src_c096_3_05 0 conv_bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_3_05 (conv_i_src_c096_3_05 conv_i_c096_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_05 (conv_q_src_c096_3_05 0 conv_bpf_c096_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c096_3_05 (conv_q_src_c096_3_05 conv_q_c096_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_06 (conv_i_src_c096_3_06 0 conv_bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_3_06 (conv_i_src_c096_3_06 conv_i_c096_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_06 (conv_q_src_c096_3_06 0 conv_bpf_c096_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c096_3_06 (conv_q_src_c096_3_06 conv_q_c096_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_07 (conv_i_src_c096_3_07 0 conv_bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_3_07 (conv_i_src_c096_3_07 conv_i_c096_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_07 (conv_q_src_c096_3_07 0 conv_bpf_c096_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c096_3_07 (conv_q_src_c096_3_07 conv_q_c096_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_08 (conv_i_src_c096_3_08 0 conv_bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c096_3_08 (conv_i_src_c096_3_08 conv_i_c096_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_08 (conv_q_src_c096_3_08 0 conv_bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_3_08 (conv_q_src_c096_3_08 conv_q_c096_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_09 (conv_i_src_c096_3_09 0 conv_bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c096_3_09 (conv_i_src_c096_3_09 conv_i_c096_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_09 (conv_q_src_c096_3_09 0 conv_bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_3_09 (conv_q_src_c096_3_09 conv_q_c096_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_10 (conv_i_src_c096_3_10 0 conv_bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c096_3_10 (conv_i_src_c096_3_10 conv_i_c096_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_10 (conv_q_src_c096_3_10 0 conv_bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_3_10 (conv_q_src_c096_3_10 conv_q_c096_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_11 (conv_i_src_c096_3_11 0 conv_bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c096_3_11 (conv_i_src_c096_3_11 conv_i_c096_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_11 (conv_q_src_c096_3_11 0 conv_bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_3_11 (conv_q_src_c096_3_11 conv_q_c096_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_12 (conv_i_src_c096_3_12 0 conv_bpf_c096_3 0) vcvs gain=1.950903220161e-01
SCONVI_c096_3_12 (conv_i_src_c096_3_12 conv_i_c096_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_12 (conv_q_src_c096_3_12 0 conv_bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c096_3_12 (conv_q_src_c096_3_12 conv_q_c096_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_13 (conv_i_src_c096_3_13 0 conv_bpf_c096_3 0) vcvs gain=5.555702330196e-01
SCONVI_c096_3_13 (conv_i_src_c096_3_13 conv_i_c096_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_13 (conv_q_src_c096_3_13 0 conv_bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c096_3_13 (conv_q_src_c096_3_13 conv_q_c096_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_14 (conv_i_src_c096_3_14 0 conv_bpf_c096_3 0) vcvs gain=8.314696123025e-01
SCONVI_c096_3_14 (conv_i_src_c096_3_14 conv_i_c096_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_14 (conv_q_src_c096_3_14 0 conv_bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c096_3_14 (conv_q_src_c096_3_14 conv_q_c096_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c096_3_15 (conv_i_src_c096_3_15 0 conv_bpf_c096_3 0) vcvs gain=9.807852804032e-01
SCONVI_c096_3_15 (conv_i_src_c096_3_15 conv_i_c096_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c096_3_15 (conv_q_src_c096_3_15 0 conv_bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c096_3_15 (conv_q_src_c096_3_15 conv_q_c096_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c096_3 (conv_i_c096_3 0) resistor r=1G
RCONVQ_c096_3 (conv_q_c096_3 0) resistor r=1G
RCONVINTI_c096_3 (conv_i_c096_3 ConvIcar_c096_3) resistor r=1k
CCONVINTI_c096_3 (ConvIcar_c096_3 0) capacitor c=80p
RCONVINTQ_c096_3 (conv_q_c096_3 ConvQcar_c096_3) resistor r=1k
CCONVINTQ_c096_3 (ConvQcar_c096_3 0) capacitor c=80p
save conv_bpf_c096_3 ConvIcar_c096_3 ConvQcar_c096_3

// conventional mixed baseline bl097, carrier_0: 250000000 Hz
CCONVBPF_c097_0 (bl097 n_conv_cbpf_c097_0) capacitor c=4.052847345694e-13
LCONVBPF_c097_0 (n_conv_cbpf_c097_0 conv_bpf_c097_0) inductor l=1.000000000000e-06
RCONVBPF_c097_0 (conv_bpf_c097_0 0) resistor r=7.853981633974e+01
ECONVI_c097_0_00 (conv_i_src_c097_0_00 0 conv_bpf_c097_0 0) vcvs gain=9.807852804032e-01
SCONVI_c097_0_00 (conv_i_src_c097_0_00 conv_i_c097_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_00 (conv_q_src_c097_0_00 0 conv_bpf_c097_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_0_00 (conv_q_src_c097_0_00 conv_q_c097_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_01 (conv_i_src_c097_0_01 0 conv_bpf_c097_0 0) vcvs gain=8.314696123025e-01
SCONVI_c097_0_01 (conv_i_src_c097_0_01 conv_i_c097_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_01 (conv_q_src_c097_0_01 0 conv_bpf_c097_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_0_01 (conv_q_src_c097_0_01 conv_q_c097_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_02 (conv_i_src_c097_0_02 0 conv_bpf_c097_0 0) vcvs gain=5.555702330196e-01
SCONVI_c097_0_02 (conv_i_src_c097_0_02 conv_i_c097_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_02 (conv_q_src_c097_0_02 0 conv_bpf_c097_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_0_02 (conv_q_src_c097_0_02 conv_q_c097_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_03 (conv_i_src_c097_0_03 0 conv_bpf_c097_0 0) vcvs gain=1.950903220161e-01
SCONVI_c097_0_03 (conv_i_src_c097_0_03 conv_i_c097_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_03 (conv_q_src_c097_0_03 0 conv_bpf_c097_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_0_03 (conv_q_src_c097_0_03 conv_q_c097_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_04 (conv_i_src_c097_0_04 0 conv_bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_0_04 (conv_i_src_c097_0_04 conv_i_c097_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_04 (conv_q_src_c097_0_04 0 conv_bpf_c097_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_0_04 (conv_q_src_c097_0_04 conv_q_c097_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_05 (conv_i_src_c097_0_05 0 conv_bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_0_05 (conv_i_src_c097_0_05 conv_i_c097_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_05 (conv_q_src_c097_0_05 0 conv_bpf_c097_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_0_05 (conv_q_src_c097_0_05 conv_q_c097_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_06 (conv_i_src_c097_0_06 0 conv_bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_0_06 (conv_i_src_c097_0_06 conv_i_c097_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_06 (conv_q_src_c097_0_06 0 conv_bpf_c097_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_0_06 (conv_q_src_c097_0_06 conv_q_c097_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_07 (conv_i_src_c097_0_07 0 conv_bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_0_07 (conv_i_src_c097_0_07 conv_i_c097_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_07 (conv_q_src_c097_0_07 0 conv_bpf_c097_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_0_07 (conv_q_src_c097_0_07 conv_q_c097_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_08 (conv_i_src_c097_0_08 0 conv_bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_0_08 (conv_i_src_c097_0_08 conv_i_c097_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_08 (conv_q_src_c097_0_08 0 conv_bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_0_08 (conv_q_src_c097_0_08 conv_q_c097_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_09 (conv_i_src_c097_0_09 0 conv_bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_0_09 (conv_i_src_c097_0_09 conv_i_c097_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_09 (conv_q_src_c097_0_09 0 conv_bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_0_09 (conv_q_src_c097_0_09 conv_q_c097_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_10 (conv_i_src_c097_0_10 0 conv_bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_0_10 (conv_i_src_c097_0_10 conv_i_c097_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_10 (conv_q_src_c097_0_10 0 conv_bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_0_10 (conv_q_src_c097_0_10 conv_q_c097_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_11 (conv_i_src_c097_0_11 0 conv_bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_0_11 (conv_i_src_c097_0_11 conv_i_c097_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_11 (conv_q_src_c097_0_11 0 conv_bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_0_11 (conv_q_src_c097_0_11 conv_q_c097_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_12 (conv_i_src_c097_0_12 0 conv_bpf_c097_0 0) vcvs gain=1.950903220161e-01
SCONVI_c097_0_12 (conv_i_src_c097_0_12 conv_i_c097_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_12 (conv_q_src_c097_0_12 0 conv_bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_0_12 (conv_q_src_c097_0_12 conv_q_c097_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_13 (conv_i_src_c097_0_13 0 conv_bpf_c097_0 0) vcvs gain=5.555702330196e-01
SCONVI_c097_0_13 (conv_i_src_c097_0_13 conv_i_c097_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_13 (conv_q_src_c097_0_13 0 conv_bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_0_13 (conv_q_src_c097_0_13 conv_q_c097_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_14 (conv_i_src_c097_0_14 0 conv_bpf_c097_0 0) vcvs gain=8.314696123025e-01
SCONVI_c097_0_14 (conv_i_src_c097_0_14 conv_i_c097_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_14 (conv_q_src_c097_0_14 0 conv_bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_0_14 (conv_q_src_c097_0_14 conv_q_c097_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_0_15 (conv_i_src_c097_0_15 0 conv_bpf_c097_0 0) vcvs gain=9.807852804032e-01
SCONVI_c097_0_15 (conv_i_src_c097_0_15 conv_i_c097_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_0_15 (conv_q_src_c097_0_15 0 conv_bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_0_15 (conv_q_src_c097_0_15 conv_q_c097_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c097_0 (conv_i_c097_0 0) resistor r=1G
RCONVQ_c097_0 (conv_q_c097_0 0) resistor r=1G
RCONVINTI_c097_0 (conv_i_c097_0 ConvIcar_c097_0) resistor r=1k
CCONVINTI_c097_0 (ConvIcar_c097_0 0) capacitor c=80p
RCONVINTQ_c097_0 (conv_q_c097_0 ConvQcar_c097_0) resistor r=1k
CCONVINTQ_c097_0 (ConvQcar_c097_0 0) capacitor c=80p
save conv_bpf_c097_0 ConvIcar_c097_0 ConvQcar_c097_0

// conventional mixed baseline bl097, carrier_1: 500000000 Hz
CCONVBPF_c097_1 (bl097 n_conv_cbpf_c097_1) capacitor c=1.013211836423e-13
LCONVBPF_c097_1 (n_conv_cbpf_c097_1 conv_bpf_c097_1) inductor l=1.000000000000e-06
RCONVBPF_c097_1 (conv_bpf_c097_1 0) resistor r=1.570796326795e+02
ECONVI_c097_1_00 (conv_i_src_c097_1_00 0 conv_bpf_c097_1 0) vcvs gain=9.807852804032e-01
SCONVI_c097_1_00 (conv_i_src_c097_1_00 conv_i_c097_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_00 (conv_q_src_c097_1_00 0 conv_bpf_c097_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_1_00 (conv_q_src_c097_1_00 conv_q_c097_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_01 (conv_i_src_c097_1_01 0 conv_bpf_c097_1 0) vcvs gain=8.314696123025e-01
SCONVI_c097_1_01 (conv_i_src_c097_1_01 conv_i_c097_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_01 (conv_q_src_c097_1_01 0 conv_bpf_c097_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_1_01 (conv_q_src_c097_1_01 conv_q_c097_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_02 (conv_i_src_c097_1_02 0 conv_bpf_c097_1 0) vcvs gain=5.555702330196e-01
SCONVI_c097_1_02 (conv_i_src_c097_1_02 conv_i_c097_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_02 (conv_q_src_c097_1_02 0 conv_bpf_c097_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_1_02 (conv_q_src_c097_1_02 conv_q_c097_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_03 (conv_i_src_c097_1_03 0 conv_bpf_c097_1 0) vcvs gain=1.950903220161e-01
SCONVI_c097_1_03 (conv_i_src_c097_1_03 conv_i_c097_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_03 (conv_q_src_c097_1_03 0 conv_bpf_c097_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_1_03 (conv_q_src_c097_1_03 conv_q_c097_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_04 (conv_i_src_c097_1_04 0 conv_bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_1_04 (conv_i_src_c097_1_04 conv_i_c097_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_04 (conv_q_src_c097_1_04 0 conv_bpf_c097_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_1_04 (conv_q_src_c097_1_04 conv_q_c097_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_05 (conv_i_src_c097_1_05 0 conv_bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_1_05 (conv_i_src_c097_1_05 conv_i_c097_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_05 (conv_q_src_c097_1_05 0 conv_bpf_c097_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_1_05 (conv_q_src_c097_1_05 conv_q_c097_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_06 (conv_i_src_c097_1_06 0 conv_bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_1_06 (conv_i_src_c097_1_06 conv_i_c097_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_06 (conv_q_src_c097_1_06 0 conv_bpf_c097_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_1_06 (conv_q_src_c097_1_06 conv_q_c097_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_07 (conv_i_src_c097_1_07 0 conv_bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_1_07 (conv_i_src_c097_1_07 conv_i_c097_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_07 (conv_q_src_c097_1_07 0 conv_bpf_c097_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_1_07 (conv_q_src_c097_1_07 conv_q_c097_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_08 (conv_i_src_c097_1_08 0 conv_bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_1_08 (conv_i_src_c097_1_08 conv_i_c097_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_08 (conv_q_src_c097_1_08 0 conv_bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_1_08 (conv_q_src_c097_1_08 conv_q_c097_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_09 (conv_i_src_c097_1_09 0 conv_bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_1_09 (conv_i_src_c097_1_09 conv_i_c097_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_09 (conv_q_src_c097_1_09 0 conv_bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_1_09 (conv_q_src_c097_1_09 conv_q_c097_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_10 (conv_i_src_c097_1_10 0 conv_bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_1_10 (conv_i_src_c097_1_10 conv_i_c097_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_10 (conv_q_src_c097_1_10 0 conv_bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_1_10 (conv_q_src_c097_1_10 conv_q_c097_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_11 (conv_i_src_c097_1_11 0 conv_bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_1_11 (conv_i_src_c097_1_11 conv_i_c097_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_11 (conv_q_src_c097_1_11 0 conv_bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_1_11 (conv_q_src_c097_1_11 conv_q_c097_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_12 (conv_i_src_c097_1_12 0 conv_bpf_c097_1 0) vcvs gain=1.950903220161e-01
SCONVI_c097_1_12 (conv_i_src_c097_1_12 conv_i_c097_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_12 (conv_q_src_c097_1_12 0 conv_bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_1_12 (conv_q_src_c097_1_12 conv_q_c097_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_13 (conv_i_src_c097_1_13 0 conv_bpf_c097_1 0) vcvs gain=5.555702330196e-01
SCONVI_c097_1_13 (conv_i_src_c097_1_13 conv_i_c097_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_13 (conv_q_src_c097_1_13 0 conv_bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_1_13 (conv_q_src_c097_1_13 conv_q_c097_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_14 (conv_i_src_c097_1_14 0 conv_bpf_c097_1 0) vcvs gain=8.314696123025e-01
SCONVI_c097_1_14 (conv_i_src_c097_1_14 conv_i_c097_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_14 (conv_q_src_c097_1_14 0 conv_bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_1_14 (conv_q_src_c097_1_14 conv_q_c097_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_1_15 (conv_i_src_c097_1_15 0 conv_bpf_c097_1 0) vcvs gain=9.807852804032e-01
SCONVI_c097_1_15 (conv_i_src_c097_1_15 conv_i_c097_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_1_15 (conv_q_src_c097_1_15 0 conv_bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_1_15 (conv_q_src_c097_1_15 conv_q_c097_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c097_1 (conv_i_c097_1 0) resistor r=1G
RCONVQ_c097_1 (conv_q_c097_1 0) resistor r=1G
RCONVINTI_c097_1 (conv_i_c097_1 ConvIcar_c097_1) resistor r=1k
CCONVINTI_c097_1 (ConvIcar_c097_1 0) capacitor c=80p
RCONVINTQ_c097_1 (conv_q_c097_1 ConvQcar_c097_1) resistor r=1k
CCONVINTQ_c097_1 (ConvQcar_c097_1 0) capacitor c=80p
save conv_bpf_c097_1 ConvIcar_c097_1 ConvQcar_c097_1

// conventional mixed baseline bl097, carrier_2: 750000000 Hz
CCONVBPF_c097_2 (bl097 n_conv_cbpf_c097_2) capacitor c=4.503163717437e-14
LCONVBPF_c097_2 (n_conv_cbpf_c097_2 conv_bpf_c097_2) inductor l=1.000000000000e-06
RCONVBPF_c097_2 (conv_bpf_c097_2 0) resistor r=2.356194490192e+02
ECONVI_c097_2_00 (conv_i_src_c097_2_00 0 conv_bpf_c097_2 0) vcvs gain=9.807852804032e-01
SCONVI_c097_2_00 (conv_i_src_c097_2_00 conv_i_c097_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_00 (conv_q_src_c097_2_00 0 conv_bpf_c097_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_2_00 (conv_q_src_c097_2_00 conv_q_c097_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_01 (conv_i_src_c097_2_01 0 conv_bpf_c097_2 0) vcvs gain=8.314696123025e-01
SCONVI_c097_2_01 (conv_i_src_c097_2_01 conv_i_c097_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_01 (conv_q_src_c097_2_01 0 conv_bpf_c097_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_2_01 (conv_q_src_c097_2_01 conv_q_c097_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_02 (conv_i_src_c097_2_02 0 conv_bpf_c097_2 0) vcvs gain=5.555702330196e-01
SCONVI_c097_2_02 (conv_i_src_c097_2_02 conv_i_c097_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_02 (conv_q_src_c097_2_02 0 conv_bpf_c097_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_2_02 (conv_q_src_c097_2_02 conv_q_c097_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_03 (conv_i_src_c097_2_03 0 conv_bpf_c097_2 0) vcvs gain=1.950903220161e-01
SCONVI_c097_2_03 (conv_i_src_c097_2_03 conv_i_c097_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_03 (conv_q_src_c097_2_03 0 conv_bpf_c097_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_2_03 (conv_q_src_c097_2_03 conv_q_c097_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_04 (conv_i_src_c097_2_04 0 conv_bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_2_04 (conv_i_src_c097_2_04 conv_i_c097_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_04 (conv_q_src_c097_2_04 0 conv_bpf_c097_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_2_04 (conv_q_src_c097_2_04 conv_q_c097_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_05 (conv_i_src_c097_2_05 0 conv_bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_2_05 (conv_i_src_c097_2_05 conv_i_c097_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_05 (conv_q_src_c097_2_05 0 conv_bpf_c097_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_2_05 (conv_q_src_c097_2_05 conv_q_c097_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_06 (conv_i_src_c097_2_06 0 conv_bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_2_06 (conv_i_src_c097_2_06 conv_i_c097_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_06 (conv_q_src_c097_2_06 0 conv_bpf_c097_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_2_06 (conv_q_src_c097_2_06 conv_q_c097_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_07 (conv_i_src_c097_2_07 0 conv_bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_2_07 (conv_i_src_c097_2_07 conv_i_c097_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_07 (conv_q_src_c097_2_07 0 conv_bpf_c097_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_2_07 (conv_q_src_c097_2_07 conv_q_c097_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_08 (conv_i_src_c097_2_08 0 conv_bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_2_08 (conv_i_src_c097_2_08 conv_i_c097_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_08 (conv_q_src_c097_2_08 0 conv_bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_2_08 (conv_q_src_c097_2_08 conv_q_c097_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_09 (conv_i_src_c097_2_09 0 conv_bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_2_09 (conv_i_src_c097_2_09 conv_i_c097_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_09 (conv_q_src_c097_2_09 0 conv_bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_2_09 (conv_q_src_c097_2_09 conv_q_c097_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_10 (conv_i_src_c097_2_10 0 conv_bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_2_10 (conv_i_src_c097_2_10 conv_i_c097_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_10 (conv_q_src_c097_2_10 0 conv_bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_2_10 (conv_q_src_c097_2_10 conv_q_c097_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_11 (conv_i_src_c097_2_11 0 conv_bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_2_11 (conv_i_src_c097_2_11 conv_i_c097_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_11 (conv_q_src_c097_2_11 0 conv_bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_2_11 (conv_q_src_c097_2_11 conv_q_c097_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_12 (conv_i_src_c097_2_12 0 conv_bpf_c097_2 0) vcvs gain=1.950903220161e-01
SCONVI_c097_2_12 (conv_i_src_c097_2_12 conv_i_c097_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_12 (conv_q_src_c097_2_12 0 conv_bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_2_12 (conv_q_src_c097_2_12 conv_q_c097_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_13 (conv_i_src_c097_2_13 0 conv_bpf_c097_2 0) vcvs gain=5.555702330196e-01
SCONVI_c097_2_13 (conv_i_src_c097_2_13 conv_i_c097_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_13 (conv_q_src_c097_2_13 0 conv_bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_2_13 (conv_q_src_c097_2_13 conv_q_c097_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_14 (conv_i_src_c097_2_14 0 conv_bpf_c097_2 0) vcvs gain=8.314696123025e-01
SCONVI_c097_2_14 (conv_i_src_c097_2_14 conv_i_c097_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_14 (conv_q_src_c097_2_14 0 conv_bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_2_14 (conv_q_src_c097_2_14 conv_q_c097_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_2_15 (conv_i_src_c097_2_15 0 conv_bpf_c097_2 0) vcvs gain=9.807852804032e-01
SCONVI_c097_2_15 (conv_i_src_c097_2_15 conv_i_c097_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_2_15 (conv_q_src_c097_2_15 0 conv_bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_2_15 (conv_q_src_c097_2_15 conv_q_c097_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c097_2 (conv_i_c097_2 0) resistor r=1G
RCONVQ_c097_2 (conv_q_c097_2 0) resistor r=1G
RCONVINTI_c097_2 (conv_i_c097_2 ConvIcar_c097_2) resistor r=1k
CCONVINTI_c097_2 (ConvIcar_c097_2 0) capacitor c=80p
RCONVINTQ_c097_2 (conv_q_c097_2 ConvQcar_c097_2) resistor r=1k
CCONVINTQ_c097_2 (ConvQcar_c097_2 0) capacitor c=80p
save conv_bpf_c097_2 ConvIcar_c097_2 ConvQcar_c097_2

// conventional mixed baseline bl097, carrier_3: 1000000000 Hz
CCONVBPF_c097_3 (bl097 n_conv_cbpf_c097_3) capacitor c=2.533029591058e-14
LCONVBPF_c097_3 (n_conv_cbpf_c097_3 conv_bpf_c097_3) inductor l=1.000000000000e-06
RCONVBPF_c097_3 (conv_bpf_c097_3 0) resistor r=3.141592653590e+02
ECONVI_c097_3_00 (conv_i_src_c097_3_00 0 conv_bpf_c097_3 0) vcvs gain=9.807852804032e-01
SCONVI_c097_3_00 (conv_i_src_c097_3_00 conv_i_c097_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_00 (conv_q_src_c097_3_00 0 conv_bpf_c097_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_3_00 (conv_q_src_c097_3_00 conv_q_c097_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_01 (conv_i_src_c097_3_01 0 conv_bpf_c097_3 0) vcvs gain=8.314696123025e-01
SCONVI_c097_3_01 (conv_i_src_c097_3_01 conv_i_c097_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_01 (conv_q_src_c097_3_01 0 conv_bpf_c097_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_3_01 (conv_q_src_c097_3_01 conv_q_c097_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_02 (conv_i_src_c097_3_02 0 conv_bpf_c097_3 0) vcvs gain=5.555702330196e-01
SCONVI_c097_3_02 (conv_i_src_c097_3_02 conv_i_c097_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_02 (conv_q_src_c097_3_02 0 conv_bpf_c097_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_3_02 (conv_q_src_c097_3_02 conv_q_c097_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_03 (conv_i_src_c097_3_03 0 conv_bpf_c097_3 0) vcvs gain=1.950903220161e-01
SCONVI_c097_3_03 (conv_i_src_c097_3_03 conv_i_c097_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_03 (conv_q_src_c097_3_03 0 conv_bpf_c097_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_3_03 (conv_q_src_c097_3_03 conv_q_c097_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_04 (conv_i_src_c097_3_04 0 conv_bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_3_04 (conv_i_src_c097_3_04 conv_i_c097_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_04 (conv_q_src_c097_3_04 0 conv_bpf_c097_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c097_3_04 (conv_q_src_c097_3_04 conv_q_c097_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_05 (conv_i_src_c097_3_05 0 conv_bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_3_05 (conv_i_src_c097_3_05 conv_i_c097_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_05 (conv_q_src_c097_3_05 0 conv_bpf_c097_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c097_3_05 (conv_q_src_c097_3_05 conv_q_c097_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_06 (conv_i_src_c097_3_06 0 conv_bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_3_06 (conv_i_src_c097_3_06 conv_i_c097_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_06 (conv_q_src_c097_3_06 0 conv_bpf_c097_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c097_3_06 (conv_q_src_c097_3_06 conv_q_c097_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_07 (conv_i_src_c097_3_07 0 conv_bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_3_07 (conv_i_src_c097_3_07 conv_i_c097_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_07 (conv_q_src_c097_3_07 0 conv_bpf_c097_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c097_3_07 (conv_q_src_c097_3_07 conv_q_c097_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_08 (conv_i_src_c097_3_08 0 conv_bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c097_3_08 (conv_i_src_c097_3_08 conv_i_c097_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_08 (conv_q_src_c097_3_08 0 conv_bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_3_08 (conv_q_src_c097_3_08 conv_q_c097_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_09 (conv_i_src_c097_3_09 0 conv_bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c097_3_09 (conv_i_src_c097_3_09 conv_i_c097_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_09 (conv_q_src_c097_3_09 0 conv_bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_3_09 (conv_q_src_c097_3_09 conv_q_c097_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_10 (conv_i_src_c097_3_10 0 conv_bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c097_3_10 (conv_i_src_c097_3_10 conv_i_c097_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_10 (conv_q_src_c097_3_10 0 conv_bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_3_10 (conv_q_src_c097_3_10 conv_q_c097_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_11 (conv_i_src_c097_3_11 0 conv_bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c097_3_11 (conv_i_src_c097_3_11 conv_i_c097_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_11 (conv_q_src_c097_3_11 0 conv_bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_3_11 (conv_q_src_c097_3_11 conv_q_c097_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_12 (conv_i_src_c097_3_12 0 conv_bpf_c097_3 0) vcvs gain=1.950903220161e-01
SCONVI_c097_3_12 (conv_i_src_c097_3_12 conv_i_c097_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_12 (conv_q_src_c097_3_12 0 conv_bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c097_3_12 (conv_q_src_c097_3_12 conv_q_c097_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_13 (conv_i_src_c097_3_13 0 conv_bpf_c097_3 0) vcvs gain=5.555702330196e-01
SCONVI_c097_3_13 (conv_i_src_c097_3_13 conv_i_c097_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_13 (conv_q_src_c097_3_13 0 conv_bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c097_3_13 (conv_q_src_c097_3_13 conv_q_c097_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_14 (conv_i_src_c097_3_14 0 conv_bpf_c097_3 0) vcvs gain=8.314696123025e-01
SCONVI_c097_3_14 (conv_i_src_c097_3_14 conv_i_c097_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_14 (conv_q_src_c097_3_14 0 conv_bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c097_3_14 (conv_q_src_c097_3_14 conv_q_c097_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c097_3_15 (conv_i_src_c097_3_15 0 conv_bpf_c097_3 0) vcvs gain=9.807852804032e-01
SCONVI_c097_3_15 (conv_i_src_c097_3_15 conv_i_c097_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c097_3_15 (conv_q_src_c097_3_15 0 conv_bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c097_3_15 (conv_q_src_c097_3_15 conv_q_c097_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c097_3 (conv_i_c097_3 0) resistor r=1G
RCONVQ_c097_3 (conv_q_c097_3 0) resistor r=1G
RCONVINTI_c097_3 (conv_i_c097_3 ConvIcar_c097_3) resistor r=1k
CCONVINTI_c097_3 (ConvIcar_c097_3 0) capacitor c=80p
RCONVINTQ_c097_3 (conv_q_c097_3 ConvQcar_c097_3) resistor r=1k
CCONVINTQ_c097_3 (ConvQcar_c097_3 0) capacitor c=80p
save conv_bpf_c097_3 ConvIcar_c097_3 ConvQcar_c097_3

// conventional mixed baseline bl098, carrier_0: 250000000 Hz
CCONVBPF_c098_0 (bl098 n_conv_cbpf_c098_0) capacitor c=4.052847345694e-13
LCONVBPF_c098_0 (n_conv_cbpf_c098_0 conv_bpf_c098_0) inductor l=1.000000000000e-06
RCONVBPF_c098_0 (conv_bpf_c098_0 0) resistor r=7.853981633974e+01
ECONVI_c098_0_00 (conv_i_src_c098_0_00 0 conv_bpf_c098_0 0) vcvs gain=9.807852804032e-01
SCONVI_c098_0_00 (conv_i_src_c098_0_00 conv_i_c098_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_00 (conv_q_src_c098_0_00 0 conv_bpf_c098_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_0_00 (conv_q_src_c098_0_00 conv_q_c098_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_01 (conv_i_src_c098_0_01 0 conv_bpf_c098_0 0) vcvs gain=8.314696123025e-01
SCONVI_c098_0_01 (conv_i_src_c098_0_01 conv_i_c098_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_01 (conv_q_src_c098_0_01 0 conv_bpf_c098_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_0_01 (conv_q_src_c098_0_01 conv_q_c098_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_02 (conv_i_src_c098_0_02 0 conv_bpf_c098_0 0) vcvs gain=5.555702330196e-01
SCONVI_c098_0_02 (conv_i_src_c098_0_02 conv_i_c098_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_02 (conv_q_src_c098_0_02 0 conv_bpf_c098_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_0_02 (conv_q_src_c098_0_02 conv_q_c098_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_03 (conv_i_src_c098_0_03 0 conv_bpf_c098_0 0) vcvs gain=1.950903220161e-01
SCONVI_c098_0_03 (conv_i_src_c098_0_03 conv_i_c098_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_03 (conv_q_src_c098_0_03 0 conv_bpf_c098_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_0_03 (conv_q_src_c098_0_03 conv_q_c098_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_04 (conv_i_src_c098_0_04 0 conv_bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_0_04 (conv_i_src_c098_0_04 conv_i_c098_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_04 (conv_q_src_c098_0_04 0 conv_bpf_c098_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_0_04 (conv_q_src_c098_0_04 conv_q_c098_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_05 (conv_i_src_c098_0_05 0 conv_bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_0_05 (conv_i_src_c098_0_05 conv_i_c098_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_05 (conv_q_src_c098_0_05 0 conv_bpf_c098_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_0_05 (conv_q_src_c098_0_05 conv_q_c098_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_06 (conv_i_src_c098_0_06 0 conv_bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_0_06 (conv_i_src_c098_0_06 conv_i_c098_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_06 (conv_q_src_c098_0_06 0 conv_bpf_c098_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_0_06 (conv_q_src_c098_0_06 conv_q_c098_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_07 (conv_i_src_c098_0_07 0 conv_bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_0_07 (conv_i_src_c098_0_07 conv_i_c098_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_07 (conv_q_src_c098_0_07 0 conv_bpf_c098_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_0_07 (conv_q_src_c098_0_07 conv_q_c098_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_08 (conv_i_src_c098_0_08 0 conv_bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_0_08 (conv_i_src_c098_0_08 conv_i_c098_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_08 (conv_q_src_c098_0_08 0 conv_bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_0_08 (conv_q_src_c098_0_08 conv_q_c098_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_09 (conv_i_src_c098_0_09 0 conv_bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_0_09 (conv_i_src_c098_0_09 conv_i_c098_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_09 (conv_q_src_c098_0_09 0 conv_bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_0_09 (conv_q_src_c098_0_09 conv_q_c098_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_10 (conv_i_src_c098_0_10 0 conv_bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_0_10 (conv_i_src_c098_0_10 conv_i_c098_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_10 (conv_q_src_c098_0_10 0 conv_bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_0_10 (conv_q_src_c098_0_10 conv_q_c098_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_11 (conv_i_src_c098_0_11 0 conv_bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_0_11 (conv_i_src_c098_0_11 conv_i_c098_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_11 (conv_q_src_c098_0_11 0 conv_bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_0_11 (conv_q_src_c098_0_11 conv_q_c098_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_12 (conv_i_src_c098_0_12 0 conv_bpf_c098_0 0) vcvs gain=1.950903220161e-01
SCONVI_c098_0_12 (conv_i_src_c098_0_12 conv_i_c098_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_12 (conv_q_src_c098_0_12 0 conv_bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_0_12 (conv_q_src_c098_0_12 conv_q_c098_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_13 (conv_i_src_c098_0_13 0 conv_bpf_c098_0 0) vcvs gain=5.555702330196e-01
SCONVI_c098_0_13 (conv_i_src_c098_0_13 conv_i_c098_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_13 (conv_q_src_c098_0_13 0 conv_bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_0_13 (conv_q_src_c098_0_13 conv_q_c098_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_14 (conv_i_src_c098_0_14 0 conv_bpf_c098_0 0) vcvs gain=8.314696123025e-01
SCONVI_c098_0_14 (conv_i_src_c098_0_14 conv_i_c098_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_14 (conv_q_src_c098_0_14 0 conv_bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_0_14 (conv_q_src_c098_0_14 conv_q_c098_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_0_15 (conv_i_src_c098_0_15 0 conv_bpf_c098_0 0) vcvs gain=9.807852804032e-01
SCONVI_c098_0_15 (conv_i_src_c098_0_15 conv_i_c098_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_0_15 (conv_q_src_c098_0_15 0 conv_bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_0_15 (conv_q_src_c098_0_15 conv_q_c098_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c098_0 (conv_i_c098_0 0) resistor r=1G
RCONVQ_c098_0 (conv_q_c098_0 0) resistor r=1G
RCONVINTI_c098_0 (conv_i_c098_0 ConvIcar_c098_0) resistor r=1k
CCONVINTI_c098_0 (ConvIcar_c098_0 0) capacitor c=80p
RCONVINTQ_c098_0 (conv_q_c098_0 ConvQcar_c098_0) resistor r=1k
CCONVINTQ_c098_0 (ConvQcar_c098_0 0) capacitor c=80p
save conv_bpf_c098_0 ConvIcar_c098_0 ConvQcar_c098_0

// conventional mixed baseline bl098, carrier_1: 500000000 Hz
CCONVBPF_c098_1 (bl098 n_conv_cbpf_c098_1) capacitor c=1.013211836423e-13
LCONVBPF_c098_1 (n_conv_cbpf_c098_1 conv_bpf_c098_1) inductor l=1.000000000000e-06
RCONVBPF_c098_1 (conv_bpf_c098_1 0) resistor r=1.570796326795e+02
ECONVI_c098_1_00 (conv_i_src_c098_1_00 0 conv_bpf_c098_1 0) vcvs gain=9.807852804032e-01
SCONVI_c098_1_00 (conv_i_src_c098_1_00 conv_i_c098_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_00 (conv_q_src_c098_1_00 0 conv_bpf_c098_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_1_00 (conv_q_src_c098_1_00 conv_q_c098_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_01 (conv_i_src_c098_1_01 0 conv_bpf_c098_1 0) vcvs gain=8.314696123025e-01
SCONVI_c098_1_01 (conv_i_src_c098_1_01 conv_i_c098_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_01 (conv_q_src_c098_1_01 0 conv_bpf_c098_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_1_01 (conv_q_src_c098_1_01 conv_q_c098_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_02 (conv_i_src_c098_1_02 0 conv_bpf_c098_1 0) vcvs gain=5.555702330196e-01
SCONVI_c098_1_02 (conv_i_src_c098_1_02 conv_i_c098_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_02 (conv_q_src_c098_1_02 0 conv_bpf_c098_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_1_02 (conv_q_src_c098_1_02 conv_q_c098_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_03 (conv_i_src_c098_1_03 0 conv_bpf_c098_1 0) vcvs gain=1.950903220161e-01
SCONVI_c098_1_03 (conv_i_src_c098_1_03 conv_i_c098_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_03 (conv_q_src_c098_1_03 0 conv_bpf_c098_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_1_03 (conv_q_src_c098_1_03 conv_q_c098_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_04 (conv_i_src_c098_1_04 0 conv_bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_1_04 (conv_i_src_c098_1_04 conv_i_c098_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_04 (conv_q_src_c098_1_04 0 conv_bpf_c098_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_1_04 (conv_q_src_c098_1_04 conv_q_c098_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_05 (conv_i_src_c098_1_05 0 conv_bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_1_05 (conv_i_src_c098_1_05 conv_i_c098_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_05 (conv_q_src_c098_1_05 0 conv_bpf_c098_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_1_05 (conv_q_src_c098_1_05 conv_q_c098_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_06 (conv_i_src_c098_1_06 0 conv_bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_1_06 (conv_i_src_c098_1_06 conv_i_c098_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_06 (conv_q_src_c098_1_06 0 conv_bpf_c098_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_1_06 (conv_q_src_c098_1_06 conv_q_c098_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_07 (conv_i_src_c098_1_07 0 conv_bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_1_07 (conv_i_src_c098_1_07 conv_i_c098_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_07 (conv_q_src_c098_1_07 0 conv_bpf_c098_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_1_07 (conv_q_src_c098_1_07 conv_q_c098_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_08 (conv_i_src_c098_1_08 0 conv_bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_1_08 (conv_i_src_c098_1_08 conv_i_c098_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_08 (conv_q_src_c098_1_08 0 conv_bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_1_08 (conv_q_src_c098_1_08 conv_q_c098_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_09 (conv_i_src_c098_1_09 0 conv_bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_1_09 (conv_i_src_c098_1_09 conv_i_c098_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_09 (conv_q_src_c098_1_09 0 conv_bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_1_09 (conv_q_src_c098_1_09 conv_q_c098_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_10 (conv_i_src_c098_1_10 0 conv_bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_1_10 (conv_i_src_c098_1_10 conv_i_c098_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_10 (conv_q_src_c098_1_10 0 conv_bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_1_10 (conv_q_src_c098_1_10 conv_q_c098_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_11 (conv_i_src_c098_1_11 0 conv_bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_1_11 (conv_i_src_c098_1_11 conv_i_c098_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_11 (conv_q_src_c098_1_11 0 conv_bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_1_11 (conv_q_src_c098_1_11 conv_q_c098_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_12 (conv_i_src_c098_1_12 0 conv_bpf_c098_1 0) vcvs gain=1.950903220161e-01
SCONVI_c098_1_12 (conv_i_src_c098_1_12 conv_i_c098_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_12 (conv_q_src_c098_1_12 0 conv_bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_1_12 (conv_q_src_c098_1_12 conv_q_c098_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_13 (conv_i_src_c098_1_13 0 conv_bpf_c098_1 0) vcvs gain=5.555702330196e-01
SCONVI_c098_1_13 (conv_i_src_c098_1_13 conv_i_c098_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_13 (conv_q_src_c098_1_13 0 conv_bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_1_13 (conv_q_src_c098_1_13 conv_q_c098_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_14 (conv_i_src_c098_1_14 0 conv_bpf_c098_1 0) vcvs gain=8.314696123025e-01
SCONVI_c098_1_14 (conv_i_src_c098_1_14 conv_i_c098_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_14 (conv_q_src_c098_1_14 0 conv_bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_1_14 (conv_q_src_c098_1_14 conv_q_c098_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_1_15 (conv_i_src_c098_1_15 0 conv_bpf_c098_1 0) vcvs gain=9.807852804032e-01
SCONVI_c098_1_15 (conv_i_src_c098_1_15 conv_i_c098_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_1_15 (conv_q_src_c098_1_15 0 conv_bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_1_15 (conv_q_src_c098_1_15 conv_q_c098_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c098_1 (conv_i_c098_1 0) resistor r=1G
RCONVQ_c098_1 (conv_q_c098_1 0) resistor r=1G
RCONVINTI_c098_1 (conv_i_c098_1 ConvIcar_c098_1) resistor r=1k
CCONVINTI_c098_1 (ConvIcar_c098_1 0) capacitor c=80p
RCONVINTQ_c098_1 (conv_q_c098_1 ConvQcar_c098_1) resistor r=1k
CCONVINTQ_c098_1 (ConvQcar_c098_1 0) capacitor c=80p
save conv_bpf_c098_1 ConvIcar_c098_1 ConvQcar_c098_1

// conventional mixed baseline bl098, carrier_2: 750000000 Hz
CCONVBPF_c098_2 (bl098 n_conv_cbpf_c098_2) capacitor c=4.503163717437e-14
LCONVBPF_c098_2 (n_conv_cbpf_c098_2 conv_bpf_c098_2) inductor l=1.000000000000e-06
RCONVBPF_c098_2 (conv_bpf_c098_2 0) resistor r=2.356194490192e+02
ECONVI_c098_2_00 (conv_i_src_c098_2_00 0 conv_bpf_c098_2 0) vcvs gain=9.807852804032e-01
SCONVI_c098_2_00 (conv_i_src_c098_2_00 conv_i_c098_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_00 (conv_q_src_c098_2_00 0 conv_bpf_c098_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_2_00 (conv_q_src_c098_2_00 conv_q_c098_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_01 (conv_i_src_c098_2_01 0 conv_bpf_c098_2 0) vcvs gain=8.314696123025e-01
SCONVI_c098_2_01 (conv_i_src_c098_2_01 conv_i_c098_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_01 (conv_q_src_c098_2_01 0 conv_bpf_c098_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_2_01 (conv_q_src_c098_2_01 conv_q_c098_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_02 (conv_i_src_c098_2_02 0 conv_bpf_c098_2 0) vcvs gain=5.555702330196e-01
SCONVI_c098_2_02 (conv_i_src_c098_2_02 conv_i_c098_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_02 (conv_q_src_c098_2_02 0 conv_bpf_c098_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_2_02 (conv_q_src_c098_2_02 conv_q_c098_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_03 (conv_i_src_c098_2_03 0 conv_bpf_c098_2 0) vcvs gain=1.950903220161e-01
SCONVI_c098_2_03 (conv_i_src_c098_2_03 conv_i_c098_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_03 (conv_q_src_c098_2_03 0 conv_bpf_c098_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_2_03 (conv_q_src_c098_2_03 conv_q_c098_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_04 (conv_i_src_c098_2_04 0 conv_bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_2_04 (conv_i_src_c098_2_04 conv_i_c098_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_04 (conv_q_src_c098_2_04 0 conv_bpf_c098_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_2_04 (conv_q_src_c098_2_04 conv_q_c098_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_05 (conv_i_src_c098_2_05 0 conv_bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_2_05 (conv_i_src_c098_2_05 conv_i_c098_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_05 (conv_q_src_c098_2_05 0 conv_bpf_c098_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_2_05 (conv_q_src_c098_2_05 conv_q_c098_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_06 (conv_i_src_c098_2_06 0 conv_bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_2_06 (conv_i_src_c098_2_06 conv_i_c098_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_06 (conv_q_src_c098_2_06 0 conv_bpf_c098_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_2_06 (conv_q_src_c098_2_06 conv_q_c098_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_07 (conv_i_src_c098_2_07 0 conv_bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_2_07 (conv_i_src_c098_2_07 conv_i_c098_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_07 (conv_q_src_c098_2_07 0 conv_bpf_c098_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_2_07 (conv_q_src_c098_2_07 conv_q_c098_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_08 (conv_i_src_c098_2_08 0 conv_bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_2_08 (conv_i_src_c098_2_08 conv_i_c098_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_08 (conv_q_src_c098_2_08 0 conv_bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_2_08 (conv_q_src_c098_2_08 conv_q_c098_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_09 (conv_i_src_c098_2_09 0 conv_bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_2_09 (conv_i_src_c098_2_09 conv_i_c098_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_09 (conv_q_src_c098_2_09 0 conv_bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_2_09 (conv_q_src_c098_2_09 conv_q_c098_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_10 (conv_i_src_c098_2_10 0 conv_bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_2_10 (conv_i_src_c098_2_10 conv_i_c098_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_10 (conv_q_src_c098_2_10 0 conv_bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_2_10 (conv_q_src_c098_2_10 conv_q_c098_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_11 (conv_i_src_c098_2_11 0 conv_bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_2_11 (conv_i_src_c098_2_11 conv_i_c098_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_11 (conv_q_src_c098_2_11 0 conv_bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_2_11 (conv_q_src_c098_2_11 conv_q_c098_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_12 (conv_i_src_c098_2_12 0 conv_bpf_c098_2 0) vcvs gain=1.950903220161e-01
SCONVI_c098_2_12 (conv_i_src_c098_2_12 conv_i_c098_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_12 (conv_q_src_c098_2_12 0 conv_bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_2_12 (conv_q_src_c098_2_12 conv_q_c098_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_13 (conv_i_src_c098_2_13 0 conv_bpf_c098_2 0) vcvs gain=5.555702330196e-01
SCONVI_c098_2_13 (conv_i_src_c098_2_13 conv_i_c098_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_13 (conv_q_src_c098_2_13 0 conv_bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_2_13 (conv_q_src_c098_2_13 conv_q_c098_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_14 (conv_i_src_c098_2_14 0 conv_bpf_c098_2 0) vcvs gain=8.314696123025e-01
SCONVI_c098_2_14 (conv_i_src_c098_2_14 conv_i_c098_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_14 (conv_q_src_c098_2_14 0 conv_bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_2_14 (conv_q_src_c098_2_14 conv_q_c098_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_2_15 (conv_i_src_c098_2_15 0 conv_bpf_c098_2 0) vcvs gain=9.807852804032e-01
SCONVI_c098_2_15 (conv_i_src_c098_2_15 conv_i_c098_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_2_15 (conv_q_src_c098_2_15 0 conv_bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_2_15 (conv_q_src_c098_2_15 conv_q_c098_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c098_2 (conv_i_c098_2 0) resistor r=1G
RCONVQ_c098_2 (conv_q_c098_2 0) resistor r=1G
RCONVINTI_c098_2 (conv_i_c098_2 ConvIcar_c098_2) resistor r=1k
CCONVINTI_c098_2 (ConvIcar_c098_2 0) capacitor c=80p
RCONVINTQ_c098_2 (conv_q_c098_2 ConvQcar_c098_2) resistor r=1k
CCONVINTQ_c098_2 (ConvQcar_c098_2 0) capacitor c=80p
save conv_bpf_c098_2 ConvIcar_c098_2 ConvQcar_c098_2

// conventional mixed baseline bl098, carrier_3: 1000000000 Hz
CCONVBPF_c098_3 (bl098 n_conv_cbpf_c098_3) capacitor c=2.533029591058e-14
LCONVBPF_c098_3 (n_conv_cbpf_c098_3 conv_bpf_c098_3) inductor l=1.000000000000e-06
RCONVBPF_c098_3 (conv_bpf_c098_3 0) resistor r=3.141592653590e+02
ECONVI_c098_3_00 (conv_i_src_c098_3_00 0 conv_bpf_c098_3 0) vcvs gain=9.807852804032e-01
SCONVI_c098_3_00 (conv_i_src_c098_3_00 conv_i_c098_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_00 (conv_q_src_c098_3_00 0 conv_bpf_c098_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_3_00 (conv_q_src_c098_3_00 conv_q_c098_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_01 (conv_i_src_c098_3_01 0 conv_bpf_c098_3 0) vcvs gain=8.314696123025e-01
SCONVI_c098_3_01 (conv_i_src_c098_3_01 conv_i_c098_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_01 (conv_q_src_c098_3_01 0 conv_bpf_c098_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_3_01 (conv_q_src_c098_3_01 conv_q_c098_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_02 (conv_i_src_c098_3_02 0 conv_bpf_c098_3 0) vcvs gain=5.555702330196e-01
SCONVI_c098_3_02 (conv_i_src_c098_3_02 conv_i_c098_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_02 (conv_q_src_c098_3_02 0 conv_bpf_c098_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_3_02 (conv_q_src_c098_3_02 conv_q_c098_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_03 (conv_i_src_c098_3_03 0 conv_bpf_c098_3 0) vcvs gain=1.950903220161e-01
SCONVI_c098_3_03 (conv_i_src_c098_3_03 conv_i_c098_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_03 (conv_q_src_c098_3_03 0 conv_bpf_c098_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_3_03 (conv_q_src_c098_3_03 conv_q_c098_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_04 (conv_i_src_c098_3_04 0 conv_bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_3_04 (conv_i_src_c098_3_04 conv_i_c098_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_04 (conv_q_src_c098_3_04 0 conv_bpf_c098_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c098_3_04 (conv_q_src_c098_3_04 conv_q_c098_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_05 (conv_i_src_c098_3_05 0 conv_bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_3_05 (conv_i_src_c098_3_05 conv_i_c098_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_05 (conv_q_src_c098_3_05 0 conv_bpf_c098_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c098_3_05 (conv_q_src_c098_3_05 conv_q_c098_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_06 (conv_i_src_c098_3_06 0 conv_bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_3_06 (conv_i_src_c098_3_06 conv_i_c098_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_06 (conv_q_src_c098_3_06 0 conv_bpf_c098_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c098_3_06 (conv_q_src_c098_3_06 conv_q_c098_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_07 (conv_i_src_c098_3_07 0 conv_bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_3_07 (conv_i_src_c098_3_07 conv_i_c098_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_07 (conv_q_src_c098_3_07 0 conv_bpf_c098_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c098_3_07 (conv_q_src_c098_3_07 conv_q_c098_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_08 (conv_i_src_c098_3_08 0 conv_bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c098_3_08 (conv_i_src_c098_3_08 conv_i_c098_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_08 (conv_q_src_c098_3_08 0 conv_bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_3_08 (conv_q_src_c098_3_08 conv_q_c098_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_09 (conv_i_src_c098_3_09 0 conv_bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c098_3_09 (conv_i_src_c098_3_09 conv_i_c098_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_09 (conv_q_src_c098_3_09 0 conv_bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_3_09 (conv_q_src_c098_3_09 conv_q_c098_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_10 (conv_i_src_c098_3_10 0 conv_bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c098_3_10 (conv_i_src_c098_3_10 conv_i_c098_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_10 (conv_q_src_c098_3_10 0 conv_bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_3_10 (conv_q_src_c098_3_10 conv_q_c098_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_11 (conv_i_src_c098_3_11 0 conv_bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c098_3_11 (conv_i_src_c098_3_11 conv_i_c098_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_11 (conv_q_src_c098_3_11 0 conv_bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_3_11 (conv_q_src_c098_3_11 conv_q_c098_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_12 (conv_i_src_c098_3_12 0 conv_bpf_c098_3 0) vcvs gain=1.950903220161e-01
SCONVI_c098_3_12 (conv_i_src_c098_3_12 conv_i_c098_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_12 (conv_q_src_c098_3_12 0 conv_bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c098_3_12 (conv_q_src_c098_3_12 conv_q_c098_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_13 (conv_i_src_c098_3_13 0 conv_bpf_c098_3 0) vcvs gain=5.555702330196e-01
SCONVI_c098_3_13 (conv_i_src_c098_3_13 conv_i_c098_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_13 (conv_q_src_c098_3_13 0 conv_bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c098_3_13 (conv_q_src_c098_3_13 conv_q_c098_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_14 (conv_i_src_c098_3_14 0 conv_bpf_c098_3 0) vcvs gain=8.314696123025e-01
SCONVI_c098_3_14 (conv_i_src_c098_3_14 conv_i_c098_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_14 (conv_q_src_c098_3_14 0 conv_bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c098_3_14 (conv_q_src_c098_3_14 conv_q_c098_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c098_3_15 (conv_i_src_c098_3_15 0 conv_bpf_c098_3 0) vcvs gain=9.807852804032e-01
SCONVI_c098_3_15 (conv_i_src_c098_3_15 conv_i_c098_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c098_3_15 (conv_q_src_c098_3_15 0 conv_bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c098_3_15 (conv_q_src_c098_3_15 conv_q_c098_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c098_3 (conv_i_c098_3 0) resistor r=1G
RCONVQ_c098_3 (conv_q_c098_3 0) resistor r=1G
RCONVINTI_c098_3 (conv_i_c098_3 ConvIcar_c098_3) resistor r=1k
CCONVINTI_c098_3 (ConvIcar_c098_3 0) capacitor c=80p
RCONVINTQ_c098_3 (conv_q_c098_3 ConvQcar_c098_3) resistor r=1k
CCONVINTQ_c098_3 (ConvQcar_c098_3 0) capacitor c=80p
save conv_bpf_c098_3 ConvIcar_c098_3 ConvQcar_c098_3

// conventional mixed baseline bl099, carrier_0: 250000000 Hz
CCONVBPF_c099_0 (bl099 n_conv_cbpf_c099_0) capacitor c=4.052847345694e-13
LCONVBPF_c099_0 (n_conv_cbpf_c099_0 conv_bpf_c099_0) inductor l=1.000000000000e-06
RCONVBPF_c099_0 (conv_bpf_c099_0 0) resistor r=7.853981633974e+01
ECONVI_c099_0_00 (conv_i_src_c099_0_00 0 conv_bpf_c099_0 0) vcvs gain=9.807852804032e-01
SCONVI_c099_0_00 (conv_i_src_c099_0_00 conv_i_c099_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_00 (conv_q_src_c099_0_00 0 conv_bpf_c099_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_0_00 (conv_q_src_c099_0_00 conv_q_c099_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_01 (conv_i_src_c099_0_01 0 conv_bpf_c099_0 0) vcvs gain=8.314696123025e-01
SCONVI_c099_0_01 (conv_i_src_c099_0_01 conv_i_c099_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_01 (conv_q_src_c099_0_01 0 conv_bpf_c099_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_0_01 (conv_q_src_c099_0_01 conv_q_c099_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_02 (conv_i_src_c099_0_02 0 conv_bpf_c099_0 0) vcvs gain=5.555702330196e-01
SCONVI_c099_0_02 (conv_i_src_c099_0_02 conv_i_c099_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_02 (conv_q_src_c099_0_02 0 conv_bpf_c099_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_0_02 (conv_q_src_c099_0_02 conv_q_c099_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_03 (conv_i_src_c099_0_03 0 conv_bpf_c099_0 0) vcvs gain=1.950903220161e-01
SCONVI_c099_0_03 (conv_i_src_c099_0_03 conv_i_c099_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_03 (conv_q_src_c099_0_03 0 conv_bpf_c099_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_0_03 (conv_q_src_c099_0_03 conv_q_c099_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_04 (conv_i_src_c099_0_04 0 conv_bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_0_04 (conv_i_src_c099_0_04 conv_i_c099_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_04 (conv_q_src_c099_0_04 0 conv_bpf_c099_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_0_04 (conv_q_src_c099_0_04 conv_q_c099_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_05 (conv_i_src_c099_0_05 0 conv_bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_0_05 (conv_i_src_c099_0_05 conv_i_c099_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_05 (conv_q_src_c099_0_05 0 conv_bpf_c099_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_0_05 (conv_q_src_c099_0_05 conv_q_c099_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_06 (conv_i_src_c099_0_06 0 conv_bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_0_06 (conv_i_src_c099_0_06 conv_i_c099_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_06 (conv_q_src_c099_0_06 0 conv_bpf_c099_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_0_06 (conv_q_src_c099_0_06 conv_q_c099_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_07 (conv_i_src_c099_0_07 0 conv_bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_0_07 (conv_i_src_c099_0_07 conv_i_c099_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_07 (conv_q_src_c099_0_07 0 conv_bpf_c099_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_0_07 (conv_q_src_c099_0_07 conv_q_c099_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_08 (conv_i_src_c099_0_08 0 conv_bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_0_08 (conv_i_src_c099_0_08 conv_i_c099_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_08 (conv_q_src_c099_0_08 0 conv_bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_0_08 (conv_q_src_c099_0_08 conv_q_c099_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_09 (conv_i_src_c099_0_09 0 conv_bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_0_09 (conv_i_src_c099_0_09 conv_i_c099_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_09 (conv_q_src_c099_0_09 0 conv_bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_0_09 (conv_q_src_c099_0_09 conv_q_c099_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_10 (conv_i_src_c099_0_10 0 conv_bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_0_10 (conv_i_src_c099_0_10 conv_i_c099_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_10 (conv_q_src_c099_0_10 0 conv_bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_0_10 (conv_q_src_c099_0_10 conv_q_c099_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_11 (conv_i_src_c099_0_11 0 conv_bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_0_11 (conv_i_src_c099_0_11 conv_i_c099_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_11 (conv_q_src_c099_0_11 0 conv_bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_0_11 (conv_q_src_c099_0_11 conv_q_c099_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_12 (conv_i_src_c099_0_12 0 conv_bpf_c099_0 0) vcvs gain=1.950903220161e-01
SCONVI_c099_0_12 (conv_i_src_c099_0_12 conv_i_c099_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_12 (conv_q_src_c099_0_12 0 conv_bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_0_12 (conv_q_src_c099_0_12 conv_q_c099_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_13 (conv_i_src_c099_0_13 0 conv_bpf_c099_0 0) vcvs gain=5.555702330196e-01
SCONVI_c099_0_13 (conv_i_src_c099_0_13 conv_i_c099_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_13 (conv_q_src_c099_0_13 0 conv_bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_0_13 (conv_q_src_c099_0_13 conv_q_c099_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_14 (conv_i_src_c099_0_14 0 conv_bpf_c099_0 0) vcvs gain=8.314696123025e-01
SCONVI_c099_0_14 (conv_i_src_c099_0_14 conv_i_c099_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_14 (conv_q_src_c099_0_14 0 conv_bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_0_14 (conv_q_src_c099_0_14 conv_q_c099_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_0_15 (conv_i_src_c099_0_15 0 conv_bpf_c099_0 0) vcvs gain=9.807852804032e-01
SCONVI_c099_0_15 (conv_i_src_c099_0_15 conv_i_c099_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_0_15 (conv_q_src_c099_0_15 0 conv_bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_0_15 (conv_q_src_c099_0_15 conv_q_c099_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c099_0 (conv_i_c099_0 0) resistor r=1G
RCONVQ_c099_0 (conv_q_c099_0 0) resistor r=1G
RCONVINTI_c099_0 (conv_i_c099_0 ConvIcar_c099_0) resistor r=1k
CCONVINTI_c099_0 (ConvIcar_c099_0 0) capacitor c=80p
RCONVINTQ_c099_0 (conv_q_c099_0 ConvQcar_c099_0) resistor r=1k
CCONVINTQ_c099_0 (ConvQcar_c099_0 0) capacitor c=80p
save conv_bpf_c099_0 ConvIcar_c099_0 ConvQcar_c099_0

// conventional mixed baseline bl099, carrier_1: 500000000 Hz
CCONVBPF_c099_1 (bl099 n_conv_cbpf_c099_1) capacitor c=1.013211836423e-13
LCONVBPF_c099_1 (n_conv_cbpf_c099_1 conv_bpf_c099_1) inductor l=1.000000000000e-06
RCONVBPF_c099_1 (conv_bpf_c099_1 0) resistor r=1.570796326795e+02
ECONVI_c099_1_00 (conv_i_src_c099_1_00 0 conv_bpf_c099_1 0) vcvs gain=9.807852804032e-01
SCONVI_c099_1_00 (conv_i_src_c099_1_00 conv_i_c099_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_00 (conv_q_src_c099_1_00 0 conv_bpf_c099_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_1_00 (conv_q_src_c099_1_00 conv_q_c099_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_01 (conv_i_src_c099_1_01 0 conv_bpf_c099_1 0) vcvs gain=8.314696123025e-01
SCONVI_c099_1_01 (conv_i_src_c099_1_01 conv_i_c099_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_01 (conv_q_src_c099_1_01 0 conv_bpf_c099_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_1_01 (conv_q_src_c099_1_01 conv_q_c099_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_02 (conv_i_src_c099_1_02 0 conv_bpf_c099_1 0) vcvs gain=5.555702330196e-01
SCONVI_c099_1_02 (conv_i_src_c099_1_02 conv_i_c099_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_02 (conv_q_src_c099_1_02 0 conv_bpf_c099_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_1_02 (conv_q_src_c099_1_02 conv_q_c099_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_03 (conv_i_src_c099_1_03 0 conv_bpf_c099_1 0) vcvs gain=1.950903220161e-01
SCONVI_c099_1_03 (conv_i_src_c099_1_03 conv_i_c099_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_03 (conv_q_src_c099_1_03 0 conv_bpf_c099_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_1_03 (conv_q_src_c099_1_03 conv_q_c099_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_04 (conv_i_src_c099_1_04 0 conv_bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_1_04 (conv_i_src_c099_1_04 conv_i_c099_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_04 (conv_q_src_c099_1_04 0 conv_bpf_c099_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_1_04 (conv_q_src_c099_1_04 conv_q_c099_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_05 (conv_i_src_c099_1_05 0 conv_bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_1_05 (conv_i_src_c099_1_05 conv_i_c099_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_05 (conv_q_src_c099_1_05 0 conv_bpf_c099_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_1_05 (conv_q_src_c099_1_05 conv_q_c099_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_06 (conv_i_src_c099_1_06 0 conv_bpf_c099_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_1_06 (conv_i_src_c099_1_06 conv_i_c099_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_06 (conv_q_src_c099_1_06 0 conv_bpf_c099_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_1_06 (conv_q_src_c099_1_06 conv_q_c099_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_07 (conv_i_src_c099_1_07 0 conv_bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_1_07 (conv_i_src_c099_1_07 conv_i_c099_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_07 (conv_q_src_c099_1_07 0 conv_bpf_c099_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_1_07 (conv_q_src_c099_1_07 conv_q_c099_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_08 (conv_i_src_c099_1_08 0 conv_bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_1_08 (conv_i_src_c099_1_08 conv_i_c099_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_08 (conv_q_src_c099_1_08 0 conv_bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_1_08 (conv_q_src_c099_1_08 conv_q_c099_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_09 (conv_i_src_c099_1_09 0 conv_bpf_c099_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_1_09 (conv_i_src_c099_1_09 conv_i_c099_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_09 (conv_q_src_c099_1_09 0 conv_bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_1_09 (conv_q_src_c099_1_09 conv_q_c099_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_10 (conv_i_src_c099_1_10 0 conv_bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_1_10 (conv_i_src_c099_1_10 conv_i_c099_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_10 (conv_q_src_c099_1_10 0 conv_bpf_c099_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_1_10 (conv_q_src_c099_1_10 conv_q_c099_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_11 (conv_i_src_c099_1_11 0 conv_bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_1_11 (conv_i_src_c099_1_11 conv_i_c099_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_11 (conv_q_src_c099_1_11 0 conv_bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_1_11 (conv_q_src_c099_1_11 conv_q_c099_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_12 (conv_i_src_c099_1_12 0 conv_bpf_c099_1 0) vcvs gain=1.950903220161e-01
SCONVI_c099_1_12 (conv_i_src_c099_1_12 conv_i_c099_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_12 (conv_q_src_c099_1_12 0 conv_bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_1_12 (conv_q_src_c099_1_12 conv_q_c099_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_13 (conv_i_src_c099_1_13 0 conv_bpf_c099_1 0) vcvs gain=5.555702330196e-01
SCONVI_c099_1_13 (conv_i_src_c099_1_13 conv_i_c099_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_13 (conv_q_src_c099_1_13 0 conv_bpf_c099_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_1_13 (conv_q_src_c099_1_13 conv_q_c099_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_14 (conv_i_src_c099_1_14 0 conv_bpf_c099_1 0) vcvs gain=8.314696123025e-01
SCONVI_c099_1_14 (conv_i_src_c099_1_14 conv_i_c099_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_14 (conv_q_src_c099_1_14 0 conv_bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_1_14 (conv_q_src_c099_1_14 conv_q_c099_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_1_15 (conv_i_src_c099_1_15 0 conv_bpf_c099_1 0) vcvs gain=9.807852804032e-01
SCONVI_c099_1_15 (conv_i_src_c099_1_15 conv_i_c099_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_1_15 (conv_q_src_c099_1_15 0 conv_bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_1_15 (conv_q_src_c099_1_15 conv_q_c099_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c099_1 (conv_i_c099_1 0) resistor r=1G
RCONVQ_c099_1 (conv_q_c099_1 0) resistor r=1G
RCONVINTI_c099_1 (conv_i_c099_1 ConvIcar_c099_1) resistor r=1k
CCONVINTI_c099_1 (ConvIcar_c099_1 0) capacitor c=80p
RCONVINTQ_c099_1 (conv_q_c099_1 ConvQcar_c099_1) resistor r=1k
CCONVINTQ_c099_1 (ConvQcar_c099_1 0) capacitor c=80p
save conv_bpf_c099_1 ConvIcar_c099_1 ConvQcar_c099_1

// conventional mixed baseline bl099, carrier_2: 750000000 Hz
CCONVBPF_c099_2 (bl099 n_conv_cbpf_c099_2) capacitor c=4.503163717437e-14
LCONVBPF_c099_2 (n_conv_cbpf_c099_2 conv_bpf_c099_2) inductor l=1.000000000000e-06
RCONVBPF_c099_2 (conv_bpf_c099_2 0) resistor r=2.356194490192e+02
ECONVI_c099_2_00 (conv_i_src_c099_2_00 0 conv_bpf_c099_2 0) vcvs gain=9.807852804032e-01
SCONVI_c099_2_00 (conv_i_src_c099_2_00 conv_i_c099_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_00 (conv_q_src_c099_2_00 0 conv_bpf_c099_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_2_00 (conv_q_src_c099_2_00 conv_q_c099_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_01 (conv_i_src_c099_2_01 0 conv_bpf_c099_2 0) vcvs gain=8.314696123025e-01
SCONVI_c099_2_01 (conv_i_src_c099_2_01 conv_i_c099_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_01 (conv_q_src_c099_2_01 0 conv_bpf_c099_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_2_01 (conv_q_src_c099_2_01 conv_q_c099_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_02 (conv_i_src_c099_2_02 0 conv_bpf_c099_2 0) vcvs gain=5.555702330196e-01
SCONVI_c099_2_02 (conv_i_src_c099_2_02 conv_i_c099_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_02 (conv_q_src_c099_2_02 0 conv_bpf_c099_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_2_02 (conv_q_src_c099_2_02 conv_q_c099_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_03 (conv_i_src_c099_2_03 0 conv_bpf_c099_2 0) vcvs gain=1.950903220161e-01
SCONVI_c099_2_03 (conv_i_src_c099_2_03 conv_i_c099_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_03 (conv_q_src_c099_2_03 0 conv_bpf_c099_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_2_03 (conv_q_src_c099_2_03 conv_q_c099_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_04 (conv_i_src_c099_2_04 0 conv_bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_2_04 (conv_i_src_c099_2_04 conv_i_c099_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_04 (conv_q_src_c099_2_04 0 conv_bpf_c099_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_2_04 (conv_q_src_c099_2_04 conv_q_c099_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_05 (conv_i_src_c099_2_05 0 conv_bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_2_05 (conv_i_src_c099_2_05 conv_i_c099_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_05 (conv_q_src_c099_2_05 0 conv_bpf_c099_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_2_05 (conv_q_src_c099_2_05 conv_q_c099_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_06 (conv_i_src_c099_2_06 0 conv_bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_2_06 (conv_i_src_c099_2_06 conv_i_c099_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_06 (conv_q_src_c099_2_06 0 conv_bpf_c099_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_2_06 (conv_q_src_c099_2_06 conv_q_c099_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_07 (conv_i_src_c099_2_07 0 conv_bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_2_07 (conv_i_src_c099_2_07 conv_i_c099_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_07 (conv_q_src_c099_2_07 0 conv_bpf_c099_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_2_07 (conv_q_src_c099_2_07 conv_q_c099_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_08 (conv_i_src_c099_2_08 0 conv_bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_2_08 (conv_i_src_c099_2_08 conv_i_c099_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_08 (conv_q_src_c099_2_08 0 conv_bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_2_08 (conv_q_src_c099_2_08 conv_q_c099_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_09 (conv_i_src_c099_2_09 0 conv_bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_2_09 (conv_i_src_c099_2_09 conv_i_c099_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_09 (conv_q_src_c099_2_09 0 conv_bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_2_09 (conv_q_src_c099_2_09 conv_q_c099_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_10 (conv_i_src_c099_2_10 0 conv_bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_2_10 (conv_i_src_c099_2_10 conv_i_c099_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_10 (conv_q_src_c099_2_10 0 conv_bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_2_10 (conv_q_src_c099_2_10 conv_q_c099_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_11 (conv_i_src_c099_2_11 0 conv_bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_2_11 (conv_i_src_c099_2_11 conv_i_c099_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_11 (conv_q_src_c099_2_11 0 conv_bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_2_11 (conv_q_src_c099_2_11 conv_q_c099_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_12 (conv_i_src_c099_2_12 0 conv_bpf_c099_2 0) vcvs gain=1.950903220161e-01
SCONVI_c099_2_12 (conv_i_src_c099_2_12 conv_i_c099_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_12 (conv_q_src_c099_2_12 0 conv_bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_2_12 (conv_q_src_c099_2_12 conv_q_c099_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_13 (conv_i_src_c099_2_13 0 conv_bpf_c099_2 0) vcvs gain=5.555702330196e-01
SCONVI_c099_2_13 (conv_i_src_c099_2_13 conv_i_c099_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_13 (conv_q_src_c099_2_13 0 conv_bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_2_13 (conv_q_src_c099_2_13 conv_q_c099_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_14 (conv_i_src_c099_2_14 0 conv_bpf_c099_2 0) vcvs gain=8.314696123025e-01
SCONVI_c099_2_14 (conv_i_src_c099_2_14 conv_i_c099_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_14 (conv_q_src_c099_2_14 0 conv_bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_2_14 (conv_q_src_c099_2_14 conv_q_c099_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_2_15 (conv_i_src_c099_2_15 0 conv_bpf_c099_2 0) vcvs gain=9.807852804032e-01
SCONVI_c099_2_15 (conv_i_src_c099_2_15 conv_i_c099_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_2_15 (conv_q_src_c099_2_15 0 conv_bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_2_15 (conv_q_src_c099_2_15 conv_q_c099_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c099_2 (conv_i_c099_2 0) resistor r=1G
RCONVQ_c099_2 (conv_q_c099_2 0) resistor r=1G
RCONVINTI_c099_2 (conv_i_c099_2 ConvIcar_c099_2) resistor r=1k
CCONVINTI_c099_2 (ConvIcar_c099_2 0) capacitor c=80p
RCONVINTQ_c099_2 (conv_q_c099_2 ConvQcar_c099_2) resistor r=1k
CCONVINTQ_c099_2 (ConvQcar_c099_2 0) capacitor c=80p
save conv_bpf_c099_2 ConvIcar_c099_2 ConvQcar_c099_2

// conventional mixed baseline bl099, carrier_3: 1000000000 Hz
CCONVBPF_c099_3 (bl099 n_conv_cbpf_c099_3) capacitor c=2.533029591058e-14
LCONVBPF_c099_3 (n_conv_cbpf_c099_3 conv_bpf_c099_3) inductor l=1.000000000000e-06
RCONVBPF_c099_3 (conv_bpf_c099_3 0) resistor r=3.141592653590e+02
ECONVI_c099_3_00 (conv_i_src_c099_3_00 0 conv_bpf_c099_3 0) vcvs gain=9.807852804032e-01
SCONVI_c099_3_00 (conv_i_src_c099_3_00 conv_i_c099_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_00 (conv_q_src_c099_3_00 0 conv_bpf_c099_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_3_00 (conv_q_src_c099_3_00 conv_q_c099_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_01 (conv_i_src_c099_3_01 0 conv_bpf_c099_3 0) vcvs gain=8.314696123025e-01
SCONVI_c099_3_01 (conv_i_src_c099_3_01 conv_i_c099_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_01 (conv_q_src_c099_3_01 0 conv_bpf_c099_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_3_01 (conv_q_src_c099_3_01 conv_q_c099_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_02 (conv_i_src_c099_3_02 0 conv_bpf_c099_3 0) vcvs gain=5.555702330196e-01
SCONVI_c099_3_02 (conv_i_src_c099_3_02 conv_i_c099_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_02 (conv_q_src_c099_3_02 0 conv_bpf_c099_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_3_02 (conv_q_src_c099_3_02 conv_q_c099_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_03 (conv_i_src_c099_3_03 0 conv_bpf_c099_3 0) vcvs gain=1.950903220161e-01
SCONVI_c099_3_03 (conv_i_src_c099_3_03 conv_i_c099_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_03 (conv_q_src_c099_3_03 0 conv_bpf_c099_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_3_03 (conv_q_src_c099_3_03 conv_q_c099_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_04 (conv_i_src_c099_3_04 0 conv_bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_3_04 (conv_i_src_c099_3_04 conv_i_c099_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_04 (conv_q_src_c099_3_04 0 conv_bpf_c099_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c099_3_04 (conv_q_src_c099_3_04 conv_q_c099_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_05 (conv_i_src_c099_3_05 0 conv_bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_3_05 (conv_i_src_c099_3_05 conv_i_c099_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_05 (conv_q_src_c099_3_05 0 conv_bpf_c099_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c099_3_05 (conv_q_src_c099_3_05 conv_q_c099_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_06 (conv_i_src_c099_3_06 0 conv_bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_3_06 (conv_i_src_c099_3_06 conv_i_c099_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_06 (conv_q_src_c099_3_06 0 conv_bpf_c099_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c099_3_06 (conv_q_src_c099_3_06 conv_q_c099_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_07 (conv_i_src_c099_3_07 0 conv_bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_3_07 (conv_i_src_c099_3_07 conv_i_c099_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_07 (conv_q_src_c099_3_07 0 conv_bpf_c099_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c099_3_07 (conv_q_src_c099_3_07 conv_q_c099_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_08 (conv_i_src_c099_3_08 0 conv_bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c099_3_08 (conv_i_src_c099_3_08 conv_i_c099_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_08 (conv_q_src_c099_3_08 0 conv_bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_3_08 (conv_q_src_c099_3_08 conv_q_c099_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_09 (conv_i_src_c099_3_09 0 conv_bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c099_3_09 (conv_i_src_c099_3_09 conv_i_c099_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_09 (conv_q_src_c099_3_09 0 conv_bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_3_09 (conv_q_src_c099_3_09 conv_q_c099_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_10 (conv_i_src_c099_3_10 0 conv_bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c099_3_10 (conv_i_src_c099_3_10 conv_i_c099_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_10 (conv_q_src_c099_3_10 0 conv_bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_3_10 (conv_q_src_c099_3_10 conv_q_c099_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_11 (conv_i_src_c099_3_11 0 conv_bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c099_3_11 (conv_i_src_c099_3_11 conv_i_c099_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_11 (conv_q_src_c099_3_11 0 conv_bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_3_11 (conv_q_src_c099_3_11 conv_q_c099_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_12 (conv_i_src_c099_3_12 0 conv_bpf_c099_3 0) vcvs gain=1.950903220161e-01
SCONVI_c099_3_12 (conv_i_src_c099_3_12 conv_i_c099_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_12 (conv_q_src_c099_3_12 0 conv_bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c099_3_12 (conv_q_src_c099_3_12 conv_q_c099_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_13 (conv_i_src_c099_3_13 0 conv_bpf_c099_3 0) vcvs gain=5.555702330196e-01
SCONVI_c099_3_13 (conv_i_src_c099_3_13 conv_i_c099_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_13 (conv_q_src_c099_3_13 0 conv_bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c099_3_13 (conv_q_src_c099_3_13 conv_q_c099_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_14 (conv_i_src_c099_3_14 0 conv_bpf_c099_3 0) vcvs gain=8.314696123025e-01
SCONVI_c099_3_14 (conv_i_src_c099_3_14 conv_i_c099_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_14 (conv_q_src_c099_3_14 0 conv_bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c099_3_14 (conv_q_src_c099_3_14 conv_q_c099_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c099_3_15 (conv_i_src_c099_3_15 0 conv_bpf_c099_3 0) vcvs gain=9.807852804032e-01
SCONVI_c099_3_15 (conv_i_src_c099_3_15 conv_i_c099_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c099_3_15 (conv_q_src_c099_3_15 0 conv_bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c099_3_15 (conv_q_src_c099_3_15 conv_q_c099_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c099_3 (conv_i_c099_3 0) resistor r=1G
RCONVQ_c099_3 (conv_q_c099_3 0) resistor r=1G
RCONVINTI_c099_3 (conv_i_c099_3 ConvIcar_c099_3) resistor r=1k
CCONVINTI_c099_3 (ConvIcar_c099_3 0) capacitor c=80p
RCONVINTQ_c099_3 (conv_q_c099_3 ConvQcar_c099_3) resistor r=1k
CCONVINTQ_c099_3 (ConvQcar_c099_3 0) capacitor c=80p
save conv_bpf_c099_3 ConvIcar_c099_3 ConvQcar_c099_3

// conventional mixed baseline bl100, carrier_0: 250000000 Hz
CCONVBPF_c100_0 (bl100 n_conv_cbpf_c100_0) capacitor c=4.052847345694e-13
LCONVBPF_c100_0 (n_conv_cbpf_c100_0 conv_bpf_c100_0) inductor l=1.000000000000e-06
RCONVBPF_c100_0 (conv_bpf_c100_0 0) resistor r=7.853981633974e+01
ECONVI_c100_0_00 (conv_i_src_c100_0_00 0 conv_bpf_c100_0 0) vcvs gain=9.807852804032e-01
SCONVI_c100_0_00 (conv_i_src_c100_0_00 conv_i_c100_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_00 (conv_q_src_c100_0_00 0 conv_bpf_c100_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_0_00 (conv_q_src_c100_0_00 conv_q_c100_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_01 (conv_i_src_c100_0_01 0 conv_bpf_c100_0 0) vcvs gain=8.314696123025e-01
SCONVI_c100_0_01 (conv_i_src_c100_0_01 conv_i_c100_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_01 (conv_q_src_c100_0_01 0 conv_bpf_c100_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_0_01 (conv_q_src_c100_0_01 conv_q_c100_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_02 (conv_i_src_c100_0_02 0 conv_bpf_c100_0 0) vcvs gain=5.555702330196e-01
SCONVI_c100_0_02 (conv_i_src_c100_0_02 conv_i_c100_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_02 (conv_q_src_c100_0_02 0 conv_bpf_c100_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_0_02 (conv_q_src_c100_0_02 conv_q_c100_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_03 (conv_i_src_c100_0_03 0 conv_bpf_c100_0 0) vcvs gain=1.950903220161e-01
SCONVI_c100_0_03 (conv_i_src_c100_0_03 conv_i_c100_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_03 (conv_q_src_c100_0_03 0 conv_bpf_c100_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_0_03 (conv_q_src_c100_0_03 conv_q_c100_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_04 (conv_i_src_c100_0_04 0 conv_bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_0_04 (conv_i_src_c100_0_04 conv_i_c100_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_04 (conv_q_src_c100_0_04 0 conv_bpf_c100_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_0_04 (conv_q_src_c100_0_04 conv_q_c100_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_05 (conv_i_src_c100_0_05 0 conv_bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_0_05 (conv_i_src_c100_0_05 conv_i_c100_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_05 (conv_q_src_c100_0_05 0 conv_bpf_c100_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_0_05 (conv_q_src_c100_0_05 conv_q_c100_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_06 (conv_i_src_c100_0_06 0 conv_bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_0_06 (conv_i_src_c100_0_06 conv_i_c100_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_06 (conv_q_src_c100_0_06 0 conv_bpf_c100_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_0_06 (conv_q_src_c100_0_06 conv_q_c100_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_07 (conv_i_src_c100_0_07 0 conv_bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_0_07 (conv_i_src_c100_0_07 conv_i_c100_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_07 (conv_q_src_c100_0_07 0 conv_bpf_c100_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_0_07 (conv_q_src_c100_0_07 conv_q_c100_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_08 (conv_i_src_c100_0_08 0 conv_bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_0_08 (conv_i_src_c100_0_08 conv_i_c100_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_08 (conv_q_src_c100_0_08 0 conv_bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_0_08 (conv_q_src_c100_0_08 conv_q_c100_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_09 (conv_i_src_c100_0_09 0 conv_bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_0_09 (conv_i_src_c100_0_09 conv_i_c100_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_09 (conv_q_src_c100_0_09 0 conv_bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_0_09 (conv_q_src_c100_0_09 conv_q_c100_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_10 (conv_i_src_c100_0_10 0 conv_bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_0_10 (conv_i_src_c100_0_10 conv_i_c100_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_10 (conv_q_src_c100_0_10 0 conv_bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_0_10 (conv_q_src_c100_0_10 conv_q_c100_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_11 (conv_i_src_c100_0_11 0 conv_bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_0_11 (conv_i_src_c100_0_11 conv_i_c100_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_11 (conv_q_src_c100_0_11 0 conv_bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_0_11 (conv_q_src_c100_0_11 conv_q_c100_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_12 (conv_i_src_c100_0_12 0 conv_bpf_c100_0 0) vcvs gain=1.950903220161e-01
SCONVI_c100_0_12 (conv_i_src_c100_0_12 conv_i_c100_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_12 (conv_q_src_c100_0_12 0 conv_bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_0_12 (conv_q_src_c100_0_12 conv_q_c100_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_13 (conv_i_src_c100_0_13 0 conv_bpf_c100_0 0) vcvs gain=5.555702330196e-01
SCONVI_c100_0_13 (conv_i_src_c100_0_13 conv_i_c100_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_13 (conv_q_src_c100_0_13 0 conv_bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_0_13 (conv_q_src_c100_0_13 conv_q_c100_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_14 (conv_i_src_c100_0_14 0 conv_bpf_c100_0 0) vcvs gain=8.314696123025e-01
SCONVI_c100_0_14 (conv_i_src_c100_0_14 conv_i_c100_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_14 (conv_q_src_c100_0_14 0 conv_bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_0_14 (conv_q_src_c100_0_14 conv_q_c100_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_0_15 (conv_i_src_c100_0_15 0 conv_bpf_c100_0 0) vcvs gain=9.807852804032e-01
SCONVI_c100_0_15 (conv_i_src_c100_0_15 conv_i_c100_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_0_15 (conv_q_src_c100_0_15 0 conv_bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_0_15 (conv_q_src_c100_0_15 conv_q_c100_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c100_0 (conv_i_c100_0 0) resistor r=1G
RCONVQ_c100_0 (conv_q_c100_0 0) resistor r=1G
RCONVINTI_c100_0 (conv_i_c100_0 ConvIcar_c100_0) resistor r=1k
CCONVINTI_c100_0 (ConvIcar_c100_0 0) capacitor c=80p
RCONVINTQ_c100_0 (conv_q_c100_0 ConvQcar_c100_0) resistor r=1k
CCONVINTQ_c100_0 (ConvQcar_c100_0 0) capacitor c=80p
save conv_bpf_c100_0 ConvIcar_c100_0 ConvQcar_c100_0

// conventional mixed baseline bl100, carrier_1: 500000000 Hz
CCONVBPF_c100_1 (bl100 n_conv_cbpf_c100_1) capacitor c=1.013211836423e-13
LCONVBPF_c100_1 (n_conv_cbpf_c100_1 conv_bpf_c100_1) inductor l=1.000000000000e-06
RCONVBPF_c100_1 (conv_bpf_c100_1 0) resistor r=1.570796326795e+02
ECONVI_c100_1_00 (conv_i_src_c100_1_00 0 conv_bpf_c100_1 0) vcvs gain=9.807852804032e-01
SCONVI_c100_1_00 (conv_i_src_c100_1_00 conv_i_c100_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_00 (conv_q_src_c100_1_00 0 conv_bpf_c100_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_1_00 (conv_q_src_c100_1_00 conv_q_c100_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_01 (conv_i_src_c100_1_01 0 conv_bpf_c100_1 0) vcvs gain=8.314696123025e-01
SCONVI_c100_1_01 (conv_i_src_c100_1_01 conv_i_c100_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_01 (conv_q_src_c100_1_01 0 conv_bpf_c100_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_1_01 (conv_q_src_c100_1_01 conv_q_c100_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_02 (conv_i_src_c100_1_02 0 conv_bpf_c100_1 0) vcvs gain=5.555702330196e-01
SCONVI_c100_1_02 (conv_i_src_c100_1_02 conv_i_c100_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_02 (conv_q_src_c100_1_02 0 conv_bpf_c100_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_1_02 (conv_q_src_c100_1_02 conv_q_c100_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_03 (conv_i_src_c100_1_03 0 conv_bpf_c100_1 0) vcvs gain=1.950903220161e-01
SCONVI_c100_1_03 (conv_i_src_c100_1_03 conv_i_c100_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_03 (conv_q_src_c100_1_03 0 conv_bpf_c100_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_1_03 (conv_q_src_c100_1_03 conv_q_c100_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_04 (conv_i_src_c100_1_04 0 conv_bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_1_04 (conv_i_src_c100_1_04 conv_i_c100_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_04 (conv_q_src_c100_1_04 0 conv_bpf_c100_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_1_04 (conv_q_src_c100_1_04 conv_q_c100_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_05 (conv_i_src_c100_1_05 0 conv_bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_1_05 (conv_i_src_c100_1_05 conv_i_c100_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_05 (conv_q_src_c100_1_05 0 conv_bpf_c100_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_1_05 (conv_q_src_c100_1_05 conv_q_c100_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_06 (conv_i_src_c100_1_06 0 conv_bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_1_06 (conv_i_src_c100_1_06 conv_i_c100_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_06 (conv_q_src_c100_1_06 0 conv_bpf_c100_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_1_06 (conv_q_src_c100_1_06 conv_q_c100_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_07 (conv_i_src_c100_1_07 0 conv_bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_1_07 (conv_i_src_c100_1_07 conv_i_c100_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_07 (conv_q_src_c100_1_07 0 conv_bpf_c100_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_1_07 (conv_q_src_c100_1_07 conv_q_c100_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_08 (conv_i_src_c100_1_08 0 conv_bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_1_08 (conv_i_src_c100_1_08 conv_i_c100_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_08 (conv_q_src_c100_1_08 0 conv_bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_1_08 (conv_q_src_c100_1_08 conv_q_c100_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_09 (conv_i_src_c100_1_09 0 conv_bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_1_09 (conv_i_src_c100_1_09 conv_i_c100_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_09 (conv_q_src_c100_1_09 0 conv_bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_1_09 (conv_q_src_c100_1_09 conv_q_c100_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_10 (conv_i_src_c100_1_10 0 conv_bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_1_10 (conv_i_src_c100_1_10 conv_i_c100_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_10 (conv_q_src_c100_1_10 0 conv_bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_1_10 (conv_q_src_c100_1_10 conv_q_c100_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_11 (conv_i_src_c100_1_11 0 conv_bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_1_11 (conv_i_src_c100_1_11 conv_i_c100_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_11 (conv_q_src_c100_1_11 0 conv_bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_1_11 (conv_q_src_c100_1_11 conv_q_c100_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_12 (conv_i_src_c100_1_12 0 conv_bpf_c100_1 0) vcvs gain=1.950903220161e-01
SCONVI_c100_1_12 (conv_i_src_c100_1_12 conv_i_c100_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_12 (conv_q_src_c100_1_12 0 conv_bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_1_12 (conv_q_src_c100_1_12 conv_q_c100_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_13 (conv_i_src_c100_1_13 0 conv_bpf_c100_1 0) vcvs gain=5.555702330196e-01
SCONVI_c100_1_13 (conv_i_src_c100_1_13 conv_i_c100_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_13 (conv_q_src_c100_1_13 0 conv_bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_1_13 (conv_q_src_c100_1_13 conv_q_c100_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_14 (conv_i_src_c100_1_14 0 conv_bpf_c100_1 0) vcvs gain=8.314696123025e-01
SCONVI_c100_1_14 (conv_i_src_c100_1_14 conv_i_c100_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_14 (conv_q_src_c100_1_14 0 conv_bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_1_14 (conv_q_src_c100_1_14 conv_q_c100_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_1_15 (conv_i_src_c100_1_15 0 conv_bpf_c100_1 0) vcvs gain=9.807852804032e-01
SCONVI_c100_1_15 (conv_i_src_c100_1_15 conv_i_c100_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_1_15 (conv_q_src_c100_1_15 0 conv_bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_1_15 (conv_q_src_c100_1_15 conv_q_c100_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c100_1 (conv_i_c100_1 0) resistor r=1G
RCONVQ_c100_1 (conv_q_c100_1 0) resistor r=1G
RCONVINTI_c100_1 (conv_i_c100_1 ConvIcar_c100_1) resistor r=1k
CCONVINTI_c100_1 (ConvIcar_c100_1 0) capacitor c=80p
RCONVINTQ_c100_1 (conv_q_c100_1 ConvQcar_c100_1) resistor r=1k
CCONVINTQ_c100_1 (ConvQcar_c100_1 0) capacitor c=80p
save conv_bpf_c100_1 ConvIcar_c100_1 ConvQcar_c100_1

// conventional mixed baseline bl100, carrier_2: 750000000 Hz
CCONVBPF_c100_2 (bl100 n_conv_cbpf_c100_2) capacitor c=4.503163717437e-14
LCONVBPF_c100_2 (n_conv_cbpf_c100_2 conv_bpf_c100_2) inductor l=1.000000000000e-06
RCONVBPF_c100_2 (conv_bpf_c100_2 0) resistor r=2.356194490192e+02
ECONVI_c100_2_00 (conv_i_src_c100_2_00 0 conv_bpf_c100_2 0) vcvs gain=9.807852804032e-01
SCONVI_c100_2_00 (conv_i_src_c100_2_00 conv_i_c100_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_00 (conv_q_src_c100_2_00 0 conv_bpf_c100_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_2_00 (conv_q_src_c100_2_00 conv_q_c100_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_01 (conv_i_src_c100_2_01 0 conv_bpf_c100_2 0) vcvs gain=8.314696123025e-01
SCONVI_c100_2_01 (conv_i_src_c100_2_01 conv_i_c100_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_01 (conv_q_src_c100_2_01 0 conv_bpf_c100_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_2_01 (conv_q_src_c100_2_01 conv_q_c100_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_02 (conv_i_src_c100_2_02 0 conv_bpf_c100_2 0) vcvs gain=5.555702330196e-01
SCONVI_c100_2_02 (conv_i_src_c100_2_02 conv_i_c100_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_02 (conv_q_src_c100_2_02 0 conv_bpf_c100_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_2_02 (conv_q_src_c100_2_02 conv_q_c100_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_03 (conv_i_src_c100_2_03 0 conv_bpf_c100_2 0) vcvs gain=1.950903220161e-01
SCONVI_c100_2_03 (conv_i_src_c100_2_03 conv_i_c100_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_03 (conv_q_src_c100_2_03 0 conv_bpf_c100_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_2_03 (conv_q_src_c100_2_03 conv_q_c100_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_04 (conv_i_src_c100_2_04 0 conv_bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_2_04 (conv_i_src_c100_2_04 conv_i_c100_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_04 (conv_q_src_c100_2_04 0 conv_bpf_c100_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_2_04 (conv_q_src_c100_2_04 conv_q_c100_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_05 (conv_i_src_c100_2_05 0 conv_bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_2_05 (conv_i_src_c100_2_05 conv_i_c100_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_05 (conv_q_src_c100_2_05 0 conv_bpf_c100_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_2_05 (conv_q_src_c100_2_05 conv_q_c100_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_06 (conv_i_src_c100_2_06 0 conv_bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_2_06 (conv_i_src_c100_2_06 conv_i_c100_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_06 (conv_q_src_c100_2_06 0 conv_bpf_c100_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_2_06 (conv_q_src_c100_2_06 conv_q_c100_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_07 (conv_i_src_c100_2_07 0 conv_bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_2_07 (conv_i_src_c100_2_07 conv_i_c100_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_07 (conv_q_src_c100_2_07 0 conv_bpf_c100_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_2_07 (conv_q_src_c100_2_07 conv_q_c100_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_08 (conv_i_src_c100_2_08 0 conv_bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_2_08 (conv_i_src_c100_2_08 conv_i_c100_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_08 (conv_q_src_c100_2_08 0 conv_bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_2_08 (conv_q_src_c100_2_08 conv_q_c100_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_09 (conv_i_src_c100_2_09 0 conv_bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_2_09 (conv_i_src_c100_2_09 conv_i_c100_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_09 (conv_q_src_c100_2_09 0 conv_bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_2_09 (conv_q_src_c100_2_09 conv_q_c100_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_10 (conv_i_src_c100_2_10 0 conv_bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_2_10 (conv_i_src_c100_2_10 conv_i_c100_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_10 (conv_q_src_c100_2_10 0 conv_bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_2_10 (conv_q_src_c100_2_10 conv_q_c100_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_11 (conv_i_src_c100_2_11 0 conv_bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_2_11 (conv_i_src_c100_2_11 conv_i_c100_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_11 (conv_q_src_c100_2_11 0 conv_bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_2_11 (conv_q_src_c100_2_11 conv_q_c100_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_12 (conv_i_src_c100_2_12 0 conv_bpf_c100_2 0) vcvs gain=1.950903220161e-01
SCONVI_c100_2_12 (conv_i_src_c100_2_12 conv_i_c100_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_12 (conv_q_src_c100_2_12 0 conv_bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_2_12 (conv_q_src_c100_2_12 conv_q_c100_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_13 (conv_i_src_c100_2_13 0 conv_bpf_c100_2 0) vcvs gain=5.555702330196e-01
SCONVI_c100_2_13 (conv_i_src_c100_2_13 conv_i_c100_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_13 (conv_q_src_c100_2_13 0 conv_bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_2_13 (conv_q_src_c100_2_13 conv_q_c100_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_14 (conv_i_src_c100_2_14 0 conv_bpf_c100_2 0) vcvs gain=8.314696123025e-01
SCONVI_c100_2_14 (conv_i_src_c100_2_14 conv_i_c100_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_14 (conv_q_src_c100_2_14 0 conv_bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_2_14 (conv_q_src_c100_2_14 conv_q_c100_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_2_15 (conv_i_src_c100_2_15 0 conv_bpf_c100_2 0) vcvs gain=9.807852804032e-01
SCONVI_c100_2_15 (conv_i_src_c100_2_15 conv_i_c100_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_2_15 (conv_q_src_c100_2_15 0 conv_bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_2_15 (conv_q_src_c100_2_15 conv_q_c100_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c100_2 (conv_i_c100_2 0) resistor r=1G
RCONVQ_c100_2 (conv_q_c100_2 0) resistor r=1G
RCONVINTI_c100_2 (conv_i_c100_2 ConvIcar_c100_2) resistor r=1k
CCONVINTI_c100_2 (ConvIcar_c100_2 0) capacitor c=80p
RCONVINTQ_c100_2 (conv_q_c100_2 ConvQcar_c100_2) resistor r=1k
CCONVINTQ_c100_2 (ConvQcar_c100_2 0) capacitor c=80p
save conv_bpf_c100_2 ConvIcar_c100_2 ConvQcar_c100_2

// conventional mixed baseline bl100, carrier_3: 1000000000 Hz
CCONVBPF_c100_3 (bl100 n_conv_cbpf_c100_3) capacitor c=2.533029591058e-14
LCONVBPF_c100_3 (n_conv_cbpf_c100_3 conv_bpf_c100_3) inductor l=1.000000000000e-06
RCONVBPF_c100_3 (conv_bpf_c100_3 0) resistor r=3.141592653590e+02
ECONVI_c100_3_00 (conv_i_src_c100_3_00 0 conv_bpf_c100_3 0) vcvs gain=9.807852804032e-01
SCONVI_c100_3_00 (conv_i_src_c100_3_00 conv_i_c100_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_00 (conv_q_src_c100_3_00 0 conv_bpf_c100_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_3_00 (conv_q_src_c100_3_00 conv_q_c100_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_01 (conv_i_src_c100_3_01 0 conv_bpf_c100_3 0) vcvs gain=8.314696123025e-01
SCONVI_c100_3_01 (conv_i_src_c100_3_01 conv_i_c100_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_01 (conv_q_src_c100_3_01 0 conv_bpf_c100_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_3_01 (conv_q_src_c100_3_01 conv_q_c100_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_02 (conv_i_src_c100_3_02 0 conv_bpf_c100_3 0) vcvs gain=5.555702330196e-01
SCONVI_c100_3_02 (conv_i_src_c100_3_02 conv_i_c100_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_02 (conv_q_src_c100_3_02 0 conv_bpf_c100_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_3_02 (conv_q_src_c100_3_02 conv_q_c100_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_03 (conv_i_src_c100_3_03 0 conv_bpf_c100_3 0) vcvs gain=1.950903220161e-01
SCONVI_c100_3_03 (conv_i_src_c100_3_03 conv_i_c100_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_03 (conv_q_src_c100_3_03 0 conv_bpf_c100_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_3_03 (conv_q_src_c100_3_03 conv_q_c100_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_04 (conv_i_src_c100_3_04 0 conv_bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_3_04 (conv_i_src_c100_3_04 conv_i_c100_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_04 (conv_q_src_c100_3_04 0 conv_bpf_c100_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c100_3_04 (conv_q_src_c100_3_04 conv_q_c100_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_05 (conv_i_src_c100_3_05 0 conv_bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_3_05 (conv_i_src_c100_3_05 conv_i_c100_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_05 (conv_q_src_c100_3_05 0 conv_bpf_c100_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c100_3_05 (conv_q_src_c100_3_05 conv_q_c100_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_06 (conv_i_src_c100_3_06 0 conv_bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_3_06 (conv_i_src_c100_3_06 conv_i_c100_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_06 (conv_q_src_c100_3_06 0 conv_bpf_c100_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c100_3_06 (conv_q_src_c100_3_06 conv_q_c100_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_07 (conv_i_src_c100_3_07 0 conv_bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_3_07 (conv_i_src_c100_3_07 conv_i_c100_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_07 (conv_q_src_c100_3_07 0 conv_bpf_c100_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c100_3_07 (conv_q_src_c100_3_07 conv_q_c100_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_08 (conv_i_src_c100_3_08 0 conv_bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c100_3_08 (conv_i_src_c100_3_08 conv_i_c100_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_08 (conv_q_src_c100_3_08 0 conv_bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_3_08 (conv_q_src_c100_3_08 conv_q_c100_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_09 (conv_i_src_c100_3_09 0 conv_bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c100_3_09 (conv_i_src_c100_3_09 conv_i_c100_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_09 (conv_q_src_c100_3_09 0 conv_bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_3_09 (conv_q_src_c100_3_09 conv_q_c100_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_10 (conv_i_src_c100_3_10 0 conv_bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c100_3_10 (conv_i_src_c100_3_10 conv_i_c100_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_10 (conv_q_src_c100_3_10 0 conv_bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_3_10 (conv_q_src_c100_3_10 conv_q_c100_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_11 (conv_i_src_c100_3_11 0 conv_bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c100_3_11 (conv_i_src_c100_3_11 conv_i_c100_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_11 (conv_q_src_c100_3_11 0 conv_bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_3_11 (conv_q_src_c100_3_11 conv_q_c100_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_12 (conv_i_src_c100_3_12 0 conv_bpf_c100_3 0) vcvs gain=1.950903220161e-01
SCONVI_c100_3_12 (conv_i_src_c100_3_12 conv_i_c100_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_12 (conv_q_src_c100_3_12 0 conv_bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c100_3_12 (conv_q_src_c100_3_12 conv_q_c100_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_13 (conv_i_src_c100_3_13 0 conv_bpf_c100_3 0) vcvs gain=5.555702330196e-01
SCONVI_c100_3_13 (conv_i_src_c100_3_13 conv_i_c100_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_13 (conv_q_src_c100_3_13 0 conv_bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c100_3_13 (conv_q_src_c100_3_13 conv_q_c100_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_14 (conv_i_src_c100_3_14 0 conv_bpf_c100_3 0) vcvs gain=8.314696123025e-01
SCONVI_c100_3_14 (conv_i_src_c100_3_14 conv_i_c100_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_14 (conv_q_src_c100_3_14 0 conv_bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c100_3_14 (conv_q_src_c100_3_14 conv_q_c100_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c100_3_15 (conv_i_src_c100_3_15 0 conv_bpf_c100_3 0) vcvs gain=9.807852804032e-01
SCONVI_c100_3_15 (conv_i_src_c100_3_15 conv_i_c100_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c100_3_15 (conv_q_src_c100_3_15 0 conv_bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c100_3_15 (conv_q_src_c100_3_15 conv_q_c100_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c100_3 (conv_i_c100_3 0) resistor r=1G
RCONVQ_c100_3 (conv_q_c100_3 0) resistor r=1G
RCONVINTI_c100_3 (conv_i_c100_3 ConvIcar_c100_3) resistor r=1k
CCONVINTI_c100_3 (ConvIcar_c100_3 0) capacitor c=80p
RCONVINTQ_c100_3 (conv_q_c100_3 ConvQcar_c100_3) resistor r=1k
CCONVINTQ_c100_3 (ConvQcar_c100_3 0) capacitor c=80p
save conv_bpf_c100_3 ConvIcar_c100_3 ConvQcar_c100_3

// conventional mixed baseline bl101, carrier_0: 250000000 Hz
CCONVBPF_c101_0 (bl101 n_conv_cbpf_c101_0) capacitor c=4.052847345694e-13
LCONVBPF_c101_0 (n_conv_cbpf_c101_0 conv_bpf_c101_0) inductor l=1.000000000000e-06
RCONVBPF_c101_0 (conv_bpf_c101_0 0) resistor r=7.853981633974e+01
ECONVI_c101_0_00 (conv_i_src_c101_0_00 0 conv_bpf_c101_0 0) vcvs gain=9.807852804032e-01
SCONVI_c101_0_00 (conv_i_src_c101_0_00 conv_i_c101_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_00 (conv_q_src_c101_0_00 0 conv_bpf_c101_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_0_00 (conv_q_src_c101_0_00 conv_q_c101_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_01 (conv_i_src_c101_0_01 0 conv_bpf_c101_0 0) vcvs gain=8.314696123025e-01
SCONVI_c101_0_01 (conv_i_src_c101_0_01 conv_i_c101_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_01 (conv_q_src_c101_0_01 0 conv_bpf_c101_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_0_01 (conv_q_src_c101_0_01 conv_q_c101_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_02 (conv_i_src_c101_0_02 0 conv_bpf_c101_0 0) vcvs gain=5.555702330196e-01
SCONVI_c101_0_02 (conv_i_src_c101_0_02 conv_i_c101_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_02 (conv_q_src_c101_0_02 0 conv_bpf_c101_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_0_02 (conv_q_src_c101_0_02 conv_q_c101_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_03 (conv_i_src_c101_0_03 0 conv_bpf_c101_0 0) vcvs gain=1.950903220161e-01
SCONVI_c101_0_03 (conv_i_src_c101_0_03 conv_i_c101_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_03 (conv_q_src_c101_0_03 0 conv_bpf_c101_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_0_03 (conv_q_src_c101_0_03 conv_q_c101_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_04 (conv_i_src_c101_0_04 0 conv_bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_0_04 (conv_i_src_c101_0_04 conv_i_c101_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_04 (conv_q_src_c101_0_04 0 conv_bpf_c101_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_0_04 (conv_q_src_c101_0_04 conv_q_c101_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_05 (conv_i_src_c101_0_05 0 conv_bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_0_05 (conv_i_src_c101_0_05 conv_i_c101_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_05 (conv_q_src_c101_0_05 0 conv_bpf_c101_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_0_05 (conv_q_src_c101_0_05 conv_q_c101_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_06 (conv_i_src_c101_0_06 0 conv_bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_0_06 (conv_i_src_c101_0_06 conv_i_c101_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_06 (conv_q_src_c101_0_06 0 conv_bpf_c101_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_0_06 (conv_q_src_c101_0_06 conv_q_c101_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_07 (conv_i_src_c101_0_07 0 conv_bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_0_07 (conv_i_src_c101_0_07 conv_i_c101_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_07 (conv_q_src_c101_0_07 0 conv_bpf_c101_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_0_07 (conv_q_src_c101_0_07 conv_q_c101_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_08 (conv_i_src_c101_0_08 0 conv_bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_0_08 (conv_i_src_c101_0_08 conv_i_c101_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_08 (conv_q_src_c101_0_08 0 conv_bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_0_08 (conv_q_src_c101_0_08 conv_q_c101_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_09 (conv_i_src_c101_0_09 0 conv_bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_0_09 (conv_i_src_c101_0_09 conv_i_c101_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_09 (conv_q_src_c101_0_09 0 conv_bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_0_09 (conv_q_src_c101_0_09 conv_q_c101_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_10 (conv_i_src_c101_0_10 0 conv_bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_0_10 (conv_i_src_c101_0_10 conv_i_c101_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_10 (conv_q_src_c101_0_10 0 conv_bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_0_10 (conv_q_src_c101_0_10 conv_q_c101_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_11 (conv_i_src_c101_0_11 0 conv_bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_0_11 (conv_i_src_c101_0_11 conv_i_c101_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_11 (conv_q_src_c101_0_11 0 conv_bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_0_11 (conv_q_src_c101_0_11 conv_q_c101_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_12 (conv_i_src_c101_0_12 0 conv_bpf_c101_0 0) vcvs gain=1.950903220161e-01
SCONVI_c101_0_12 (conv_i_src_c101_0_12 conv_i_c101_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_12 (conv_q_src_c101_0_12 0 conv_bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_0_12 (conv_q_src_c101_0_12 conv_q_c101_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_13 (conv_i_src_c101_0_13 0 conv_bpf_c101_0 0) vcvs gain=5.555702330196e-01
SCONVI_c101_0_13 (conv_i_src_c101_0_13 conv_i_c101_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_13 (conv_q_src_c101_0_13 0 conv_bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_0_13 (conv_q_src_c101_0_13 conv_q_c101_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_14 (conv_i_src_c101_0_14 0 conv_bpf_c101_0 0) vcvs gain=8.314696123025e-01
SCONVI_c101_0_14 (conv_i_src_c101_0_14 conv_i_c101_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_14 (conv_q_src_c101_0_14 0 conv_bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_0_14 (conv_q_src_c101_0_14 conv_q_c101_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_0_15 (conv_i_src_c101_0_15 0 conv_bpf_c101_0 0) vcvs gain=9.807852804032e-01
SCONVI_c101_0_15 (conv_i_src_c101_0_15 conv_i_c101_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_0_15 (conv_q_src_c101_0_15 0 conv_bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_0_15 (conv_q_src_c101_0_15 conv_q_c101_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c101_0 (conv_i_c101_0 0) resistor r=1G
RCONVQ_c101_0 (conv_q_c101_0 0) resistor r=1G
RCONVINTI_c101_0 (conv_i_c101_0 ConvIcar_c101_0) resistor r=1k
CCONVINTI_c101_0 (ConvIcar_c101_0 0) capacitor c=80p
RCONVINTQ_c101_0 (conv_q_c101_0 ConvQcar_c101_0) resistor r=1k
CCONVINTQ_c101_0 (ConvQcar_c101_0 0) capacitor c=80p
save conv_bpf_c101_0 ConvIcar_c101_0 ConvQcar_c101_0

// conventional mixed baseline bl101, carrier_1: 500000000 Hz
CCONVBPF_c101_1 (bl101 n_conv_cbpf_c101_1) capacitor c=1.013211836423e-13
LCONVBPF_c101_1 (n_conv_cbpf_c101_1 conv_bpf_c101_1) inductor l=1.000000000000e-06
RCONVBPF_c101_1 (conv_bpf_c101_1 0) resistor r=1.570796326795e+02
ECONVI_c101_1_00 (conv_i_src_c101_1_00 0 conv_bpf_c101_1 0) vcvs gain=9.807852804032e-01
SCONVI_c101_1_00 (conv_i_src_c101_1_00 conv_i_c101_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_00 (conv_q_src_c101_1_00 0 conv_bpf_c101_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_1_00 (conv_q_src_c101_1_00 conv_q_c101_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_01 (conv_i_src_c101_1_01 0 conv_bpf_c101_1 0) vcvs gain=8.314696123025e-01
SCONVI_c101_1_01 (conv_i_src_c101_1_01 conv_i_c101_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_01 (conv_q_src_c101_1_01 0 conv_bpf_c101_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_1_01 (conv_q_src_c101_1_01 conv_q_c101_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_02 (conv_i_src_c101_1_02 0 conv_bpf_c101_1 0) vcvs gain=5.555702330196e-01
SCONVI_c101_1_02 (conv_i_src_c101_1_02 conv_i_c101_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_02 (conv_q_src_c101_1_02 0 conv_bpf_c101_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_1_02 (conv_q_src_c101_1_02 conv_q_c101_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_03 (conv_i_src_c101_1_03 0 conv_bpf_c101_1 0) vcvs gain=1.950903220161e-01
SCONVI_c101_1_03 (conv_i_src_c101_1_03 conv_i_c101_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_03 (conv_q_src_c101_1_03 0 conv_bpf_c101_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_1_03 (conv_q_src_c101_1_03 conv_q_c101_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_04 (conv_i_src_c101_1_04 0 conv_bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_1_04 (conv_i_src_c101_1_04 conv_i_c101_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_04 (conv_q_src_c101_1_04 0 conv_bpf_c101_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_1_04 (conv_q_src_c101_1_04 conv_q_c101_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_05 (conv_i_src_c101_1_05 0 conv_bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_1_05 (conv_i_src_c101_1_05 conv_i_c101_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_05 (conv_q_src_c101_1_05 0 conv_bpf_c101_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_1_05 (conv_q_src_c101_1_05 conv_q_c101_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_06 (conv_i_src_c101_1_06 0 conv_bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_1_06 (conv_i_src_c101_1_06 conv_i_c101_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_06 (conv_q_src_c101_1_06 0 conv_bpf_c101_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_1_06 (conv_q_src_c101_1_06 conv_q_c101_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_07 (conv_i_src_c101_1_07 0 conv_bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_1_07 (conv_i_src_c101_1_07 conv_i_c101_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_07 (conv_q_src_c101_1_07 0 conv_bpf_c101_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_1_07 (conv_q_src_c101_1_07 conv_q_c101_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_08 (conv_i_src_c101_1_08 0 conv_bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_1_08 (conv_i_src_c101_1_08 conv_i_c101_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_08 (conv_q_src_c101_1_08 0 conv_bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_1_08 (conv_q_src_c101_1_08 conv_q_c101_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_09 (conv_i_src_c101_1_09 0 conv_bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_1_09 (conv_i_src_c101_1_09 conv_i_c101_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_09 (conv_q_src_c101_1_09 0 conv_bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_1_09 (conv_q_src_c101_1_09 conv_q_c101_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_10 (conv_i_src_c101_1_10 0 conv_bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_1_10 (conv_i_src_c101_1_10 conv_i_c101_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_10 (conv_q_src_c101_1_10 0 conv_bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_1_10 (conv_q_src_c101_1_10 conv_q_c101_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_11 (conv_i_src_c101_1_11 0 conv_bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_1_11 (conv_i_src_c101_1_11 conv_i_c101_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_11 (conv_q_src_c101_1_11 0 conv_bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_1_11 (conv_q_src_c101_1_11 conv_q_c101_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_12 (conv_i_src_c101_1_12 0 conv_bpf_c101_1 0) vcvs gain=1.950903220161e-01
SCONVI_c101_1_12 (conv_i_src_c101_1_12 conv_i_c101_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_12 (conv_q_src_c101_1_12 0 conv_bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_1_12 (conv_q_src_c101_1_12 conv_q_c101_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_13 (conv_i_src_c101_1_13 0 conv_bpf_c101_1 0) vcvs gain=5.555702330196e-01
SCONVI_c101_1_13 (conv_i_src_c101_1_13 conv_i_c101_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_13 (conv_q_src_c101_1_13 0 conv_bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_1_13 (conv_q_src_c101_1_13 conv_q_c101_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_14 (conv_i_src_c101_1_14 0 conv_bpf_c101_1 0) vcvs gain=8.314696123025e-01
SCONVI_c101_1_14 (conv_i_src_c101_1_14 conv_i_c101_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_14 (conv_q_src_c101_1_14 0 conv_bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_1_14 (conv_q_src_c101_1_14 conv_q_c101_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_1_15 (conv_i_src_c101_1_15 0 conv_bpf_c101_1 0) vcvs gain=9.807852804032e-01
SCONVI_c101_1_15 (conv_i_src_c101_1_15 conv_i_c101_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_1_15 (conv_q_src_c101_1_15 0 conv_bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_1_15 (conv_q_src_c101_1_15 conv_q_c101_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c101_1 (conv_i_c101_1 0) resistor r=1G
RCONVQ_c101_1 (conv_q_c101_1 0) resistor r=1G
RCONVINTI_c101_1 (conv_i_c101_1 ConvIcar_c101_1) resistor r=1k
CCONVINTI_c101_1 (ConvIcar_c101_1 0) capacitor c=80p
RCONVINTQ_c101_1 (conv_q_c101_1 ConvQcar_c101_1) resistor r=1k
CCONVINTQ_c101_1 (ConvQcar_c101_1 0) capacitor c=80p
save conv_bpf_c101_1 ConvIcar_c101_1 ConvQcar_c101_1

// conventional mixed baseline bl101, carrier_2: 750000000 Hz
CCONVBPF_c101_2 (bl101 n_conv_cbpf_c101_2) capacitor c=4.503163717437e-14
LCONVBPF_c101_2 (n_conv_cbpf_c101_2 conv_bpf_c101_2) inductor l=1.000000000000e-06
RCONVBPF_c101_2 (conv_bpf_c101_2 0) resistor r=2.356194490192e+02
ECONVI_c101_2_00 (conv_i_src_c101_2_00 0 conv_bpf_c101_2 0) vcvs gain=9.807852804032e-01
SCONVI_c101_2_00 (conv_i_src_c101_2_00 conv_i_c101_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_00 (conv_q_src_c101_2_00 0 conv_bpf_c101_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_2_00 (conv_q_src_c101_2_00 conv_q_c101_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_01 (conv_i_src_c101_2_01 0 conv_bpf_c101_2 0) vcvs gain=8.314696123025e-01
SCONVI_c101_2_01 (conv_i_src_c101_2_01 conv_i_c101_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_01 (conv_q_src_c101_2_01 0 conv_bpf_c101_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_2_01 (conv_q_src_c101_2_01 conv_q_c101_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_02 (conv_i_src_c101_2_02 0 conv_bpf_c101_2 0) vcvs gain=5.555702330196e-01
SCONVI_c101_2_02 (conv_i_src_c101_2_02 conv_i_c101_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_02 (conv_q_src_c101_2_02 0 conv_bpf_c101_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_2_02 (conv_q_src_c101_2_02 conv_q_c101_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_03 (conv_i_src_c101_2_03 0 conv_bpf_c101_2 0) vcvs gain=1.950903220161e-01
SCONVI_c101_2_03 (conv_i_src_c101_2_03 conv_i_c101_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_03 (conv_q_src_c101_2_03 0 conv_bpf_c101_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_2_03 (conv_q_src_c101_2_03 conv_q_c101_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_04 (conv_i_src_c101_2_04 0 conv_bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_2_04 (conv_i_src_c101_2_04 conv_i_c101_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_04 (conv_q_src_c101_2_04 0 conv_bpf_c101_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_2_04 (conv_q_src_c101_2_04 conv_q_c101_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_05 (conv_i_src_c101_2_05 0 conv_bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_2_05 (conv_i_src_c101_2_05 conv_i_c101_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_05 (conv_q_src_c101_2_05 0 conv_bpf_c101_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_2_05 (conv_q_src_c101_2_05 conv_q_c101_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_06 (conv_i_src_c101_2_06 0 conv_bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_2_06 (conv_i_src_c101_2_06 conv_i_c101_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_06 (conv_q_src_c101_2_06 0 conv_bpf_c101_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_2_06 (conv_q_src_c101_2_06 conv_q_c101_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_07 (conv_i_src_c101_2_07 0 conv_bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_2_07 (conv_i_src_c101_2_07 conv_i_c101_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_07 (conv_q_src_c101_2_07 0 conv_bpf_c101_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_2_07 (conv_q_src_c101_2_07 conv_q_c101_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_08 (conv_i_src_c101_2_08 0 conv_bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_2_08 (conv_i_src_c101_2_08 conv_i_c101_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_08 (conv_q_src_c101_2_08 0 conv_bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_2_08 (conv_q_src_c101_2_08 conv_q_c101_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_09 (conv_i_src_c101_2_09 0 conv_bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_2_09 (conv_i_src_c101_2_09 conv_i_c101_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_09 (conv_q_src_c101_2_09 0 conv_bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_2_09 (conv_q_src_c101_2_09 conv_q_c101_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_10 (conv_i_src_c101_2_10 0 conv_bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_2_10 (conv_i_src_c101_2_10 conv_i_c101_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_10 (conv_q_src_c101_2_10 0 conv_bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_2_10 (conv_q_src_c101_2_10 conv_q_c101_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_11 (conv_i_src_c101_2_11 0 conv_bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_2_11 (conv_i_src_c101_2_11 conv_i_c101_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_11 (conv_q_src_c101_2_11 0 conv_bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_2_11 (conv_q_src_c101_2_11 conv_q_c101_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_12 (conv_i_src_c101_2_12 0 conv_bpf_c101_2 0) vcvs gain=1.950903220161e-01
SCONVI_c101_2_12 (conv_i_src_c101_2_12 conv_i_c101_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_12 (conv_q_src_c101_2_12 0 conv_bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_2_12 (conv_q_src_c101_2_12 conv_q_c101_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_13 (conv_i_src_c101_2_13 0 conv_bpf_c101_2 0) vcvs gain=5.555702330196e-01
SCONVI_c101_2_13 (conv_i_src_c101_2_13 conv_i_c101_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_13 (conv_q_src_c101_2_13 0 conv_bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_2_13 (conv_q_src_c101_2_13 conv_q_c101_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_14 (conv_i_src_c101_2_14 0 conv_bpf_c101_2 0) vcvs gain=8.314696123025e-01
SCONVI_c101_2_14 (conv_i_src_c101_2_14 conv_i_c101_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_14 (conv_q_src_c101_2_14 0 conv_bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_2_14 (conv_q_src_c101_2_14 conv_q_c101_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_2_15 (conv_i_src_c101_2_15 0 conv_bpf_c101_2 0) vcvs gain=9.807852804032e-01
SCONVI_c101_2_15 (conv_i_src_c101_2_15 conv_i_c101_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_2_15 (conv_q_src_c101_2_15 0 conv_bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_2_15 (conv_q_src_c101_2_15 conv_q_c101_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c101_2 (conv_i_c101_2 0) resistor r=1G
RCONVQ_c101_2 (conv_q_c101_2 0) resistor r=1G
RCONVINTI_c101_2 (conv_i_c101_2 ConvIcar_c101_2) resistor r=1k
CCONVINTI_c101_2 (ConvIcar_c101_2 0) capacitor c=80p
RCONVINTQ_c101_2 (conv_q_c101_2 ConvQcar_c101_2) resistor r=1k
CCONVINTQ_c101_2 (ConvQcar_c101_2 0) capacitor c=80p
save conv_bpf_c101_2 ConvIcar_c101_2 ConvQcar_c101_2

// conventional mixed baseline bl101, carrier_3: 1000000000 Hz
CCONVBPF_c101_3 (bl101 n_conv_cbpf_c101_3) capacitor c=2.533029591058e-14
LCONVBPF_c101_3 (n_conv_cbpf_c101_3 conv_bpf_c101_3) inductor l=1.000000000000e-06
RCONVBPF_c101_3 (conv_bpf_c101_3 0) resistor r=3.141592653590e+02
ECONVI_c101_3_00 (conv_i_src_c101_3_00 0 conv_bpf_c101_3 0) vcvs gain=9.807852804032e-01
SCONVI_c101_3_00 (conv_i_src_c101_3_00 conv_i_c101_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_00 (conv_q_src_c101_3_00 0 conv_bpf_c101_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_3_00 (conv_q_src_c101_3_00 conv_q_c101_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_01 (conv_i_src_c101_3_01 0 conv_bpf_c101_3 0) vcvs gain=8.314696123025e-01
SCONVI_c101_3_01 (conv_i_src_c101_3_01 conv_i_c101_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_01 (conv_q_src_c101_3_01 0 conv_bpf_c101_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_3_01 (conv_q_src_c101_3_01 conv_q_c101_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_02 (conv_i_src_c101_3_02 0 conv_bpf_c101_3 0) vcvs gain=5.555702330196e-01
SCONVI_c101_3_02 (conv_i_src_c101_3_02 conv_i_c101_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_02 (conv_q_src_c101_3_02 0 conv_bpf_c101_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_3_02 (conv_q_src_c101_3_02 conv_q_c101_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_03 (conv_i_src_c101_3_03 0 conv_bpf_c101_3 0) vcvs gain=1.950903220161e-01
SCONVI_c101_3_03 (conv_i_src_c101_3_03 conv_i_c101_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_03 (conv_q_src_c101_3_03 0 conv_bpf_c101_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_3_03 (conv_q_src_c101_3_03 conv_q_c101_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_04 (conv_i_src_c101_3_04 0 conv_bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_3_04 (conv_i_src_c101_3_04 conv_i_c101_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_04 (conv_q_src_c101_3_04 0 conv_bpf_c101_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c101_3_04 (conv_q_src_c101_3_04 conv_q_c101_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_05 (conv_i_src_c101_3_05 0 conv_bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_3_05 (conv_i_src_c101_3_05 conv_i_c101_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_05 (conv_q_src_c101_3_05 0 conv_bpf_c101_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c101_3_05 (conv_q_src_c101_3_05 conv_q_c101_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_06 (conv_i_src_c101_3_06 0 conv_bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_3_06 (conv_i_src_c101_3_06 conv_i_c101_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_06 (conv_q_src_c101_3_06 0 conv_bpf_c101_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c101_3_06 (conv_q_src_c101_3_06 conv_q_c101_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_07 (conv_i_src_c101_3_07 0 conv_bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_3_07 (conv_i_src_c101_3_07 conv_i_c101_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_07 (conv_q_src_c101_3_07 0 conv_bpf_c101_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c101_3_07 (conv_q_src_c101_3_07 conv_q_c101_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_08 (conv_i_src_c101_3_08 0 conv_bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c101_3_08 (conv_i_src_c101_3_08 conv_i_c101_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_08 (conv_q_src_c101_3_08 0 conv_bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_3_08 (conv_q_src_c101_3_08 conv_q_c101_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_09 (conv_i_src_c101_3_09 0 conv_bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c101_3_09 (conv_i_src_c101_3_09 conv_i_c101_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_09 (conv_q_src_c101_3_09 0 conv_bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_3_09 (conv_q_src_c101_3_09 conv_q_c101_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_10 (conv_i_src_c101_3_10 0 conv_bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c101_3_10 (conv_i_src_c101_3_10 conv_i_c101_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_10 (conv_q_src_c101_3_10 0 conv_bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_3_10 (conv_q_src_c101_3_10 conv_q_c101_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_11 (conv_i_src_c101_3_11 0 conv_bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c101_3_11 (conv_i_src_c101_3_11 conv_i_c101_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_11 (conv_q_src_c101_3_11 0 conv_bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_3_11 (conv_q_src_c101_3_11 conv_q_c101_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_12 (conv_i_src_c101_3_12 0 conv_bpf_c101_3 0) vcvs gain=1.950903220161e-01
SCONVI_c101_3_12 (conv_i_src_c101_3_12 conv_i_c101_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_12 (conv_q_src_c101_3_12 0 conv_bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c101_3_12 (conv_q_src_c101_3_12 conv_q_c101_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_13 (conv_i_src_c101_3_13 0 conv_bpf_c101_3 0) vcvs gain=5.555702330196e-01
SCONVI_c101_3_13 (conv_i_src_c101_3_13 conv_i_c101_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_13 (conv_q_src_c101_3_13 0 conv_bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c101_3_13 (conv_q_src_c101_3_13 conv_q_c101_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_14 (conv_i_src_c101_3_14 0 conv_bpf_c101_3 0) vcvs gain=8.314696123025e-01
SCONVI_c101_3_14 (conv_i_src_c101_3_14 conv_i_c101_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_14 (conv_q_src_c101_3_14 0 conv_bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c101_3_14 (conv_q_src_c101_3_14 conv_q_c101_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c101_3_15 (conv_i_src_c101_3_15 0 conv_bpf_c101_3 0) vcvs gain=9.807852804032e-01
SCONVI_c101_3_15 (conv_i_src_c101_3_15 conv_i_c101_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c101_3_15 (conv_q_src_c101_3_15 0 conv_bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c101_3_15 (conv_q_src_c101_3_15 conv_q_c101_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c101_3 (conv_i_c101_3 0) resistor r=1G
RCONVQ_c101_3 (conv_q_c101_3 0) resistor r=1G
RCONVINTI_c101_3 (conv_i_c101_3 ConvIcar_c101_3) resistor r=1k
CCONVINTI_c101_3 (ConvIcar_c101_3 0) capacitor c=80p
RCONVINTQ_c101_3 (conv_q_c101_3 ConvQcar_c101_3) resistor r=1k
CCONVINTQ_c101_3 (ConvQcar_c101_3 0) capacitor c=80p
save conv_bpf_c101_3 ConvIcar_c101_3 ConvQcar_c101_3

// conventional mixed baseline bl102, carrier_0: 250000000 Hz
CCONVBPF_c102_0 (bl102 n_conv_cbpf_c102_0) capacitor c=4.052847345694e-13
LCONVBPF_c102_0 (n_conv_cbpf_c102_0 conv_bpf_c102_0) inductor l=1.000000000000e-06
RCONVBPF_c102_0 (conv_bpf_c102_0 0) resistor r=7.853981633974e+01
ECONVI_c102_0_00 (conv_i_src_c102_0_00 0 conv_bpf_c102_0 0) vcvs gain=9.807852804032e-01
SCONVI_c102_0_00 (conv_i_src_c102_0_00 conv_i_c102_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_00 (conv_q_src_c102_0_00 0 conv_bpf_c102_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_0_00 (conv_q_src_c102_0_00 conv_q_c102_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_01 (conv_i_src_c102_0_01 0 conv_bpf_c102_0 0) vcvs gain=8.314696123025e-01
SCONVI_c102_0_01 (conv_i_src_c102_0_01 conv_i_c102_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_01 (conv_q_src_c102_0_01 0 conv_bpf_c102_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_0_01 (conv_q_src_c102_0_01 conv_q_c102_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_02 (conv_i_src_c102_0_02 0 conv_bpf_c102_0 0) vcvs gain=5.555702330196e-01
SCONVI_c102_0_02 (conv_i_src_c102_0_02 conv_i_c102_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_02 (conv_q_src_c102_0_02 0 conv_bpf_c102_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_0_02 (conv_q_src_c102_0_02 conv_q_c102_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_03 (conv_i_src_c102_0_03 0 conv_bpf_c102_0 0) vcvs gain=1.950903220161e-01
SCONVI_c102_0_03 (conv_i_src_c102_0_03 conv_i_c102_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_03 (conv_q_src_c102_0_03 0 conv_bpf_c102_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_0_03 (conv_q_src_c102_0_03 conv_q_c102_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_04 (conv_i_src_c102_0_04 0 conv_bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_0_04 (conv_i_src_c102_0_04 conv_i_c102_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_04 (conv_q_src_c102_0_04 0 conv_bpf_c102_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_0_04 (conv_q_src_c102_0_04 conv_q_c102_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_05 (conv_i_src_c102_0_05 0 conv_bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_0_05 (conv_i_src_c102_0_05 conv_i_c102_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_05 (conv_q_src_c102_0_05 0 conv_bpf_c102_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_0_05 (conv_q_src_c102_0_05 conv_q_c102_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_06 (conv_i_src_c102_0_06 0 conv_bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_0_06 (conv_i_src_c102_0_06 conv_i_c102_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_06 (conv_q_src_c102_0_06 0 conv_bpf_c102_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_0_06 (conv_q_src_c102_0_06 conv_q_c102_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_07 (conv_i_src_c102_0_07 0 conv_bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_0_07 (conv_i_src_c102_0_07 conv_i_c102_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_07 (conv_q_src_c102_0_07 0 conv_bpf_c102_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_0_07 (conv_q_src_c102_0_07 conv_q_c102_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_08 (conv_i_src_c102_0_08 0 conv_bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_0_08 (conv_i_src_c102_0_08 conv_i_c102_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_08 (conv_q_src_c102_0_08 0 conv_bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_0_08 (conv_q_src_c102_0_08 conv_q_c102_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_09 (conv_i_src_c102_0_09 0 conv_bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_0_09 (conv_i_src_c102_0_09 conv_i_c102_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_09 (conv_q_src_c102_0_09 0 conv_bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_0_09 (conv_q_src_c102_0_09 conv_q_c102_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_10 (conv_i_src_c102_0_10 0 conv_bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_0_10 (conv_i_src_c102_0_10 conv_i_c102_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_10 (conv_q_src_c102_0_10 0 conv_bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_0_10 (conv_q_src_c102_0_10 conv_q_c102_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_11 (conv_i_src_c102_0_11 0 conv_bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_0_11 (conv_i_src_c102_0_11 conv_i_c102_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_11 (conv_q_src_c102_0_11 0 conv_bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_0_11 (conv_q_src_c102_0_11 conv_q_c102_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_12 (conv_i_src_c102_0_12 0 conv_bpf_c102_0 0) vcvs gain=1.950903220161e-01
SCONVI_c102_0_12 (conv_i_src_c102_0_12 conv_i_c102_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_12 (conv_q_src_c102_0_12 0 conv_bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_0_12 (conv_q_src_c102_0_12 conv_q_c102_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_13 (conv_i_src_c102_0_13 0 conv_bpf_c102_0 0) vcvs gain=5.555702330196e-01
SCONVI_c102_0_13 (conv_i_src_c102_0_13 conv_i_c102_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_13 (conv_q_src_c102_0_13 0 conv_bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_0_13 (conv_q_src_c102_0_13 conv_q_c102_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_14 (conv_i_src_c102_0_14 0 conv_bpf_c102_0 0) vcvs gain=8.314696123025e-01
SCONVI_c102_0_14 (conv_i_src_c102_0_14 conv_i_c102_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_14 (conv_q_src_c102_0_14 0 conv_bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_0_14 (conv_q_src_c102_0_14 conv_q_c102_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_0_15 (conv_i_src_c102_0_15 0 conv_bpf_c102_0 0) vcvs gain=9.807852804032e-01
SCONVI_c102_0_15 (conv_i_src_c102_0_15 conv_i_c102_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_0_15 (conv_q_src_c102_0_15 0 conv_bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_0_15 (conv_q_src_c102_0_15 conv_q_c102_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c102_0 (conv_i_c102_0 0) resistor r=1G
RCONVQ_c102_0 (conv_q_c102_0 0) resistor r=1G
RCONVINTI_c102_0 (conv_i_c102_0 ConvIcar_c102_0) resistor r=1k
CCONVINTI_c102_0 (ConvIcar_c102_0 0) capacitor c=80p
RCONVINTQ_c102_0 (conv_q_c102_0 ConvQcar_c102_0) resistor r=1k
CCONVINTQ_c102_0 (ConvQcar_c102_0 0) capacitor c=80p
save conv_bpf_c102_0 ConvIcar_c102_0 ConvQcar_c102_0

// conventional mixed baseline bl102, carrier_1: 500000000 Hz
CCONVBPF_c102_1 (bl102 n_conv_cbpf_c102_1) capacitor c=1.013211836423e-13
LCONVBPF_c102_1 (n_conv_cbpf_c102_1 conv_bpf_c102_1) inductor l=1.000000000000e-06
RCONVBPF_c102_1 (conv_bpf_c102_1 0) resistor r=1.570796326795e+02
ECONVI_c102_1_00 (conv_i_src_c102_1_00 0 conv_bpf_c102_1 0) vcvs gain=9.807852804032e-01
SCONVI_c102_1_00 (conv_i_src_c102_1_00 conv_i_c102_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_00 (conv_q_src_c102_1_00 0 conv_bpf_c102_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_1_00 (conv_q_src_c102_1_00 conv_q_c102_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_01 (conv_i_src_c102_1_01 0 conv_bpf_c102_1 0) vcvs gain=8.314696123025e-01
SCONVI_c102_1_01 (conv_i_src_c102_1_01 conv_i_c102_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_01 (conv_q_src_c102_1_01 0 conv_bpf_c102_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_1_01 (conv_q_src_c102_1_01 conv_q_c102_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_02 (conv_i_src_c102_1_02 0 conv_bpf_c102_1 0) vcvs gain=5.555702330196e-01
SCONVI_c102_1_02 (conv_i_src_c102_1_02 conv_i_c102_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_02 (conv_q_src_c102_1_02 0 conv_bpf_c102_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_1_02 (conv_q_src_c102_1_02 conv_q_c102_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_03 (conv_i_src_c102_1_03 0 conv_bpf_c102_1 0) vcvs gain=1.950903220161e-01
SCONVI_c102_1_03 (conv_i_src_c102_1_03 conv_i_c102_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_03 (conv_q_src_c102_1_03 0 conv_bpf_c102_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_1_03 (conv_q_src_c102_1_03 conv_q_c102_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_04 (conv_i_src_c102_1_04 0 conv_bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_1_04 (conv_i_src_c102_1_04 conv_i_c102_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_04 (conv_q_src_c102_1_04 0 conv_bpf_c102_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_1_04 (conv_q_src_c102_1_04 conv_q_c102_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_05 (conv_i_src_c102_1_05 0 conv_bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_1_05 (conv_i_src_c102_1_05 conv_i_c102_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_05 (conv_q_src_c102_1_05 0 conv_bpf_c102_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_1_05 (conv_q_src_c102_1_05 conv_q_c102_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_06 (conv_i_src_c102_1_06 0 conv_bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_1_06 (conv_i_src_c102_1_06 conv_i_c102_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_06 (conv_q_src_c102_1_06 0 conv_bpf_c102_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_1_06 (conv_q_src_c102_1_06 conv_q_c102_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_07 (conv_i_src_c102_1_07 0 conv_bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_1_07 (conv_i_src_c102_1_07 conv_i_c102_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_07 (conv_q_src_c102_1_07 0 conv_bpf_c102_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_1_07 (conv_q_src_c102_1_07 conv_q_c102_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_08 (conv_i_src_c102_1_08 0 conv_bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_1_08 (conv_i_src_c102_1_08 conv_i_c102_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_08 (conv_q_src_c102_1_08 0 conv_bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_1_08 (conv_q_src_c102_1_08 conv_q_c102_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_09 (conv_i_src_c102_1_09 0 conv_bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_1_09 (conv_i_src_c102_1_09 conv_i_c102_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_09 (conv_q_src_c102_1_09 0 conv_bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_1_09 (conv_q_src_c102_1_09 conv_q_c102_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_10 (conv_i_src_c102_1_10 0 conv_bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_1_10 (conv_i_src_c102_1_10 conv_i_c102_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_10 (conv_q_src_c102_1_10 0 conv_bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_1_10 (conv_q_src_c102_1_10 conv_q_c102_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_11 (conv_i_src_c102_1_11 0 conv_bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_1_11 (conv_i_src_c102_1_11 conv_i_c102_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_11 (conv_q_src_c102_1_11 0 conv_bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_1_11 (conv_q_src_c102_1_11 conv_q_c102_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_12 (conv_i_src_c102_1_12 0 conv_bpf_c102_1 0) vcvs gain=1.950903220161e-01
SCONVI_c102_1_12 (conv_i_src_c102_1_12 conv_i_c102_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_12 (conv_q_src_c102_1_12 0 conv_bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_1_12 (conv_q_src_c102_1_12 conv_q_c102_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_13 (conv_i_src_c102_1_13 0 conv_bpf_c102_1 0) vcvs gain=5.555702330196e-01
SCONVI_c102_1_13 (conv_i_src_c102_1_13 conv_i_c102_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_13 (conv_q_src_c102_1_13 0 conv_bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_1_13 (conv_q_src_c102_1_13 conv_q_c102_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_14 (conv_i_src_c102_1_14 0 conv_bpf_c102_1 0) vcvs gain=8.314696123025e-01
SCONVI_c102_1_14 (conv_i_src_c102_1_14 conv_i_c102_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_14 (conv_q_src_c102_1_14 0 conv_bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_1_14 (conv_q_src_c102_1_14 conv_q_c102_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_1_15 (conv_i_src_c102_1_15 0 conv_bpf_c102_1 0) vcvs gain=9.807852804032e-01
SCONVI_c102_1_15 (conv_i_src_c102_1_15 conv_i_c102_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_1_15 (conv_q_src_c102_1_15 0 conv_bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_1_15 (conv_q_src_c102_1_15 conv_q_c102_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c102_1 (conv_i_c102_1 0) resistor r=1G
RCONVQ_c102_1 (conv_q_c102_1 0) resistor r=1G
RCONVINTI_c102_1 (conv_i_c102_1 ConvIcar_c102_1) resistor r=1k
CCONVINTI_c102_1 (ConvIcar_c102_1 0) capacitor c=80p
RCONVINTQ_c102_1 (conv_q_c102_1 ConvQcar_c102_1) resistor r=1k
CCONVINTQ_c102_1 (ConvQcar_c102_1 0) capacitor c=80p
save conv_bpf_c102_1 ConvIcar_c102_1 ConvQcar_c102_1

// conventional mixed baseline bl102, carrier_2: 750000000 Hz
CCONVBPF_c102_2 (bl102 n_conv_cbpf_c102_2) capacitor c=4.503163717437e-14
LCONVBPF_c102_2 (n_conv_cbpf_c102_2 conv_bpf_c102_2) inductor l=1.000000000000e-06
RCONVBPF_c102_2 (conv_bpf_c102_2 0) resistor r=2.356194490192e+02
ECONVI_c102_2_00 (conv_i_src_c102_2_00 0 conv_bpf_c102_2 0) vcvs gain=9.807852804032e-01
SCONVI_c102_2_00 (conv_i_src_c102_2_00 conv_i_c102_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_00 (conv_q_src_c102_2_00 0 conv_bpf_c102_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_2_00 (conv_q_src_c102_2_00 conv_q_c102_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_01 (conv_i_src_c102_2_01 0 conv_bpf_c102_2 0) vcvs gain=8.314696123025e-01
SCONVI_c102_2_01 (conv_i_src_c102_2_01 conv_i_c102_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_01 (conv_q_src_c102_2_01 0 conv_bpf_c102_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_2_01 (conv_q_src_c102_2_01 conv_q_c102_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_02 (conv_i_src_c102_2_02 0 conv_bpf_c102_2 0) vcvs gain=5.555702330196e-01
SCONVI_c102_2_02 (conv_i_src_c102_2_02 conv_i_c102_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_02 (conv_q_src_c102_2_02 0 conv_bpf_c102_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_2_02 (conv_q_src_c102_2_02 conv_q_c102_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_03 (conv_i_src_c102_2_03 0 conv_bpf_c102_2 0) vcvs gain=1.950903220161e-01
SCONVI_c102_2_03 (conv_i_src_c102_2_03 conv_i_c102_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_03 (conv_q_src_c102_2_03 0 conv_bpf_c102_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_2_03 (conv_q_src_c102_2_03 conv_q_c102_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_04 (conv_i_src_c102_2_04 0 conv_bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_2_04 (conv_i_src_c102_2_04 conv_i_c102_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_04 (conv_q_src_c102_2_04 0 conv_bpf_c102_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_2_04 (conv_q_src_c102_2_04 conv_q_c102_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_05 (conv_i_src_c102_2_05 0 conv_bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_2_05 (conv_i_src_c102_2_05 conv_i_c102_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_05 (conv_q_src_c102_2_05 0 conv_bpf_c102_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_2_05 (conv_q_src_c102_2_05 conv_q_c102_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_06 (conv_i_src_c102_2_06 0 conv_bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_2_06 (conv_i_src_c102_2_06 conv_i_c102_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_06 (conv_q_src_c102_2_06 0 conv_bpf_c102_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_2_06 (conv_q_src_c102_2_06 conv_q_c102_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_07 (conv_i_src_c102_2_07 0 conv_bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_2_07 (conv_i_src_c102_2_07 conv_i_c102_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_07 (conv_q_src_c102_2_07 0 conv_bpf_c102_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_2_07 (conv_q_src_c102_2_07 conv_q_c102_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_08 (conv_i_src_c102_2_08 0 conv_bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_2_08 (conv_i_src_c102_2_08 conv_i_c102_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_08 (conv_q_src_c102_2_08 0 conv_bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_2_08 (conv_q_src_c102_2_08 conv_q_c102_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_09 (conv_i_src_c102_2_09 0 conv_bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_2_09 (conv_i_src_c102_2_09 conv_i_c102_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_09 (conv_q_src_c102_2_09 0 conv_bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_2_09 (conv_q_src_c102_2_09 conv_q_c102_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_10 (conv_i_src_c102_2_10 0 conv_bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_2_10 (conv_i_src_c102_2_10 conv_i_c102_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_10 (conv_q_src_c102_2_10 0 conv_bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_2_10 (conv_q_src_c102_2_10 conv_q_c102_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_11 (conv_i_src_c102_2_11 0 conv_bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_2_11 (conv_i_src_c102_2_11 conv_i_c102_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_11 (conv_q_src_c102_2_11 0 conv_bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_2_11 (conv_q_src_c102_2_11 conv_q_c102_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_12 (conv_i_src_c102_2_12 0 conv_bpf_c102_2 0) vcvs gain=1.950903220161e-01
SCONVI_c102_2_12 (conv_i_src_c102_2_12 conv_i_c102_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_12 (conv_q_src_c102_2_12 0 conv_bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_2_12 (conv_q_src_c102_2_12 conv_q_c102_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_13 (conv_i_src_c102_2_13 0 conv_bpf_c102_2 0) vcvs gain=5.555702330196e-01
SCONVI_c102_2_13 (conv_i_src_c102_2_13 conv_i_c102_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_13 (conv_q_src_c102_2_13 0 conv_bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_2_13 (conv_q_src_c102_2_13 conv_q_c102_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_14 (conv_i_src_c102_2_14 0 conv_bpf_c102_2 0) vcvs gain=8.314696123025e-01
SCONVI_c102_2_14 (conv_i_src_c102_2_14 conv_i_c102_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_14 (conv_q_src_c102_2_14 0 conv_bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_2_14 (conv_q_src_c102_2_14 conv_q_c102_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_2_15 (conv_i_src_c102_2_15 0 conv_bpf_c102_2 0) vcvs gain=9.807852804032e-01
SCONVI_c102_2_15 (conv_i_src_c102_2_15 conv_i_c102_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_2_15 (conv_q_src_c102_2_15 0 conv_bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_2_15 (conv_q_src_c102_2_15 conv_q_c102_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c102_2 (conv_i_c102_2 0) resistor r=1G
RCONVQ_c102_2 (conv_q_c102_2 0) resistor r=1G
RCONVINTI_c102_2 (conv_i_c102_2 ConvIcar_c102_2) resistor r=1k
CCONVINTI_c102_2 (ConvIcar_c102_2 0) capacitor c=80p
RCONVINTQ_c102_2 (conv_q_c102_2 ConvQcar_c102_2) resistor r=1k
CCONVINTQ_c102_2 (ConvQcar_c102_2 0) capacitor c=80p
save conv_bpf_c102_2 ConvIcar_c102_2 ConvQcar_c102_2

// conventional mixed baseline bl102, carrier_3: 1000000000 Hz
CCONVBPF_c102_3 (bl102 n_conv_cbpf_c102_3) capacitor c=2.533029591058e-14
LCONVBPF_c102_3 (n_conv_cbpf_c102_3 conv_bpf_c102_3) inductor l=1.000000000000e-06
RCONVBPF_c102_3 (conv_bpf_c102_3 0) resistor r=3.141592653590e+02
ECONVI_c102_3_00 (conv_i_src_c102_3_00 0 conv_bpf_c102_3 0) vcvs gain=9.807852804032e-01
SCONVI_c102_3_00 (conv_i_src_c102_3_00 conv_i_c102_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_00 (conv_q_src_c102_3_00 0 conv_bpf_c102_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_3_00 (conv_q_src_c102_3_00 conv_q_c102_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_01 (conv_i_src_c102_3_01 0 conv_bpf_c102_3 0) vcvs gain=8.314696123025e-01
SCONVI_c102_3_01 (conv_i_src_c102_3_01 conv_i_c102_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_01 (conv_q_src_c102_3_01 0 conv_bpf_c102_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_3_01 (conv_q_src_c102_3_01 conv_q_c102_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_02 (conv_i_src_c102_3_02 0 conv_bpf_c102_3 0) vcvs gain=5.555702330196e-01
SCONVI_c102_3_02 (conv_i_src_c102_3_02 conv_i_c102_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_02 (conv_q_src_c102_3_02 0 conv_bpf_c102_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_3_02 (conv_q_src_c102_3_02 conv_q_c102_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_03 (conv_i_src_c102_3_03 0 conv_bpf_c102_3 0) vcvs gain=1.950903220161e-01
SCONVI_c102_3_03 (conv_i_src_c102_3_03 conv_i_c102_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_03 (conv_q_src_c102_3_03 0 conv_bpf_c102_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_3_03 (conv_q_src_c102_3_03 conv_q_c102_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_04 (conv_i_src_c102_3_04 0 conv_bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_3_04 (conv_i_src_c102_3_04 conv_i_c102_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_04 (conv_q_src_c102_3_04 0 conv_bpf_c102_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c102_3_04 (conv_q_src_c102_3_04 conv_q_c102_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_05 (conv_i_src_c102_3_05 0 conv_bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_3_05 (conv_i_src_c102_3_05 conv_i_c102_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_05 (conv_q_src_c102_3_05 0 conv_bpf_c102_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c102_3_05 (conv_q_src_c102_3_05 conv_q_c102_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_06 (conv_i_src_c102_3_06 0 conv_bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_3_06 (conv_i_src_c102_3_06 conv_i_c102_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_06 (conv_q_src_c102_3_06 0 conv_bpf_c102_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c102_3_06 (conv_q_src_c102_3_06 conv_q_c102_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_07 (conv_i_src_c102_3_07 0 conv_bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_3_07 (conv_i_src_c102_3_07 conv_i_c102_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_07 (conv_q_src_c102_3_07 0 conv_bpf_c102_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c102_3_07 (conv_q_src_c102_3_07 conv_q_c102_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_08 (conv_i_src_c102_3_08 0 conv_bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c102_3_08 (conv_i_src_c102_3_08 conv_i_c102_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_08 (conv_q_src_c102_3_08 0 conv_bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_3_08 (conv_q_src_c102_3_08 conv_q_c102_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_09 (conv_i_src_c102_3_09 0 conv_bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c102_3_09 (conv_i_src_c102_3_09 conv_i_c102_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_09 (conv_q_src_c102_3_09 0 conv_bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_3_09 (conv_q_src_c102_3_09 conv_q_c102_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_10 (conv_i_src_c102_3_10 0 conv_bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c102_3_10 (conv_i_src_c102_3_10 conv_i_c102_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_10 (conv_q_src_c102_3_10 0 conv_bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_3_10 (conv_q_src_c102_3_10 conv_q_c102_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_11 (conv_i_src_c102_3_11 0 conv_bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c102_3_11 (conv_i_src_c102_3_11 conv_i_c102_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_11 (conv_q_src_c102_3_11 0 conv_bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_3_11 (conv_q_src_c102_3_11 conv_q_c102_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_12 (conv_i_src_c102_3_12 0 conv_bpf_c102_3 0) vcvs gain=1.950903220161e-01
SCONVI_c102_3_12 (conv_i_src_c102_3_12 conv_i_c102_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_12 (conv_q_src_c102_3_12 0 conv_bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c102_3_12 (conv_q_src_c102_3_12 conv_q_c102_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_13 (conv_i_src_c102_3_13 0 conv_bpf_c102_3 0) vcvs gain=5.555702330196e-01
SCONVI_c102_3_13 (conv_i_src_c102_3_13 conv_i_c102_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_13 (conv_q_src_c102_3_13 0 conv_bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c102_3_13 (conv_q_src_c102_3_13 conv_q_c102_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_14 (conv_i_src_c102_3_14 0 conv_bpf_c102_3 0) vcvs gain=8.314696123025e-01
SCONVI_c102_3_14 (conv_i_src_c102_3_14 conv_i_c102_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_14 (conv_q_src_c102_3_14 0 conv_bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c102_3_14 (conv_q_src_c102_3_14 conv_q_c102_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c102_3_15 (conv_i_src_c102_3_15 0 conv_bpf_c102_3 0) vcvs gain=9.807852804032e-01
SCONVI_c102_3_15 (conv_i_src_c102_3_15 conv_i_c102_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c102_3_15 (conv_q_src_c102_3_15 0 conv_bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c102_3_15 (conv_q_src_c102_3_15 conv_q_c102_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c102_3 (conv_i_c102_3 0) resistor r=1G
RCONVQ_c102_3 (conv_q_c102_3 0) resistor r=1G
RCONVINTI_c102_3 (conv_i_c102_3 ConvIcar_c102_3) resistor r=1k
CCONVINTI_c102_3 (ConvIcar_c102_3 0) capacitor c=80p
RCONVINTQ_c102_3 (conv_q_c102_3 ConvQcar_c102_3) resistor r=1k
CCONVINTQ_c102_3 (ConvQcar_c102_3 0) capacitor c=80p
save conv_bpf_c102_3 ConvIcar_c102_3 ConvQcar_c102_3

// conventional mixed baseline bl103, carrier_0: 250000000 Hz
CCONVBPF_c103_0 (bl103 n_conv_cbpf_c103_0) capacitor c=4.052847345694e-13
LCONVBPF_c103_0 (n_conv_cbpf_c103_0 conv_bpf_c103_0) inductor l=1.000000000000e-06
RCONVBPF_c103_0 (conv_bpf_c103_0 0) resistor r=7.853981633974e+01
ECONVI_c103_0_00 (conv_i_src_c103_0_00 0 conv_bpf_c103_0 0) vcvs gain=9.807852804032e-01
SCONVI_c103_0_00 (conv_i_src_c103_0_00 conv_i_c103_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_00 (conv_q_src_c103_0_00 0 conv_bpf_c103_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_0_00 (conv_q_src_c103_0_00 conv_q_c103_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_01 (conv_i_src_c103_0_01 0 conv_bpf_c103_0 0) vcvs gain=8.314696123025e-01
SCONVI_c103_0_01 (conv_i_src_c103_0_01 conv_i_c103_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_01 (conv_q_src_c103_0_01 0 conv_bpf_c103_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_0_01 (conv_q_src_c103_0_01 conv_q_c103_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_02 (conv_i_src_c103_0_02 0 conv_bpf_c103_0 0) vcvs gain=5.555702330196e-01
SCONVI_c103_0_02 (conv_i_src_c103_0_02 conv_i_c103_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_02 (conv_q_src_c103_0_02 0 conv_bpf_c103_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_0_02 (conv_q_src_c103_0_02 conv_q_c103_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_03 (conv_i_src_c103_0_03 0 conv_bpf_c103_0 0) vcvs gain=1.950903220161e-01
SCONVI_c103_0_03 (conv_i_src_c103_0_03 conv_i_c103_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_03 (conv_q_src_c103_0_03 0 conv_bpf_c103_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_0_03 (conv_q_src_c103_0_03 conv_q_c103_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_04 (conv_i_src_c103_0_04 0 conv_bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_0_04 (conv_i_src_c103_0_04 conv_i_c103_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_04 (conv_q_src_c103_0_04 0 conv_bpf_c103_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_0_04 (conv_q_src_c103_0_04 conv_q_c103_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_05 (conv_i_src_c103_0_05 0 conv_bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_0_05 (conv_i_src_c103_0_05 conv_i_c103_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_05 (conv_q_src_c103_0_05 0 conv_bpf_c103_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_0_05 (conv_q_src_c103_0_05 conv_q_c103_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_06 (conv_i_src_c103_0_06 0 conv_bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_0_06 (conv_i_src_c103_0_06 conv_i_c103_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_06 (conv_q_src_c103_0_06 0 conv_bpf_c103_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_0_06 (conv_q_src_c103_0_06 conv_q_c103_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_07 (conv_i_src_c103_0_07 0 conv_bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_0_07 (conv_i_src_c103_0_07 conv_i_c103_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_07 (conv_q_src_c103_0_07 0 conv_bpf_c103_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_0_07 (conv_q_src_c103_0_07 conv_q_c103_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_08 (conv_i_src_c103_0_08 0 conv_bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_0_08 (conv_i_src_c103_0_08 conv_i_c103_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_08 (conv_q_src_c103_0_08 0 conv_bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_0_08 (conv_q_src_c103_0_08 conv_q_c103_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_09 (conv_i_src_c103_0_09 0 conv_bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_0_09 (conv_i_src_c103_0_09 conv_i_c103_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_09 (conv_q_src_c103_0_09 0 conv_bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_0_09 (conv_q_src_c103_0_09 conv_q_c103_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_10 (conv_i_src_c103_0_10 0 conv_bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_0_10 (conv_i_src_c103_0_10 conv_i_c103_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_10 (conv_q_src_c103_0_10 0 conv_bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_0_10 (conv_q_src_c103_0_10 conv_q_c103_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_11 (conv_i_src_c103_0_11 0 conv_bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_0_11 (conv_i_src_c103_0_11 conv_i_c103_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_11 (conv_q_src_c103_0_11 0 conv_bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_0_11 (conv_q_src_c103_0_11 conv_q_c103_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_12 (conv_i_src_c103_0_12 0 conv_bpf_c103_0 0) vcvs gain=1.950903220161e-01
SCONVI_c103_0_12 (conv_i_src_c103_0_12 conv_i_c103_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_12 (conv_q_src_c103_0_12 0 conv_bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_0_12 (conv_q_src_c103_0_12 conv_q_c103_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_13 (conv_i_src_c103_0_13 0 conv_bpf_c103_0 0) vcvs gain=5.555702330196e-01
SCONVI_c103_0_13 (conv_i_src_c103_0_13 conv_i_c103_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_13 (conv_q_src_c103_0_13 0 conv_bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_0_13 (conv_q_src_c103_0_13 conv_q_c103_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_14 (conv_i_src_c103_0_14 0 conv_bpf_c103_0 0) vcvs gain=8.314696123025e-01
SCONVI_c103_0_14 (conv_i_src_c103_0_14 conv_i_c103_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_14 (conv_q_src_c103_0_14 0 conv_bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_0_14 (conv_q_src_c103_0_14 conv_q_c103_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_0_15 (conv_i_src_c103_0_15 0 conv_bpf_c103_0 0) vcvs gain=9.807852804032e-01
SCONVI_c103_0_15 (conv_i_src_c103_0_15 conv_i_c103_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_0_15 (conv_q_src_c103_0_15 0 conv_bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_0_15 (conv_q_src_c103_0_15 conv_q_c103_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c103_0 (conv_i_c103_0 0) resistor r=1G
RCONVQ_c103_0 (conv_q_c103_0 0) resistor r=1G
RCONVINTI_c103_0 (conv_i_c103_0 ConvIcar_c103_0) resistor r=1k
CCONVINTI_c103_0 (ConvIcar_c103_0 0) capacitor c=80p
RCONVINTQ_c103_0 (conv_q_c103_0 ConvQcar_c103_0) resistor r=1k
CCONVINTQ_c103_0 (ConvQcar_c103_0 0) capacitor c=80p
save conv_bpf_c103_0 ConvIcar_c103_0 ConvQcar_c103_0

// conventional mixed baseline bl103, carrier_1: 500000000 Hz
CCONVBPF_c103_1 (bl103 n_conv_cbpf_c103_1) capacitor c=1.013211836423e-13
LCONVBPF_c103_1 (n_conv_cbpf_c103_1 conv_bpf_c103_1) inductor l=1.000000000000e-06
RCONVBPF_c103_1 (conv_bpf_c103_1 0) resistor r=1.570796326795e+02
ECONVI_c103_1_00 (conv_i_src_c103_1_00 0 conv_bpf_c103_1 0) vcvs gain=9.807852804032e-01
SCONVI_c103_1_00 (conv_i_src_c103_1_00 conv_i_c103_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_00 (conv_q_src_c103_1_00 0 conv_bpf_c103_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_1_00 (conv_q_src_c103_1_00 conv_q_c103_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_01 (conv_i_src_c103_1_01 0 conv_bpf_c103_1 0) vcvs gain=8.314696123025e-01
SCONVI_c103_1_01 (conv_i_src_c103_1_01 conv_i_c103_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_01 (conv_q_src_c103_1_01 0 conv_bpf_c103_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_1_01 (conv_q_src_c103_1_01 conv_q_c103_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_02 (conv_i_src_c103_1_02 0 conv_bpf_c103_1 0) vcvs gain=5.555702330196e-01
SCONVI_c103_1_02 (conv_i_src_c103_1_02 conv_i_c103_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_02 (conv_q_src_c103_1_02 0 conv_bpf_c103_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_1_02 (conv_q_src_c103_1_02 conv_q_c103_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_03 (conv_i_src_c103_1_03 0 conv_bpf_c103_1 0) vcvs gain=1.950903220161e-01
SCONVI_c103_1_03 (conv_i_src_c103_1_03 conv_i_c103_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_03 (conv_q_src_c103_1_03 0 conv_bpf_c103_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_1_03 (conv_q_src_c103_1_03 conv_q_c103_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_04 (conv_i_src_c103_1_04 0 conv_bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_1_04 (conv_i_src_c103_1_04 conv_i_c103_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_04 (conv_q_src_c103_1_04 0 conv_bpf_c103_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_1_04 (conv_q_src_c103_1_04 conv_q_c103_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_05 (conv_i_src_c103_1_05 0 conv_bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_1_05 (conv_i_src_c103_1_05 conv_i_c103_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_05 (conv_q_src_c103_1_05 0 conv_bpf_c103_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_1_05 (conv_q_src_c103_1_05 conv_q_c103_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_06 (conv_i_src_c103_1_06 0 conv_bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_1_06 (conv_i_src_c103_1_06 conv_i_c103_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_06 (conv_q_src_c103_1_06 0 conv_bpf_c103_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_1_06 (conv_q_src_c103_1_06 conv_q_c103_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_07 (conv_i_src_c103_1_07 0 conv_bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_1_07 (conv_i_src_c103_1_07 conv_i_c103_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_07 (conv_q_src_c103_1_07 0 conv_bpf_c103_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_1_07 (conv_q_src_c103_1_07 conv_q_c103_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_08 (conv_i_src_c103_1_08 0 conv_bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_1_08 (conv_i_src_c103_1_08 conv_i_c103_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_08 (conv_q_src_c103_1_08 0 conv_bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_1_08 (conv_q_src_c103_1_08 conv_q_c103_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_09 (conv_i_src_c103_1_09 0 conv_bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_1_09 (conv_i_src_c103_1_09 conv_i_c103_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_09 (conv_q_src_c103_1_09 0 conv_bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_1_09 (conv_q_src_c103_1_09 conv_q_c103_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_10 (conv_i_src_c103_1_10 0 conv_bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_1_10 (conv_i_src_c103_1_10 conv_i_c103_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_10 (conv_q_src_c103_1_10 0 conv_bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_1_10 (conv_q_src_c103_1_10 conv_q_c103_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_11 (conv_i_src_c103_1_11 0 conv_bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_1_11 (conv_i_src_c103_1_11 conv_i_c103_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_11 (conv_q_src_c103_1_11 0 conv_bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_1_11 (conv_q_src_c103_1_11 conv_q_c103_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_12 (conv_i_src_c103_1_12 0 conv_bpf_c103_1 0) vcvs gain=1.950903220161e-01
SCONVI_c103_1_12 (conv_i_src_c103_1_12 conv_i_c103_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_12 (conv_q_src_c103_1_12 0 conv_bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_1_12 (conv_q_src_c103_1_12 conv_q_c103_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_13 (conv_i_src_c103_1_13 0 conv_bpf_c103_1 0) vcvs gain=5.555702330196e-01
SCONVI_c103_1_13 (conv_i_src_c103_1_13 conv_i_c103_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_13 (conv_q_src_c103_1_13 0 conv_bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_1_13 (conv_q_src_c103_1_13 conv_q_c103_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_14 (conv_i_src_c103_1_14 0 conv_bpf_c103_1 0) vcvs gain=8.314696123025e-01
SCONVI_c103_1_14 (conv_i_src_c103_1_14 conv_i_c103_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_14 (conv_q_src_c103_1_14 0 conv_bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_1_14 (conv_q_src_c103_1_14 conv_q_c103_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_1_15 (conv_i_src_c103_1_15 0 conv_bpf_c103_1 0) vcvs gain=9.807852804032e-01
SCONVI_c103_1_15 (conv_i_src_c103_1_15 conv_i_c103_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_1_15 (conv_q_src_c103_1_15 0 conv_bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_1_15 (conv_q_src_c103_1_15 conv_q_c103_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c103_1 (conv_i_c103_1 0) resistor r=1G
RCONVQ_c103_1 (conv_q_c103_1 0) resistor r=1G
RCONVINTI_c103_1 (conv_i_c103_1 ConvIcar_c103_1) resistor r=1k
CCONVINTI_c103_1 (ConvIcar_c103_1 0) capacitor c=80p
RCONVINTQ_c103_1 (conv_q_c103_1 ConvQcar_c103_1) resistor r=1k
CCONVINTQ_c103_1 (ConvQcar_c103_1 0) capacitor c=80p
save conv_bpf_c103_1 ConvIcar_c103_1 ConvQcar_c103_1

// conventional mixed baseline bl103, carrier_2: 750000000 Hz
CCONVBPF_c103_2 (bl103 n_conv_cbpf_c103_2) capacitor c=4.503163717437e-14
LCONVBPF_c103_2 (n_conv_cbpf_c103_2 conv_bpf_c103_2) inductor l=1.000000000000e-06
RCONVBPF_c103_2 (conv_bpf_c103_2 0) resistor r=2.356194490192e+02
ECONVI_c103_2_00 (conv_i_src_c103_2_00 0 conv_bpf_c103_2 0) vcvs gain=9.807852804032e-01
SCONVI_c103_2_00 (conv_i_src_c103_2_00 conv_i_c103_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_00 (conv_q_src_c103_2_00 0 conv_bpf_c103_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_2_00 (conv_q_src_c103_2_00 conv_q_c103_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_01 (conv_i_src_c103_2_01 0 conv_bpf_c103_2 0) vcvs gain=8.314696123025e-01
SCONVI_c103_2_01 (conv_i_src_c103_2_01 conv_i_c103_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_01 (conv_q_src_c103_2_01 0 conv_bpf_c103_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_2_01 (conv_q_src_c103_2_01 conv_q_c103_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_02 (conv_i_src_c103_2_02 0 conv_bpf_c103_2 0) vcvs gain=5.555702330196e-01
SCONVI_c103_2_02 (conv_i_src_c103_2_02 conv_i_c103_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_02 (conv_q_src_c103_2_02 0 conv_bpf_c103_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_2_02 (conv_q_src_c103_2_02 conv_q_c103_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_03 (conv_i_src_c103_2_03 0 conv_bpf_c103_2 0) vcvs gain=1.950903220161e-01
SCONVI_c103_2_03 (conv_i_src_c103_2_03 conv_i_c103_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_03 (conv_q_src_c103_2_03 0 conv_bpf_c103_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_2_03 (conv_q_src_c103_2_03 conv_q_c103_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_04 (conv_i_src_c103_2_04 0 conv_bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_2_04 (conv_i_src_c103_2_04 conv_i_c103_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_04 (conv_q_src_c103_2_04 0 conv_bpf_c103_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_2_04 (conv_q_src_c103_2_04 conv_q_c103_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_05 (conv_i_src_c103_2_05 0 conv_bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_2_05 (conv_i_src_c103_2_05 conv_i_c103_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_05 (conv_q_src_c103_2_05 0 conv_bpf_c103_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_2_05 (conv_q_src_c103_2_05 conv_q_c103_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_06 (conv_i_src_c103_2_06 0 conv_bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_2_06 (conv_i_src_c103_2_06 conv_i_c103_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_06 (conv_q_src_c103_2_06 0 conv_bpf_c103_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_2_06 (conv_q_src_c103_2_06 conv_q_c103_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_07 (conv_i_src_c103_2_07 0 conv_bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_2_07 (conv_i_src_c103_2_07 conv_i_c103_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_07 (conv_q_src_c103_2_07 0 conv_bpf_c103_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_2_07 (conv_q_src_c103_2_07 conv_q_c103_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_08 (conv_i_src_c103_2_08 0 conv_bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_2_08 (conv_i_src_c103_2_08 conv_i_c103_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_08 (conv_q_src_c103_2_08 0 conv_bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_2_08 (conv_q_src_c103_2_08 conv_q_c103_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_09 (conv_i_src_c103_2_09 0 conv_bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_2_09 (conv_i_src_c103_2_09 conv_i_c103_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_09 (conv_q_src_c103_2_09 0 conv_bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_2_09 (conv_q_src_c103_2_09 conv_q_c103_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_10 (conv_i_src_c103_2_10 0 conv_bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_2_10 (conv_i_src_c103_2_10 conv_i_c103_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_10 (conv_q_src_c103_2_10 0 conv_bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_2_10 (conv_q_src_c103_2_10 conv_q_c103_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_11 (conv_i_src_c103_2_11 0 conv_bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_2_11 (conv_i_src_c103_2_11 conv_i_c103_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_11 (conv_q_src_c103_2_11 0 conv_bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_2_11 (conv_q_src_c103_2_11 conv_q_c103_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_12 (conv_i_src_c103_2_12 0 conv_bpf_c103_2 0) vcvs gain=1.950903220161e-01
SCONVI_c103_2_12 (conv_i_src_c103_2_12 conv_i_c103_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_12 (conv_q_src_c103_2_12 0 conv_bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_2_12 (conv_q_src_c103_2_12 conv_q_c103_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_13 (conv_i_src_c103_2_13 0 conv_bpf_c103_2 0) vcvs gain=5.555702330196e-01
SCONVI_c103_2_13 (conv_i_src_c103_2_13 conv_i_c103_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_13 (conv_q_src_c103_2_13 0 conv_bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_2_13 (conv_q_src_c103_2_13 conv_q_c103_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_14 (conv_i_src_c103_2_14 0 conv_bpf_c103_2 0) vcvs gain=8.314696123025e-01
SCONVI_c103_2_14 (conv_i_src_c103_2_14 conv_i_c103_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_14 (conv_q_src_c103_2_14 0 conv_bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_2_14 (conv_q_src_c103_2_14 conv_q_c103_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_2_15 (conv_i_src_c103_2_15 0 conv_bpf_c103_2 0) vcvs gain=9.807852804032e-01
SCONVI_c103_2_15 (conv_i_src_c103_2_15 conv_i_c103_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_2_15 (conv_q_src_c103_2_15 0 conv_bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_2_15 (conv_q_src_c103_2_15 conv_q_c103_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c103_2 (conv_i_c103_2 0) resistor r=1G
RCONVQ_c103_2 (conv_q_c103_2 0) resistor r=1G
RCONVINTI_c103_2 (conv_i_c103_2 ConvIcar_c103_2) resistor r=1k
CCONVINTI_c103_2 (ConvIcar_c103_2 0) capacitor c=80p
RCONVINTQ_c103_2 (conv_q_c103_2 ConvQcar_c103_2) resistor r=1k
CCONVINTQ_c103_2 (ConvQcar_c103_2 0) capacitor c=80p
save conv_bpf_c103_2 ConvIcar_c103_2 ConvQcar_c103_2

// conventional mixed baseline bl103, carrier_3: 1000000000 Hz
CCONVBPF_c103_3 (bl103 n_conv_cbpf_c103_3) capacitor c=2.533029591058e-14
LCONVBPF_c103_3 (n_conv_cbpf_c103_3 conv_bpf_c103_3) inductor l=1.000000000000e-06
RCONVBPF_c103_3 (conv_bpf_c103_3 0) resistor r=3.141592653590e+02
ECONVI_c103_3_00 (conv_i_src_c103_3_00 0 conv_bpf_c103_3 0) vcvs gain=9.807852804032e-01
SCONVI_c103_3_00 (conv_i_src_c103_3_00 conv_i_c103_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_00 (conv_q_src_c103_3_00 0 conv_bpf_c103_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_3_00 (conv_q_src_c103_3_00 conv_q_c103_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_01 (conv_i_src_c103_3_01 0 conv_bpf_c103_3 0) vcvs gain=8.314696123025e-01
SCONVI_c103_3_01 (conv_i_src_c103_3_01 conv_i_c103_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_01 (conv_q_src_c103_3_01 0 conv_bpf_c103_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_3_01 (conv_q_src_c103_3_01 conv_q_c103_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_02 (conv_i_src_c103_3_02 0 conv_bpf_c103_3 0) vcvs gain=5.555702330196e-01
SCONVI_c103_3_02 (conv_i_src_c103_3_02 conv_i_c103_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_02 (conv_q_src_c103_3_02 0 conv_bpf_c103_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_3_02 (conv_q_src_c103_3_02 conv_q_c103_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_03 (conv_i_src_c103_3_03 0 conv_bpf_c103_3 0) vcvs gain=1.950903220161e-01
SCONVI_c103_3_03 (conv_i_src_c103_3_03 conv_i_c103_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_03 (conv_q_src_c103_3_03 0 conv_bpf_c103_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_3_03 (conv_q_src_c103_3_03 conv_q_c103_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_04 (conv_i_src_c103_3_04 0 conv_bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_3_04 (conv_i_src_c103_3_04 conv_i_c103_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_04 (conv_q_src_c103_3_04 0 conv_bpf_c103_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c103_3_04 (conv_q_src_c103_3_04 conv_q_c103_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_05 (conv_i_src_c103_3_05 0 conv_bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_3_05 (conv_i_src_c103_3_05 conv_i_c103_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_05 (conv_q_src_c103_3_05 0 conv_bpf_c103_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c103_3_05 (conv_q_src_c103_3_05 conv_q_c103_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_06 (conv_i_src_c103_3_06 0 conv_bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_3_06 (conv_i_src_c103_3_06 conv_i_c103_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_06 (conv_q_src_c103_3_06 0 conv_bpf_c103_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c103_3_06 (conv_q_src_c103_3_06 conv_q_c103_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_07 (conv_i_src_c103_3_07 0 conv_bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_3_07 (conv_i_src_c103_3_07 conv_i_c103_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_07 (conv_q_src_c103_3_07 0 conv_bpf_c103_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c103_3_07 (conv_q_src_c103_3_07 conv_q_c103_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_08 (conv_i_src_c103_3_08 0 conv_bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c103_3_08 (conv_i_src_c103_3_08 conv_i_c103_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_08 (conv_q_src_c103_3_08 0 conv_bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_3_08 (conv_q_src_c103_3_08 conv_q_c103_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_09 (conv_i_src_c103_3_09 0 conv_bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c103_3_09 (conv_i_src_c103_3_09 conv_i_c103_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_09 (conv_q_src_c103_3_09 0 conv_bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_3_09 (conv_q_src_c103_3_09 conv_q_c103_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_10 (conv_i_src_c103_3_10 0 conv_bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c103_3_10 (conv_i_src_c103_3_10 conv_i_c103_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_10 (conv_q_src_c103_3_10 0 conv_bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_3_10 (conv_q_src_c103_3_10 conv_q_c103_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_11 (conv_i_src_c103_3_11 0 conv_bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c103_3_11 (conv_i_src_c103_3_11 conv_i_c103_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_11 (conv_q_src_c103_3_11 0 conv_bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_3_11 (conv_q_src_c103_3_11 conv_q_c103_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_12 (conv_i_src_c103_3_12 0 conv_bpf_c103_3 0) vcvs gain=1.950903220161e-01
SCONVI_c103_3_12 (conv_i_src_c103_3_12 conv_i_c103_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_12 (conv_q_src_c103_3_12 0 conv_bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c103_3_12 (conv_q_src_c103_3_12 conv_q_c103_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_13 (conv_i_src_c103_3_13 0 conv_bpf_c103_3 0) vcvs gain=5.555702330196e-01
SCONVI_c103_3_13 (conv_i_src_c103_3_13 conv_i_c103_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_13 (conv_q_src_c103_3_13 0 conv_bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c103_3_13 (conv_q_src_c103_3_13 conv_q_c103_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_14 (conv_i_src_c103_3_14 0 conv_bpf_c103_3 0) vcvs gain=8.314696123025e-01
SCONVI_c103_3_14 (conv_i_src_c103_3_14 conv_i_c103_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_14 (conv_q_src_c103_3_14 0 conv_bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c103_3_14 (conv_q_src_c103_3_14 conv_q_c103_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c103_3_15 (conv_i_src_c103_3_15 0 conv_bpf_c103_3 0) vcvs gain=9.807852804032e-01
SCONVI_c103_3_15 (conv_i_src_c103_3_15 conv_i_c103_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c103_3_15 (conv_q_src_c103_3_15 0 conv_bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c103_3_15 (conv_q_src_c103_3_15 conv_q_c103_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c103_3 (conv_i_c103_3 0) resistor r=1G
RCONVQ_c103_3 (conv_q_c103_3 0) resistor r=1G
RCONVINTI_c103_3 (conv_i_c103_3 ConvIcar_c103_3) resistor r=1k
CCONVINTI_c103_3 (ConvIcar_c103_3 0) capacitor c=80p
RCONVINTQ_c103_3 (conv_q_c103_3 ConvQcar_c103_3) resistor r=1k
CCONVINTQ_c103_3 (ConvQcar_c103_3 0) capacitor c=80p
save conv_bpf_c103_3 ConvIcar_c103_3 ConvQcar_c103_3

// conventional mixed baseline bl104, carrier_0: 250000000 Hz
CCONVBPF_c104_0 (bl104 n_conv_cbpf_c104_0) capacitor c=4.052847345694e-13
LCONVBPF_c104_0 (n_conv_cbpf_c104_0 conv_bpf_c104_0) inductor l=1.000000000000e-06
RCONVBPF_c104_0 (conv_bpf_c104_0 0) resistor r=7.853981633974e+01
ECONVI_c104_0_00 (conv_i_src_c104_0_00 0 conv_bpf_c104_0 0) vcvs gain=9.807852804032e-01
SCONVI_c104_0_00 (conv_i_src_c104_0_00 conv_i_c104_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_00 (conv_q_src_c104_0_00 0 conv_bpf_c104_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_0_00 (conv_q_src_c104_0_00 conv_q_c104_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_01 (conv_i_src_c104_0_01 0 conv_bpf_c104_0 0) vcvs gain=8.314696123025e-01
SCONVI_c104_0_01 (conv_i_src_c104_0_01 conv_i_c104_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_01 (conv_q_src_c104_0_01 0 conv_bpf_c104_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_0_01 (conv_q_src_c104_0_01 conv_q_c104_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_02 (conv_i_src_c104_0_02 0 conv_bpf_c104_0 0) vcvs gain=5.555702330196e-01
SCONVI_c104_0_02 (conv_i_src_c104_0_02 conv_i_c104_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_02 (conv_q_src_c104_0_02 0 conv_bpf_c104_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_0_02 (conv_q_src_c104_0_02 conv_q_c104_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_03 (conv_i_src_c104_0_03 0 conv_bpf_c104_0 0) vcvs gain=1.950903220161e-01
SCONVI_c104_0_03 (conv_i_src_c104_0_03 conv_i_c104_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_03 (conv_q_src_c104_0_03 0 conv_bpf_c104_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_0_03 (conv_q_src_c104_0_03 conv_q_c104_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_04 (conv_i_src_c104_0_04 0 conv_bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_0_04 (conv_i_src_c104_0_04 conv_i_c104_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_04 (conv_q_src_c104_0_04 0 conv_bpf_c104_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_0_04 (conv_q_src_c104_0_04 conv_q_c104_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_05 (conv_i_src_c104_0_05 0 conv_bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_0_05 (conv_i_src_c104_0_05 conv_i_c104_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_05 (conv_q_src_c104_0_05 0 conv_bpf_c104_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_0_05 (conv_q_src_c104_0_05 conv_q_c104_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_06 (conv_i_src_c104_0_06 0 conv_bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_0_06 (conv_i_src_c104_0_06 conv_i_c104_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_06 (conv_q_src_c104_0_06 0 conv_bpf_c104_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_0_06 (conv_q_src_c104_0_06 conv_q_c104_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_07 (conv_i_src_c104_0_07 0 conv_bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_0_07 (conv_i_src_c104_0_07 conv_i_c104_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_07 (conv_q_src_c104_0_07 0 conv_bpf_c104_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_0_07 (conv_q_src_c104_0_07 conv_q_c104_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_08 (conv_i_src_c104_0_08 0 conv_bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_0_08 (conv_i_src_c104_0_08 conv_i_c104_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_08 (conv_q_src_c104_0_08 0 conv_bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_0_08 (conv_q_src_c104_0_08 conv_q_c104_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_09 (conv_i_src_c104_0_09 0 conv_bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_0_09 (conv_i_src_c104_0_09 conv_i_c104_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_09 (conv_q_src_c104_0_09 0 conv_bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_0_09 (conv_q_src_c104_0_09 conv_q_c104_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_10 (conv_i_src_c104_0_10 0 conv_bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_0_10 (conv_i_src_c104_0_10 conv_i_c104_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_10 (conv_q_src_c104_0_10 0 conv_bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_0_10 (conv_q_src_c104_0_10 conv_q_c104_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_11 (conv_i_src_c104_0_11 0 conv_bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_0_11 (conv_i_src_c104_0_11 conv_i_c104_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_11 (conv_q_src_c104_0_11 0 conv_bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_0_11 (conv_q_src_c104_0_11 conv_q_c104_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_12 (conv_i_src_c104_0_12 0 conv_bpf_c104_0 0) vcvs gain=1.950903220161e-01
SCONVI_c104_0_12 (conv_i_src_c104_0_12 conv_i_c104_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_12 (conv_q_src_c104_0_12 0 conv_bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_0_12 (conv_q_src_c104_0_12 conv_q_c104_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_13 (conv_i_src_c104_0_13 0 conv_bpf_c104_0 0) vcvs gain=5.555702330196e-01
SCONVI_c104_0_13 (conv_i_src_c104_0_13 conv_i_c104_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_13 (conv_q_src_c104_0_13 0 conv_bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_0_13 (conv_q_src_c104_0_13 conv_q_c104_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_14 (conv_i_src_c104_0_14 0 conv_bpf_c104_0 0) vcvs gain=8.314696123025e-01
SCONVI_c104_0_14 (conv_i_src_c104_0_14 conv_i_c104_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_14 (conv_q_src_c104_0_14 0 conv_bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_0_14 (conv_q_src_c104_0_14 conv_q_c104_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_0_15 (conv_i_src_c104_0_15 0 conv_bpf_c104_0 0) vcvs gain=9.807852804032e-01
SCONVI_c104_0_15 (conv_i_src_c104_0_15 conv_i_c104_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_0_15 (conv_q_src_c104_0_15 0 conv_bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_0_15 (conv_q_src_c104_0_15 conv_q_c104_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c104_0 (conv_i_c104_0 0) resistor r=1G
RCONVQ_c104_0 (conv_q_c104_0 0) resistor r=1G
RCONVINTI_c104_0 (conv_i_c104_0 ConvIcar_c104_0) resistor r=1k
CCONVINTI_c104_0 (ConvIcar_c104_0 0) capacitor c=80p
RCONVINTQ_c104_0 (conv_q_c104_0 ConvQcar_c104_0) resistor r=1k
CCONVINTQ_c104_0 (ConvQcar_c104_0 0) capacitor c=80p
save conv_bpf_c104_0 ConvIcar_c104_0 ConvQcar_c104_0

// conventional mixed baseline bl104, carrier_1: 500000000 Hz
CCONVBPF_c104_1 (bl104 n_conv_cbpf_c104_1) capacitor c=1.013211836423e-13
LCONVBPF_c104_1 (n_conv_cbpf_c104_1 conv_bpf_c104_1) inductor l=1.000000000000e-06
RCONVBPF_c104_1 (conv_bpf_c104_1 0) resistor r=1.570796326795e+02
ECONVI_c104_1_00 (conv_i_src_c104_1_00 0 conv_bpf_c104_1 0) vcvs gain=9.807852804032e-01
SCONVI_c104_1_00 (conv_i_src_c104_1_00 conv_i_c104_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_00 (conv_q_src_c104_1_00 0 conv_bpf_c104_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_1_00 (conv_q_src_c104_1_00 conv_q_c104_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_01 (conv_i_src_c104_1_01 0 conv_bpf_c104_1 0) vcvs gain=8.314696123025e-01
SCONVI_c104_1_01 (conv_i_src_c104_1_01 conv_i_c104_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_01 (conv_q_src_c104_1_01 0 conv_bpf_c104_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_1_01 (conv_q_src_c104_1_01 conv_q_c104_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_02 (conv_i_src_c104_1_02 0 conv_bpf_c104_1 0) vcvs gain=5.555702330196e-01
SCONVI_c104_1_02 (conv_i_src_c104_1_02 conv_i_c104_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_02 (conv_q_src_c104_1_02 0 conv_bpf_c104_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_1_02 (conv_q_src_c104_1_02 conv_q_c104_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_03 (conv_i_src_c104_1_03 0 conv_bpf_c104_1 0) vcvs gain=1.950903220161e-01
SCONVI_c104_1_03 (conv_i_src_c104_1_03 conv_i_c104_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_03 (conv_q_src_c104_1_03 0 conv_bpf_c104_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_1_03 (conv_q_src_c104_1_03 conv_q_c104_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_04 (conv_i_src_c104_1_04 0 conv_bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_1_04 (conv_i_src_c104_1_04 conv_i_c104_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_04 (conv_q_src_c104_1_04 0 conv_bpf_c104_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_1_04 (conv_q_src_c104_1_04 conv_q_c104_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_05 (conv_i_src_c104_1_05 0 conv_bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_1_05 (conv_i_src_c104_1_05 conv_i_c104_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_05 (conv_q_src_c104_1_05 0 conv_bpf_c104_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_1_05 (conv_q_src_c104_1_05 conv_q_c104_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_06 (conv_i_src_c104_1_06 0 conv_bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_1_06 (conv_i_src_c104_1_06 conv_i_c104_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_06 (conv_q_src_c104_1_06 0 conv_bpf_c104_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_1_06 (conv_q_src_c104_1_06 conv_q_c104_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_07 (conv_i_src_c104_1_07 0 conv_bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_1_07 (conv_i_src_c104_1_07 conv_i_c104_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_07 (conv_q_src_c104_1_07 0 conv_bpf_c104_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_1_07 (conv_q_src_c104_1_07 conv_q_c104_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_08 (conv_i_src_c104_1_08 0 conv_bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_1_08 (conv_i_src_c104_1_08 conv_i_c104_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_08 (conv_q_src_c104_1_08 0 conv_bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_1_08 (conv_q_src_c104_1_08 conv_q_c104_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_09 (conv_i_src_c104_1_09 0 conv_bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_1_09 (conv_i_src_c104_1_09 conv_i_c104_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_09 (conv_q_src_c104_1_09 0 conv_bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_1_09 (conv_q_src_c104_1_09 conv_q_c104_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_10 (conv_i_src_c104_1_10 0 conv_bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_1_10 (conv_i_src_c104_1_10 conv_i_c104_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_10 (conv_q_src_c104_1_10 0 conv_bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_1_10 (conv_q_src_c104_1_10 conv_q_c104_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_11 (conv_i_src_c104_1_11 0 conv_bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_1_11 (conv_i_src_c104_1_11 conv_i_c104_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_11 (conv_q_src_c104_1_11 0 conv_bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_1_11 (conv_q_src_c104_1_11 conv_q_c104_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_12 (conv_i_src_c104_1_12 0 conv_bpf_c104_1 0) vcvs gain=1.950903220161e-01
SCONVI_c104_1_12 (conv_i_src_c104_1_12 conv_i_c104_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_12 (conv_q_src_c104_1_12 0 conv_bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_1_12 (conv_q_src_c104_1_12 conv_q_c104_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_13 (conv_i_src_c104_1_13 0 conv_bpf_c104_1 0) vcvs gain=5.555702330196e-01
SCONVI_c104_1_13 (conv_i_src_c104_1_13 conv_i_c104_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_13 (conv_q_src_c104_1_13 0 conv_bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_1_13 (conv_q_src_c104_1_13 conv_q_c104_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_14 (conv_i_src_c104_1_14 0 conv_bpf_c104_1 0) vcvs gain=8.314696123025e-01
SCONVI_c104_1_14 (conv_i_src_c104_1_14 conv_i_c104_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_14 (conv_q_src_c104_1_14 0 conv_bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_1_14 (conv_q_src_c104_1_14 conv_q_c104_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_1_15 (conv_i_src_c104_1_15 0 conv_bpf_c104_1 0) vcvs gain=9.807852804032e-01
SCONVI_c104_1_15 (conv_i_src_c104_1_15 conv_i_c104_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_1_15 (conv_q_src_c104_1_15 0 conv_bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_1_15 (conv_q_src_c104_1_15 conv_q_c104_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c104_1 (conv_i_c104_1 0) resistor r=1G
RCONVQ_c104_1 (conv_q_c104_1 0) resistor r=1G
RCONVINTI_c104_1 (conv_i_c104_1 ConvIcar_c104_1) resistor r=1k
CCONVINTI_c104_1 (ConvIcar_c104_1 0) capacitor c=80p
RCONVINTQ_c104_1 (conv_q_c104_1 ConvQcar_c104_1) resistor r=1k
CCONVINTQ_c104_1 (ConvQcar_c104_1 0) capacitor c=80p
save conv_bpf_c104_1 ConvIcar_c104_1 ConvQcar_c104_1

// conventional mixed baseline bl104, carrier_2: 750000000 Hz
CCONVBPF_c104_2 (bl104 n_conv_cbpf_c104_2) capacitor c=4.503163717437e-14
LCONVBPF_c104_2 (n_conv_cbpf_c104_2 conv_bpf_c104_2) inductor l=1.000000000000e-06
RCONVBPF_c104_2 (conv_bpf_c104_2 0) resistor r=2.356194490192e+02
ECONVI_c104_2_00 (conv_i_src_c104_2_00 0 conv_bpf_c104_2 0) vcvs gain=9.807852804032e-01
SCONVI_c104_2_00 (conv_i_src_c104_2_00 conv_i_c104_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_00 (conv_q_src_c104_2_00 0 conv_bpf_c104_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_2_00 (conv_q_src_c104_2_00 conv_q_c104_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_01 (conv_i_src_c104_2_01 0 conv_bpf_c104_2 0) vcvs gain=8.314696123025e-01
SCONVI_c104_2_01 (conv_i_src_c104_2_01 conv_i_c104_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_01 (conv_q_src_c104_2_01 0 conv_bpf_c104_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_2_01 (conv_q_src_c104_2_01 conv_q_c104_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_02 (conv_i_src_c104_2_02 0 conv_bpf_c104_2 0) vcvs gain=5.555702330196e-01
SCONVI_c104_2_02 (conv_i_src_c104_2_02 conv_i_c104_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_02 (conv_q_src_c104_2_02 0 conv_bpf_c104_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_2_02 (conv_q_src_c104_2_02 conv_q_c104_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_03 (conv_i_src_c104_2_03 0 conv_bpf_c104_2 0) vcvs gain=1.950903220161e-01
SCONVI_c104_2_03 (conv_i_src_c104_2_03 conv_i_c104_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_03 (conv_q_src_c104_2_03 0 conv_bpf_c104_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_2_03 (conv_q_src_c104_2_03 conv_q_c104_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_04 (conv_i_src_c104_2_04 0 conv_bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_2_04 (conv_i_src_c104_2_04 conv_i_c104_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_04 (conv_q_src_c104_2_04 0 conv_bpf_c104_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_2_04 (conv_q_src_c104_2_04 conv_q_c104_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_05 (conv_i_src_c104_2_05 0 conv_bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_2_05 (conv_i_src_c104_2_05 conv_i_c104_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_05 (conv_q_src_c104_2_05 0 conv_bpf_c104_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_2_05 (conv_q_src_c104_2_05 conv_q_c104_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_06 (conv_i_src_c104_2_06 0 conv_bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_2_06 (conv_i_src_c104_2_06 conv_i_c104_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_06 (conv_q_src_c104_2_06 0 conv_bpf_c104_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_2_06 (conv_q_src_c104_2_06 conv_q_c104_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_07 (conv_i_src_c104_2_07 0 conv_bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_2_07 (conv_i_src_c104_2_07 conv_i_c104_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_07 (conv_q_src_c104_2_07 0 conv_bpf_c104_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_2_07 (conv_q_src_c104_2_07 conv_q_c104_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_08 (conv_i_src_c104_2_08 0 conv_bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_2_08 (conv_i_src_c104_2_08 conv_i_c104_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_08 (conv_q_src_c104_2_08 0 conv_bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_2_08 (conv_q_src_c104_2_08 conv_q_c104_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_09 (conv_i_src_c104_2_09 0 conv_bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_2_09 (conv_i_src_c104_2_09 conv_i_c104_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_09 (conv_q_src_c104_2_09 0 conv_bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_2_09 (conv_q_src_c104_2_09 conv_q_c104_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_10 (conv_i_src_c104_2_10 0 conv_bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_2_10 (conv_i_src_c104_2_10 conv_i_c104_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_10 (conv_q_src_c104_2_10 0 conv_bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_2_10 (conv_q_src_c104_2_10 conv_q_c104_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_11 (conv_i_src_c104_2_11 0 conv_bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_2_11 (conv_i_src_c104_2_11 conv_i_c104_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_11 (conv_q_src_c104_2_11 0 conv_bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_2_11 (conv_q_src_c104_2_11 conv_q_c104_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_12 (conv_i_src_c104_2_12 0 conv_bpf_c104_2 0) vcvs gain=1.950903220161e-01
SCONVI_c104_2_12 (conv_i_src_c104_2_12 conv_i_c104_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_12 (conv_q_src_c104_2_12 0 conv_bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_2_12 (conv_q_src_c104_2_12 conv_q_c104_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_13 (conv_i_src_c104_2_13 0 conv_bpf_c104_2 0) vcvs gain=5.555702330196e-01
SCONVI_c104_2_13 (conv_i_src_c104_2_13 conv_i_c104_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_13 (conv_q_src_c104_2_13 0 conv_bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_2_13 (conv_q_src_c104_2_13 conv_q_c104_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_14 (conv_i_src_c104_2_14 0 conv_bpf_c104_2 0) vcvs gain=8.314696123025e-01
SCONVI_c104_2_14 (conv_i_src_c104_2_14 conv_i_c104_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_14 (conv_q_src_c104_2_14 0 conv_bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_2_14 (conv_q_src_c104_2_14 conv_q_c104_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_2_15 (conv_i_src_c104_2_15 0 conv_bpf_c104_2 0) vcvs gain=9.807852804032e-01
SCONVI_c104_2_15 (conv_i_src_c104_2_15 conv_i_c104_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_2_15 (conv_q_src_c104_2_15 0 conv_bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_2_15 (conv_q_src_c104_2_15 conv_q_c104_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c104_2 (conv_i_c104_2 0) resistor r=1G
RCONVQ_c104_2 (conv_q_c104_2 0) resistor r=1G
RCONVINTI_c104_2 (conv_i_c104_2 ConvIcar_c104_2) resistor r=1k
CCONVINTI_c104_2 (ConvIcar_c104_2 0) capacitor c=80p
RCONVINTQ_c104_2 (conv_q_c104_2 ConvQcar_c104_2) resistor r=1k
CCONVINTQ_c104_2 (ConvQcar_c104_2 0) capacitor c=80p
save conv_bpf_c104_2 ConvIcar_c104_2 ConvQcar_c104_2

// conventional mixed baseline bl104, carrier_3: 1000000000 Hz
CCONVBPF_c104_3 (bl104 n_conv_cbpf_c104_3) capacitor c=2.533029591058e-14
LCONVBPF_c104_3 (n_conv_cbpf_c104_3 conv_bpf_c104_3) inductor l=1.000000000000e-06
RCONVBPF_c104_3 (conv_bpf_c104_3 0) resistor r=3.141592653590e+02
ECONVI_c104_3_00 (conv_i_src_c104_3_00 0 conv_bpf_c104_3 0) vcvs gain=9.807852804032e-01
SCONVI_c104_3_00 (conv_i_src_c104_3_00 conv_i_c104_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_00 (conv_q_src_c104_3_00 0 conv_bpf_c104_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_3_00 (conv_q_src_c104_3_00 conv_q_c104_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_01 (conv_i_src_c104_3_01 0 conv_bpf_c104_3 0) vcvs gain=8.314696123025e-01
SCONVI_c104_3_01 (conv_i_src_c104_3_01 conv_i_c104_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_01 (conv_q_src_c104_3_01 0 conv_bpf_c104_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_3_01 (conv_q_src_c104_3_01 conv_q_c104_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_02 (conv_i_src_c104_3_02 0 conv_bpf_c104_3 0) vcvs gain=5.555702330196e-01
SCONVI_c104_3_02 (conv_i_src_c104_3_02 conv_i_c104_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_02 (conv_q_src_c104_3_02 0 conv_bpf_c104_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_3_02 (conv_q_src_c104_3_02 conv_q_c104_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_03 (conv_i_src_c104_3_03 0 conv_bpf_c104_3 0) vcvs gain=1.950903220161e-01
SCONVI_c104_3_03 (conv_i_src_c104_3_03 conv_i_c104_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_03 (conv_q_src_c104_3_03 0 conv_bpf_c104_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_3_03 (conv_q_src_c104_3_03 conv_q_c104_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_04 (conv_i_src_c104_3_04 0 conv_bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_3_04 (conv_i_src_c104_3_04 conv_i_c104_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_04 (conv_q_src_c104_3_04 0 conv_bpf_c104_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c104_3_04 (conv_q_src_c104_3_04 conv_q_c104_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_05 (conv_i_src_c104_3_05 0 conv_bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_3_05 (conv_i_src_c104_3_05 conv_i_c104_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_05 (conv_q_src_c104_3_05 0 conv_bpf_c104_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c104_3_05 (conv_q_src_c104_3_05 conv_q_c104_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_06 (conv_i_src_c104_3_06 0 conv_bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_3_06 (conv_i_src_c104_3_06 conv_i_c104_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_06 (conv_q_src_c104_3_06 0 conv_bpf_c104_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c104_3_06 (conv_q_src_c104_3_06 conv_q_c104_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_07 (conv_i_src_c104_3_07 0 conv_bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_3_07 (conv_i_src_c104_3_07 conv_i_c104_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_07 (conv_q_src_c104_3_07 0 conv_bpf_c104_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c104_3_07 (conv_q_src_c104_3_07 conv_q_c104_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_08 (conv_i_src_c104_3_08 0 conv_bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c104_3_08 (conv_i_src_c104_3_08 conv_i_c104_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_08 (conv_q_src_c104_3_08 0 conv_bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_3_08 (conv_q_src_c104_3_08 conv_q_c104_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_09 (conv_i_src_c104_3_09 0 conv_bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c104_3_09 (conv_i_src_c104_3_09 conv_i_c104_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_09 (conv_q_src_c104_3_09 0 conv_bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_3_09 (conv_q_src_c104_3_09 conv_q_c104_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_10 (conv_i_src_c104_3_10 0 conv_bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c104_3_10 (conv_i_src_c104_3_10 conv_i_c104_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_10 (conv_q_src_c104_3_10 0 conv_bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_3_10 (conv_q_src_c104_3_10 conv_q_c104_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_11 (conv_i_src_c104_3_11 0 conv_bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c104_3_11 (conv_i_src_c104_3_11 conv_i_c104_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_11 (conv_q_src_c104_3_11 0 conv_bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_3_11 (conv_q_src_c104_3_11 conv_q_c104_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_12 (conv_i_src_c104_3_12 0 conv_bpf_c104_3 0) vcvs gain=1.950903220161e-01
SCONVI_c104_3_12 (conv_i_src_c104_3_12 conv_i_c104_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_12 (conv_q_src_c104_3_12 0 conv_bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c104_3_12 (conv_q_src_c104_3_12 conv_q_c104_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_13 (conv_i_src_c104_3_13 0 conv_bpf_c104_3 0) vcvs gain=5.555702330196e-01
SCONVI_c104_3_13 (conv_i_src_c104_3_13 conv_i_c104_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_13 (conv_q_src_c104_3_13 0 conv_bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c104_3_13 (conv_q_src_c104_3_13 conv_q_c104_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_14 (conv_i_src_c104_3_14 0 conv_bpf_c104_3 0) vcvs gain=8.314696123025e-01
SCONVI_c104_3_14 (conv_i_src_c104_3_14 conv_i_c104_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_14 (conv_q_src_c104_3_14 0 conv_bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c104_3_14 (conv_q_src_c104_3_14 conv_q_c104_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c104_3_15 (conv_i_src_c104_3_15 0 conv_bpf_c104_3 0) vcvs gain=9.807852804032e-01
SCONVI_c104_3_15 (conv_i_src_c104_3_15 conv_i_c104_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c104_3_15 (conv_q_src_c104_3_15 0 conv_bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c104_3_15 (conv_q_src_c104_3_15 conv_q_c104_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c104_3 (conv_i_c104_3 0) resistor r=1G
RCONVQ_c104_3 (conv_q_c104_3 0) resistor r=1G
RCONVINTI_c104_3 (conv_i_c104_3 ConvIcar_c104_3) resistor r=1k
CCONVINTI_c104_3 (ConvIcar_c104_3 0) capacitor c=80p
RCONVINTQ_c104_3 (conv_q_c104_3 ConvQcar_c104_3) resistor r=1k
CCONVINTQ_c104_3 (ConvQcar_c104_3 0) capacitor c=80p
