SCONVQ_c025_3_14 (conv_q_src_c025_3_14 conv_q_c025_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_15 (conv_i_src_c025_3_15 0 conv_bpf_c025_3 0) vcvs gain=9.807852804032e-01
SCONVI_c025_3_15 (conv_i_src_c025_3_15 conv_i_c025_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_15 (conv_q_src_c025_3_15 0 conv_bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_3_15 (conv_q_src_c025_3_15 conv_q_c025_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c025_3 (conv_i_c025_3 0) resistor r=1G
RCONVQ_c025_3 (conv_q_c025_3 0) resistor r=1G
RCONVINTI_c025_3 (conv_i_c025_3 ConvIcar_c025_3) resistor r=1k
CCONVINTI_c025_3 (ConvIcar_c025_3 0) capacitor c=80p
RCONVINTQ_c025_3 (conv_q_c025_3 ConvQcar_c025_3) resistor r=1k
CCONVINTQ_c025_3 (ConvQcar_c025_3 0) capacitor c=80p
save conv_bpf_c025_3 ConvIcar_c025_3 ConvQcar_c025_3

// conventional mixed baseline bl026, carrier_0: 250000000 Hz
CCONVBPF_c026_0 (bl026 n_conv_cbpf_c026_0) capacitor c=4.052847345694e-13
LCONVBPF_c026_0 (n_conv_cbpf_c026_0 conv_bpf_c026_0) inductor l=1.000000000000e-06
RCONVBPF_c026_0 (conv_bpf_c026_0 0) resistor r=7.853981633974e+01
ECONVI_c026_0_00 (conv_i_src_c026_0_00 0 conv_bpf_c026_0 0) vcvs gain=9.807852804032e-01
SCONVI_c026_0_00 (conv_i_src_c026_0_00 conv_i_c026_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_00 (conv_q_src_c026_0_00 0 conv_bpf_c026_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_0_00 (conv_q_src_c026_0_00 conv_q_c026_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_01 (conv_i_src_c026_0_01 0 conv_bpf_c026_0 0) vcvs gain=8.314696123025e-01
SCONVI_c026_0_01 (conv_i_src_c026_0_01 conv_i_c026_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_01 (conv_q_src_c026_0_01 0 conv_bpf_c026_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_0_01 (conv_q_src_c026_0_01 conv_q_c026_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_02 (conv_i_src_c026_0_02 0 conv_bpf_c026_0 0) vcvs gain=5.555702330196e-01
SCONVI_c026_0_02 (conv_i_src_c026_0_02 conv_i_c026_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_02 (conv_q_src_c026_0_02 0 conv_bpf_c026_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_0_02 (conv_q_src_c026_0_02 conv_q_c026_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_03 (conv_i_src_c026_0_03 0 conv_bpf_c026_0 0) vcvs gain=1.950903220161e-01
SCONVI_c026_0_03 (conv_i_src_c026_0_03 conv_i_c026_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_03 (conv_q_src_c026_0_03 0 conv_bpf_c026_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_0_03 (conv_q_src_c026_0_03 conv_q_c026_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_04 (conv_i_src_c026_0_04 0 conv_bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_0_04 (conv_i_src_c026_0_04 conv_i_c026_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_04 (conv_q_src_c026_0_04 0 conv_bpf_c026_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_0_04 (conv_q_src_c026_0_04 conv_q_c026_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_05 (conv_i_src_c026_0_05 0 conv_bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_0_05 (conv_i_src_c026_0_05 conv_i_c026_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_05 (conv_q_src_c026_0_05 0 conv_bpf_c026_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_0_05 (conv_q_src_c026_0_05 conv_q_c026_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_06 (conv_i_src_c026_0_06 0 conv_bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_0_06 (conv_i_src_c026_0_06 conv_i_c026_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_06 (conv_q_src_c026_0_06 0 conv_bpf_c026_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_0_06 (conv_q_src_c026_0_06 conv_q_c026_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_07 (conv_i_src_c026_0_07 0 conv_bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_0_07 (conv_i_src_c026_0_07 conv_i_c026_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_07 (conv_q_src_c026_0_07 0 conv_bpf_c026_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_0_07 (conv_q_src_c026_0_07 conv_q_c026_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_08 (conv_i_src_c026_0_08 0 conv_bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_0_08 (conv_i_src_c026_0_08 conv_i_c026_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_08 (conv_q_src_c026_0_08 0 conv_bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_0_08 (conv_q_src_c026_0_08 conv_q_c026_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_09 (conv_i_src_c026_0_09 0 conv_bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_0_09 (conv_i_src_c026_0_09 conv_i_c026_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_09 (conv_q_src_c026_0_09 0 conv_bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_0_09 (conv_q_src_c026_0_09 conv_q_c026_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_10 (conv_i_src_c026_0_10 0 conv_bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_0_10 (conv_i_src_c026_0_10 conv_i_c026_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_10 (conv_q_src_c026_0_10 0 conv_bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_0_10 (conv_q_src_c026_0_10 conv_q_c026_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_11 (conv_i_src_c026_0_11 0 conv_bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_0_11 (conv_i_src_c026_0_11 conv_i_c026_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_11 (conv_q_src_c026_0_11 0 conv_bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_0_11 (conv_q_src_c026_0_11 conv_q_c026_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_12 (conv_i_src_c026_0_12 0 conv_bpf_c026_0 0) vcvs gain=1.950903220161e-01
SCONVI_c026_0_12 (conv_i_src_c026_0_12 conv_i_c026_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_12 (conv_q_src_c026_0_12 0 conv_bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_0_12 (conv_q_src_c026_0_12 conv_q_c026_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_13 (conv_i_src_c026_0_13 0 conv_bpf_c026_0 0) vcvs gain=5.555702330196e-01
SCONVI_c026_0_13 (conv_i_src_c026_0_13 conv_i_c026_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_13 (conv_q_src_c026_0_13 0 conv_bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_0_13 (conv_q_src_c026_0_13 conv_q_c026_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_14 (conv_i_src_c026_0_14 0 conv_bpf_c026_0 0) vcvs gain=8.314696123025e-01
SCONVI_c026_0_14 (conv_i_src_c026_0_14 conv_i_c026_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_14 (conv_q_src_c026_0_14 0 conv_bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_0_14 (conv_q_src_c026_0_14 conv_q_c026_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_0_15 (conv_i_src_c026_0_15 0 conv_bpf_c026_0 0) vcvs gain=9.807852804032e-01
SCONVI_c026_0_15 (conv_i_src_c026_0_15 conv_i_c026_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_0_15 (conv_q_src_c026_0_15 0 conv_bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_0_15 (conv_q_src_c026_0_15 conv_q_c026_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c026_0 (conv_i_c026_0 0) resistor r=1G
RCONVQ_c026_0 (conv_q_c026_0 0) resistor r=1G
RCONVINTI_c026_0 (conv_i_c026_0 ConvIcar_c026_0) resistor r=1k
CCONVINTI_c026_0 (ConvIcar_c026_0 0) capacitor c=80p
RCONVINTQ_c026_0 (conv_q_c026_0 ConvQcar_c026_0) resistor r=1k
CCONVINTQ_c026_0 (ConvQcar_c026_0 0) capacitor c=80p
save conv_bpf_c026_0 ConvIcar_c026_0 ConvQcar_c026_0

// conventional mixed baseline bl026, carrier_1: 500000000 Hz
CCONVBPF_c026_1 (bl026 n_conv_cbpf_c026_1) capacitor c=1.013211836423e-13
LCONVBPF_c026_1 (n_conv_cbpf_c026_1 conv_bpf_c026_1) inductor l=1.000000000000e-06
RCONVBPF_c026_1 (conv_bpf_c026_1 0) resistor r=1.570796326795e+02
ECONVI_c026_1_00 (conv_i_src_c026_1_00 0 conv_bpf_c026_1 0) vcvs gain=9.807852804032e-01
SCONVI_c026_1_00 (conv_i_src_c026_1_00 conv_i_c026_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_00 (conv_q_src_c026_1_00 0 conv_bpf_c026_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_1_00 (conv_q_src_c026_1_00 conv_q_c026_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_01 (conv_i_src_c026_1_01 0 conv_bpf_c026_1 0) vcvs gain=8.314696123025e-01
SCONVI_c026_1_01 (conv_i_src_c026_1_01 conv_i_c026_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_01 (conv_q_src_c026_1_01 0 conv_bpf_c026_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_1_01 (conv_q_src_c026_1_01 conv_q_c026_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_02 (conv_i_src_c026_1_02 0 conv_bpf_c026_1 0) vcvs gain=5.555702330196e-01
SCONVI_c026_1_02 (conv_i_src_c026_1_02 conv_i_c026_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_02 (conv_q_src_c026_1_02 0 conv_bpf_c026_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_1_02 (conv_q_src_c026_1_02 conv_q_c026_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_03 (conv_i_src_c026_1_03 0 conv_bpf_c026_1 0) vcvs gain=1.950903220161e-01
SCONVI_c026_1_03 (conv_i_src_c026_1_03 conv_i_c026_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_03 (conv_q_src_c026_1_03 0 conv_bpf_c026_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_1_03 (conv_q_src_c026_1_03 conv_q_c026_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_04 (conv_i_src_c026_1_04 0 conv_bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_1_04 (conv_i_src_c026_1_04 conv_i_c026_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_04 (conv_q_src_c026_1_04 0 conv_bpf_c026_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_1_04 (conv_q_src_c026_1_04 conv_q_c026_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_05 (conv_i_src_c026_1_05 0 conv_bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_1_05 (conv_i_src_c026_1_05 conv_i_c026_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_05 (conv_q_src_c026_1_05 0 conv_bpf_c026_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_1_05 (conv_q_src_c026_1_05 conv_q_c026_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_06 (conv_i_src_c026_1_06 0 conv_bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_1_06 (conv_i_src_c026_1_06 conv_i_c026_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_06 (conv_q_src_c026_1_06 0 conv_bpf_c026_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_1_06 (conv_q_src_c026_1_06 conv_q_c026_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_07 (conv_i_src_c026_1_07 0 conv_bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_1_07 (conv_i_src_c026_1_07 conv_i_c026_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_07 (conv_q_src_c026_1_07 0 conv_bpf_c026_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_1_07 (conv_q_src_c026_1_07 conv_q_c026_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_08 (conv_i_src_c026_1_08 0 conv_bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_1_08 (conv_i_src_c026_1_08 conv_i_c026_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_08 (conv_q_src_c026_1_08 0 conv_bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_1_08 (conv_q_src_c026_1_08 conv_q_c026_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_09 (conv_i_src_c026_1_09 0 conv_bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_1_09 (conv_i_src_c026_1_09 conv_i_c026_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_09 (conv_q_src_c026_1_09 0 conv_bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_1_09 (conv_q_src_c026_1_09 conv_q_c026_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_10 (conv_i_src_c026_1_10 0 conv_bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_1_10 (conv_i_src_c026_1_10 conv_i_c026_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_10 (conv_q_src_c026_1_10 0 conv_bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_1_10 (conv_q_src_c026_1_10 conv_q_c026_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_11 (conv_i_src_c026_1_11 0 conv_bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_1_11 (conv_i_src_c026_1_11 conv_i_c026_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_11 (conv_q_src_c026_1_11 0 conv_bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_1_11 (conv_q_src_c026_1_11 conv_q_c026_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_12 (conv_i_src_c026_1_12 0 conv_bpf_c026_1 0) vcvs gain=1.950903220161e-01
SCONVI_c026_1_12 (conv_i_src_c026_1_12 conv_i_c026_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_12 (conv_q_src_c026_1_12 0 conv_bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_1_12 (conv_q_src_c026_1_12 conv_q_c026_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_13 (conv_i_src_c026_1_13 0 conv_bpf_c026_1 0) vcvs gain=5.555702330196e-01
SCONVI_c026_1_13 (conv_i_src_c026_1_13 conv_i_c026_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_13 (conv_q_src_c026_1_13 0 conv_bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_1_13 (conv_q_src_c026_1_13 conv_q_c026_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_14 (conv_i_src_c026_1_14 0 conv_bpf_c026_1 0) vcvs gain=8.314696123025e-01
SCONVI_c026_1_14 (conv_i_src_c026_1_14 conv_i_c026_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_14 (conv_q_src_c026_1_14 0 conv_bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_1_14 (conv_q_src_c026_1_14 conv_q_c026_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_1_15 (conv_i_src_c026_1_15 0 conv_bpf_c026_1 0) vcvs gain=9.807852804032e-01
SCONVI_c026_1_15 (conv_i_src_c026_1_15 conv_i_c026_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_1_15 (conv_q_src_c026_1_15 0 conv_bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_1_15 (conv_q_src_c026_1_15 conv_q_c026_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c026_1 (conv_i_c026_1 0) resistor r=1G
RCONVQ_c026_1 (conv_q_c026_1 0) resistor r=1G
RCONVINTI_c026_1 (conv_i_c026_1 ConvIcar_c026_1) resistor r=1k
CCONVINTI_c026_1 (ConvIcar_c026_1 0) capacitor c=80p
RCONVINTQ_c026_1 (conv_q_c026_1 ConvQcar_c026_1) resistor r=1k
CCONVINTQ_c026_1 (ConvQcar_c026_1 0) capacitor c=80p
save conv_bpf_c026_1 ConvIcar_c026_1 ConvQcar_c026_1

// conventional mixed baseline bl026, carrier_2: 750000000 Hz
CCONVBPF_c026_2 (bl026 n_conv_cbpf_c026_2) capacitor c=4.503163717437e-14
LCONVBPF_c026_2 (n_conv_cbpf_c026_2 conv_bpf_c026_2) inductor l=1.000000000000e-06
RCONVBPF_c026_2 (conv_bpf_c026_2 0) resistor r=2.356194490192e+02
ECONVI_c026_2_00 (conv_i_src_c026_2_00 0 conv_bpf_c026_2 0) vcvs gain=9.807852804032e-01
SCONVI_c026_2_00 (conv_i_src_c026_2_00 conv_i_c026_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_00 (conv_q_src_c026_2_00 0 conv_bpf_c026_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_2_00 (conv_q_src_c026_2_00 conv_q_c026_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_01 (conv_i_src_c026_2_01 0 conv_bpf_c026_2 0) vcvs gain=8.314696123025e-01
SCONVI_c026_2_01 (conv_i_src_c026_2_01 conv_i_c026_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_01 (conv_q_src_c026_2_01 0 conv_bpf_c026_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_2_01 (conv_q_src_c026_2_01 conv_q_c026_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_02 (conv_i_src_c026_2_02 0 conv_bpf_c026_2 0) vcvs gain=5.555702330196e-01
SCONVI_c026_2_02 (conv_i_src_c026_2_02 conv_i_c026_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_02 (conv_q_src_c026_2_02 0 conv_bpf_c026_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_2_02 (conv_q_src_c026_2_02 conv_q_c026_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_03 (conv_i_src_c026_2_03 0 conv_bpf_c026_2 0) vcvs gain=1.950903220161e-01
SCONVI_c026_2_03 (conv_i_src_c026_2_03 conv_i_c026_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_03 (conv_q_src_c026_2_03 0 conv_bpf_c026_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_2_03 (conv_q_src_c026_2_03 conv_q_c026_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_04 (conv_i_src_c026_2_04 0 conv_bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_2_04 (conv_i_src_c026_2_04 conv_i_c026_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_04 (conv_q_src_c026_2_04 0 conv_bpf_c026_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_2_04 (conv_q_src_c026_2_04 conv_q_c026_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_05 (conv_i_src_c026_2_05 0 conv_bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_2_05 (conv_i_src_c026_2_05 conv_i_c026_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_05 (conv_q_src_c026_2_05 0 conv_bpf_c026_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_2_05 (conv_q_src_c026_2_05 conv_q_c026_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_06 (conv_i_src_c026_2_06 0 conv_bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_2_06 (conv_i_src_c026_2_06 conv_i_c026_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_06 (conv_q_src_c026_2_06 0 conv_bpf_c026_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_2_06 (conv_q_src_c026_2_06 conv_q_c026_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_07 (conv_i_src_c026_2_07 0 conv_bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_2_07 (conv_i_src_c026_2_07 conv_i_c026_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_07 (conv_q_src_c026_2_07 0 conv_bpf_c026_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_2_07 (conv_q_src_c026_2_07 conv_q_c026_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_08 (conv_i_src_c026_2_08 0 conv_bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_2_08 (conv_i_src_c026_2_08 conv_i_c026_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_08 (conv_q_src_c026_2_08 0 conv_bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_2_08 (conv_q_src_c026_2_08 conv_q_c026_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_09 (conv_i_src_c026_2_09 0 conv_bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_2_09 (conv_i_src_c026_2_09 conv_i_c026_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_09 (conv_q_src_c026_2_09 0 conv_bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_2_09 (conv_q_src_c026_2_09 conv_q_c026_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_10 (conv_i_src_c026_2_10 0 conv_bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_2_10 (conv_i_src_c026_2_10 conv_i_c026_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_10 (conv_q_src_c026_2_10 0 conv_bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_2_10 (conv_q_src_c026_2_10 conv_q_c026_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_11 (conv_i_src_c026_2_11 0 conv_bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_2_11 (conv_i_src_c026_2_11 conv_i_c026_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_11 (conv_q_src_c026_2_11 0 conv_bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_2_11 (conv_q_src_c026_2_11 conv_q_c026_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_12 (conv_i_src_c026_2_12 0 conv_bpf_c026_2 0) vcvs gain=1.950903220161e-01
SCONVI_c026_2_12 (conv_i_src_c026_2_12 conv_i_c026_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_12 (conv_q_src_c026_2_12 0 conv_bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_2_12 (conv_q_src_c026_2_12 conv_q_c026_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_13 (conv_i_src_c026_2_13 0 conv_bpf_c026_2 0) vcvs gain=5.555702330196e-01
SCONVI_c026_2_13 (conv_i_src_c026_2_13 conv_i_c026_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_13 (conv_q_src_c026_2_13 0 conv_bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_2_13 (conv_q_src_c026_2_13 conv_q_c026_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_14 (conv_i_src_c026_2_14 0 conv_bpf_c026_2 0) vcvs gain=8.314696123025e-01
SCONVI_c026_2_14 (conv_i_src_c026_2_14 conv_i_c026_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_14 (conv_q_src_c026_2_14 0 conv_bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_2_14 (conv_q_src_c026_2_14 conv_q_c026_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_2_15 (conv_i_src_c026_2_15 0 conv_bpf_c026_2 0) vcvs gain=9.807852804032e-01
SCONVI_c026_2_15 (conv_i_src_c026_2_15 conv_i_c026_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_2_15 (conv_q_src_c026_2_15 0 conv_bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_2_15 (conv_q_src_c026_2_15 conv_q_c026_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c026_2 (conv_i_c026_2 0) resistor r=1G
RCONVQ_c026_2 (conv_q_c026_2 0) resistor r=1G
RCONVINTI_c026_2 (conv_i_c026_2 ConvIcar_c026_2) resistor r=1k
CCONVINTI_c026_2 (ConvIcar_c026_2 0) capacitor c=80p
RCONVINTQ_c026_2 (conv_q_c026_2 ConvQcar_c026_2) resistor r=1k
CCONVINTQ_c026_2 (ConvQcar_c026_2 0) capacitor c=80p
save conv_bpf_c026_2 ConvIcar_c026_2 ConvQcar_c026_2

// conventional mixed baseline bl026, carrier_3: 1000000000 Hz
CCONVBPF_c026_3 (bl026 n_conv_cbpf_c026_3) capacitor c=2.533029591058e-14
LCONVBPF_c026_3 (n_conv_cbpf_c026_3 conv_bpf_c026_3) inductor l=1.000000000000e-06
RCONVBPF_c026_3 (conv_bpf_c026_3 0) resistor r=3.141592653590e+02
ECONVI_c026_3_00 (conv_i_src_c026_3_00 0 conv_bpf_c026_3 0) vcvs gain=9.807852804032e-01
SCONVI_c026_3_00 (conv_i_src_c026_3_00 conv_i_c026_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_00 (conv_q_src_c026_3_00 0 conv_bpf_c026_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_3_00 (conv_q_src_c026_3_00 conv_q_c026_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_01 (conv_i_src_c026_3_01 0 conv_bpf_c026_3 0) vcvs gain=8.314696123025e-01
SCONVI_c026_3_01 (conv_i_src_c026_3_01 conv_i_c026_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_01 (conv_q_src_c026_3_01 0 conv_bpf_c026_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_3_01 (conv_q_src_c026_3_01 conv_q_c026_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_02 (conv_i_src_c026_3_02 0 conv_bpf_c026_3 0) vcvs gain=5.555702330196e-01
SCONVI_c026_3_02 (conv_i_src_c026_3_02 conv_i_c026_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_02 (conv_q_src_c026_3_02 0 conv_bpf_c026_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_3_02 (conv_q_src_c026_3_02 conv_q_c026_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_03 (conv_i_src_c026_3_03 0 conv_bpf_c026_3 0) vcvs gain=1.950903220161e-01
SCONVI_c026_3_03 (conv_i_src_c026_3_03 conv_i_c026_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_03 (conv_q_src_c026_3_03 0 conv_bpf_c026_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_3_03 (conv_q_src_c026_3_03 conv_q_c026_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_04 (conv_i_src_c026_3_04 0 conv_bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_3_04 (conv_i_src_c026_3_04 conv_i_c026_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_04 (conv_q_src_c026_3_04 0 conv_bpf_c026_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c026_3_04 (conv_q_src_c026_3_04 conv_q_c026_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_05 (conv_i_src_c026_3_05 0 conv_bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_3_05 (conv_i_src_c026_3_05 conv_i_c026_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_05 (conv_q_src_c026_3_05 0 conv_bpf_c026_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c026_3_05 (conv_q_src_c026_3_05 conv_q_c026_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_06 (conv_i_src_c026_3_06 0 conv_bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_3_06 (conv_i_src_c026_3_06 conv_i_c026_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_06 (conv_q_src_c026_3_06 0 conv_bpf_c026_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c026_3_06 (conv_q_src_c026_3_06 conv_q_c026_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_07 (conv_i_src_c026_3_07 0 conv_bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_3_07 (conv_i_src_c026_3_07 conv_i_c026_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_07 (conv_q_src_c026_3_07 0 conv_bpf_c026_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c026_3_07 (conv_q_src_c026_3_07 conv_q_c026_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_08 (conv_i_src_c026_3_08 0 conv_bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c026_3_08 (conv_i_src_c026_3_08 conv_i_c026_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_08 (conv_q_src_c026_3_08 0 conv_bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_3_08 (conv_q_src_c026_3_08 conv_q_c026_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_09 (conv_i_src_c026_3_09 0 conv_bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c026_3_09 (conv_i_src_c026_3_09 conv_i_c026_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_09 (conv_q_src_c026_3_09 0 conv_bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_3_09 (conv_q_src_c026_3_09 conv_q_c026_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_10 (conv_i_src_c026_3_10 0 conv_bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c026_3_10 (conv_i_src_c026_3_10 conv_i_c026_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_10 (conv_q_src_c026_3_10 0 conv_bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_3_10 (conv_q_src_c026_3_10 conv_q_c026_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_11 (conv_i_src_c026_3_11 0 conv_bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c026_3_11 (conv_i_src_c026_3_11 conv_i_c026_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_11 (conv_q_src_c026_3_11 0 conv_bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_3_11 (conv_q_src_c026_3_11 conv_q_c026_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_12 (conv_i_src_c026_3_12 0 conv_bpf_c026_3 0) vcvs gain=1.950903220161e-01
SCONVI_c026_3_12 (conv_i_src_c026_3_12 conv_i_c026_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_12 (conv_q_src_c026_3_12 0 conv_bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c026_3_12 (conv_q_src_c026_3_12 conv_q_c026_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_13 (conv_i_src_c026_3_13 0 conv_bpf_c026_3 0) vcvs gain=5.555702330196e-01
SCONVI_c026_3_13 (conv_i_src_c026_3_13 conv_i_c026_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_13 (conv_q_src_c026_3_13 0 conv_bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c026_3_13 (conv_q_src_c026_3_13 conv_q_c026_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_14 (conv_i_src_c026_3_14 0 conv_bpf_c026_3 0) vcvs gain=8.314696123025e-01
SCONVI_c026_3_14 (conv_i_src_c026_3_14 conv_i_c026_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_14 (conv_q_src_c026_3_14 0 conv_bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c026_3_14 (conv_q_src_c026_3_14 conv_q_c026_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c026_3_15 (conv_i_src_c026_3_15 0 conv_bpf_c026_3 0) vcvs gain=9.807852804032e-01
SCONVI_c026_3_15 (conv_i_src_c026_3_15 conv_i_c026_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c026_3_15 (conv_q_src_c026_3_15 0 conv_bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c026_3_15 (conv_q_src_c026_3_15 conv_q_c026_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c026_3 (conv_i_c026_3 0) resistor r=1G
RCONVQ_c026_3 (conv_q_c026_3 0) resistor r=1G
RCONVINTI_c026_3 (conv_i_c026_3 ConvIcar_c026_3) resistor r=1k
CCONVINTI_c026_3 (ConvIcar_c026_3 0) capacitor c=80p
RCONVINTQ_c026_3 (conv_q_c026_3 ConvQcar_c026_3) resistor r=1k
CCONVINTQ_c026_3 (ConvQcar_c026_3 0) capacitor c=80p
save conv_bpf_c026_3 ConvIcar_c026_3 ConvQcar_c026_3

// conventional mixed baseline bl027, carrier_0: 250000000 Hz
CCONVBPF_c027_0 (bl027 n_conv_cbpf_c027_0) capacitor c=4.052847345694e-13
LCONVBPF_c027_0 (n_conv_cbpf_c027_0 conv_bpf_c027_0) inductor l=1.000000000000e-06
RCONVBPF_c027_0 (conv_bpf_c027_0 0) resistor r=7.853981633974e+01
ECONVI_c027_0_00 (conv_i_src_c027_0_00 0 conv_bpf_c027_0 0) vcvs gain=9.807852804032e-01
SCONVI_c027_0_00 (conv_i_src_c027_0_00 conv_i_c027_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_00 (conv_q_src_c027_0_00 0 conv_bpf_c027_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_0_00 (conv_q_src_c027_0_00 conv_q_c027_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_01 (conv_i_src_c027_0_01 0 conv_bpf_c027_0 0) vcvs gain=8.314696123025e-01
SCONVI_c027_0_01 (conv_i_src_c027_0_01 conv_i_c027_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_01 (conv_q_src_c027_0_01 0 conv_bpf_c027_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_0_01 (conv_q_src_c027_0_01 conv_q_c027_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_02 (conv_i_src_c027_0_02 0 conv_bpf_c027_0 0) vcvs gain=5.555702330196e-01
SCONVI_c027_0_02 (conv_i_src_c027_0_02 conv_i_c027_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_02 (conv_q_src_c027_0_02 0 conv_bpf_c027_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_0_02 (conv_q_src_c027_0_02 conv_q_c027_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_03 (conv_i_src_c027_0_03 0 conv_bpf_c027_0 0) vcvs gain=1.950903220161e-01
SCONVI_c027_0_03 (conv_i_src_c027_0_03 conv_i_c027_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_03 (conv_q_src_c027_0_03 0 conv_bpf_c027_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_0_03 (conv_q_src_c027_0_03 conv_q_c027_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_04 (conv_i_src_c027_0_04 0 conv_bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_0_04 (conv_i_src_c027_0_04 conv_i_c027_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_04 (conv_q_src_c027_0_04 0 conv_bpf_c027_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_0_04 (conv_q_src_c027_0_04 conv_q_c027_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_05 (conv_i_src_c027_0_05 0 conv_bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_0_05 (conv_i_src_c027_0_05 conv_i_c027_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_05 (conv_q_src_c027_0_05 0 conv_bpf_c027_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_0_05 (conv_q_src_c027_0_05 conv_q_c027_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_06 (conv_i_src_c027_0_06 0 conv_bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_0_06 (conv_i_src_c027_0_06 conv_i_c027_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_06 (conv_q_src_c027_0_06 0 conv_bpf_c027_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_0_06 (conv_q_src_c027_0_06 conv_q_c027_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_07 (conv_i_src_c027_0_07 0 conv_bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_0_07 (conv_i_src_c027_0_07 conv_i_c027_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_07 (conv_q_src_c027_0_07 0 conv_bpf_c027_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_0_07 (conv_q_src_c027_0_07 conv_q_c027_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_08 (conv_i_src_c027_0_08 0 conv_bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_0_08 (conv_i_src_c027_0_08 conv_i_c027_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_08 (conv_q_src_c027_0_08 0 conv_bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_0_08 (conv_q_src_c027_0_08 conv_q_c027_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_09 (conv_i_src_c027_0_09 0 conv_bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_0_09 (conv_i_src_c027_0_09 conv_i_c027_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_09 (conv_q_src_c027_0_09 0 conv_bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_0_09 (conv_q_src_c027_0_09 conv_q_c027_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_10 (conv_i_src_c027_0_10 0 conv_bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_0_10 (conv_i_src_c027_0_10 conv_i_c027_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_10 (conv_q_src_c027_0_10 0 conv_bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_0_10 (conv_q_src_c027_0_10 conv_q_c027_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_11 (conv_i_src_c027_0_11 0 conv_bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_0_11 (conv_i_src_c027_0_11 conv_i_c027_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_11 (conv_q_src_c027_0_11 0 conv_bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_0_11 (conv_q_src_c027_0_11 conv_q_c027_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_12 (conv_i_src_c027_0_12 0 conv_bpf_c027_0 0) vcvs gain=1.950903220161e-01
SCONVI_c027_0_12 (conv_i_src_c027_0_12 conv_i_c027_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_12 (conv_q_src_c027_0_12 0 conv_bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_0_12 (conv_q_src_c027_0_12 conv_q_c027_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_13 (conv_i_src_c027_0_13 0 conv_bpf_c027_0 0) vcvs gain=5.555702330196e-01
SCONVI_c027_0_13 (conv_i_src_c027_0_13 conv_i_c027_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_13 (conv_q_src_c027_0_13 0 conv_bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_0_13 (conv_q_src_c027_0_13 conv_q_c027_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_14 (conv_i_src_c027_0_14 0 conv_bpf_c027_0 0) vcvs gain=8.314696123025e-01
SCONVI_c027_0_14 (conv_i_src_c027_0_14 conv_i_c027_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_14 (conv_q_src_c027_0_14 0 conv_bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_0_14 (conv_q_src_c027_0_14 conv_q_c027_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_0_15 (conv_i_src_c027_0_15 0 conv_bpf_c027_0 0) vcvs gain=9.807852804032e-01
SCONVI_c027_0_15 (conv_i_src_c027_0_15 conv_i_c027_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_0_15 (conv_q_src_c027_0_15 0 conv_bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_0_15 (conv_q_src_c027_0_15 conv_q_c027_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c027_0 (conv_i_c027_0 0) resistor r=1G
RCONVQ_c027_0 (conv_q_c027_0 0) resistor r=1G
RCONVINTI_c027_0 (conv_i_c027_0 ConvIcar_c027_0) resistor r=1k
CCONVINTI_c027_0 (ConvIcar_c027_0 0) capacitor c=80p
RCONVINTQ_c027_0 (conv_q_c027_0 ConvQcar_c027_0) resistor r=1k
CCONVINTQ_c027_0 (ConvQcar_c027_0 0) capacitor c=80p
save conv_bpf_c027_0 ConvIcar_c027_0 ConvQcar_c027_0

// conventional mixed baseline bl027, carrier_1: 500000000 Hz
CCONVBPF_c027_1 (bl027 n_conv_cbpf_c027_1) capacitor c=1.013211836423e-13
LCONVBPF_c027_1 (n_conv_cbpf_c027_1 conv_bpf_c027_1) inductor l=1.000000000000e-06
RCONVBPF_c027_1 (conv_bpf_c027_1 0) resistor r=1.570796326795e+02
ECONVI_c027_1_00 (conv_i_src_c027_1_00 0 conv_bpf_c027_1 0) vcvs gain=9.807852804032e-01
SCONVI_c027_1_00 (conv_i_src_c027_1_00 conv_i_c027_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_00 (conv_q_src_c027_1_00 0 conv_bpf_c027_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_1_00 (conv_q_src_c027_1_00 conv_q_c027_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_01 (conv_i_src_c027_1_01 0 conv_bpf_c027_1 0) vcvs gain=8.314696123025e-01
SCONVI_c027_1_01 (conv_i_src_c027_1_01 conv_i_c027_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_01 (conv_q_src_c027_1_01 0 conv_bpf_c027_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_1_01 (conv_q_src_c027_1_01 conv_q_c027_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_02 (conv_i_src_c027_1_02 0 conv_bpf_c027_1 0) vcvs gain=5.555702330196e-01
SCONVI_c027_1_02 (conv_i_src_c027_1_02 conv_i_c027_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_02 (conv_q_src_c027_1_02 0 conv_bpf_c027_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_1_02 (conv_q_src_c027_1_02 conv_q_c027_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_03 (conv_i_src_c027_1_03 0 conv_bpf_c027_1 0) vcvs gain=1.950903220161e-01
SCONVI_c027_1_03 (conv_i_src_c027_1_03 conv_i_c027_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_03 (conv_q_src_c027_1_03 0 conv_bpf_c027_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_1_03 (conv_q_src_c027_1_03 conv_q_c027_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_04 (conv_i_src_c027_1_04 0 conv_bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_1_04 (conv_i_src_c027_1_04 conv_i_c027_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_04 (conv_q_src_c027_1_04 0 conv_bpf_c027_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_1_04 (conv_q_src_c027_1_04 conv_q_c027_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_05 (conv_i_src_c027_1_05 0 conv_bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_1_05 (conv_i_src_c027_1_05 conv_i_c027_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_05 (conv_q_src_c027_1_05 0 conv_bpf_c027_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_1_05 (conv_q_src_c027_1_05 conv_q_c027_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_06 (conv_i_src_c027_1_06 0 conv_bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_1_06 (conv_i_src_c027_1_06 conv_i_c027_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_06 (conv_q_src_c027_1_06 0 conv_bpf_c027_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_1_06 (conv_q_src_c027_1_06 conv_q_c027_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_07 (conv_i_src_c027_1_07 0 conv_bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_1_07 (conv_i_src_c027_1_07 conv_i_c027_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_07 (conv_q_src_c027_1_07 0 conv_bpf_c027_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_1_07 (conv_q_src_c027_1_07 conv_q_c027_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_08 (conv_i_src_c027_1_08 0 conv_bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_1_08 (conv_i_src_c027_1_08 conv_i_c027_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_08 (conv_q_src_c027_1_08 0 conv_bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_1_08 (conv_q_src_c027_1_08 conv_q_c027_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_09 (conv_i_src_c027_1_09 0 conv_bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_1_09 (conv_i_src_c027_1_09 conv_i_c027_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_09 (conv_q_src_c027_1_09 0 conv_bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_1_09 (conv_q_src_c027_1_09 conv_q_c027_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_10 (conv_i_src_c027_1_10 0 conv_bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_1_10 (conv_i_src_c027_1_10 conv_i_c027_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_10 (conv_q_src_c027_1_10 0 conv_bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_1_10 (conv_q_src_c027_1_10 conv_q_c027_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_11 (conv_i_src_c027_1_11 0 conv_bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_1_11 (conv_i_src_c027_1_11 conv_i_c027_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_11 (conv_q_src_c027_1_11 0 conv_bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_1_11 (conv_q_src_c027_1_11 conv_q_c027_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_12 (conv_i_src_c027_1_12 0 conv_bpf_c027_1 0) vcvs gain=1.950903220161e-01
SCONVI_c027_1_12 (conv_i_src_c027_1_12 conv_i_c027_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_12 (conv_q_src_c027_1_12 0 conv_bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_1_12 (conv_q_src_c027_1_12 conv_q_c027_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_13 (conv_i_src_c027_1_13 0 conv_bpf_c027_1 0) vcvs gain=5.555702330196e-01
SCONVI_c027_1_13 (conv_i_src_c027_1_13 conv_i_c027_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_13 (conv_q_src_c027_1_13 0 conv_bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_1_13 (conv_q_src_c027_1_13 conv_q_c027_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_14 (conv_i_src_c027_1_14 0 conv_bpf_c027_1 0) vcvs gain=8.314696123025e-01
SCONVI_c027_1_14 (conv_i_src_c027_1_14 conv_i_c027_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_14 (conv_q_src_c027_1_14 0 conv_bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_1_14 (conv_q_src_c027_1_14 conv_q_c027_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_1_15 (conv_i_src_c027_1_15 0 conv_bpf_c027_1 0) vcvs gain=9.807852804032e-01
SCONVI_c027_1_15 (conv_i_src_c027_1_15 conv_i_c027_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_1_15 (conv_q_src_c027_1_15 0 conv_bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_1_15 (conv_q_src_c027_1_15 conv_q_c027_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c027_1 (conv_i_c027_1 0) resistor r=1G
RCONVQ_c027_1 (conv_q_c027_1 0) resistor r=1G
RCONVINTI_c027_1 (conv_i_c027_1 ConvIcar_c027_1) resistor r=1k
CCONVINTI_c027_1 (ConvIcar_c027_1 0) capacitor c=80p
RCONVINTQ_c027_1 (conv_q_c027_1 ConvQcar_c027_1) resistor r=1k
CCONVINTQ_c027_1 (ConvQcar_c027_1 0) capacitor c=80p
save conv_bpf_c027_1 ConvIcar_c027_1 ConvQcar_c027_1

// conventional mixed baseline bl027, carrier_2: 750000000 Hz
CCONVBPF_c027_2 (bl027 n_conv_cbpf_c027_2) capacitor c=4.503163717437e-14
LCONVBPF_c027_2 (n_conv_cbpf_c027_2 conv_bpf_c027_2) inductor l=1.000000000000e-06
RCONVBPF_c027_2 (conv_bpf_c027_2 0) resistor r=2.356194490192e+02
ECONVI_c027_2_00 (conv_i_src_c027_2_00 0 conv_bpf_c027_2 0) vcvs gain=9.807852804032e-01
SCONVI_c027_2_00 (conv_i_src_c027_2_00 conv_i_c027_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_00 (conv_q_src_c027_2_00 0 conv_bpf_c027_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_2_00 (conv_q_src_c027_2_00 conv_q_c027_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_01 (conv_i_src_c027_2_01 0 conv_bpf_c027_2 0) vcvs gain=8.314696123025e-01
SCONVI_c027_2_01 (conv_i_src_c027_2_01 conv_i_c027_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_01 (conv_q_src_c027_2_01 0 conv_bpf_c027_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_2_01 (conv_q_src_c027_2_01 conv_q_c027_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_02 (conv_i_src_c027_2_02 0 conv_bpf_c027_2 0) vcvs gain=5.555702330196e-01
SCONVI_c027_2_02 (conv_i_src_c027_2_02 conv_i_c027_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_02 (conv_q_src_c027_2_02 0 conv_bpf_c027_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_2_02 (conv_q_src_c027_2_02 conv_q_c027_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_03 (conv_i_src_c027_2_03 0 conv_bpf_c027_2 0) vcvs gain=1.950903220161e-01
SCONVI_c027_2_03 (conv_i_src_c027_2_03 conv_i_c027_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_03 (conv_q_src_c027_2_03 0 conv_bpf_c027_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_2_03 (conv_q_src_c027_2_03 conv_q_c027_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_04 (conv_i_src_c027_2_04 0 conv_bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_2_04 (conv_i_src_c027_2_04 conv_i_c027_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_04 (conv_q_src_c027_2_04 0 conv_bpf_c027_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_2_04 (conv_q_src_c027_2_04 conv_q_c027_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_05 (conv_i_src_c027_2_05 0 conv_bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_2_05 (conv_i_src_c027_2_05 conv_i_c027_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_05 (conv_q_src_c027_2_05 0 conv_bpf_c027_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_2_05 (conv_q_src_c027_2_05 conv_q_c027_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_06 (conv_i_src_c027_2_06 0 conv_bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_2_06 (conv_i_src_c027_2_06 conv_i_c027_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_06 (conv_q_src_c027_2_06 0 conv_bpf_c027_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_2_06 (conv_q_src_c027_2_06 conv_q_c027_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_07 (conv_i_src_c027_2_07 0 conv_bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_2_07 (conv_i_src_c027_2_07 conv_i_c027_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_07 (conv_q_src_c027_2_07 0 conv_bpf_c027_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_2_07 (conv_q_src_c027_2_07 conv_q_c027_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_08 (conv_i_src_c027_2_08 0 conv_bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_2_08 (conv_i_src_c027_2_08 conv_i_c027_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_08 (conv_q_src_c027_2_08 0 conv_bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_2_08 (conv_q_src_c027_2_08 conv_q_c027_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_09 (conv_i_src_c027_2_09 0 conv_bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_2_09 (conv_i_src_c027_2_09 conv_i_c027_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_09 (conv_q_src_c027_2_09 0 conv_bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_2_09 (conv_q_src_c027_2_09 conv_q_c027_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_10 (conv_i_src_c027_2_10 0 conv_bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_2_10 (conv_i_src_c027_2_10 conv_i_c027_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_10 (conv_q_src_c027_2_10 0 conv_bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_2_10 (conv_q_src_c027_2_10 conv_q_c027_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_11 (conv_i_src_c027_2_11 0 conv_bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_2_11 (conv_i_src_c027_2_11 conv_i_c027_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_11 (conv_q_src_c027_2_11 0 conv_bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_2_11 (conv_q_src_c027_2_11 conv_q_c027_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_12 (conv_i_src_c027_2_12 0 conv_bpf_c027_2 0) vcvs gain=1.950903220161e-01
SCONVI_c027_2_12 (conv_i_src_c027_2_12 conv_i_c027_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_12 (conv_q_src_c027_2_12 0 conv_bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_2_12 (conv_q_src_c027_2_12 conv_q_c027_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_13 (conv_i_src_c027_2_13 0 conv_bpf_c027_2 0) vcvs gain=5.555702330196e-01
SCONVI_c027_2_13 (conv_i_src_c027_2_13 conv_i_c027_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_13 (conv_q_src_c027_2_13 0 conv_bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_2_13 (conv_q_src_c027_2_13 conv_q_c027_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_14 (conv_i_src_c027_2_14 0 conv_bpf_c027_2 0) vcvs gain=8.314696123025e-01
SCONVI_c027_2_14 (conv_i_src_c027_2_14 conv_i_c027_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_14 (conv_q_src_c027_2_14 0 conv_bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_2_14 (conv_q_src_c027_2_14 conv_q_c027_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_2_15 (conv_i_src_c027_2_15 0 conv_bpf_c027_2 0) vcvs gain=9.807852804032e-01
SCONVI_c027_2_15 (conv_i_src_c027_2_15 conv_i_c027_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_2_15 (conv_q_src_c027_2_15 0 conv_bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_2_15 (conv_q_src_c027_2_15 conv_q_c027_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c027_2 (conv_i_c027_2 0) resistor r=1G
RCONVQ_c027_2 (conv_q_c027_2 0) resistor r=1G
RCONVINTI_c027_2 (conv_i_c027_2 ConvIcar_c027_2) resistor r=1k
CCONVINTI_c027_2 (ConvIcar_c027_2 0) capacitor c=80p
RCONVINTQ_c027_2 (conv_q_c027_2 ConvQcar_c027_2) resistor r=1k
CCONVINTQ_c027_2 (ConvQcar_c027_2 0) capacitor c=80p
save conv_bpf_c027_2 ConvIcar_c027_2 ConvQcar_c027_2

// conventional mixed baseline bl027, carrier_3: 1000000000 Hz
CCONVBPF_c027_3 (bl027 n_conv_cbpf_c027_3) capacitor c=2.533029591058e-14
LCONVBPF_c027_3 (n_conv_cbpf_c027_3 conv_bpf_c027_3) inductor l=1.000000000000e-06
RCONVBPF_c027_3 (conv_bpf_c027_3 0) resistor r=3.141592653590e+02
ECONVI_c027_3_00 (conv_i_src_c027_3_00 0 conv_bpf_c027_3 0) vcvs gain=9.807852804032e-01
SCONVI_c027_3_00 (conv_i_src_c027_3_00 conv_i_c027_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_00 (conv_q_src_c027_3_00 0 conv_bpf_c027_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_3_00 (conv_q_src_c027_3_00 conv_q_c027_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_01 (conv_i_src_c027_3_01 0 conv_bpf_c027_3 0) vcvs gain=8.314696123025e-01
SCONVI_c027_3_01 (conv_i_src_c027_3_01 conv_i_c027_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_01 (conv_q_src_c027_3_01 0 conv_bpf_c027_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_3_01 (conv_q_src_c027_3_01 conv_q_c027_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_02 (conv_i_src_c027_3_02 0 conv_bpf_c027_3 0) vcvs gain=5.555702330196e-01
SCONVI_c027_3_02 (conv_i_src_c027_3_02 conv_i_c027_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_02 (conv_q_src_c027_3_02 0 conv_bpf_c027_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_3_02 (conv_q_src_c027_3_02 conv_q_c027_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_03 (conv_i_src_c027_3_03 0 conv_bpf_c027_3 0) vcvs gain=1.950903220161e-01
SCONVI_c027_3_03 (conv_i_src_c027_3_03 conv_i_c027_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_03 (conv_q_src_c027_3_03 0 conv_bpf_c027_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_3_03 (conv_q_src_c027_3_03 conv_q_c027_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_04 (conv_i_src_c027_3_04 0 conv_bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_3_04 (conv_i_src_c027_3_04 conv_i_c027_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_04 (conv_q_src_c027_3_04 0 conv_bpf_c027_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c027_3_04 (conv_q_src_c027_3_04 conv_q_c027_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_05 (conv_i_src_c027_3_05 0 conv_bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_3_05 (conv_i_src_c027_3_05 conv_i_c027_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_05 (conv_q_src_c027_3_05 0 conv_bpf_c027_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c027_3_05 (conv_q_src_c027_3_05 conv_q_c027_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_06 (conv_i_src_c027_3_06 0 conv_bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_3_06 (conv_i_src_c027_3_06 conv_i_c027_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_06 (conv_q_src_c027_3_06 0 conv_bpf_c027_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c027_3_06 (conv_q_src_c027_3_06 conv_q_c027_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_07 (conv_i_src_c027_3_07 0 conv_bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_3_07 (conv_i_src_c027_3_07 conv_i_c027_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_07 (conv_q_src_c027_3_07 0 conv_bpf_c027_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c027_3_07 (conv_q_src_c027_3_07 conv_q_c027_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_08 (conv_i_src_c027_3_08 0 conv_bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c027_3_08 (conv_i_src_c027_3_08 conv_i_c027_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_08 (conv_q_src_c027_3_08 0 conv_bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_3_08 (conv_q_src_c027_3_08 conv_q_c027_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_09 (conv_i_src_c027_3_09 0 conv_bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c027_3_09 (conv_i_src_c027_3_09 conv_i_c027_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_09 (conv_q_src_c027_3_09 0 conv_bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_3_09 (conv_q_src_c027_3_09 conv_q_c027_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_10 (conv_i_src_c027_3_10 0 conv_bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c027_3_10 (conv_i_src_c027_3_10 conv_i_c027_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_10 (conv_q_src_c027_3_10 0 conv_bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_3_10 (conv_q_src_c027_3_10 conv_q_c027_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_11 (conv_i_src_c027_3_11 0 conv_bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c027_3_11 (conv_i_src_c027_3_11 conv_i_c027_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_11 (conv_q_src_c027_3_11 0 conv_bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_3_11 (conv_q_src_c027_3_11 conv_q_c027_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_12 (conv_i_src_c027_3_12 0 conv_bpf_c027_3 0) vcvs gain=1.950903220161e-01
SCONVI_c027_3_12 (conv_i_src_c027_3_12 conv_i_c027_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_12 (conv_q_src_c027_3_12 0 conv_bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c027_3_12 (conv_q_src_c027_3_12 conv_q_c027_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_13 (conv_i_src_c027_3_13 0 conv_bpf_c027_3 0) vcvs gain=5.555702330196e-01
SCONVI_c027_3_13 (conv_i_src_c027_3_13 conv_i_c027_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_13 (conv_q_src_c027_3_13 0 conv_bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c027_3_13 (conv_q_src_c027_3_13 conv_q_c027_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_14 (conv_i_src_c027_3_14 0 conv_bpf_c027_3 0) vcvs gain=8.314696123025e-01
SCONVI_c027_3_14 (conv_i_src_c027_3_14 conv_i_c027_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_14 (conv_q_src_c027_3_14 0 conv_bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c027_3_14 (conv_q_src_c027_3_14 conv_q_c027_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c027_3_15 (conv_i_src_c027_3_15 0 conv_bpf_c027_3 0) vcvs gain=9.807852804032e-01
SCONVI_c027_3_15 (conv_i_src_c027_3_15 conv_i_c027_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c027_3_15 (conv_q_src_c027_3_15 0 conv_bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c027_3_15 (conv_q_src_c027_3_15 conv_q_c027_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c027_3 (conv_i_c027_3 0) resistor r=1G
RCONVQ_c027_3 (conv_q_c027_3 0) resistor r=1G
RCONVINTI_c027_3 (conv_i_c027_3 ConvIcar_c027_3) resistor r=1k
CCONVINTI_c027_3 (ConvIcar_c027_3 0) capacitor c=80p
RCONVINTQ_c027_3 (conv_q_c027_3 ConvQcar_c027_3) resistor r=1k
CCONVINTQ_c027_3 (ConvQcar_c027_3 0) capacitor c=80p
save conv_bpf_c027_3 ConvIcar_c027_3 ConvQcar_c027_3

// conventional mixed baseline bl028, carrier_0: 250000000 Hz
CCONVBPF_c028_0 (bl028 n_conv_cbpf_c028_0) capacitor c=4.052847345694e-13
LCONVBPF_c028_0 (n_conv_cbpf_c028_0 conv_bpf_c028_0) inductor l=1.000000000000e-06
RCONVBPF_c028_0 (conv_bpf_c028_0 0) resistor r=7.853981633974e+01
ECONVI_c028_0_00 (conv_i_src_c028_0_00 0 conv_bpf_c028_0 0) vcvs gain=9.807852804032e-01
SCONVI_c028_0_00 (conv_i_src_c028_0_00 conv_i_c028_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_00 (conv_q_src_c028_0_00 0 conv_bpf_c028_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_0_00 (conv_q_src_c028_0_00 conv_q_c028_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_01 (conv_i_src_c028_0_01 0 conv_bpf_c028_0 0) vcvs gain=8.314696123025e-01
SCONVI_c028_0_01 (conv_i_src_c028_0_01 conv_i_c028_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_01 (conv_q_src_c028_0_01 0 conv_bpf_c028_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_0_01 (conv_q_src_c028_0_01 conv_q_c028_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_02 (conv_i_src_c028_0_02 0 conv_bpf_c028_0 0) vcvs gain=5.555702330196e-01
SCONVI_c028_0_02 (conv_i_src_c028_0_02 conv_i_c028_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_02 (conv_q_src_c028_0_02 0 conv_bpf_c028_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_0_02 (conv_q_src_c028_0_02 conv_q_c028_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_03 (conv_i_src_c028_0_03 0 conv_bpf_c028_0 0) vcvs gain=1.950903220161e-01
SCONVI_c028_0_03 (conv_i_src_c028_0_03 conv_i_c028_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_03 (conv_q_src_c028_0_03 0 conv_bpf_c028_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_0_03 (conv_q_src_c028_0_03 conv_q_c028_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_04 (conv_i_src_c028_0_04 0 conv_bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_0_04 (conv_i_src_c028_0_04 conv_i_c028_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_04 (conv_q_src_c028_0_04 0 conv_bpf_c028_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_0_04 (conv_q_src_c028_0_04 conv_q_c028_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_05 (conv_i_src_c028_0_05 0 conv_bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_0_05 (conv_i_src_c028_0_05 conv_i_c028_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_05 (conv_q_src_c028_0_05 0 conv_bpf_c028_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_0_05 (conv_q_src_c028_0_05 conv_q_c028_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_06 (conv_i_src_c028_0_06 0 conv_bpf_c028_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_0_06 (conv_i_src_c028_0_06 conv_i_c028_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_06 (conv_q_src_c028_0_06 0 conv_bpf_c028_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_0_06 (conv_q_src_c028_0_06 conv_q_c028_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_07 (conv_i_src_c028_0_07 0 conv_bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_0_07 (conv_i_src_c028_0_07 conv_i_c028_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_07 (conv_q_src_c028_0_07 0 conv_bpf_c028_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_0_07 (conv_q_src_c028_0_07 conv_q_c028_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_08 (conv_i_src_c028_0_08 0 conv_bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_0_08 (conv_i_src_c028_0_08 conv_i_c028_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_08 (conv_q_src_c028_0_08 0 conv_bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_0_08 (conv_q_src_c028_0_08 conv_q_c028_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_09 (conv_i_src_c028_0_09 0 conv_bpf_c028_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_0_09 (conv_i_src_c028_0_09 conv_i_c028_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_09 (conv_q_src_c028_0_09 0 conv_bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_0_09 (conv_q_src_c028_0_09 conv_q_c028_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_10 (conv_i_src_c028_0_10 0 conv_bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_0_10 (conv_i_src_c028_0_10 conv_i_c028_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_10 (conv_q_src_c028_0_10 0 conv_bpf_c028_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_0_10 (conv_q_src_c028_0_10 conv_q_c028_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_11 (conv_i_src_c028_0_11 0 conv_bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_0_11 (conv_i_src_c028_0_11 conv_i_c028_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_11 (conv_q_src_c028_0_11 0 conv_bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_0_11 (conv_q_src_c028_0_11 conv_q_c028_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_12 (conv_i_src_c028_0_12 0 conv_bpf_c028_0 0) vcvs gain=1.950903220161e-01
SCONVI_c028_0_12 (conv_i_src_c028_0_12 conv_i_c028_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_12 (conv_q_src_c028_0_12 0 conv_bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_0_12 (conv_q_src_c028_0_12 conv_q_c028_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_13 (conv_i_src_c028_0_13 0 conv_bpf_c028_0 0) vcvs gain=5.555702330196e-01
SCONVI_c028_0_13 (conv_i_src_c028_0_13 conv_i_c028_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_13 (conv_q_src_c028_0_13 0 conv_bpf_c028_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_0_13 (conv_q_src_c028_0_13 conv_q_c028_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_14 (conv_i_src_c028_0_14 0 conv_bpf_c028_0 0) vcvs gain=8.314696123025e-01
SCONVI_c028_0_14 (conv_i_src_c028_0_14 conv_i_c028_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_14 (conv_q_src_c028_0_14 0 conv_bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_0_14 (conv_q_src_c028_0_14 conv_q_c028_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_0_15 (conv_i_src_c028_0_15 0 conv_bpf_c028_0 0) vcvs gain=9.807852804032e-01
SCONVI_c028_0_15 (conv_i_src_c028_0_15 conv_i_c028_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_0_15 (conv_q_src_c028_0_15 0 conv_bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_0_15 (conv_q_src_c028_0_15 conv_q_c028_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c028_0 (conv_i_c028_0 0) resistor r=1G
RCONVQ_c028_0 (conv_q_c028_0 0) resistor r=1G
RCONVINTI_c028_0 (conv_i_c028_0 ConvIcar_c028_0) resistor r=1k
CCONVINTI_c028_0 (ConvIcar_c028_0 0) capacitor c=80p
RCONVINTQ_c028_0 (conv_q_c028_0 ConvQcar_c028_0) resistor r=1k
CCONVINTQ_c028_0 (ConvQcar_c028_0 0) capacitor c=80p
save conv_bpf_c028_0 ConvIcar_c028_0 ConvQcar_c028_0

// conventional mixed baseline bl028, carrier_1: 500000000 Hz
CCONVBPF_c028_1 (bl028 n_conv_cbpf_c028_1) capacitor c=1.013211836423e-13
LCONVBPF_c028_1 (n_conv_cbpf_c028_1 conv_bpf_c028_1) inductor l=1.000000000000e-06
RCONVBPF_c028_1 (conv_bpf_c028_1 0) resistor r=1.570796326795e+02
ECONVI_c028_1_00 (conv_i_src_c028_1_00 0 conv_bpf_c028_1 0) vcvs gain=9.807852804032e-01
SCONVI_c028_1_00 (conv_i_src_c028_1_00 conv_i_c028_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_00 (conv_q_src_c028_1_00 0 conv_bpf_c028_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_1_00 (conv_q_src_c028_1_00 conv_q_c028_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_01 (conv_i_src_c028_1_01 0 conv_bpf_c028_1 0) vcvs gain=8.314696123025e-01
SCONVI_c028_1_01 (conv_i_src_c028_1_01 conv_i_c028_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_01 (conv_q_src_c028_1_01 0 conv_bpf_c028_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_1_01 (conv_q_src_c028_1_01 conv_q_c028_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_02 (conv_i_src_c028_1_02 0 conv_bpf_c028_1 0) vcvs gain=5.555702330196e-01
SCONVI_c028_1_02 (conv_i_src_c028_1_02 conv_i_c028_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_02 (conv_q_src_c028_1_02 0 conv_bpf_c028_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_1_02 (conv_q_src_c028_1_02 conv_q_c028_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_03 (conv_i_src_c028_1_03 0 conv_bpf_c028_1 0) vcvs gain=1.950903220161e-01
SCONVI_c028_1_03 (conv_i_src_c028_1_03 conv_i_c028_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_03 (conv_q_src_c028_1_03 0 conv_bpf_c028_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_1_03 (conv_q_src_c028_1_03 conv_q_c028_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_04 (conv_i_src_c028_1_04 0 conv_bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_1_04 (conv_i_src_c028_1_04 conv_i_c028_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_04 (conv_q_src_c028_1_04 0 conv_bpf_c028_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_1_04 (conv_q_src_c028_1_04 conv_q_c028_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_05 (conv_i_src_c028_1_05 0 conv_bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_1_05 (conv_i_src_c028_1_05 conv_i_c028_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_05 (conv_q_src_c028_1_05 0 conv_bpf_c028_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_1_05 (conv_q_src_c028_1_05 conv_q_c028_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_06 (conv_i_src_c028_1_06 0 conv_bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_1_06 (conv_i_src_c028_1_06 conv_i_c028_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_06 (conv_q_src_c028_1_06 0 conv_bpf_c028_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_1_06 (conv_q_src_c028_1_06 conv_q_c028_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_07 (conv_i_src_c028_1_07 0 conv_bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_1_07 (conv_i_src_c028_1_07 conv_i_c028_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_07 (conv_q_src_c028_1_07 0 conv_bpf_c028_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_1_07 (conv_q_src_c028_1_07 conv_q_c028_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_08 (conv_i_src_c028_1_08 0 conv_bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_1_08 (conv_i_src_c028_1_08 conv_i_c028_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_08 (conv_q_src_c028_1_08 0 conv_bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_1_08 (conv_q_src_c028_1_08 conv_q_c028_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_09 (conv_i_src_c028_1_09 0 conv_bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_1_09 (conv_i_src_c028_1_09 conv_i_c028_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_09 (conv_q_src_c028_1_09 0 conv_bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_1_09 (conv_q_src_c028_1_09 conv_q_c028_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_10 (conv_i_src_c028_1_10 0 conv_bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_1_10 (conv_i_src_c028_1_10 conv_i_c028_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_10 (conv_q_src_c028_1_10 0 conv_bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_1_10 (conv_q_src_c028_1_10 conv_q_c028_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_11 (conv_i_src_c028_1_11 0 conv_bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_1_11 (conv_i_src_c028_1_11 conv_i_c028_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_11 (conv_q_src_c028_1_11 0 conv_bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_1_11 (conv_q_src_c028_1_11 conv_q_c028_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_12 (conv_i_src_c028_1_12 0 conv_bpf_c028_1 0) vcvs gain=1.950903220161e-01
SCONVI_c028_1_12 (conv_i_src_c028_1_12 conv_i_c028_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_12 (conv_q_src_c028_1_12 0 conv_bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_1_12 (conv_q_src_c028_1_12 conv_q_c028_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_13 (conv_i_src_c028_1_13 0 conv_bpf_c028_1 0) vcvs gain=5.555702330196e-01
SCONVI_c028_1_13 (conv_i_src_c028_1_13 conv_i_c028_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_13 (conv_q_src_c028_1_13 0 conv_bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_1_13 (conv_q_src_c028_1_13 conv_q_c028_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_14 (conv_i_src_c028_1_14 0 conv_bpf_c028_1 0) vcvs gain=8.314696123025e-01
SCONVI_c028_1_14 (conv_i_src_c028_1_14 conv_i_c028_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_14 (conv_q_src_c028_1_14 0 conv_bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_1_14 (conv_q_src_c028_1_14 conv_q_c028_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_1_15 (conv_i_src_c028_1_15 0 conv_bpf_c028_1 0) vcvs gain=9.807852804032e-01
SCONVI_c028_1_15 (conv_i_src_c028_1_15 conv_i_c028_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_1_15 (conv_q_src_c028_1_15 0 conv_bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_1_15 (conv_q_src_c028_1_15 conv_q_c028_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c028_1 (conv_i_c028_1 0) resistor r=1G
RCONVQ_c028_1 (conv_q_c028_1 0) resistor r=1G
RCONVINTI_c028_1 (conv_i_c028_1 ConvIcar_c028_1) resistor r=1k
CCONVINTI_c028_1 (ConvIcar_c028_1 0) capacitor c=80p
RCONVINTQ_c028_1 (conv_q_c028_1 ConvQcar_c028_1) resistor r=1k
CCONVINTQ_c028_1 (ConvQcar_c028_1 0) capacitor c=80p
save conv_bpf_c028_1 ConvIcar_c028_1 ConvQcar_c028_1

// conventional mixed baseline bl028, carrier_2: 750000000 Hz
CCONVBPF_c028_2 (bl028 n_conv_cbpf_c028_2) capacitor c=4.503163717437e-14
LCONVBPF_c028_2 (n_conv_cbpf_c028_2 conv_bpf_c028_2) inductor l=1.000000000000e-06
RCONVBPF_c028_2 (conv_bpf_c028_2 0) resistor r=2.356194490192e+02
ECONVI_c028_2_00 (conv_i_src_c028_2_00 0 conv_bpf_c028_2 0) vcvs gain=9.807852804032e-01
SCONVI_c028_2_00 (conv_i_src_c028_2_00 conv_i_c028_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_00 (conv_q_src_c028_2_00 0 conv_bpf_c028_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_2_00 (conv_q_src_c028_2_00 conv_q_c028_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_01 (conv_i_src_c028_2_01 0 conv_bpf_c028_2 0) vcvs gain=8.314696123025e-01
SCONVI_c028_2_01 (conv_i_src_c028_2_01 conv_i_c028_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_01 (conv_q_src_c028_2_01 0 conv_bpf_c028_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_2_01 (conv_q_src_c028_2_01 conv_q_c028_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_02 (conv_i_src_c028_2_02 0 conv_bpf_c028_2 0) vcvs gain=5.555702330196e-01
SCONVI_c028_2_02 (conv_i_src_c028_2_02 conv_i_c028_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_02 (conv_q_src_c028_2_02 0 conv_bpf_c028_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_2_02 (conv_q_src_c028_2_02 conv_q_c028_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_03 (conv_i_src_c028_2_03 0 conv_bpf_c028_2 0) vcvs gain=1.950903220161e-01
SCONVI_c028_2_03 (conv_i_src_c028_2_03 conv_i_c028_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_03 (conv_q_src_c028_2_03 0 conv_bpf_c028_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_2_03 (conv_q_src_c028_2_03 conv_q_c028_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_04 (conv_i_src_c028_2_04 0 conv_bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_2_04 (conv_i_src_c028_2_04 conv_i_c028_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_04 (conv_q_src_c028_2_04 0 conv_bpf_c028_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_2_04 (conv_q_src_c028_2_04 conv_q_c028_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_05 (conv_i_src_c028_2_05 0 conv_bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_2_05 (conv_i_src_c028_2_05 conv_i_c028_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_05 (conv_q_src_c028_2_05 0 conv_bpf_c028_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_2_05 (conv_q_src_c028_2_05 conv_q_c028_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_06 (conv_i_src_c028_2_06 0 conv_bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_2_06 (conv_i_src_c028_2_06 conv_i_c028_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_06 (conv_q_src_c028_2_06 0 conv_bpf_c028_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_2_06 (conv_q_src_c028_2_06 conv_q_c028_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_07 (conv_i_src_c028_2_07 0 conv_bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_2_07 (conv_i_src_c028_2_07 conv_i_c028_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_07 (conv_q_src_c028_2_07 0 conv_bpf_c028_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_2_07 (conv_q_src_c028_2_07 conv_q_c028_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_08 (conv_i_src_c028_2_08 0 conv_bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_2_08 (conv_i_src_c028_2_08 conv_i_c028_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_08 (conv_q_src_c028_2_08 0 conv_bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_2_08 (conv_q_src_c028_2_08 conv_q_c028_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_09 (conv_i_src_c028_2_09 0 conv_bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_2_09 (conv_i_src_c028_2_09 conv_i_c028_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_09 (conv_q_src_c028_2_09 0 conv_bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_2_09 (conv_q_src_c028_2_09 conv_q_c028_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_10 (conv_i_src_c028_2_10 0 conv_bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_2_10 (conv_i_src_c028_2_10 conv_i_c028_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_10 (conv_q_src_c028_2_10 0 conv_bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_2_10 (conv_q_src_c028_2_10 conv_q_c028_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_11 (conv_i_src_c028_2_11 0 conv_bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_2_11 (conv_i_src_c028_2_11 conv_i_c028_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_11 (conv_q_src_c028_2_11 0 conv_bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_2_11 (conv_q_src_c028_2_11 conv_q_c028_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_12 (conv_i_src_c028_2_12 0 conv_bpf_c028_2 0) vcvs gain=1.950903220161e-01
SCONVI_c028_2_12 (conv_i_src_c028_2_12 conv_i_c028_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_12 (conv_q_src_c028_2_12 0 conv_bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_2_12 (conv_q_src_c028_2_12 conv_q_c028_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_13 (conv_i_src_c028_2_13 0 conv_bpf_c028_2 0) vcvs gain=5.555702330196e-01
SCONVI_c028_2_13 (conv_i_src_c028_2_13 conv_i_c028_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_13 (conv_q_src_c028_2_13 0 conv_bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_2_13 (conv_q_src_c028_2_13 conv_q_c028_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_14 (conv_i_src_c028_2_14 0 conv_bpf_c028_2 0) vcvs gain=8.314696123025e-01
SCONVI_c028_2_14 (conv_i_src_c028_2_14 conv_i_c028_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_14 (conv_q_src_c028_2_14 0 conv_bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_2_14 (conv_q_src_c028_2_14 conv_q_c028_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_2_15 (conv_i_src_c028_2_15 0 conv_bpf_c028_2 0) vcvs gain=9.807852804032e-01
SCONVI_c028_2_15 (conv_i_src_c028_2_15 conv_i_c028_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_2_15 (conv_q_src_c028_2_15 0 conv_bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_2_15 (conv_q_src_c028_2_15 conv_q_c028_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c028_2 (conv_i_c028_2 0) resistor r=1G
RCONVQ_c028_2 (conv_q_c028_2 0) resistor r=1G
RCONVINTI_c028_2 (conv_i_c028_2 ConvIcar_c028_2) resistor r=1k
CCONVINTI_c028_2 (ConvIcar_c028_2 0) capacitor c=80p
RCONVINTQ_c028_2 (conv_q_c028_2 ConvQcar_c028_2) resistor r=1k
CCONVINTQ_c028_2 (ConvQcar_c028_2 0) capacitor c=80p
save conv_bpf_c028_2 ConvIcar_c028_2 ConvQcar_c028_2

// conventional mixed baseline bl028, carrier_3: 1000000000 Hz
CCONVBPF_c028_3 (bl028 n_conv_cbpf_c028_3) capacitor c=2.533029591058e-14
LCONVBPF_c028_3 (n_conv_cbpf_c028_3 conv_bpf_c028_3) inductor l=1.000000000000e-06
RCONVBPF_c028_3 (conv_bpf_c028_3 0) resistor r=3.141592653590e+02
ECONVI_c028_3_00 (conv_i_src_c028_3_00 0 conv_bpf_c028_3 0) vcvs gain=9.807852804032e-01
SCONVI_c028_3_00 (conv_i_src_c028_3_00 conv_i_c028_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_00 (conv_q_src_c028_3_00 0 conv_bpf_c028_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_3_00 (conv_q_src_c028_3_00 conv_q_c028_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_01 (conv_i_src_c028_3_01 0 conv_bpf_c028_3 0) vcvs gain=8.314696123025e-01
SCONVI_c028_3_01 (conv_i_src_c028_3_01 conv_i_c028_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_01 (conv_q_src_c028_3_01 0 conv_bpf_c028_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_3_01 (conv_q_src_c028_3_01 conv_q_c028_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_02 (conv_i_src_c028_3_02 0 conv_bpf_c028_3 0) vcvs gain=5.555702330196e-01
SCONVI_c028_3_02 (conv_i_src_c028_3_02 conv_i_c028_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_02 (conv_q_src_c028_3_02 0 conv_bpf_c028_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_3_02 (conv_q_src_c028_3_02 conv_q_c028_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_03 (conv_i_src_c028_3_03 0 conv_bpf_c028_3 0) vcvs gain=1.950903220161e-01
SCONVI_c028_3_03 (conv_i_src_c028_3_03 conv_i_c028_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_03 (conv_q_src_c028_3_03 0 conv_bpf_c028_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_3_03 (conv_q_src_c028_3_03 conv_q_c028_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_04 (conv_i_src_c028_3_04 0 conv_bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_3_04 (conv_i_src_c028_3_04 conv_i_c028_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_04 (conv_q_src_c028_3_04 0 conv_bpf_c028_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c028_3_04 (conv_q_src_c028_3_04 conv_q_c028_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_05 (conv_i_src_c028_3_05 0 conv_bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_3_05 (conv_i_src_c028_3_05 conv_i_c028_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_05 (conv_q_src_c028_3_05 0 conv_bpf_c028_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c028_3_05 (conv_q_src_c028_3_05 conv_q_c028_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_06 (conv_i_src_c028_3_06 0 conv_bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_3_06 (conv_i_src_c028_3_06 conv_i_c028_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_06 (conv_q_src_c028_3_06 0 conv_bpf_c028_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c028_3_06 (conv_q_src_c028_3_06 conv_q_c028_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_07 (conv_i_src_c028_3_07 0 conv_bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_3_07 (conv_i_src_c028_3_07 conv_i_c028_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_07 (conv_q_src_c028_3_07 0 conv_bpf_c028_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c028_3_07 (conv_q_src_c028_3_07 conv_q_c028_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_08 (conv_i_src_c028_3_08 0 conv_bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c028_3_08 (conv_i_src_c028_3_08 conv_i_c028_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_08 (conv_q_src_c028_3_08 0 conv_bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_3_08 (conv_q_src_c028_3_08 conv_q_c028_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_09 (conv_i_src_c028_3_09 0 conv_bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c028_3_09 (conv_i_src_c028_3_09 conv_i_c028_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_09 (conv_q_src_c028_3_09 0 conv_bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_3_09 (conv_q_src_c028_3_09 conv_q_c028_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_10 (conv_i_src_c028_3_10 0 conv_bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c028_3_10 (conv_i_src_c028_3_10 conv_i_c028_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_10 (conv_q_src_c028_3_10 0 conv_bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_3_10 (conv_q_src_c028_3_10 conv_q_c028_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_11 (conv_i_src_c028_3_11 0 conv_bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c028_3_11 (conv_i_src_c028_3_11 conv_i_c028_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_11 (conv_q_src_c028_3_11 0 conv_bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_3_11 (conv_q_src_c028_3_11 conv_q_c028_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_12 (conv_i_src_c028_3_12 0 conv_bpf_c028_3 0) vcvs gain=1.950903220161e-01
SCONVI_c028_3_12 (conv_i_src_c028_3_12 conv_i_c028_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_12 (conv_q_src_c028_3_12 0 conv_bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c028_3_12 (conv_q_src_c028_3_12 conv_q_c028_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_13 (conv_i_src_c028_3_13 0 conv_bpf_c028_3 0) vcvs gain=5.555702330196e-01
SCONVI_c028_3_13 (conv_i_src_c028_3_13 conv_i_c028_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_13 (conv_q_src_c028_3_13 0 conv_bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c028_3_13 (conv_q_src_c028_3_13 conv_q_c028_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_14 (conv_i_src_c028_3_14 0 conv_bpf_c028_3 0) vcvs gain=8.314696123025e-01
SCONVI_c028_3_14 (conv_i_src_c028_3_14 conv_i_c028_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_14 (conv_q_src_c028_3_14 0 conv_bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c028_3_14 (conv_q_src_c028_3_14 conv_q_c028_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c028_3_15 (conv_i_src_c028_3_15 0 conv_bpf_c028_3 0) vcvs gain=9.807852804032e-01
SCONVI_c028_3_15 (conv_i_src_c028_3_15 conv_i_c028_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c028_3_15 (conv_q_src_c028_3_15 0 conv_bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c028_3_15 (conv_q_src_c028_3_15 conv_q_c028_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c028_3 (conv_i_c028_3 0) resistor r=1G
RCONVQ_c028_3 (conv_q_c028_3 0) resistor r=1G
RCONVINTI_c028_3 (conv_i_c028_3 ConvIcar_c028_3) resistor r=1k
CCONVINTI_c028_3 (ConvIcar_c028_3 0) capacitor c=80p
RCONVINTQ_c028_3 (conv_q_c028_3 ConvQcar_c028_3) resistor r=1k
CCONVINTQ_c028_3 (ConvQcar_c028_3 0) capacitor c=80p
save conv_bpf_c028_3 ConvIcar_c028_3 ConvQcar_c028_3

// conventional mixed baseline bl029, carrier_0: 250000000 Hz
CCONVBPF_c029_0 (bl029 n_conv_cbpf_c029_0) capacitor c=4.052847345694e-13
LCONVBPF_c029_0 (n_conv_cbpf_c029_0 conv_bpf_c029_0) inductor l=1.000000000000e-06
RCONVBPF_c029_0 (conv_bpf_c029_0 0) resistor r=7.853981633974e+01
ECONVI_c029_0_00 (conv_i_src_c029_0_00 0 conv_bpf_c029_0 0) vcvs gain=9.807852804032e-01
SCONVI_c029_0_00 (conv_i_src_c029_0_00 conv_i_c029_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_00 (conv_q_src_c029_0_00 0 conv_bpf_c029_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_0_00 (conv_q_src_c029_0_00 conv_q_c029_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_01 (conv_i_src_c029_0_01 0 conv_bpf_c029_0 0) vcvs gain=8.314696123025e-01
SCONVI_c029_0_01 (conv_i_src_c029_0_01 conv_i_c029_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_01 (conv_q_src_c029_0_01 0 conv_bpf_c029_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_0_01 (conv_q_src_c029_0_01 conv_q_c029_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_02 (conv_i_src_c029_0_02 0 conv_bpf_c029_0 0) vcvs gain=5.555702330196e-01
SCONVI_c029_0_02 (conv_i_src_c029_0_02 conv_i_c029_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_02 (conv_q_src_c029_0_02 0 conv_bpf_c029_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_0_02 (conv_q_src_c029_0_02 conv_q_c029_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_03 (conv_i_src_c029_0_03 0 conv_bpf_c029_0 0) vcvs gain=1.950903220161e-01
SCONVI_c029_0_03 (conv_i_src_c029_0_03 conv_i_c029_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_03 (conv_q_src_c029_0_03 0 conv_bpf_c029_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_0_03 (conv_q_src_c029_0_03 conv_q_c029_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_04 (conv_i_src_c029_0_04 0 conv_bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_0_04 (conv_i_src_c029_0_04 conv_i_c029_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_04 (conv_q_src_c029_0_04 0 conv_bpf_c029_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_0_04 (conv_q_src_c029_0_04 conv_q_c029_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_05 (conv_i_src_c029_0_05 0 conv_bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_0_05 (conv_i_src_c029_0_05 conv_i_c029_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_05 (conv_q_src_c029_0_05 0 conv_bpf_c029_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_0_05 (conv_q_src_c029_0_05 conv_q_c029_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_06 (conv_i_src_c029_0_06 0 conv_bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_0_06 (conv_i_src_c029_0_06 conv_i_c029_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_06 (conv_q_src_c029_0_06 0 conv_bpf_c029_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_0_06 (conv_q_src_c029_0_06 conv_q_c029_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_07 (conv_i_src_c029_0_07 0 conv_bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_0_07 (conv_i_src_c029_0_07 conv_i_c029_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_07 (conv_q_src_c029_0_07 0 conv_bpf_c029_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_0_07 (conv_q_src_c029_0_07 conv_q_c029_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_08 (conv_i_src_c029_0_08 0 conv_bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_0_08 (conv_i_src_c029_0_08 conv_i_c029_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_08 (conv_q_src_c029_0_08 0 conv_bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_0_08 (conv_q_src_c029_0_08 conv_q_c029_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_09 (conv_i_src_c029_0_09 0 conv_bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_0_09 (conv_i_src_c029_0_09 conv_i_c029_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_09 (conv_q_src_c029_0_09 0 conv_bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_0_09 (conv_q_src_c029_0_09 conv_q_c029_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_10 (conv_i_src_c029_0_10 0 conv_bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_0_10 (conv_i_src_c029_0_10 conv_i_c029_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_10 (conv_q_src_c029_0_10 0 conv_bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_0_10 (conv_q_src_c029_0_10 conv_q_c029_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_11 (conv_i_src_c029_0_11 0 conv_bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_0_11 (conv_i_src_c029_0_11 conv_i_c029_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_11 (conv_q_src_c029_0_11 0 conv_bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_0_11 (conv_q_src_c029_0_11 conv_q_c029_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_12 (conv_i_src_c029_0_12 0 conv_bpf_c029_0 0) vcvs gain=1.950903220161e-01
SCONVI_c029_0_12 (conv_i_src_c029_0_12 conv_i_c029_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_12 (conv_q_src_c029_0_12 0 conv_bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_0_12 (conv_q_src_c029_0_12 conv_q_c029_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_13 (conv_i_src_c029_0_13 0 conv_bpf_c029_0 0) vcvs gain=5.555702330196e-01
SCONVI_c029_0_13 (conv_i_src_c029_0_13 conv_i_c029_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_13 (conv_q_src_c029_0_13 0 conv_bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_0_13 (conv_q_src_c029_0_13 conv_q_c029_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_14 (conv_i_src_c029_0_14 0 conv_bpf_c029_0 0) vcvs gain=8.314696123025e-01
SCONVI_c029_0_14 (conv_i_src_c029_0_14 conv_i_c029_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_14 (conv_q_src_c029_0_14 0 conv_bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_0_14 (conv_q_src_c029_0_14 conv_q_c029_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_0_15 (conv_i_src_c029_0_15 0 conv_bpf_c029_0 0) vcvs gain=9.807852804032e-01
SCONVI_c029_0_15 (conv_i_src_c029_0_15 conv_i_c029_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_0_15 (conv_q_src_c029_0_15 0 conv_bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_0_15 (conv_q_src_c029_0_15 conv_q_c029_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c029_0 (conv_i_c029_0 0) resistor r=1G
RCONVQ_c029_0 (conv_q_c029_0 0) resistor r=1G
RCONVINTI_c029_0 (conv_i_c029_0 ConvIcar_c029_0) resistor r=1k
CCONVINTI_c029_0 (ConvIcar_c029_0 0) capacitor c=80p
RCONVINTQ_c029_0 (conv_q_c029_0 ConvQcar_c029_0) resistor r=1k
CCONVINTQ_c029_0 (ConvQcar_c029_0 0) capacitor c=80p
save conv_bpf_c029_0 ConvIcar_c029_0 ConvQcar_c029_0

// conventional mixed baseline bl029, carrier_1: 500000000 Hz
CCONVBPF_c029_1 (bl029 n_conv_cbpf_c029_1) capacitor c=1.013211836423e-13
LCONVBPF_c029_1 (n_conv_cbpf_c029_1 conv_bpf_c029_1) inductor l=1.000000000000e-06
RCONVBPF_c029_1 (conv_bpf_c029_1 0) resistor r=1.570796326795e+02
ECONVI_c029_1_00 (conv_i_src_c029_1_00 0 conv_bpf_c029_1 0) vcvs gain=9.807852804032e-01
SCONVI_c029_1_00 (conv_i_src_c029_1_00 conv_i_c029_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_00 (conv_q_src_c029_1_00 0 conv_bpf_c029_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_1_00 (conv_q_src_c029_1_00 conv_q_c029_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_01 (conv_i_src_c029_1_01 0 conv_bpf_c029_1 0) vcvs gain=8.314696123025e-01
SCONVI_c029_1_01 (conv_i_src_c029_1_01 conv_i_c029_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_01 (conv_q_src_c029_1_01 0 conv_bpf_c029_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_1_01 (conv_q_src_c029_1_01 conv_q_c029_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_02 (conv_i_src_c029_1_02 0 conv_bpf_c029_1 0) vcvs gain=5.555702330196e-01
SCONVI_c029_1_02 (conv_i_src_c029_1_02 conv_i_c029_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_02 (conv_q_src_c029_1_02 0 conv_bpf_c029_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_1_02 (conv_q_src_c029_1_02 conv_q_c029_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_03 (conv_i_src_c029_1_03 0 conv_bpf_c029_1 0) vcvs gain=1.950903220161e-01
SCONVI_c029_1_03 (conv_i_src_c029_1_03 conv_i_c029_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_03 (conv_q_src_c029_1_03 0 conv_bpf_c029_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_1_03 (conv_q_src_c029_1_03 conv_q_c029_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_04 (conv_i_src_c029_1_04 0 conv_bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_1_04 (conv_i_src_c029_1_04 conv_i_c029_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_04 (conv_q_src_c029_1_04 0 conv_bpf_c029_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_1_04 (conv_q_src_c029_1_04 conv_q_c029_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_05 (conv_i_src_c029_1_05 0 conv_bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_1_05 (conv_i_src_c029_1_05 conv_i_c029_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_05 (conv_q_src_c029_1_05 0 conv_bpf_c029_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_1_05 (conv_q_src_c029_1_05 conv_q_c029_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_06 (conv_i_src_c029_1_06 0 conv_bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_1_06 (conv_i_src_c029_1_06 conv_i_c029_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_06 (conv_q_src_c029_1_06 0 conv_bpf_c029_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_1_06 (conv_q_src_c029_1_06 conv_q_c029_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_07 (conv_i_src_c029_1_07 0 conv_bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_1_07 (conv_i_src_c029_1_07 conv_i_c029_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_07 (conv_q_src_c029_1_07 0 conv_bpf_c029_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_1_07 (conv_q_src_c029_1_07 conv_q_c029_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_08 (conv_i_src_c029_1_08 0 conv_bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_1_08 (conv_i_src_c029_1_08 conv_i_c029_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_08 (conv_q_src_c029_1_08 0 conv_bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_1_08 (conv_q_src_c029_1_08 conv_q_c029_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_09 (conv_i_src_c029_1_09 0 conv_bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_1_09 (conv_i_src_c029_1_09 conv_i_c029_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_09 (conv_q_src_c029_1_09 0 conv_bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_1_09 (conv_q_src_c029_1_09 conv_q_c029_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_10 (conv_i_src_c029_1_10 0 conv_bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_1_10 (conv_i_src_c029_1_10 conv_i_c029_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_10 (conv_q_src_c029_1_10 0 conv_bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_1_10 (conv_q_src_c029_1_10 conv_q_c029_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_11 (conv_i_src_c029_1_11 0 conv_bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_1_11 (conv_i_src_c029_1_11 conv_i_c029_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_11 (conv_q_src_c029_1_11 0 conv_bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_1_11 (conv_q_src_c029_1_11 conv_q_c029_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_12 (conv_i_src_c029_1_12 0 conv_bpf_c029_1 0) vcvs gain=1.950903220161e-01
SCONVI_c029_1_12 (conv_i_src_c029_1_12 conv_i_c029_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_12 (conv_q_src_c029_1_12 0 conv_bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_1_12 (conv_q_src_c029_1_12 conv_q_c029_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_13 (conv_i_src_c029_1_13 0 conv_bpf_c029_1 0) vcvs gain=5.555702330196e-01
SCONVI_c029_1_13 (conv_i_src_c029_1_13 conv_i_c029_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_13 (conv_q_src_c029_1_13 0 conv_bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_1_13 (conv_q_src_c029_1_13 conv_q_c029_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_14 (conv_i_src_c029_1_14 0 conv_bpf_c029_1 0) vcvs gain=8.314696123025e-01
SCONVI_c029_1_14 (conv_i_src_c029_1_14 conv_i_c029_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_14 (conv_q_src_c029_1_14 0 conv_bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_1_14 (conv_q_src_c029_1_14 conv_q_c029_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_1_15 (conv_i_src_c029_1_15 0 conv_bpf_c029_1 0) vcvs gain=9.807852804032e-01
SCONVI_c029_1_15 (conv_i_src_c029_1_15 conv_i_c029_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_1_15 (conv_q_src_c029_1_15 0 conv_bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_1_15 (conv_q_src_c029_1_15 conv_q_c029_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c029_1 (conv_i_c029_1 0) resistor r=1G
RCONVQ_c029_1 (conv_q_c029_1 0) resistor r=1G
RCONVINTI_c029_1 (conv_i_c029_1 ConvIcar_c029_1) resistor r=1k
CCONVINTI_c029_1 (ConvIcar_c029_1 0) capacitor c=80p
RCONVINTQ_c029_1 (conv_q_c029_1 ConvQcar_c029_1) resistor r=1k
CCONVINTQ_c029_1 (ConvQcar_c029_1 0) capacitor c=80p
save conv_bpf_c029_1 ConvIcar_c029_1 ConvQcar_c029_1

// conventional mixed baseline bl029, carrier_2: 750000000 Hz
CCONVBPF_c029_2 (bl029 n_conv_cbpf_c029_2) capacitor c=4.503163717437e-14
LCONVBPF_c029_2 (n_conv_cbpf_c029_2 conv_bpf_c029_2) inductor l=1.000000000000e-06
RCONVBPF_c029_2 (conv_bpf_c029_2 0) resistor r=2.356194490192e+02
ECONVI_c029_2_00 (conv_i_src_c029_2_00 0 conv_bpf_c029_2 0) vcvs gain=9.807852804032e-01
SCONVI_c029_2_00 (conv_i_src_c029_2_00 conv_i_c029_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_00 (conv_q_src_c029_2_00 0 conv_bpf_c029_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_2_00 (conv_q_src_c029_2_00 conv_q_c029_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_01 (conv_i_src_c029_2_01 0 conv_bpf_c029_2 0) vcvs gain=8.314696123025e-01
SCONVI_c029_2_01 (conv_i_src_c029_2_01 conv_i_c029_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_01 (conv_q_src_c029_2_01 0 conv_bpf_c029_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_2_01 (conv_q_src_c029_2_01 conv_q_c029_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_02 (conv_i_src_c029_2_02 0 conv_bpf_c029_2 0) vcvs gain=5.555702330196e-01
SCONVI_c029_2_02 (conv_i_src_c029_2_02 conv_i_c029_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_02 (conv_q_src_c029_2_02 0 conv_bpf_c029_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_2_02 (conv_q_src_c029_2_02 conv_q_c029_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_03 (conv_i_src_c029_2_03 0 conv_bpf_c029_2 0) vcvs gain=1.950903220161e-01
SCONVI_c029_2_03 (conv_i_src_c029_2_03 conv_i_c029_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_03 (conv_q_src_c029_2_03 0 conv_bpf_c029_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_2_03 (conv_q_src_c029_2_03 conv_q_c029_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_04 (conv_i_src_c029_2_04 0 conv_bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_2_04 (conv_i_src_c029_2_04 conv_i_c029_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_04 (conv_q_src_c029_2_04 0 conv_bpf_c029_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_2_04 (conv_q_src_c029_2_04 conv_q_c029_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_05 (conv_i_src_c029_2_05 0 conv_bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_2_05 (conv_i_src_c029_2_05 conv_i_c029_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_05 (conv_q_src_c029_2_05 0 conv_bpf_c029_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_2_05 (conv_q_src_c029_2_05 conv_q_c029_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_06 (conv_i_src_c029_2_06 0 conv_bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_2_06 (conv_i_src_c029_2_06 conv_i_c029_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_06 (conv_q_src_c029_2_06 0 conv_bpf_c029_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_2_06 (conv_q_src_c029_2_06 conv_q_c029_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_07 (conv_i_src_c029_2_07 0 conv_bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_2_07 (conv_i_src_c029_2_07 conv_i_c029_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_07 (conv_q_src_c029_2_07 0 conv_bpf_c029_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_2_07 (conv_q_src_c029_2_07 conv_q_c029_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_08 (conv_i_src_c029_2_08 0 conv_bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_2_08 (conv_i_src_c029_2_08 conv_i_c029_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_08 (conv_q_src_c029_2_08 0 conv_bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_2_08 (conv_q_src_c029_2_08 conv_q_c029_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_09 (conv_i_src_c029_2_09 0 conv_bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_2_09 (conv_i_src_c029_2_09 conv_i_c029_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_09 (conv_q_src_c029_2_09 0 conv_bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_2_09 (conv_q_src_c029_2_09 conv_q_c029_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_10 (conv_i_src_c029_2_10 0 conv_bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_2_10 (conv_i_src_c029_2_10 conv_i_c029_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_10 (conv_q_src_c029_2_10 0 conv_bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_2_10 (conv_q_src_c029_2_10 conv_q_c029_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_11 (conv_i_src_c029_2_11 0 conv_bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_2_11 (conv_i_src_c029_2_11 conv_i_c029_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_11 (conv_q_src_c029_2_11 0 conv_bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_2_11 (conv_q_src_c029_2_11 conv_q_c029_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_12 (conv_i_src_c029_2_12 0 conv_bpf_c029_2 0) vcvs gain=1.950903220161e-01
SCONVI_c029_2_12 (conv_i_src_c029_2_12 conv_i_c029_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_12 (conv_q_src_c029_2_12 0 conv_bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_2_12 (conv_q_src_c029_2_12 conv_q_c029_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_13 (conv_i_src_c029_2_13 0 conv_bpf_c029_2 0) vcvs gain=5.555702330196e-01
SCONVI_c029_2_13 (conv_i_src_c029_2_13 conv_i_c029_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_13 (conv_q_src_c029_2_13 0 conv_bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_2_13 (conv_q_src_c029_2_13 conv_q_c029_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_14 (conv_i_src_c029_2_14 0 conv_bpf_c029_2 0) vcvs gain=8.314696123025e-01
SCONVI_c029_2_14 (conv_i_src_c029_2_14 conv_i_c029_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_14 (conv_q_src_c029_2_14 0 conv_bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_2_14 (conv_q_src_c029_2_14 conv_q_c029_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_2_15 (conv_i_src_c029_2_15 0 conv_bpf_c029_2 0) vcvs gain=9.807852804032e-01
SCONVI_c029_2_15 (conv_i_src_c029_2_15 conv_i_c029_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_2_15 (conv_q_src_c029_2_15 0 conv_bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_2_15 (conv_q_src_c029_2_15 conv_q_c029_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c029_2 (conv_i_c029_2 0) resistor r=1G
RCONVQ_c029_2 (conv_q_c029_2 0) resistor r=1G
RCONVINTI_c029_2 (conv_i_c029_2 ConvIcar_c029_2) resistor r=1k
CCONVINTI_c029_2 (ConvIcar_c029_2 0) capacitor c=80p
RCONVINTQ_c029_2 (conv_q_c029_2 ConvQcar_c029_2) resistor r=1k
CCONVINTQ_c029_2 (ConvQcar_c029_2 0) capacitor c=80p
save conv_bpf_c029_2 ConvIcar_c029_2 ConvQcar_c029_2

// conventional mixed baseline bl029, carrier_3: 1000000000 Hz
CCONVBPF_c029_3 (bl029 n_conv_cbpf_c029_3) capacitor c=2.533029591058e-14
LCONVBPF_c029_3 (n_conv_cbpf_c029_3 conv_bpf_c029_3) inductor l=1.000000000000e-06
RCONVBPF_c029_3 (conv_bpf_c029_3 0) resistor r=3.141592653590e+02
ECONVI_c029_3_00 (conv_i_src_c029_3_00 0 conv_bpf_c029_3 0) vcvs gain=9.807852804032e-01
SCONVI_c029_3_00 (conv_i_src_c029_3_00 conv_i_c029_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_00 (conv_q_src_c029_3_00 0 conv_bpf_c029_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_3_00 (conv_q_src_c029_3_00 conv_q_c029_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_01 (conv_i_src_c029_3_01 0 conv_bpf_c029_3 0) vcvs gain=8.314696123025e-01
SCONVI_c029_3_01 (conv_i_src_c029_3_01 conv_i_c029_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_01 (conv_q_src_c029_3_01 0 conv_bpf_c029_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_3_01 (conv_q_src_c029_3_01 conv_q_c029_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_02 (conv_i_src_c029_3_02 0 conv_bpf_c029_3 0) vcvs gain=5.555702330196e-01
SCONVI_c029_3_02 (conv_i_src_c029_3_02 conv_i_c029_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_02 (conv_q_src_c029_3_02 0 conv_bpf_c029_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_3_02 (conv_q_src_c029_3_02 conv_q_c029_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_03 (conv_i_src_c029_3_03 0 conv_bpf_c029_3 0) vcvs gain=1.950903220161e-01
SCONVI_c029_3_03 (conv_i_src_c029_3_03 conv_i_c029_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_03 (conv_q_src_c029_3_03 0 conv_bpf_c029_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_3_03 (conv_q_src_c029_3_03 conv_q_c029_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_04 (conv_i_src_c029_3_04 0 conv_bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_3_04 (conv_i_src_c029_3_04 conv_i_c029_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_04 (conv_q_src_c029_3_04 0 conv_bpf_c029_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c029_3_04 (conv_q_src_c029_3_04 conv_q_c029_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_05 (conv_i_src_c029_3_05 0 conv_bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_3_05 (conv_i_src_c029_3_05 conv_i_c029_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_05 (conv_q_src_c029_3_05 0 conv_bpf_c029_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c029_3_05 (conv_q_src_c029_3_05 conv_q_c029_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_06 (conv_i_src_c029_3_06 0 conv_bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_3_06 (conv_i_src_c029_3_06 conv_i_c029_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_06 (conv_q_src_c029_3_06 0 conv_bpf_c029_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c029_3_06 (conv_q_src_c029_3_06 conv_q_c029_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_07 (conv_i_src_c029_3_07 0 conv_bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_3_07 (conv_i_src_c029_3_07 conv_i_c029_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_07 (conv_q_src_c029_3_07 0 conv_bpf_c029_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c029_3_07 (conv_q_src_c029_3_07 conv_q_c029_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_08 (conv_i_src_c029_3_08 0 conv_bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c029_3_08 (conv_i_src_c029_3_08 conv_i_c029_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_08 (conv_q_src_c029_3_08 0 conv_bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_3_08 (conv_q_src_c029_3_08 conv_q_c029_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_09 (conv_i_src_c029_3_09 0 conv_bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c029_3_09 (conv_i_src_c029_3_09 conv_i_c029_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_09 (conv_q_src_c029_3_09 0 conv_bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_3_09 (conv_q_src_c029_3_09 conv_q_c029_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_10 (conv_i_src_c029_3_10 0 conv_bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c029_3_10 (conv_i_src_c029_3_10 conv_i_c029_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_10 (conv_q_src_c029_3_10 0 conv_bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_3_10 (conv_q_src_c029_3_10 conv_q_c029_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_11 (conv_i_src_c029_3_11 0 conv_bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c029_3_11 (conv_i_src_c029_3_11 conv_i_c029_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_11 (conv_q_src_c029_3_11 0 conv_bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_3_11 (conv_q_src_c029_3_11 conv_q_c029_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_12 (conv_i_src_c029_3_12 0 conv_bpf_c029_3 0) vcvs gain=1.950903220161e-01
SCONVI_c029_3_12 (conv_i_src_c029_3_12 conv_i_c029_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_12 (conv_q_src_c029_3_12 0 conv_bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c029_3_12 (conv_q_src_c029_3_12 conv_q_c029_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_13 (conv_i_src_c029_3_13 0 conv_bpf_c029_3 0) vcvs gain=5.555702330196e-01
SCONVI_c029_3_13 (conv_i_src_c029_3_13 conv_i_c029_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_13 (conv_q_src_c029_3_13 0 conv_bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c029_3_13 (conv_q_src_c029_3_13 conv_q_c029_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_14 (conv_i_src_c029_3_14 0 conv_bpf_c029_3 0) vcvs gain=8.314696123025e-01
SCONVI_c029_3_14 (conv_i_src_c029_3_14 conv_i_c029_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_14 (conv_q_src_c029_3_14 0 conv_bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c029_3_14 (conv_q_src_c029_3_14 conv_q_c029_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c029_3_15 (conv_i_src_c029_3_15 0 conv_bpf_c029_3 0) vcvs gain=9.807852804032e-01
SCONVI_c029_3_15 (conv_i_src_c029_3_15 conv_i_c029_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c029_3_15 (conv_q_src_c029_3_15 0 conv_bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c029_3_15 (conv_q_src_c029_3_15 conv_q_c029_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c029_3 (conv_i_c029_3 0) resistor r=1G
RCONVQ_c029_3 (conv_q_c029_3 0) resistor r=1G
RCONVINTI_c029_3 (conv_i_c029_3 ConvIcar_c029_3) resistor r=1k
CCONVINTI_c029_3 (ConvIcar_c029_3 0) capacitor c=80p
RCONVINTQ_c029_3 (conv_q_c029_3 ConvQcar_c029_3) resistor r=1k
CCONVINTQ_c029_3 (ConvQcar_c029_3 0) capacitor c=80p
save conv_bpf_c029_3 ConvIcar_c029_3 ConvQcar_c029_3

// conventional mixed baseline bl030, carrier_0: 250000000 Hz
CCONVBPF_c030_0 (bl030 n_conv_cbpf_c030_0) capacitor c=4.052847345694e-13
LCONVBPF_c030_0 (n_conv_cbpf_c030_0 conv_bpf_c030_0) inductor l=1.000000000000e-06
RCONVBPF_c030_0 (conv_bpf_c030_0 0) resistor r=7.853981633974e+01
ECONVI_c030_0_00 (conv_i_src_c030_0_00 0 conv_bpf_c030_0 0) vcvs gain=9.807852804032e-01
SCONVI_c030_0_00 (conv_i_src_c030_0_00 conv_i_c030_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_00 (conv_q_src_c030_0_00 0 conv_bpf_c030_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_0_00 (conv_q_src_c030_0_00 conv_q_c030_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_01 (conv_i_src_c030_0_01 0 conv_bpf_c030_0 0) vcvs gain=8.314696123025e-01
SCONVI_c030_0_01 (conv_i_src_c030_0_01 conv_i_c030_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_01 (conv_q_src_c030_0_01 0 conv_bpf_c030_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_0_01 (conv_q_src_c030_0_01 conv_q_c030_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_02 (conv_i_src_c030_0_02 0 conv_bpf_c030_0 0) vcvs gain=5.555702330196e-01
SCONVI_c030_0_02 (conv_i_src_c030_0_02 conv_i_c030_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_02 (conv_q_src_c030_0_02 0 conv_bpf_c030_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_0_02 (conv_q_src_c030_0_02 conv_q_c030_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_03 (conv_i_src_c030_0_03 0 conv_bpf_c030_0 0) vcvs gain=1.950903220161e-01
SCONVI_c030_0_03 (conv_i_src_c030_0_03 conv_i_c030_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_03 (conv_q_src_c030_0_03 0 conv_bpf_c030_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_0_03 (conv_q_src_c030_0_03 conv_q_c030_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_04 (conv_i_src_c030_0_04 0 conv_bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_0_04 (conv_i_src_c030_0_04 conv_i_c030_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_04 (conv_q_src_c030_0_04 0 conv_bpf_c030_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_0_04 (conv_q_src_c030_0_04 conv_q_c030_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_05 (conv_i_src_c030_0_05 0 conv_bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_0_05 (conv_i_src_c030_0_05 conv_i_c030_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_05 (conv_q_src_c030_0_05 0 conv_bpf_c030_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_0_05 (conv_q_src_c030_0_05 conv_q_c030_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_06 (conv_i_src_c030_0_06 0 conv_bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_0_06 (conv_i_src_c030_0_06 conv_i_c030_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_06 (conv_q_src_c030_0_06 0 conv_bpf_c030_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_0_06 (conv_q_src_c030_0_06 conv_q_c030_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_07 (conv_i_src_c030_0_07 0 conv_bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_0_07 (conv_i_src_c030_0_07 conv_i_c030_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_07 (conv_q_src_c030_0_07 0 conv_bpf_c030_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_0_07 (conv_q_src_c030_0_07 conv_q_c030_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_08 (conv_i_src_c030_0_08 0 conv_bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_0_08 (conv_i_src_c030_0_08 conv_i_c030_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_08 (conv_q_src_c030_0_08 0 conv_bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_0_08 (conv_q_src_c030_0_08 conv_q_c030_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_09 (conv_i_src_c030_0_09 0 conv_bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_0_09 (conv_i_src_c030_0_09 conv_i_c030_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_09 (conv_q_src_c030_0_09 0 conv_bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_0_09 (conv_q_src_c030_0_09 conv_q_c030_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_10 (conv_i_src_c030_0_10 0 conv_bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_0_10 (conv_i_src_c030_0_10 conv_i_c030_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_10 (conv_q_src_c030_0_10 0 conv_bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_0_10 (conv_q_src_c030_0_10 conv_q_c030_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_11 (conv_i_src_c030_0_11 0 conv_bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_0_11 (conv_i_src_c030_0_11 conv_i_c030_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_11 (conv_q_src_c030_0_11 0 conv_bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_0_11 (conv_q_src_c030_0_11 conv_q_c030_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_12 (conv_i_src_c030_0_12 0 conv_bpf_c030_0 0) vcvs gain=1.950903220161e-01
SCONVI_c030_0_12 (conv_i_src_c030_0_12 conv_i_c030_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_12 (conv_q_src_c030_0_12 0 conv_bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_0_12 (conv_q_src_c030_0_12 conv_q_c030_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_13 (conv_i_src_c030_0_13 0 conv_bpf_c030_0 0) vcvs gain=5.555702330196e-01
SCONVI_c030_0_13 (conv_i_src_c030_0_13 conv_i_c030_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_13 (conv_q_src_c030_0_13 0 conv_bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_0_13 (conv_q_src_c030_0_13 conv_q_c030_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_14 (conv_i_src_c030_0_14 0 conv_bpf_c030_0 0) vcvs gain=8.314696123025e-01
SCONVI_c030_0_14 (conv_i_src_c030_0_14 conv_i_c030_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_14 (conv_q_src_c030_0_14 0 conv_bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_0_14 (conv_q_src_c030_0_14 conv_q_c030_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_0_15 (conv_i_src_c030_0_15 0 conv_bpf_c030_0 0) vcvs gain=9.807852804032e-01
SCONVI_c030_0_15 (conv_i_src_c030_0_15 conv_i_c030_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_0_15 (conv_q_src_c030_0_15 0 conv_bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_0_15 (conv_q_src_c030_0_15 conv_q_c030_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c030_0 (conv_i_c030_0 0) resistor r=1G
RCONVQ_c030_0 (conv_q_c030_0 0) resistor r=1G
RCONVINTI_c030_0 (conv_i_c030_0 ConvIcar_c030_0) resistor r=1k
CCONVINTI_c030_0 (ConvIcar_c030_0 0) capacitor c=80p
RCONVINTQ_c030_0 (conv_q_c030_0 ConvQcar_c030_0) resistor r=1k
CCONVINTQ_c030_0 (ConvQcar_c030_0 0) capacitor c=80p
save conv_bpf_c030_0 ConvIcar_c030_0 ConvQcar_c030_0

// conventional mixed baseline bl030, carrier_1: 500000000 Hz
CCONVBPF_c030_1 (bl030 n_conv_cbpf_c030_1) capacitor c=1.013211836423e-13
LCONVBPF_c030_1 (n_conv_cbpf_c030_1 conv_bpf_c030_1) inductor l=1.000000000000e-06
RCONVBPF_c030_1 (conv_bpf_c030_1 0) resistor r=1.570796326795e+02
ECONVI_c030_1_00 (conv_i_src_c030_1_00 0 conv_bpf_c030_1 0) vcvs gain=9.807852804032e-01
SCONVI_c030_1_00 (conv_i_src_c030_1_00 conv_i_c030_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_00 (conv_q_src_c030_1_00 0 conv_bpf_c030_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_1_00 (conv_q_src_c030_1_00 conv_q_c030_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_01 (conv_i_src_c030_1_01 0 conv_bpf_c030_1 0) vcvs gain=8.314696123025e-01
SCONVI_c030_1_01 (conv_i_src_c030_1_01 conv_i_c030_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_01 (conv_q_src_c030_1_01 0 conv_bpf_c030_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_1_01 (conv_q_src_c030_1_01 conv_q_c030_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_02 (conv_i_src_c030_1_02 0 conv_bpf_c030_1 0) vcvs gain=5.555702330196e-01
SCONVI_c030_1_02 (conv_i_src_c030_1_02 conv_i_c030_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_02 (conv_q_src_c030_1_02 0 conv_bpf_c030_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_1_02 (conv_q_src_c030_1_02 conv_q_c030_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_03 (conv_i_src_c030_1_03 0 conv_bpf_c030_1 0) vcvs gain=1.950903220161e-01
SCONVI_c030_1_03 (conv_i_src_c030_1_03 conv_i_c030_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_03 (conv_q_src_c030_1_03 0 conv_bpf_c030_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_1_03 (conv_q_src_c030_1_03 conv_q_c030_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_04 (conv_i_src_c030_1_04 0 conv_bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_1_04 (conv_i_src_c030_1_04 conv_i_c030_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_04 (conv_q_src_c030_1_04 0 conv_bpf_c030_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_1_04 (conv_q_src_c030_1_04 conv_q_c030_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_05 (conv_i_src_c030_1_05 0 conv_bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_1_05 (conv_i_src_c030_1_05 conv_i_c030_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_05 (conv_q_src_c030_1_05 0 conv_bpf_c030_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_1_05 (conv_q_src_c030_1_05 conv_q_c030_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_06 (conv_i_src_c030_1_06 0 conv_bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_1_06 (conv_i_src_c030_1_06 conv_i_c030_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_06 (conv_q_src_c030_1_06 0 conv_bpf_c030_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_1_06 (conv_q_src_c030_1_06 conv_q_c030_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_07 (conv_i_src_c030_1_07 0 conv_bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_1_07 (conv_i_src_c030_1_07 conv_i_c030_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_07 (conv_q_src_c030_1_07 0 conv_bpf_c030_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_1_07 (conv_q_src_c030_1_07 conv_q_c030_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_08 (conv_i_src_c030_1_08 0 conv_bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_1_08 (conv_i_src_c030_1_08 conv_i_c030_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_08 (conv_q_src_c030_1_08 0 conv_bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_1_08 (conv_q_src_c030_1_08 conv_q_c030_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_09 (conv_i_src_c030_1_09 0 conv_bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_1_09 (conv_i_src_c030_1_09 conv_i_c030_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_09 (conv_q_src_c030_1_09 0 conv_bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_1_09 (conv_q_src_c030_1_09 conv_q_c030_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_10 (conv_i_src_c030_1_10 0 conv_bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_1_10 (conv_i_src_c030_1_10 conv_i_c030_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_10 (conv_q_src_c030_1_10 0 conv_bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_1_10 (conv_q_src_c030_1_10 conv_q_c030_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_11 (conv_i_src_c030_1_11 0 conv_bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_1_11 (conv_i_src_c030_1_11 conv_i_c030_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_11 (conv_q_src_c030_1_11 0 conv_bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_1_11 (conv_q_src_c030_1_11 conv_q_c030_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_12 (conv_i_src_c030_1_12 0 conv_bpf_c030_1 0) vcvs gain=1.950903220161e-01
SCONVI_c030_1_12 (conv_i_src_c030_1_12 conv_i_c030_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_12 (conv_q_src_c030_1_12 0 conv_bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_1_12 (conv_q_src_c030_1_12 conv_q_c030_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_13 (conv_i_src_c030_1_13 0 conv_bpf_c030_1 0) vcvs gain=5.555702330196e-01
SCONVI_c030_1_13 (conv_i_src_c030_1_13 conv_i_c030_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_13 (conv_q_src_c030_1_13 0 conv_bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_1_13 (conv_q_src_c030_1_13 conv_q_c030_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_14 (conv_i_src_c030_1_14 0 conv_bpf_c030_1 0) vcvs gain=8.314696123025e-01
SCONVI_c030_1_14 (conv_i_src_c030_1_14 conv_i_c030_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_14 (conv_q_src_c030_1_14 0 conv_bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_1_14 (conv_q_src_c030_1_14 conv_q_c030_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_1_15 (conv_i_src_c030_1_15 0 conv_bpf_c030_1 0) vcvs gain=9.807852804032e-01
SCONVI_c030_1_15 (conv_i_src_c030_1_15 conv_i_c030_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_1_15 (conv_q_src_c030_1_15 0 conv_bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_1_15 (conv_q_src_c030_1_15 conv_q_c030_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c030_1 (conv_i_c030_1 0) resistor r=1G
RCONVQ_c030_1 (conv_q_c030_1 0) resistor r=1G
RCONVINTI_c030_1 (conv_i_c030_1 ConvIcar_c030_1) resistor r=1k
CCONVINTI_c030_1 (ConvIcar_c030_1 0) capacitor c=80p
RCONVINTQ_c030_1 (conv_q_c030_1 ConvQcar_c030_1) resistor r=1k
CCONVINTQ_c030_1 (ConvQcar_c030_1 0) capacitor c=80p
save conv_bpf_c030_1 ConvIcar_c030_1 ConvQcar_c030_1

// conventional mixed baseline bl030, carrier_2: 750000000 Hz
CCONVBPF_c030_2 (bl030 n_conv_cbpf_c030_2) capacitor c=4.503163717437e-14
LCONVBPF_c030_2 (n_conv_cbpf_c030_2 conv_bpf_c030_2) inductor l=1.000000000000e-06
RCONVBPF_c030_2 (conv_bpf_c030_2 0) resistor r=2.356194490192e+02
ECONVI_c030_2_00 (conv_i_src_c030_2_00 0 conv_bpf_c030_2 0) vcvs gain=9.807852804032e-01
SCONVI_c030_2_00 (conv_i_src_c030_2_00 conv_i_c030_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_00 (conv_q_src_c030_2_00 0 conv_bpf_c030_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_2_00 (conv_q_src_c030_2_00 conv_q_c030_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_01 (conv_i_src_c030_2_01 0 conv_bpf_c030_2 0) vcvs gain=8.314696123025e-01
SCONVI_c030_2_01 (conv_i_src_c030_2_01 conv_i_c030_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_01 (conv_q_src_c030_2_01 0 conv_bpf_c030_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_2_01 (conv_q_src_c030_2_01 conv_q_c030_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_02 (conv_i_src_c030_2_02 0 conv_bpf_c030_2 0) vcvs gain=5.555702330196e-01
SCONVI_c030_2_02 (conv_i_src_c030_2_02 conv_i_c030_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_02 (conv_q_src_c030_2_02 0 conv_bpf_c030_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_2_02 (conv_q_src_c030_2_02 conv_q_c030_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_03 (conv_i_src_c030_2_03 0 conv_bpf_c030_2 0) vcvs gain=1.950903220161e-01
SCONVI_c030_2_03 (conv_i_src_c030_2_03 conv_i_c030_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_03 (conv_q_src_c030_2_03 0 conv_bpf_c030_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_2_03 (conv_q_src_c030_2_03 conv_q_c030_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_04 (conv_i_src_c030_2_04 0 conv_bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_2_04 (conv_i_src_c030_2_04 conv_i_c030_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_04 (conv_q_src_c030_2_04 0 conv_bpf_c030_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_2_04 (conv_q_src_c030_2_04 conv_q_c030_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_05 (conv_i_src_c030_2_05 0 conv_bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_2_05 (conv_i_src_c030_2_05 conv_i_c030_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_05 (conv_q_src_c030_2_05 0 conv_bpf_c030_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_2_05 (conv_q_src_c030_2_05 conv_q_c030_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_06 (conv_i_src_c030_2_06 0 conv_bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_2_06 (conv_i_src_c030_2_06 conv_i_c030_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_06 (conv_q_src_c030_2_06 0 conv_bpf_c030_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_2_06 (conv_q_src_c030_2_06 conv_q_c030_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_07 (conv_i_src_c030_2_07 0 conv_bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_2_07 (conv_i_src_c030_2_07 conv_i_c030_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_07 (conv_q_src_c030_2_07 0 conv_bpf_c030_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_2_07 (conv_q_src_c030_2_07 conv_q_c030_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_08 (conv_i_src_c030_2_08 0 conv_bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_2_08 (conv_i_src_c030_2_08 conv_i_c030_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_08 (conv_q_src_c030_2_08 0 conv_bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_2_08 (conv_q_src_c030_2_08 conv_q_c030_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_09 (conv_i_src_c030_2_09 0 conv_bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_2_09 (conv_i_src_c030_2_09 conv_i_c030_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_09 (conv_q_src_c030_2_09 0 conv_bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_2_09 (conv_q_src_c030_2_09 conv_q_c030_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_10 (conv_i_src_c030_2_10 0 conv_bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_2_10 (conv_i_src_c030_2_10 conv_i_c030_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_10 (conv_q_src_c030_2_10 0 conv_bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_2_10 (conv_q_src_c030_2_10 conv_q_c030_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_11 (conv_i_src_c030_2_11 0 conv_bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_2_11 (conv_i_src_c030_2_11 conv_i_c030_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_11 (conv_q_src_c030_2_11 0 conv_bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_2_11 (conv_q_src_c030_2_11 conv_q_c030_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_12 (conv_i_src_c030_2_12 0 conv_bpf_c030_2 0) vcvs gain=1.950903220161e-01
SCONVI_c030_2_12 (conv_i_src_c030_2_12 conv_i_c030_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_12 (conv_q_src_c030_2_12 0 conv_bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_2_12 (conv_q_src_c030_2_12 conv_q_c030_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_13 (conv_i_src_c030_2_13 0 conv_bpf_c030_2 0) vcvs gain=5.555702330196e-01
SCONVI_c030_2_13 (conv_i_src_c030_2_13 conv_i_c030_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_13 (conv_q_src_c030_2_13 0 conv_bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_2_13 (conv_q_src_c030_2_13 conv_q_c030_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_14 (conv_i_src_c030_2_14 0 conv_bpf_c030_2 0) vcvs gain=8.314696123025e-01
SCONVI_c030_2_14 (conv_i_src_c030_2_14 conv_i_c030_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_14 (conv_q_src_c030_2_14 0 conv_bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_2_14 (conv_q_src_c030_2_14 conv_q_c030_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_2_15 (conv_i_src_c030_2_15 0 conv_bpf_c030_2 0) vcvs gain=9.807852804032e-01
SCONVI_c030_2_15 (conv_i_src_c030_2_15 conv_i_c030_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_2_15 (conv_q_src_c030_2_15 0 conv_bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_2_15 (conv_q_src_c030_2_15 conv_q_c030_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c030_2 (conv_i_c030_2 0) resistor r=1G
RCONVQ_c030_2 (conv_q_c030_2 0) resistor r=1G
RCONVINTI_c030_2 (conv_i_c030_2 ConvIcar_c030_2) resistor r=1k
CCONVINTI_c030_2 (ConvIcar_c030_2 0) capacitor c=80p
RCONVINTQ_c030_2 (conv_q_c030_2 ConvQcar_c030_2) resistor r=1k
CCONVINTQ_c030_2 (ConvQcar_c030_2 0) capacitor c=80p
save conv_bpf_c030_2 ConvIcar_c030_2 ConvQcar_c030_2

// conventional mixed baseline bl030, carrier_3: 1000000000 Hz
CCONVBPF_c030_3 (bl030 n_conv_cbpf_c030_3) capacitor c=2.533029591058e-14
LCONVBPF_c030_3 (n_conv_cbpf_c030_3 conv_bpf_c030_3) inductor l=1.000000000000e-06
RCONVBPF_c030_3 (conv_bpf_c030_3 0) resistor r=3.141592653590e+02
ECONVI_c030_3_00 (conv_i_src_c030_3_00 0 conv_bpf_c030_3 0) vcvs gain=9.807852804032e-01
SCONVI_c030_3_00 (conv_i_src_c030_3_00 conv_i_c030_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_00 (conv_q_src_c030_3_00 0 conv_bpf_c030_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_3_00 (conv_q_src_c030_3_00 conv_q_c030_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_01 (conv_i_src_c030_3_01 0 conv_bpf_c030_3 0) vcvs gain=8.314696123025e-01
SCONVI_c030_3_01 (conv_i_src_c030_3_01 conv_i_c030_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_01 (conv_q_src_c030_3_01 0 conv_bpf_c030_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_3_01 (conv_q_src_c030_3_01 conv_q_c030_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_02 (conv_i_src_c030_3_02 0 conv_bpf_c030_3 0) vcvs gain=5.555702330196e-01
SCONVI_c030_3_02 (conv_i_src_c030_3_02 conv_i_c030_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_02 (conv_q_src_c030_3_02 0 conv_bpf_c030_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_3_02 (conv_q_src_c030_3_02 conv_q_c030_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_03 (conv_i_src_c030_3_03 0 conv_bpf_c030_3 0) vcvs gain=1.950903220161e-01
SCONVI_c030_3_03 (conv_i_src_c030_3_03 conv_i_c030_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_03 (conv_q_src_c030_3_03 0 conv_bpf_c030_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_3_03 (conv_q_src_c030_3_03 conv_q_c030_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_04 (conv_i_src_c030_3_04 0 conv_bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_3_04 (conv_i_src_c030_3_04 conv_i_c030_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_04 (conv_q_src_c030_3_04 0 conv_bpf_c030_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c030_3_04 (conv_q_src_c030_3_04 conv_q_c030_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_05 (conv_i_src_c030_3_05 0 conv_bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_3_05 (conv_i_src_c030_3_05 conv_i_c030_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_05 (conv_q_src_c030_3_05 0 conv_bpf_c030_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c030_3_05 (conv_q_src_c030_3_05 conv_q_c030_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_06 (conv_i_src_c030_3_06 0 conv_bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_3_06 (conv_i_src_c030_3_06 conv_i_c030_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_06 (conv_q_src_c030_3_06 0 conv_bpf_c030_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c030_3_06 (conv_q_src_c030_3_06 conv_q_c030_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_07 (conv_i_src_c030_3_07 0 conv_bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_3_07 (conv_i_src_c030_3_07 conv_i_c030_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_07 (conv_q_src_c030_3_07 0 conv_bpf_c030_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c030_3_07 (conv_q_src_c030_3_07 conv_q_c030_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_08 (conv_i_src_c030_3_08 0 conv_bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c030_3_08 (conv_i_src_c030_3_08 conv_i_c030_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_08 (conv_q_src_c030_3_08 0 conv_bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_3_08 (conv_q_src_c030_3_08 conv_q_c030_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_09 (conv_i_src_c030_3_09 0 conv_bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c030_3_09 (conv_i_src_c030_3_09 conv_i_c030_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_09 (conv_q_src_c030_3_09 0 conv_bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_3_09 (conv_q_src_c030_3_09 conv_q_c030_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_10 (conv_i_src_c030_3_10 0 conv_bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c030_3_10 (conv_i_src_c030_3_10 conv_i_c030_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_10 (conv_q_src_c030_3_10 0 conv_bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_3_10 (conv_q_src_c030_3_10 conv_q_c030_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_11 (conv_i_src_c030_3_11 0 conv_bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c030_3_11 (conv_i_src_c030_3_11 conv_i_c030_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_11 (conv_q_src_c030_3_11 0 conv_bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_3_11 (conv_q_src_c030_3_11 conv_q_c030_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_12 (conv_i_src_c030_3_12 0 conv_bpf_c030_3 0) vcvs gain=1.950903220161e-01
SCONVI_c030_3_12 (conv_i_src_c030_3_12 conv_i_c030_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_12 (conv_q_src_c030_3_12 0 conv_bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c030_3_12 (conv_q_src_c030_3_12 conv_q_c030_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_13 (conv_i_src_c030_3_13 0 conv_bpf_c030_3 0) vcvs gain=5.555702330196e-01
SCONVI_c030_3_13 (conv_i_src_c030_3_13 conv_i_c030_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_13 (conv_q_src_c030_3_13 0 conv_bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c030_3_13 (conv_q_src_c030_3_13 conv_q_c030_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_14 (conv_i_src_c030_3_14 0 conv_bpf_c030_3 0) vcvs gain=8.314696123025e-01
SCONVI_c030_3_14 (conv_i_src_c030_3_14 conv_i_c030_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_14 (conv_q_src_c030_3_14 0 conv_bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c030_3_14 (conv_q_src_c030_3_14 conv_q_c030_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c030_3_15 (conv_i_src_c030_3_15 0 conv_bpf_c030_3 0) vcvs gain=9.807852804032e-01
SCONVI_c030_3_15 (conv_i_src_c030_3_15 conv_i_c030_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c030_3_15 (conv_q_src_c030_3_15 0 conv_bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c030_3_15 (conv_q_src_c030_3_15 conv_q_c030_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c030_3 (conv_i_c030_3 0) resistor r=1G
RCONVQ_c030_3 (conv_q_c030_3 0) resistor r=1G
RCONVINTI_c030_3 (conv_i_c030_3 ConvIcar_c030_3) resistor r=1k
CCONVINTI_c030_3 (ConvIcar_c030_3 0) capacitor c=80p
RCONVINTQ_c030_3 (conv_q_c030_3 ConvQcar_c030_3) resistor r=1k
CCONVINTQ_c030_3 (ConvQcar_c030_3 0) capacitor c=80p
save conv_bpf_c030_3 ConvIcar_c030_3 ConvQcar_c030_3

// conventional mixed baseline bl031, carrier_0: 250000000 Hz
CCONVBPF_c031_0 (bl031 n_conv_cbpf_c031_0) capacitor c=4.052847345694e-13
LCONVBPF_c031_0 (n_conv_cbpf_c031_0 conv_bpf_c031_0) inductor l=1.000000000000e-06
RCONVBPF_c031_0 (conv_bpf_c031_0 0) resistor r=7.853981633974e+01
ECONVI_c031_0_00 (conv_i_src_c031_0_00 0 conv_bpf_c031_0 0) vcvs gain=9.807852804032e-01
SCONVI_c031_0_00 (conv_i_src_c031_0_00 conv_i_c031_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_00 (conv_q_src_c031_0_00 0 conv_bpf_c031_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_0_00 (conv_q_src_c031_0_00 conv_q_c031_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_01 (conv_i_src_c031_0_01 0 conv_bpf_c031_0 0) vcvs gain=8.314696123025e-01
SCONVI_c031_0_01 (conv_i_src_c031_0_01 conv_i_c031_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_01 (conv_q_src_c031_0_01 0 conv_bpf_c031_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_0_01 (conv_q_src_c031_0_01 conv_q_c031_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_02 (conv_i_src_c031_0_02 0 conv_bpf_c031_0 0) vcvs gain=5.555702330196e-01
SCONVI_c031_0_02 (conv_i_src_c031_0_02 conv_i_c031_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_02 (conv_q_src_c031_0_02 0 conv_bpf_c031_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_0_02 (conv_q_src_c031_0_02 conv_q_c031_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_03 (conv_i_src_c031_0_03 0 conv_bpf_c031_0 0) vcvs gain=1.950903220161e-01
SCONVI_c031_0_03 (conv_i_src_c031_0_03 conv_i_c031_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_03 (conv_q_src_c031_0_03 0 conv_bpf_c031_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_0_03 (conv_q_src_c031_0_03 conv_q_c031_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_04 (conv_i_src_c031_0_04 0 conv_bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_0_04 (conv_i_src_c031_0_04 conv_i_c031_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_04 (conv_q_src_c031_0_04 0 conv_bpf_c031_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_0_04 (conv_q_src_c031_0_04 conv_q_c031_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_05 (conv_i_src_c031_0_05 0 conv_bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_0_05 (conv_i_src_c031_0_05 conv_i_c031_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_05 (conv_q_src_c031_0_05 0 conv_bpf_c031_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_0_05 (conv_q_src_c031_0_05 conv_q_c031_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_06 (conv_i_src_c031_0_06 0 conv_bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_0_06 (conv_i_src_c031_0_06 conv_i_c031_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_06 (conv_q_src_c031_0_06 0 conv_bpf_c031_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_0_06 (conv_q_src_c031_0_06 conv_q_c031_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_07 (conv_i_src_c031_0_07 0 conv_bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_0_07 (conv_i_src_c031_0_07 conv_i_c031_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_07 (conv_q_src_c031_0_07 0 conv_bpf_c031_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_0_07 (conv_q_src_c031_0_07 conv_q_c031_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_08 (conv_i_src_c031_0_08 0 conv_bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_0_08 (conv_i_src_c031_0_08 conv_i_c031_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_08 (conv_q_src_c031_0_08 0 conv_bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_0_08 (conv_q_src_c031_0_08 conv_q_c031_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_09 (conv_i_src_c031_0_09 0 conv_bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_0_09 (conv_i_src_c031_0_09 conv_i_c031_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_09 (conv_q_src_c031_0_09 0 conv_bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_0_09 (conv_q_src_c031_0_09 conv_q_c031_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_10 (conv_i_src_c031_0_10 0 conv_bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_0_10 (conv_i_src_c031_0_10 conv_i_c031_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_10 (conv_q_src_c031_0_10 0 conv_bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_0_10 (conv_q_src_c031_0_10 conv_q_c031_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_11 (conv_i_src_c031_0_11 0 conv_bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_0_11 (conv_i_src_c031_0_11 conv_i_c031_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_11 (conv_q_src_c031_0_11 0 conv_bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_0_11 (conv_q_src_c031_0_11 conv_q_c031_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_12 (conv_i_src_c031_0_12 0 conv_bpf_c031_0 0) vcvs gain=1.950903220161e-01
SCONVI_c031_0_12 (conv_i_src_c031_0_12 conv_i_c031_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_12 (conv_q_src_c031_0_12 0 conv_bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_0_12 (conv_q_src_c031_0_12 conv_q_c031_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_13 (conv_i_src_c031_0_13 0 conv_bpf_c031_0 0) vcvs gain=5.555702330196e-01
SCONVI_c031_0_13 (conv_i_src_c031_0_13 conv_i_c031_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_13 (conv_q_src_c031_0_13 0 conv_bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_0_13 (conv_q_src_c031_0_13 conv_q_c031_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_14 (conv_i_src_c031_0_14 0 conv_bpf_c031_0 0) vcvs gain=8.314696123025e-01
SCONVI_c031_0_14 (conv_i_src_c031_0_14 conv_i_c031_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_14 (conv_q_src_c031_0_14 0 conv_bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_0_14 (conv_q_src_c031_0_14 conv_q_c031_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_0_15 (conv_i_src_c031_0_15 0 conv_bpf_c031_0 0) vcvs gain=9.807852804032e-01
SCONVI_c031_0_15 (conv_i_src_c031_0_15 conv_i_c031_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_0_15 (conv_q_src_c031_0_15 0 conv_bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_0_15 (conv_q_src_c031_0_15 conv_q_c031_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c031_0 (conv_i_c031_0 0) resistor r=1G
RCONVQ_c031_0 (conv_q_c031_0 0) resistor r=1G
RCONVINTI_c031_0 (conv_i_c031_0 ConvIcar_c031_0) resistor r=1k
CCONVINTI_c031_0 (ConvIcar_c031_0 0) capacitor c=80p
RCONVINTQ_c031_0 (conv_q_c031_0 ConvQcar_c031_0) resistor r=1k
CCONVINTQ_c031_0 (ConvQcar_c031_0 0) capacitor c=80p
save conv_bpf_c031_0 ConvIcar_c031_0 ConvQcar_c031_0

// conventional mixed baseline bl031, carrier_1: 500000000 Hz
CCONVBPF_c031_1 (bl031 n_conv_cbpf_c031_1) capacitor c=1.013211836423e-13
LCONVBPF_c031_1 (n_conv_cbpf_c031_1 conv_bpf_c031_1) inductor l=1.000000000000e-06
RCONVBPF_c031_1 (conv_bpf_c031_1 0) resistor r=1.570796326795e+02
ECONVI_c031_1_00 (conv_i_src_c031_1_00 0 conv_bpf_c031_1 0) vcvs gain=9.807852804032e-01
SCONVI_c031_1_00 (conv_i_src_c031_1_00 conv_i_c031_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_00 (conv_q_src_c031_1_00 0 conv_bpf_c031_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_1_00 (conv_q_src_c031_1_00 conv_q_c031_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_01 (conv_i_src_c031_1_01 0 conv_bpf_c031_1 0) vcvs gain=8.314696123025e-01
SCONVI_c031_1_01 (conv_i_src_c031_1_01 conv_i_c031_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_01 (conv_q_src_c031_1_01 0 conv_bpf_c031_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_1_01 (conv_q_src_c031_1_01 conv_q_c031_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_02 (conv_i_src_c031_1_02 0 conv_bpf_c031_1 0) vcvs gain=5.555702330196e-01
SCONVI_c031_1_02 (conv_i_src_c031_1_02 conv_i_c031_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_02 (conv_q_src_c031_1_02 0 conv_bpf_c031_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_1_02 (conv_q_src_c031_1_02 conv_q_c031_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_03 (conv_i_src_c031_1_03 0 conv_bpf_c031_1 0) vcvs gain=1.950903220161e-01
SCONVI_c031_1_03 (conv_i_src_c031_1_03 conv_i_c031_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_03 (conv_q_src_c031_1_03 0 conv_bpf_c031_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_1_03 (conv_q_src_c031_1_03 conv_q_c031_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_04 (conv_i_src_c031_1_04 0 conv_bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_1_04 (conv_i_src_c031_1_04 conv_i_c031_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_04 (conv_q_src_c031_1_04 0 conv_bpf_c031_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_1_04 (conv_q_src_c031_1_04 conv_q_c031_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_05 (conv_i_src_c031_1_05 0 conv_bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_1_05 (conv_i_src_c031_1_05 conv_i_c031_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_05 (conv_q_src_c031_1_05 0 conv_bpf_c031_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_1_05 (conv_q_src_c031_1_05 conv_q_c031_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_06 (conv_i_src_c031_1_06 0 conv_bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_1_06 (conv_i_src_c031_1_06 conv_i_c031_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_06 (conv_q_src_c031_1_06 0 conv_bpf_c031_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_1_06 (conv_q_src_c031_1_06 conv_q_c031_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_07 (conv_i_src_c031_1_07 0 conv_bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_1_07 (conv_i_src_c031_1_07 conv_i_c031_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_07 (conv_q_src_c031_1_07 0 conv_bpf_c031_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_1_07 (conv_q_src_c031_1_07 conv_q_c031_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_08 (conv_i_src_c031_1_08 0 conv_bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_1_08 (conv_i_src_c031_1_08 conv_i_c031_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_08 (conv_q_src_c031_1_08 0 conv_bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_1_08 (conv_q_src_c031_1_08 conv_q_c031_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_09 (conv_i_src_c031_1_09 0 conv_bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_1_09 (conv_i_src_c031_1_09 conv_i_c031_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_09 (conv_q_src_c031_1_09 0 conv_bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_1_09 (conv_q_src_c031_1_09 conv_q_c031_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_10 (conv_i_src_c031_1_10 0 conv_bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_1_10 (conv_i_src_c031_1_10 conv_i_c031_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_10 (conv_q_src_c031_1_10 0 conv_bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_1_10 (conv_q_src_c031_1_10 conv_q_c031_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_11 (conv_i_src_c031_1_11 0 conv_bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_1_11 (conv_i_src_c031_1_11 conv_i_c031_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_11 (conv_q_src_c031_1_11 0 conv_bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_1_11 (conv_q_src_c031_1_11 conv_q_c031_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_12 (conv_i_src_c031_1_12 0 conv_bpf_c031_1 0) vcvs gain=1.950903220161e-01
SCONVI_c031_1_12 (conv_i_src_c031_1_12 conv_i_c031_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_12 (conv_q_src_c031_1_12 0 conv_bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_1_12 (conv_q_src_c031_1_12 conv_q_c031_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_13 (conv_i_src_c031_1_13 0 conv_bpf_c031_1 0) vcvs gain=5.555702330196e-01
SCONVI_c031_1_13 (conv_i_src_c031_1_13 conv_i_c031_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_13 (conv_q_src_c031_1_13 0 conv_bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_1_13 (conv_q_src_c031_1_13 conv_q_c031_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_14 (conv_i_src_c031_1_14 0 conv_bpf_c031_1 0) vcvs gain=8.314696123025e-01
SCONVI_c031_1_14 (conv_i_src_c031_1_14 conv_i_c031_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_14 (conv_q_src_c031_1_14 0 conv_bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_1_14 (conv_q_src_c031_1_14 conv_q_c031_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_1_15 (conv_i_src_c031_1_15 0 conv_bpf_c031_1 0) vcvs gain=9.807852804032e-01
SCONVI_c031_1_15 (conv_i_src_c031_1_15 conv_i_c031_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_1_15 (conv_q_src_c031_1_15 0 conv_bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_1_15 (conv_q_src_c031_1_15 conv_q_c031_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c031_1 (conv_i_c031_1 0) resistor r=1G
RCONVQ_c031_1 (conv_q_c031_1 0) resistor r=1G
RCONVINTI_c031_1 (conv_i_c031_1 ConvIcar_c031_1) resistor r=1k
CCONVINTI_c031_1 (ConvIcar_c031_1 0) capacitor c=80p
RCONVINTQ_c031_1 (conv_q_c031_1 ConvQcar_c031_1) resistor r=1k
CCONVINTQ_c031_1 (ConvQcar_c031_1 0) capacitor c=80p
save conv_bpf_c031_1 ConvIcar_c031_1 ConvQcar_c031_1

// conventional mixed baseline bl031, carrier_2: 750000000 Hz
CCONVBPF_c031_2 (bl031 n_conv_cbpf_c031_2) capacitor c=4.503163717437e-14
LCONVBPF_c031_2 (n_conv_cbpf_c031_2 conv_bpf_c031_2) inductor l=1.000000000000e-06
RCONVBPF_c031_2 (conv_bpf_c031_2 0) resistor r=2.356194490192e+02
ECONVI_c031_2_00 (conv_i_src_c031_2_00 0 conv_bpf_c031_2 0) vcvs gain=9.807852804032e-01
SCONVI_c031_2_00 (conv_i_src_c031_2_00 conv_i_c031_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_00 (conv_q_src_c031_2_00 0 conv_bpf_c031_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_2_00 (conv_q_src_c031_2_00 conv_q_c031_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_01 (conv_i_src_c031_2_01 0 conv_bpf_c031_2 0) vcvs gain=8.314696123025e-01
SCONVI_c031_2_01 (conv_i_src_c031_2_01 conv_i_c031_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_01 (conv_q_src_c031_2_01 0 conv_bpf_c031_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_2_01 (conv_q_src_c031_2_01 conv_q_c031_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_02 (conv_i_src_c031_2_02 0 conv_bpf_c031_2 0) vcvs gain=5.555702330196e-01
SCONVI_c031_2_02 (conv_i_src_c031_2_02 conv_i_c031_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_02 (conv_q_src_c031_2_02 0 conv_bpf_c031_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_2_02 (conv_q_src_c031_2_02 conv_q_c031_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_03 (conv_i_src_c031_2_03 0 conv_bpf_c031_2 0) vcvs gain=1.950903220161e-01
SCONVI_c031_2_03 (conv_i_src_c031_2_03 conv_i_c031_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_03 (conv_q_src_c031_2_03 0 conv_bpf_c031_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_2_03 (conv_q_src_c031_2_03 conv_q_c031_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_04 (conv_i_src_c031_2_04 0 conv_bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_2_04 (conv_i_src_c031_2_04 conv_i_c031_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_04 (conv_q_src_c031_2_04 0 conv_bpf_c031_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_2_04 (conv_q_src_c031_2_04 conv_q_c031_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_05 (conv_i_src_c031_2_05 0 conv_bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_2_05 (conv_i_src_c031_2_05 conv_i_c031_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_05 (conv_q_src_c031_2_05 0 conv_bpf_c031_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_2_05 (conv_q_src_c031_2_05 conv_q_c031_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_06 (conv_i_src_c031_2_06 0 conv_bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_2_06 (conv_i_src_c031_2_06 conv_i_c031_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_06 (conv_q_src_c031_2_06 0 conv_bpf_c031_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_2_06 (conv_q_src_c031_2_06 conv_q_c031_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_07 (conv_i_src_c031_2_07 0 conv_bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_2_07 (conv_i_src_c031_2_07 conv_i_c031_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_07 (conv_q_src_c031_2_07 0 conv_bpf_c031_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_2_07 (conv_q_src_c031_2_07 conv_q_c031_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_08 (conv_i_src_c031_2_08 0 conv_bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_2_08 (conv_i_src_c031_2_08 conv_i_c031_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_08 (conv_q_src_c031_2_08 0 conv_bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_2_08 (conv_q_src_c031_2_08 conv_q_c031_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_09 (conv_i_src_c031_2_09 0 conv_bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_2_09 (conv_i_src_c031_2_09 conv_i_c031_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_09 (conv_q_src_c031_2_09 0 conv_bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_2_09 (conv_q_src_c031_2_09 conv_q_c031_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_10 (conv_i_src_c031_2_10 0 conv_bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_2_10 (conv_i_src_c031_2_10 conv_i_c031_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_10 (conv_q_src_c031_2_10 0 conv_bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_2_10 (conv_q_src_c031_2_10 conv_q_c031_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_11 (conv_i_src_c031_2_11 0 conv_bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_2_11 (conv_i_src_c031_2_11 conv_i_c031_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_11 (conv_q_src_c031_2_11 0 conv_bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_2_11 (conv_q_src_c031_2_11 conv_q_c031_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_12 (conv_i_src_c031_2_12 0 conv_bpf_c031_2 0) vcvs gain=1.950903220161e-01
SCONVI_c031_2_12 (conv_i_src_c031_2_12 conv_i_c031_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_12 (conv_q_src_c031_2_12 0 conv_bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_2_12 (conv_q_src_c031_2_12 conv_q_c031_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_13 (conv_i_src_c031_2_13 0 conv_bpf_c031_2 0) vcvs gain=5.555702330196e-01
SCONVI_c031_2_13 (conv_i_src_c031_2_13 conv_i_c031_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_13 (conv_q_src_c031_2_13 0 conv_bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_2_13 (conv_q_src_c031_2_13 conv_q_c031_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_14 (conv_i_src_c031_2_14 0 conv_bpf_c031_2 0) vcvs gain=8.314696123025e-01
SCONVI_c031_2_14 (conv_i_src_c031_2_14 conv_i_c031_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_14 (conv_q_src_c031_2_14 0 conv_bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_2_14 (conv_q_src_c031_2_14 conv_q_c031_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_2_15 (conv_i_src_c031_2_15 0 conv_bpf_c031_2 0) vcvs gain=9.807852804032e-01
SCONVI_c031_2_15 (conv_i_src_c031_2_15 conv_i_c031_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_2_15 (conv_q_src_c031_2_15 0 conv_bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_2_15 (conv_q_src_c031_2_15 conv_q_c031_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c031_2 (conv_i_c031_2 0) resistor r=1G
RCONVQ_c031_2 (conv_q_c031_2 0) resistor r=1G
RCONVINTI_c031_2 (conv_i_c031_2 ConvIcar_c031_2) resistor r=1k
CCONVINTI_c031_2 (ConvIcar_c031_2 0) capacitor c=80p
RCONVINTQ_c031_2 (conv_q_c031_2 ConvQcar_c031_2) resistor r=1k
CCONVINTQ_c031_2 (ConvQcar_c031_2 0) capacitor c=80p
save conv_bpf_c031_2 ConvIcar_c031_2 ConvQcar_c031_2

// conventional mixed baseline bl031, carrier_3: 1000000000 Hz
CCONVBPF_c031_3 (bl031 n_conv_cbpf_c031_3) capacitor c=2.533029591058e-14
LCONVBPF_c031_3 (n_conv_cbpf_c031_3 conv_bpf_c031_3) inductor l=1.000000000000e-06
RCONVBPF_c031_3 (conv_bpf_c031_3 0) resistor r=3.141592653590e+02
ECONVI_c031_3_00 (conv_i_src_c031_3_00 0 conv_bpf_c031_3 0) vcvs gain=9.807852804032e-01
SCONVI_c031_3_00 (conv_i_src_c031_3_00 conv_i_c031_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_00 (conv_q_src_c031_3_00 0 conv_bpf_c031_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_3_00 (conv_q_src_c031_3_00 conv_q_c031_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_01 (conv_i_src_c031_3_01 0 conv_bpf_c031_3 0) vcvs gain=8.314696123025e-01
SCONVI_c031_3_01 (conv_i_src_c031_3_01 conv_i_c031_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_01 (conv_q_src_c031_3_01 0 conv_bpf_c031_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_3_01 (conv_q_src_c031_3_01 conv_q_c031_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_02 (conv_i_src_c031_3_02 0 conv_bpf_c031_3 0) vcvs gain=5.555702330196e-01
SCONVI_c031_3_02 (conv_i_src_c031_3_02 conv_i_c031_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_02 (conv_q_src_c031_3_02 0 conv_bpf_c031_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_3_02 (conv_q_src_c031_3_02 conv_q_c031_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_03 (conv_i_src_c031_3_03 0 conv_bpf_c031_3 0) vcvs gain=1.950903220161e-01
SCONVI_c031_3_03 (conv_i_src_c031_3_03 conv_i_c031_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_03 (conv_q_src_c031_3_03 0 conv_bpf_c031_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_3_03 (conv_q_src_c031_3_03 conv_q_c031_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_04 (conv_i_src_c031_3_04 0 conv_bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_3_04 (conv_i_src_c031_3_04 conv_i_c031_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_04 (conv_q_src_c031_3_04 0 conv_bpf_c031_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c031_3_04 (conv_q_src_c031_3_04 conv_q_c031_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_05 (conv_i_src_c031_3_05 0 conv_bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_3_05 (conv_i_src_c031_3_05 conv_i_c031_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_05 (conv_q_src_c031_3_05 0 conv_bpf_c031_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c031_3_05 (conv_q_src_c031_3_05 conv_q_c031_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_06 (conv_i_src_c031_3_06 0 conv_bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_3_06 (conv_i_src_c031_3_06 conv_i_c031_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_06 (conv_q_src_c031_3_06 0 conv_bpf_c031_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c031_3_06 (conv_q_src_c031_3_06 conv_q_c031_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_07 (conv_i_src_c031_3_07 0 conv_bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_3_07 (conv_i_src_c031_3_07 conv_i_c031_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_07 (conv_q_src_c031_3_07 0 conv_bpf_c031_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c031_3_07 (conv_q_src_c031_3_07 conv_q_c031_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_08 (conv_i_src_c031_3_08 0 conv_bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c031_3_08 (conv_i_src_c031_3_08 conv_i_c031_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_08 (conv_q_src_c031_3_08 0 conv_bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_3_08 (conv_q_src_c031_3_08 conv_q_c031_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_09 (conv_i_src_c031_3_09 0 conv_bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c031_3_09 (conv_i_src_c031_3_09 conv_i_c031_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_09 (conv_q_src_c031_3_09 0 conv_bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_3_09 (conv_q_src_c031_3_09 conv_q_c031_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_10 (conv_i_src_c031_3_10 0 conv_bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c031_3_10 (conv_i_src_c031_3_10 conv_i_c031_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_10 (conv_q_src_c031_3_10 0 conv_bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_3_10 (conv_q_src_c031_3_10 conv_q_c031_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_11 (conv_i_src_c031_3_11 0 conv_bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c031_3_11 (conv_i_src_c031_3_11 conv_i_c031_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_11 (conv_q_src_c031_3_11 0 conv_bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_3_11 (conv_q_src_c031_3_11 conv_q_c031_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_12 (conv_i_src_c031_3_12 0 conv_bpf_c031_3 0) vcvs gain=1.950903220161e-01
SCONVI_c031_3_12 (conv_i_src_c031_3_12 conv_i_c031_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_12 (conv_q_src_c031_3_12 0 conv_bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c031_3_12 (conv_q_src_c031_3_12 conv_q_c031_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_13 (conv_i_src_c031_3_13 0 conv_bpf_c031_3 0) vcvs gain=5.555702330196e-01
SCONVI_c031_3_13 (conv_i_src_c031_3_13 conv_i_c031_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_13 (conv_q_src_c031_3_13 0 conv_bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c031_3_13 (conv_q_src_c031_3_13 conv_q_c031_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_14 (conv_i_src_c031_3_14 0 conv_bpf_c031_3 0) vcvs gain=8.314696123025e-01
SCONVI_c031_3_14 (conv_i_src_c031_3_14 conv_i_c031_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_14 (conv_q_src_c031_3_14 0 conv_bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c031_3_14 (conv_q_src_c031_3_14 conv_q_c031_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c031_3_15 (conv_i_src_c031_3_15 0 conv_bpf_c031_3 0) vcvs gain=9.807852804032e-01
SCONVI_c031_3_15 (conv_i_src_c031_3_15 conv_i_c031_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c031_3_15 (conv_q_src_c031_3_15 0 conv_bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c031_3_15 (conv_q_src_c031_3_15 conv_q_c031_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c031_3 (conv_i_c031_3 0) resistor r=1G
RCONVQ_c031_3 (conv_q_c031_3 0) resistor r=1G
RCONVINTI_c031_3 (conv_i_c031_3 ConvIcar_c031_3) resistor r=1k
CCONVINTI_c031_3 (ConvIcar_c031_3 0) capacitor c=80p
RCONVINTQ_c031_3 (conv_q_c031_3 ConvQcar_c031_3) resistor r=1k
CCONVINTQ_c031_3 (ConvQcar_c031_3 0) capacitor c=80p
save conv_bpf_c031_3 ConvIcar_c031_3 ConvQcar_c031_3

// conventional mixed baseline bl032, carrier_0: 250000000 Hz
CCONVBPF_c032_0 (bl032 n_conv_cbpf_c032_0) capacitor c=4.052847345694e-13
LCONVBPF_c032_0 (n_conv_cbpf_c032_0 conv_bpf_c032_0) inductor l=1.000000000000e-06
RCONVBPF_c032_0 (conv_bpf_c032_0 0) resistor r=7.853981633974e+01
ECONVI_c032_0_00 (conv_i_src_c032_0_00 0 conv_bpf_c032_0 0) vcvs gain=9.807852804032e-01
SCONVI_c032_0_00 (conv_i_src_c032_0_00 conv_i_c032_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_00 (conv_q_src_c032_0_00 0 conv_bpf_c032_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_0_00 (conv_q_src_c032_0_00 conv_q_c032_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_01 (conv_i_src_c032_0_01 0 conv_bpf_c032_0 0) vcvs gain=8.314696123025e-01
SCONVI_c032_0_01 (conv_i_src_c032_0_01 conv_i_c032_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_01 (conv_q_src_c032_0_01 0 conv_bpf_c032_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_0_01 (conv_q_src_c032_0_01 conv_q_c032_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_02 (conv_i_src_c032_0_02 0 conv_bpf_c032_0 0) vcvs gain=5.555702330196e-01
SCONVI_c032_0_02 (conv_i_src_c032_0_02 conv_i_c032_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_02 (conv_q_src_c032_0_02 0 conv_bpf_c032_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_0_02 (conv_q_src_c032_0_02 conv_q_c032_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_03 (conv_i_src_c032_0_03 0 conv_bpf_c032_0 0) vcvs gain=1.950903220161e-01
SCONVI_c032_0_03 (conv_i_src_c032_0_03 conv_i_c032_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_03 (conv_q_src_c032_0_03 0 conv_bpf_c032_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_0_03 (conv_q_src_c032_0_03 conv_q_c032_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_04 (conv_i_src_c032_0_04 0 conv_bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_0_04 (conv_i_src_c032_0_04 conv_i_c032_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_04 (conv_q_src_c032_0_04 0 conv_bpf_c032_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_0_04 (conv_q_src_c032_0_04 conv_q_c032_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_05 (conv_i_src_c032_0_05 0 conv_bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_0_05 (conv_i_src_c032_0_05 conv_i_c032_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_05 (conv_q_src_c032_0_05 0 conv_bpf_c032_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_0_05 (conv_q_src_c032_0_05 conv_q_c032_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_06 (conv_i_src_c032_0_06 0 conv_bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_0_06 (conv_i_src_c032_0_06 conv_i_c032_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_06 (conv_q_src_c032_0_06 0 conv_bpf_c032_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_0_06 (conv_q_src_c032_0_06 conv_q_c032_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_07 (conv_i_src_c032_0_07 0 conv_bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_0_07 (conv_i_src_c032_0_07 conv_i_c032_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_07 (conv_q_src_c032_0_07 0 conv_bpf_c032_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_0_07 (conv_q_src_c032_0_07 conv_q_c032_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_08 (conv_i_src_c032_0_08 0 conv_bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_0_08 (conv_i_src_c032_0_08 conv_i_c032_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_08 (conv_q_src_c032_0_08 0 conv_bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_0_08 (conv_q_src_c032_0_08 conv_q_c032_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_09 (conv_i_src_c032_0_09 0 conv_bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_0_09 (conv_i_src_c032_0_09 conv_i_c032_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_09 (conv_q_src_c032_0_09 0 conv_bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_0_09 (conv_q_src_c032_0_09 conv_q_c032_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_10 (conv_i_src_c032_0_10 0 conv_bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_0_10 (conv_i_src_c032_0_10 conv_i_c032_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_10 (conv_q_src_c032_0_10 0 conv_bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_0_10 (conv_q_src_c032_0_10 conv_q_c032_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_11 (conv_i_src_c032_0_11 0 conv_bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_0_11 (conv_i_src_c032_0_11 conv_i_c032_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_11 (conv_q_src_c032_0_11 0 conv_bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_0_11 (conv_q_src_c032_0_11 conv_q_c032_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_12 (conv_i_src_c032_0_12 0 conv_bpf_c032_0 0) vcvs gain=1.950903220161e-01
SCONVI_c032_0_12 (conv_i_src_c032_0_12 conv_i_c032_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_12 (conv_q_src_c032_0_12 0 conv_bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_0_12 (conv_q_src_c032_0_12 conv_q_c032_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_13 (conv_i_src_c032_0_13 0 conv_bpf_c032_0 0) vcvs gain=5.555702330196e-01
SCONVI_c032_0_13 (conv_i_src_c032_0_13 conv_i_c032_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_13 (conv_q_src_c032_0_13 0 conv_bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_0_13 (conv_q_src_c032_0_13 conv_q_c032_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_14 (conv_i_src_c032_0_14 0 conv_bpf_c032_0 0) vcvs gain=8.314696123025e-01
SCONVI_c032_0_14 (conv_i_src_c032_0_14 conv_i_c032_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_14 (conv_q_src_c032_0_14 0 conv_bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_0_14 (conv_q_src_c032_0_14 conv_q_c032_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_0_15 (conv_i_src_c032_0_15 0 conv_bpf_c032_0 0) vcvs gain=9.807852804032e-01
SCONVI_c032_0_15 (conv_i_src_c032_0_15 conv_i_c032_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_0_15 (conv_q_src_c032_0_15 0 conv_bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_0_15 (conv_q_src_c032_0_15 conv_q_c032_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c032_0 (conv_i_c032_0 0) resistor r=1G
RCONVQ_c032_0 (conv_q_c032_0 0) resistor r=1G
RCONVINTI_c032_0 (conv_i_c032_0 ConvIcar_c032_0) resistor r=1k
CCONVINTI_c032_0 (ConvIcar_c032_0 0) capacitor c=80p
RCONVINTQ_c032_0 (conv_q_c032_0 ConvQcar_c032_0) resistor r=1k
CCONVINTQ_c032_0 (ConvQcar_c032_0 0) capacitor c=80p
save conv_bpf_c032_0 ConvIcar_c032_0 ConvQcar_c032_0

// conventional mixed baseline bl032, carrier_1: 500000000 Hz
CCONVBPF_c032_1 (bl032 n_conv_cbpf_c032_1) capacitor c=1.013211836423e-13
LCONVBPF_c032_1 (n_conv_cbpf_c032_1 conv_bpf_c032_1) inductor l=1.000000000000e-06
RCONVBPF_c032_1 (conv_bpf_c032_1 0) resistor r=1.570796326795e+02
ECONVI_c032_1_00 (conv_i_src_c032_1_00 0 conv_bpf_c032_1 0) vcvs gain=9.807852804032e-01
SCONVI_c032_1_00 (conv_i_src_c032_1_00 conv_i_c032_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_00 (conv_q_src_c032_1_00 0 conv_bpf_c032_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_1_00 (conv_q_src_c032_1_00 conv_q_c032_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_01 (conv_i_src_c032_1_01 0 conv_bpf_c032_1 0) vcvs gain=8.314696123025e-01
SCONVI_c032_1_01 (conv_i_src_c032_1_01 conv_i_c032_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_01 (conv_q_src_c032_1_01 0 conv_bpf_c032_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_1_01 (conv_q_src_c032_1_01 conv_q_c032_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_02 (conv_i_src_c032_1_02 0 conv_bpf_c032_1 0) vcvs gain=5.555702330196e-01
SCONVI_c032_1_02 (conv_i_src_c032_1_02 conv_i_c032_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_02 (conv_q_src_c032_1_02 0 conv_bpf_c032_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_1_02 (conv_q_src_c032_1_02 conv_q_c032_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_03 (conv_i_src_c032_1_03 0 conv_bpf_c032_1 0) vcvs gain=1.950903220161e-01
SCONVI_c032_1_03 (conv_i_src_c032_1_03 conv_i_c032_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_03 (conv_q_src_c032_1_03 0 conv_bpf_c032_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_1_03 (conv_q_src_c032_1_03 conv_q_c032_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_04 (conv_i_src_c032_1_04 0 conv_bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_1_04 (conv_i_src_c032_1_04 conv_i_c032_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_04 (conv_q_src_c032_1_04 0 conv_bpf_c032_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_1_04 (conv_q_src_c032_1_04 conv_q_c032_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_05 (conv_i_src_c032_1_05 0 conv_bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_1_05 (conv_i_src_c032_1_05 conv_i_c032_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_05 (conv_q_src_c032_1_05 0 conv_bpf_c032_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_1_05 (conv_q_src_c032_1_05 conv_q_c032_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_06 (conv_i_src_c032_1_06 0 conv_bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_1_06 (conv_i_src_c032_1_06 conv_i_c032_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_06 (conv_q_src_c032_1_06 0 conv_bpf_c032_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_1_06 (conv_q_src_c032_1_06 conv_q_c032_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_07 (conv_i_src_c032_1_07 0 conv_bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_1_07 (conv_i_src_c032_1_07 conv_i_c032_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_07 (conv_q_src_c032_1_07 0 conv_bpf_c032_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_1_07 (conv_q_src_c032_1_07 conv_q_c032_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_08 (conv_i_src_c032_1_08 0 conv_bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_1_08 (conv_i_src_c032_1_08 conv_i_c032_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_08 (conv_q_src_c032_1_08 0 conv_bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_1_08 (conv_q_src_c032_1_08 conv_q_c032_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_09 (conv_i_src_c032_1_09 0 conv_bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_1_09 (conv_i_src_c032_1_09 conv_i_c032_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_09 (conv_q_src_c032_1_09 0 conv_bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_1_09 (conv_q_src_c032_1_09 conv_q_c032_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_10 (conv_i_src_c032_1_10 0 conv_bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_1_10 (conv_i_src_c032_1_10 conv_i_c032_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_10 (conv_q_src_c032_1_10 0 conv_bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_1_10 (conv_q_src_c032_1_10 conv_q_c032_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_11 (conv_i_src_c032_1_11 0 conv_bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_1_11 (conv_i_src_c032_1_11 conv_i_c032_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_11 (conv_q_src_c032_1_11 0 conv_bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_1_11 (conv_q_src_c032_1_11 conv_q_c032_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_12 (conv_i_src_c032_1_12 0 conv_bpf_c032_1 0) vcvs gain=1.950903220161e-01
SCONVI_c032_1_12 (conv_i_src_c032_1_12 conv_i_c032_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_12 (conv_q_src_c032_1_12 0 conv_bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_1_12 (conv_q_src_c032_1_12 conv_q_c032_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_13 (conv_i_src_c032_1_13 0 conv_bpf_c032_1 0) vcvs gain=5.555702330196e-01
SCONVI_c032_1_13 (conv_i_src_c032_1_13 conv_i_c032_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_13 (conv_q_src_c032_1_13 0 conv_bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_1_13 (conv_q_src_c032_1_13 conv_q_c032_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_14 (conv_i_src_c032_1_14 0 conv_bpf_c032_1 0) vcvs gain=8.314696123025e-01
SCONVI_c032_1_14 (conv_i_src_c032_1_14 conv_i_c032_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_14 (conv_q_src_c032_1_14 0 conv_bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_1_14 (conv_q_src_c032_1_14 conv_q_c032_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_1_15 (conv_i_src_c032_1_15 0 conv_bpf_c032_1 0) vcvs gain=9.807852804032e-01
SCONVI_c032_1_15 (conv_i_src_c032_1_15 conv_i_c032_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_1_15 (conv_q_src_c032_1_15 0 conv_bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_1_15 (conv_q_src_c032_1_15 conv_q_c032_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c032_1 (conv_i_c032_1 0) resistor r=1G
RCONVQ_c032_1 (conv_q_c032_1 0) resistor r=1G
RCONVINTI_c032_1 (conv_i_c032_1 ConvIcar_c032_1) resistor r=1k
CCONVINTI_c032_1 (ConvIcar_c032_1 0) capacitor c=80p
RCONVINTQ_c032_1 (conv_q_c032_1 ConvQcar_c032_1) resistor r=1k
CCONVINTQ_c032_1 (ConvQcar_c032_1 0) capacitor c=80p
save conv_bpf_c032_1 ConvIcar_c032_1 ConvQcar_c032_1

// conventional mixed baseline bl032, carrier_2: 750000000 Hz
CCONVBPF_c032_2 (bl032 n_conv_cbpf_c032_2) capacitor c=4.503163717437e-14
LCONVBPF_c032_2 (n_conv_cbpf_c032_2 conv_bpf_c032_2) inductor l=1.000000000000e-06
RCONVBPF_c032_2 (conv_bpf_c032_2 0) resistor r=2.356194490192e+02
ECONVI_c032_2_00 (conv_i_src_c032_2_00 0 conv_bpf_c032_2 0) vcvs gain=9.807852804032e-01
SCONVI_c032_2_00 (conv_i_src_c032_2_00 conv_i_c032_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_00 (conv_q_src_c032_2_00 0 conv_bpf_c032_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_2_00 (conv_q_src_c032_2_00 conv_q_c032_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_01 (conv_i_src_c032_2_01 0 conv_bpf_c032_2 0) vcvs gain=8.314696123025e-01
SCONVI_c032_2_01 (conv_i_src_c032_2_01 conv_i_c032_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_01 (conv_q_src_c032_2_01 0 conv_bpf_c032_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_2_01 (conv_q_src_c032_2_01 conv_q_c032_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_02 (conv_i_src_c032_2_02 0 conv_bpf_c032_2 0) vcvs gain=5.555702330196e-01
SCONVI_c032_2_02 (conv_i_src_c032_2_02 conv_i_c032_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_02 (conv_q_src_c032_2_02 0 conv_bpf_c032_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_2_02 (conv_q_src_c032_2_02 conv_q_c032_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_03 (conv_i_src_c032_2_03 0 conv_bpf_c032_2 0) vcvs gain=1.950903220161e-01
SCONVI_c032_2_03 (conv_i_src_c032_2_03 conv_i_c032_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_03 (conv_q_src_c032_2_03 0 conv_bpf_c032_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_2_03 (conv_q_src_c032_2_03 conv_q_c032_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_04 (conv_i_src_c032_2_04 0 conv_bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_2_04 (conv_i_src_c032_2_04 conv_i_c032_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_04 (conv_q_src_c032_2_04 0 conv_bpf_c032_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_2_04 (conv_q_src_c032_2_04 conv_q_c032_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_05 (conv_i_src_c032_2_05 0 conv_bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_2_05 (conv_i_src_c032_2_05 conv_i_c032_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_05 (conv_q_src_c032_2_05 0 conv_bpf_c032_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_2_05 (conv_q_src_c032_2_05 conv_q_c032_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_06 (conv_i_src_c032_2_06 0 conv_bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_2_06 (conv_i_src_c032_2_06 conv_i_c032_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_06 (conv_q_src_c032_2_06 0 conv_bpf_c032_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_2_06 (conv_q_src_c032_2_06 conv_q_c032_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_07 (conv_i_src_c032_2_07 0 conv_bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_2_07 (conv_i_src_c032_2_07 conv_i_c032_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_07 (conv_q_src_c032_2_07 0 conv_bpf_c032_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_2_07 (conv_q_src_c032_2_07 conv_q_c032_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_08 (conv_i_src_c032_2_08 0 conv_bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_2_08 (conv_i_src_c032_2_08 conv_i_c032_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_08 (conv_q_src_c032_2_08 0 conv_bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_2_08 (conv_q_src_c032_2_08 conv_q_c032_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_09 (conv_i_src_c032_2_09 0 conv_bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_2_09 (conv_i_src_c032_2_09 conv_i_c032_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_09 (conv_q_src_c032_2_09 0 conv_bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_2_09 (conv_q_src_c032_2_09 conv_q_c032_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_10 (conv_i_src_c032_2_10 0 conv_bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_2_10 (conv_i_src_c032_2_10 conv_i_c032_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_10 (conv_q_src_c032_2_10 0 conv_bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_2_10 (conv_q_src_c032_2_10 conv_q_c032_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_11 (conv_i_src_c032_2_11 0 conv_bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_2_11 (conv_i_src_c032_2_11 conv_i_c032_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_11 (conv_q_src_c032_2_11 0 conv_bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_2_11 (conv_q_src_c032_2_11 conv_q_c032_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_12 (conv_i_src_c032_2_12 0 conv_bpf_c032_2 0) vcvs gain=1.950903220161e-01
SCONVI_c032_2_12 (conv_i_src_c032_2_12 conv_i_c032_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_12 (conv_q_src_c032_2_12 0 conv_bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_2_12 (conv_q_src_c032_2_12 conv_q_c032_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_13 (conv_i_src_c032_2_13 0 conv_bpf_c032_2 0) vcvs gain=5.555702330196e-01
SCONVI_c032_2_13 (conv_i_src_c032_2_13 conv_i_c032_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_13 (conv_q_src_c032_2_13 0 conv_bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_2_13 (conv_q_src_c032_2_13 conv_q_c032_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_14 (conv_i_src_c032_2_14 0 conv_bpf_c032_2 0) vcvs gain=8.314696123025e-01
SCONVI_c032_2_14 (conv_i_src_c032_2_14 conv_i_c032_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_14 (conv_q_src_c032_2_14 0 conv_bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_2_14 (conv_q_src_c032_2_14 conv_q_c032_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_2_15 (conv_i_src_c032_2_15 0 conv_bpf_c032_2 0) vcvs gain=9.807852804032e-01
SCONVI_c032_2_15 (conv_i_src_c032_2_15 conv_i_c032_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_2_15 (conv_q_src_c032_2_15 0 conv_bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_2_15 (conv_q_src_c032_2_15 conv_q_c032_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c032_2 (conv_i_c032_2 0) resistor r=1G
RCONVQ_c032_2 (conv_q_c032_2 0) resistor r=1G
RCONVINTI_c032_2 (conv_i_c032_2 ConvIcar_c032_2) resistor r=1k
CCONVINTI_c032_2 (ConvIcar_c032_2 0) capacitor c=80p
RCONVINTQ_c032_2 (conv_q_c032_2 ConvQcar_c032_2) resistor r=1k
CCONVINTQ_c032_2 (ConvQcar_c032_2 0) capacitor c=80p
save conv_bpf_c032_2 ConvIcar_c032_2 ConvQcar_c032_2

// conventional mixed baseline bl032, carrier_3: 1000000000 Hz
CCONVBPF_c032_3 (bl032 n_conv_cbpf_c032_3) capacitor c=2.533029591058e-14
LCONVBPF_c032_3 (n_conv_cbpf_c032_3 conv_bpf_c032_3) inductor l=1.000000000000e-06
RCONVBPF_c032_3 (conv_bpf_c032_3 0) resistor r=3.141592653590e+02
ECONVI_c032_3_00 (conv_i_src_c032_3_00 0 conv_bpf_c032_3 0) vcvs gain=9.807852804032e-01
SCONVI_c032_3_00 (conv_i_src_c032_3_00 conv_i_c032_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_00 (conv_q_src_c032_3_00 0 conv_bpf_c032_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_3_00 (conv_q_src_c032_3_00 conv_q_c032_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_01 (conv_i_src_c032_3_01 0 conv_bpf_c032_3 0) vcvs gain=8.314696123025e-01
SCONVI_c032_3_01 (conv_i_src_c032_3_01 conv_i_c032_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_01 (conv_q_src_c032_3_01 0 conv_bpf_c032_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_3_01 (conv_q_src_c032_3_01 conv_q_c032_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_02 (conv_i_src_c032_3_02 0 conv_bpf_c032_3 0) vcvs gain=5.555702330196e-01
SCONVI_c032_3_02 (conv_i_src_c032_3_02 conv_i_c032_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_02 (conv_q_src_c032_3_02 0 conv_bpf_c032_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_3_02 (conv_q_src_c032_3_02 conv_q_c032_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_03 (conv_i_src_c032_3_03 0 conv_bpf_c032_3 0) vcvs gain=1.950903220161e-01
SCONVI_c032_3_03 (conv_i_src_c032_3_03 conv_i_c032_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_03 (conv_q_src_c032_3_03 0 conv_bpf_c032_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_3_03 (conv_q_src_c032_3_03 conv_q_c032_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_04 (conv_i_src_c032_3_04 0 conv_bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_3_04 (conv_i_src_c032_3_04 conv_i_c032_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_04 (conv_q_src_c032_3_04 0 conv_bpf_c032_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c032_3_04 (conv_q_src_c032_3_04 conv_q_c032_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_05 (conv_i_src_c032_3_05 0 conv_bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_3_05 (conv_i_src_c032_3_05 conv_i_c032_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_05 (conv_q_src_c032_3_05 0 conv_bpf_c032_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c032_3_05 (conv_q_src_c032_3_05 conv_q_c032_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_06 (conv_i_src_c032_3_06 0 conv_bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_3_06 (conv_i_src_c032_3_06 conv_i_c032_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_06 (conv_q_src_c032_3_06 0 conv_bpf_c032_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c032_3_06 (conv_q_src_c032_3_06 conv_q_c032_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_07 (conv_i_src_c032_3_07 0 conv_bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_3_07 (conv_i_src_c032_3_07 conv_i_c032_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_07 (conv_q_src_c032_3_07 0 conv_bpf_c032_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c032_3_07 (conv_q_src_c032_3_07 conv_q_c032_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_08 (conv_i_src_c032_3_08 0 conv_bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c032_3_08 (conv_i_src_c032_3_08 conv_i_c032_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_08 (conv_q_src_c032_3_08 0 conv_bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_3_08 (conv_q_src_c032_3_08 conv_q_c032_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_09 (conv_i_src_c032_3_09 0 conv_bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c032_3_09 (conv_i_src_c032_3_09 conv_i_c032_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_09 (conv_q_src_c032_3_09 0 conv_bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_3_09 (conv_q_src_c032_3_09 conv_q_c032_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_10 (conv_i_src_c032_3_10 0 conv_bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c032_3_10 (conv_i_src_c032_3_10 conv_i_c032_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_10 (conv_q_src_c032_3_10 0 conv_bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_3_10 (conv_q_src_c032_3_10 conv_q_c032_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_11 (conv_i_src_c032_3_11 0 conv_bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c032_3_11 (conv_i_src_c032_3_11 conv_i_c032_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_11 (conv_q_src_c032_3_11 0 conv_bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_3_11 (conv_q_src_c032_3_11 conv_q_c032_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_12 (conv_i_src_c032_3_12 0 conv_bpf_c032_3 0) vcvs gain=1.950903220161e-01
SCONVI_c032_3_12 (conv_i_src_c032_3_12 conv_i_c032_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_12 (conv_q_src_c032_3_12 0 conv_bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c032_3_12 (conv_q_src_c032_3_12 conv_q_c032_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_13 (conv_i_src_c032_3_13 0 conv_bpf_c032_3 0) vcvs gain=5.555702330196e-01
SCONVI_c032_3_13 (conv_i_src_c032_3_13 conv_i_c032_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_13 (conv_q_src_c032_3_13 0 conv_bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c032_3_13 (conv_q_src_c032_3_13 conv_q_c032_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_14 (conv_i_src_c032_3_14 0 conv_bpf_c032_3 0) vcvs gain=8.314696123025e-01
SCONVI_c032_3_14 (conv_i_src_c032_3_14 conv_i_c032_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_14 (conv_q_src_c032_3_14 0 conv_bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c032_3_14 (conv_q_src_c032_3_14 conv_q_c032_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c032_3_15 (conv_i_src_c032_3_15 0 conv_bpf_c032_3 0) vcvs gain=9.807852804032e-01
SCONVI_c032_3_15 (conv_i_src_c032_3_15 conv_i_c032_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c032_3_15 (conv_q_src_c032_3_15 0 conv_bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c032_3_15 (conv_q_src_c032_3_15 conv_q_c032_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c032_3 (conv_i_c032_3 0) resistor r=1G
RCONVQ_c032_3 (conv_q_c032_3 0) resistor r=1G
RCONVINTI_c032_3 (conv_i_c032_3 ConvIcar_c032_3) resistor r=1k
CCONVINTI_c032_3 (ConvIcar_c032_3 0) capacitor c=80p
RCONVINTQ_c032_3 (conv_q_c032_3 ConvQcar_c032_3) resistor r=1k
CCONVINTQ_c032_3 (ConvQcar_c032_3 0) capacitor c=80p
save conv_bpf_c032_3 ConvIcar_c032_3 ConvQcar_c032_3

// conventional mixed baseline bl033, carrier_0: 250000000 Hz
CCONVBPF_c033_0 (bl033 n_conv_cbpf_c033_0) capacitor c=4.052847345694e-13
LCONVBPF_c033_0 (n_conv_cbpf_c033_0 conv_bpf_c033_0) inductor l=1.000000000000e-06
RCONVBPF_c033_0 (conv_bpf_c033_0 0) resistor r=7.853981633974e+01
ECONVI_c033_0_00 (conv_i_src_c033_0_00 0 conv_bpf_c033_0 0) vcvs gain=9.807852804032e-01
SCONVI_c033_0_00 (conv_i_src_c033_0_00 conv_i_c033_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_00 (conv_q_src_c033_0_00 0 conv_bpf_c033_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_0_00 (conv_q_src_c033_0_00 conv_q_c033_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_01 (conv_i_src_c033_0_01 0 conv_bpf_c033_0 0) vcvs gain=8.314696123025e-01
SCONVI_c033_0_01 (conv_i_src_c033_0_01 conv_i_c033_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_01 (conv_q_src_c033_0_01 0 conv_bpf_c033_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_0_01 (conv_q_src_c033_0_01 conv_q_c033_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_02 (conv_i_src_c033_0_02 0 conv_bpf_c033_0 0) vcvs gain=5.555702330196e-01
SCONVI_c033_0_02 (conv_i_src_c033_0_02 conv_i_c033_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_02 (conv_q_src_c033_0_02 0 conv_bpf_c033_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_0_02 (conv_q_src_c033_0_02 conv_q_c033_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_03 (conv_i_src_c033_0_03 0 conv_bpf_c033_0 0) vcvs gain=1.950903220161e-01
SCONVI_c033_0_03 (conv_i_src_c033_0_03 conv_i_c033_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_03 (conv_q_src_c033_0_03 0 conv_bpf_c033_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_0_03 (conv_q_src_c033_0_03 conv_q_c033_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_04 (conv_i_src_c033_0_04 0 conv_bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_0_04 (conv_i_src_c033_0_04 conv_i_c033_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_04 (conv_q_src_c033_0_04 0 conv_bpf_c033_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_0_04 (conv_q_src_c033_0_04 conv_q_c033_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_05 (conv_i_src_c033_0_05 0 conv_bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_0_05 (conv_i_src_c033_0_05 conv_i_c033_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_05 (conv_q_src_c033_0_05 0 conv_bpf_c033_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_0_05 (conv_q_src_c033_0_05 conv_q_c033_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_06 (conv_i_src_c033_0_06 0 conv_bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_0_06 (conv_i_src_c033_0_06 conv_i_c033_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_06 (conv_q_src_c033_0_06 0 conv_bpf_c033_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_0_06 (conv_q_src_c033_0_06 conv_q_c033_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_07 (conv_i_src_c033_0_07 0 conv_bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_0_07 (conv_i_src_c033_0_07 conv_i_c033_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_07 (conv_q_src_c033_0_07 0 conv_bpf_c033_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_0_07 (conv_q_src_c033_0_07 conv_q_c033_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_08 (conv_i_src_c033_0_08 0 conv_bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_0_08 (conv_i_src_c033_0_08 conv_i_c033_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_08 (conv_q_src_c033_0_08 0 conv_bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_0_08 (conv_q_src_c033_0_08 conv_q_c033_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_09 (conv_i_src_c033_0_09 0 conv_bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_0_09 (conv_i_src_c033_0_09 conv_i_c033_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_09 (conv_q_src_c033_0_09 0 conv_bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_0_09 (conv_q_src_c033_0_09 conv_q_c033_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_10 (conv_i_src_c033_0_10 0 conv_bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_0_10 (conv_i_src_c033_0_10 conv_i_c033_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_10 (conv_q_src_c033_0_10 0 conv_bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_0_10 (conv_q_src_c033_0_10 conv_q_c033_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_11 (conv_i_src_c033_0_11 0 conv_bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_0_11 (conv_i_src_c033_0_11 conv_i_c033_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_11 (conv_q_src_c033_0_11 0 conv_bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_0_11 (conv_q_src_c033_0_11 conv_q_c033_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_12 (conv_i_src_c033_0_12 0 conv_bpf_c033_0 0) vcvs gain=1.950903220161e-01
SCONVI_c033_0_12 (conv_i_src_c033_0_12 conv_i_c033_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_12 (conv_q_src_c033_0_12 0 conv_bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_0_12 (conv_q_src_c033_0_12 conv_q_c033_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_13 (conv_i_src_c033_0_13 0 conv_bpf_c033_0 0) vcvs gain=5.555702330196e-01
SCONVI_c033_0_13 (conv_i_src_c033_0_13 conv_i_c033_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_13 (conv_q_src_c033_0_13 0 conv_bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_0_13 (conv_q_src_c033_0_13 conv_q_c033_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_14 (conv_i_src_c033_0_14 0 conv_bpf_c033_0 0) vcvs gain=8.314696123025e-01
SCONVI_c033_0_14 (conv_i_src_c033_0_14 conv_i_c033_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_14 (conv_q_src_c033_0_14 0 conv_bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_0_14 (conv_q_src_c033_0_14 conv_q_c033_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_0_15 (conv_i_src_c033_0_15 0 conv_bpf_c033_0 0) vcvs gain=9.807852804032e-01
SCONVI_c033_0_15 (conv_i_src_c033_0_15 conv_i_c033_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_0_15 (conv_q_src_c033_0_15 0 conv_bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_0_15 (conv_q_src_c033_0_15 conv_q_c033_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c033_0 (conv_i_c033_0 0) resistor r=1G
RCONVQ_c033_0 (conv_q_c033_0 0) resistor r=1G
RCONVINTI_c033_0 (conv_i_c033_0 ConvIcar_c033_0) resistor r=1k
CCONVINTI_c033_0 (ConvIcar_c033_0 0) capacitor c=80p
RCONVINTQ_c033_0 (conv_q_c033_0 ConvQcar_c033_0) resistor r=1k
CCONVINTQ_c033_0 (ConvQcar_c033_0 0) capacitor c=80p
save conv_bpf_c033_0 ConvIcar_c033_0 ConvQcar_c033_0

// conventional mixed baseline bl033, carrier_1: 500000000 Hz
CCONVBPF_c033_1 (bl033 n_conv_cbpf_c033_1) capacitor c=1.013211836423e-13
LCONVBPF_c033_1 (n_conv_cbpf_c033_1 conv_bpf_c033_1) inductor l=1.000000000000e-06
RCONVBPF_c033_1 (conv_bpf_c033_1 0) resistor r=1.570796326795e+02
ECONVI_c033_1_00 (conv_i_src_c033_1_00 0 conv_bpf_c033_1 0) vcvs gain=9.807852804032e-01
SCONVI_c033_1_00 (conv_i_src_c033_1_00 conv_i_c033_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_00 (conv_q_src_c033_1_00 0 conv_bpf_c033_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_1_00 (conv_q_src_c033_1_00 conv_q_c033_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_01 (conv_i_src_c033_1_01 0 conv_bpf_c033_1 0) vcvs gain=8.314696123025e-01
SCONVI_c033_1_01 (conv_i_src_c033_1_01 conv_i_c033_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_01 (conv_q_src_c033_1_01 0 conv_bpf_c033_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_1_01 (conv_q_src_c033_1_01 conv_q_c033_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_02 (conv_i_src_c033_1_02 0 conv_bpf_c033_1 0) vcvs gain=5.555702330196e-01
SCONVI_c033_1_02 (conv_i_src_c033_1_02 conv_i_c033_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_02 (conv_q_src_c033_1_02 0 conv_bpf_c033_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_1_02 (conv_q_src_c033_1_02 conv_q_c033_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_03 (conv_i_src_c033_1_03 0 conv_bpf_c033_1 0) vcvs gain=1.950903220161e-01
SCONVI_c033_1_03 (conv_i_src_c033_1_03 conv_i_c033_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_03 (conv_q_src_c033_1_03 0 conv_bpf_c033_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_1_03 (conv_q_src_c033_1_03 conv_q_c033_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_04 (conv_i_src_c033_1_04 0 conv_bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_1_04 (conv_i_src_c033_1_04 conv_i_c033_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_04 (conv_q_src_c033_1_04 0 conv_bpf_c033_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_1_04 (conv_q_src_c033_1_04 conv_q_c033_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_05 (conv_i_src_c033_1_05 0 conv_bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_1_05 (conv_i_src_c033_1_05 conv_i_c033_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_05 (conv_q_src_c033_1_05 0 conv_bpf_c033_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_1_05 (conv_q_src_c033_1_05 conv_q_c033_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_06 (conv_i_src_c033_1_06 0 conv_bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_1_06 (conv_i_src_c033_1_06 conv_i_c033_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_06 (conv_q_src_c033_1_06 0 conv_bpf_c033_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_1_06 (conv_q_src_c033_1_06 conv_q_c033_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_07 (conv_i_src_c033_1_07 0 conv_bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_1_07 (conv_i_src_c033_1_07 conv_i_c033_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_07 (conv_q_src_c033_1_07 0 conv_bpf_c033_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_1_07 (conv_q_src_c033_1_07 conv_q_c033_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_08 (conv_i_src_c033_1_08 0 conv_bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_1_08 (conv_i_src_c033_1_08 conv_i_c033_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_08 (conv_q_src_c033_1_08 0 conv_bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_1_08 (conv_q_src_c033_1_08 conv_q_c033_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_09 (conv_i_src_c033_1_09 0 conv_bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_1_09 (conv_i_src_c033_1_09 conv_i_c033_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_09 (conv_q_src_c033_1_09 0 conv_bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_1_09 (conv_q_src_c033_1_09 conv_q_c033_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_10 (conv_i_src_c033_1_10 0 conv_bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_1_10 (conv_i_src_c033_1_10 conv_i_c033_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_10 (conv_q_src_c033_1_10 0 conv_bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_1_10 (conv_q_src_c033_1_10 conv_q_c033_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_11 (conv_i_src_c033_1_11 0 conv_bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_1_11 (conv_i_src_c033_1_11 conv_i_c033_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_11 (conv_q_src_c033_1_11 0 conv_bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_1_11 (conv_q_src_c033_1_11 conv_q_c033_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_12 (conv_i_src_c033_1_12 0 conv_bpf_c033_1 0) vcvs gain=1.950903220161e-01
SCONVI_c033_1_12 (conv_i_src_c033_1_12 conv_i_c033_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_12 (conv_q_src_c033_1_12 0 conv_bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_1_12 (conv_q_src_c033_1_12 conv_q_c033_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_13 (conv_i_src_c033_1_13 0 conv_bpf_c033_1 0) vcvs gain=5.555702330196e-01
SCONVI_c033_1_13 (conv_i_src_c033_1_13 conv_i_c033_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_13 (conv_q_src_c033_1_13 0 conv_bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_1_13 (conv_q_src_c033_1_13 conv_q_c033_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_14 (conv_i_src_c033_1_14 0 conv_bpf_c033_1 0) vcvs gain=8.314696123025e-01
SCONVI_c033_1_14 (conv_i_src_c033_1_14 conv_i_c033_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_14 (conv_q_src_c033_1_14 0 conv_bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_1_14 (conv_q_src_c033_1_14 conv_q_c033_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_1_15 (conv_i_src_c033_1_15 0 conv_bpf_c033_1 0) vcvs gain=9.807852804032e-01
SCONVI_c033_1_15 (conv_i_src_c033_1_15 conv_i_c033_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_1_15 (conv_q_src_c033_1_15 0 conv_bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_1_15 (conv_q_src_c033_1_15 conv_q_c033_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c033_1 (conv_i_c033_1 0) resistor r=1G
RCONVQ_c033_1 (conv_q_c033_1 0) resistor r=1G
RCONVINTI_c033_1 (conv_i_c033_1 ConvIcar_c033_1) resistor r=1k
CCONVINTI_c033_1 (ConvIcar_c033_1 0) capacitor c=80p
RCONVINTQ_c033_1 (conv_q_c033_1 ConvQcar_c033_1) resistor r=1k
CCONVINTQ_c033_1 (ConvQcar_c033_1 0) capacitor c=80p
save conv_bpf_c033_1 ConvIcar_c033_1 ConvQcar_c033_1

// conventional mixed baseline bl033, carrier_2: 750000000 Hz
CCONVBPF_c033_2 (bl033 n_conv_cbpf_c033_2) capacitor c=4.503163717437e-14
LCONVBPF_c033_2 (n_conv_cbpf_c033_2 conv_bpf_c033_2) inductor l=1.000000000000e-06
RCONVBPF_c033_2 (conv_bpf_c033_2 0) resistor r=2.356194490192e+02
ECONVI_c033_2_00 (conv_i_src_c033_2_00 0 conv_bpf_c033_2 0) vcvs gain=9.807852804032e-01
SCONVI_c033_2_00 (conv_i_src_c033_2_00 conv_i_c033_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_00 (conv_q_src_c033_2_00 0 conv_bpf_c033_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_2_00 (conv_q_src_c033_2_00 conv_q_c033_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_01 (conv_i_src_c033_2_01 0 conv_bpf_c033_2 0) vcvs gain=8.314696123025e-01
SCONVI_c033_2_01 (conv_i_src_c033_2_01 conv_i_c033_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_01 (conv_q_src_c033_2_01 0 conv_bpf_c033_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_2_01 (conv_q_src_c033_2_01 conv_q_c033_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_02 (conv_i_src_c033_2_02 0 conv_bpf_c033_2 0) vcvs gain=5.555702330196e-01
SCONVI_c033_2_02 (conv_i_src_c033_2_02 conv_i_c033_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_02 (conv_q_src_c033_2_02 0 conv_bpf_c033_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_2_02 (conv_q_src_c033_2_02 conv_q_c033_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_03 (conv_i_src_c033_2_03 0 conv_bpf_c033_2 0) vcvs gain=1.950903220161e-01
SCONVI_c033_2_03 (conv_i_src_c033_2_03 conv_i_c033_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_03 (conv_q_src_c033_2_03 0 conv_bpf_c033_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_2_03 (conv_q_src_c033_2_03 conv_q_c033_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_04 (conv_i_src_c033_2_04 0 conv_bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_2_04 (conv_i_src_c033_2_04 conv_i_c033_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_04 (conv_q_src_c033_2_04 0 conv_bpf_c033_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_2_04 (conv_q_src_c033_2_04 conv_q_c033_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_05 (conv_i_src_c033_2_05 0 conv_bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_2_05 (conv_i_src_c033_2_05 conv_i_c033_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_05 (conv_q_src_c033_2_05 0 conv_bpf_c033_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_2_05 (conv_q_src_c033_2_05 conv_q_c033_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_06 (conv_i_src_c033_2_06 0 conv_bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_2_06 (conv_i_src_c033_2_06 conv_i_c033_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_06 (conv_q_src_c033_2_06 0 conv_bpf_c033_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_2_06 (conv_q_src_c033_2_06 conv_q_c033_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_07 (conv_i_src_c033_2_07 0 conv_bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_2_07 (conv_i_src_c033_2_07 conv_i_c033_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_07 (conv_q_src_c033_2_07 0 conv_bpf_c033_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_2_07 (conv_q_src_c033_2_07 conv_q_c033_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_08 (conv_i_src_c033_2_08 0 conv_bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_2_08 (conv_i_src_c033_2_08 conv_i_c033_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_08 (conv_q_src_c033_2_08 0 conv_bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_2_08 (conv_q_src_c033_2_08 conv_q_c033_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_09 (conv_i_src_c033_2_09 0 conv_bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_2_09 (conv_i_src_c033_2_09 conv_i_c033_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_09 (conv_q_src_c033_2_09 0 conv_bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_2_09 (conv_q_src_c033_2_09 conv_q_c033_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_10 (conv_i_src_c033_2_10 0 conv_bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_2_10 (conv_i_src_c033_2_10 conv_i_c033_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_10 (conv_q_src_c033_2_10 0 conv_bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_2_10 (conv_q_src_c033_2_10 conv_q_c033_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_11 (conv_i_src_c033_2_11 0 conv_bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_2_11 (conv_i_src_c033_2_11 conv_i_c033_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_11 (conv_q_src_c033_2_11 0 conv_bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_2_11 (conv_q_src_c033_2_11 conv_q_c033_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_12 (conv_i_src_c033_2_12 0 conv_bpf_c033_2 0) vcvs gain=1.950903220161e-01
SCONVI_c033_2_12 (conv_i_src_c033_2_12 conv_i_c033_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_12 (conv_q_src_c033_2_12 0 conv_bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_2_12 (conv_q_src_c033_2_12 conv_q_c033_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_13 (conv_i_src_c033_2_13 0 conv_bpf_c033_2 0) vcvs gain=5.555702330196e-01
SCONVI_c033_2_13 (conv_i_src_c033_2_13 conv_i_c033_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_13 (conv_q_src_c033_2_13 0 conv_bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_2_13 (conv_q_src_c033_2_13 conv_q_c033_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_14 (conv_i_src_c033_2_14 0 conv_bpf_c033_2 0) vcvs gain=8.314696123025e-01
SCONVI_c033_2_14 (conv_i_src_c033_2_14 conv_i_c033_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_14 (conv_q_src_c033_2_14 0 conv_bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_2_14 (conv_q_src_c033_2_14 conv_q_c033_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_2_15 (conv_i_src_c033_2_15 0 conv_bpf_c033_2 0) vcvs gain=9.807852804032e-01
SCONVI_c033_2_15 (conv_i_src_c033_2_15 conv_i_c033_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_2_15 (conv_q_src_c033_2_15 0 conv_bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_2_15 (conv_q_src_c033_2_15 conv_q_c033_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c033_2 (conv_i_c033_2 0) resistor r=1G
RCONVQ_c033_2 (conv_q_c033_2 0) resistor r=1G
RCONVINTI_c033_2 (conv_i_c033_2 ConvIcar_c033_2) resistor r=1k
CCONVINTI_c033_2 (ConvIcar_c033_2 0) capacitor c=80p
RCONVINTQ_c033_2 (conv_q_c033_2 ConvQcar_c033_2) resistor r=1k
CCONVINTQ_c033_2 (ConvQcar_c033_2 0) capacitor c=80p
save conv_bpf_c033_2 ConvIcar_c033_2 ConvQcar_c033_2

// conventional mixed baseline bl033, carrier_3: 1000000000 Hz
CCONVBPF_c033_3 (bl033 n_conv_cbpf_c033_3) capacitor c=2.533029591058e-14
LCONVBPF_c033_3 (n_conv_cbpf_c033_3 conv_bpf_c033_3) inductor l=1.000000000000e-06
RCONVBPF_c033_3 (conv_bpf_c033_3 0) resistor r=3.141592653590e+02
ECONVI_c033_3_00 (conv_i_src_c033_3_00 0 conv_bpf_c033_3 0) vcvs gain=9.807852804032e-01
SCONVI_c033_3_00 (conv_i_src_c033_3_00 conv_i_c033_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_00 (conv_q_src_c033_3_00 0 conv_bpf_c033_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_3_00 (conv_q_src_c033_3_00 conv_q_c033_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_01 (conv_i_src_c033_3_01 0 conv_bpf_c033_3 0) vcvs gain=8.314696123025e-01
SCONVI_c033_3_01 (conv_i_src_c033_3_01 conv_i_c033_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_01 (conv_q_src_c033_3_01 0 conv_bpf_c033_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_3_01 (conv_q_src_c033_3_01 conv_q_c033_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_02 (conv_i_src_c033_3_02 0 conv_bpf_c033_3 0) vcvs gain=5.555702330196e-01
SCONVI_c033_3_02 (conv_i_src_c033_3_02 conv_i_c033_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_02 (conv_q_src_c033_3_02 0 conv_bpf_c033_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_3_02 (conv_q_src_c033_3_02 conv_q_c033_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_03 (conv_i_src_c033_3_03 0 conv_bpf_c033_3 0) vcvs gain=1.950903220161e-01
SCONVI_c033_3_03 (conv_i_src_c033_3_03 conv_i_c033_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_03 (conv_q_src_c033_3_03 0 conv_bpf_c033_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_3_03 (conv_q_src_c033_3_03 conv_q_c033_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_04 (conv_i_src_c033_3_04 0 conv_bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_3_04 (conv_i_src_c033_3_04 conv_i_c033_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_04 (conv_q_src_c033_3_04 0 conv_bpf_c033_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c033_3_04 (conv_q_src_c033_3_04 conv_q_c033_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_05 (conv_i_src_c033_3_05 0 conv_bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_3_05 (conv_i_src_c033_3_05 conv_i_c033_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_05 (conv_q_src_c033_3_05 0 conv_bpf_c033_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c033_3_05 (conv_q_src_c033_3_05 conv_q_c033_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_06 (conv_i_src_c033_3_06 0 conv_bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_3_06 (conv_i_src_c033_3_06 conv_i_c033_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_06 (conv_q_src_c033_3_06 0 conv_bpf_c033_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c033_3_06 (conv_q_src_c033_3_06 conv_q_c033_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_07 (conv_i_src_c033_3_07 0 conv_bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_3_07 (conv_i_src_c033_3_07 conv_i_c033_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_07 (conv_q_src_c033_3_07 0 conv_bpf_c033_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c033_3_07 (conv_q_src_c033_3_07 conv_q_c033_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_08 (conv_i_src_c033_3_08 0 conv_bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c033_3_08 (conv_i_src_c033_3_08 conv_i_c033_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_08 (conv_q_src_c033_3_08 0 conv_bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_3_08 (conv_q_src_c033_3_08 conv_q_c033_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_09 (conv_i_src_c033_3_09 0 conv_bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c033_3_09 (conv_i_src_c033_3_09 conv_i_c033_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_09 (conv_q_src_c033_3_09 0 conv_bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_3_09 (conv_q_src_c033_3_09 conv_q_c033_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_10 (conv_i_src_c033_3_10 0 conv_bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c033_3_10 (conv_i_src_c033_3_10 conv_i_c033_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_10 (conv_q_src_c033_3_10 0 conv_bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_3_10 (conv_q_src_c033_3_10 conv_q_c033_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_11 (conv_i_src_c033_3_11 0 conv_bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c033_3_11 (conv_i_src_c033_3_11 conv_i_c033_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_11 (conv_q_src_c033_3_11 0 conv_bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_3_11 (conv_q_src_c033_3_11 conv_q_c033_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_12 (conv_i_src_c033_3_12 0 conv_bpf_c033_3 0) vcvs gain=1.950903220161e-01
SCONVI_c033_3_12 (conv_i_src_c033_3_12 conv_i_c033_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_12 (conv_q_src_c033_3_12 0 conv_bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c033_3_12 (conv_q_src_c033_3_12 conv_q_c033_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_13 (conv_i_src_c033_3_13 0 conv_bpf_c033_3 0) vcvs gain=5.555702330196e-01
SCONVI_c033_3_13 (conv_i_src_c033_3_13 conv_i_c033_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_13 (conv_q_src_c033_3_13 0 conv_bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c033_3_13 (conv_q_src_c033_3_13 conv_q_c033_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_14 (conv_i_src_c033_3_14 0 conv_bpf_c033_3 0) vcvs gain=8.314696123025e-01
SCONVI_c033_3_14 (conv_i_src_c033_3_14 conv_i_c033_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_14 (conv_q_src_c033_3_14 0 conv_bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c033_3_14 (conv_q_src_c033_3_14 conv_q_c033_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c033_3_15 (conv_i_src_c033_3_15 0 conv_bpf_c033_3 0) vcvs gain=9.807852804032e-01
SCONVI_c033_3_15 (conv_i_src_c033_3_15 conv_i_c033_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c033_3_15 (conv_q_src_c033_3_15 0 conv_bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c033_3_15 (conv_q_src_c033_3_15 conv_q_c033_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c033_3 (conv_i_c033_3 0) resistor r=1G
RCONVQ_c033_3 (conv_q_c033_3 0) resistor r=1G
RCONVINTI_c033_3 (conv_i_c033_3 ConvIcar_c033_3) resistor r=1k
CCONVINTI_c033_3 (ConvIcar_c033_3 0) capacitor c=80p
RCONVINTQ_c033_3 (conv_q_c033_3 ConvQcar_c033_3) resistor r=1k
CCONVINTQ_c033_3 (ConvQcar_c033_3 0) capacitor c=80p
save conv_bpf_c033_3 ConvIcar_c033_3 ConvQcar_c033_3

// conventional mixed baseline bl034, carrier_0: 250000000 Hz
CCONVBPF_c034_0 (bl034 n_conv_cbpf_c034_0) capacitor c=4.052847345694e-13
LCONVBPF_c034_0 (n_conv_cbpf_c034_0 conv_bpf_c034_0) inductor l=1.000000000000e-06
RCONVBPF_c034_0 (conv_bpf_c034_0 0) resistor r=7.853981633974e+01
ECONVI_c034_0_00 (conv_i_src_c034_0_00 0 conv_bpf_c034_0 0) vcvs gain=9.807852804032e-01
SCONVI_c034_0_00 (conv_i_src_c034_0_00 conv_i_c034_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_00 (conv_q_src_c034_0_00 0 conv_bpf_c034_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_0_00 (conv_q_src_c034_0_00 conv_q_c034_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_01 (conv_i_src_c034_0_01 0 conv_bpf_c034_0 0) vcvs gain=8.314696123025e-01
SCONVI_c034_0_01 (conv_i_src_c034_0_01 conv_i_c034_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_01 (conv_q_src_c034_0_01 0 conv_bpf_c034_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_0_01 (conv_q_src_c034_0_01 conv_q_c034_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_02 (conv_i_src_c034_0_02 0 conv_bpf_c034_0 0) vcvs gain=5.555702330196e-01
SCONVI_c034_0_02 (conv_i_src_c034_0_02 conv_i_c034_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_02 (conv_q_src_c034_0_02 0 conv_bpf_c034_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_0_02 (conv_q_src_c034_0_02 conv_q_c034_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_03 (conv_i_src_c034_0_03 0 conv_bpf_c034_0 0) vcvs gain=1.950903220161e-01
SCONVI_c034_0_03 (conv_i_src_c034_0_03 conv_i_c034_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_03 (conv_q_src_c034_0_03 0 conv_bpf_c034_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_0_03 (conv_q_src_c034_0_03 conv_q_c034_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_04 (conv_i_src_c034_0_04 0 conv_bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_0_04 (conv_i_src_c034_0_04 conv_i_c034_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_04 (conv_q_src_c034_0_04 0 conv_bpf_c034_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_0_04 (conv_q_src_c034_0_04 conv_q_c034_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_05 (conv_i_src_c034_0_05 0 conv_bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_0_05 (conv_i_src_c034_0_05 conv_i_c034_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_05 (conv_q_src_c034_0_05 0 conv_bpf_c034_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_0_05 (conv_q_src_c034_0_05 conv_q_c034_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_06 (conv_i_src_c034_0_06 0 conv_bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_0_06 (conv_i_src_c034_0_06 conv_i_c034_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_06 (conv_q_src_c034_0_06 0 conv_bpf_c034_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_0_06 (conv_q_src_c034_0_06 conv_q_c034_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_07 (conv_i_src_c034_0_07 0 conv_bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_0_07 (conv_i_src_c034_0_07 conv_i_c034_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_07 (conv_q_src_c034_0_07 0 conv_bpf_c034_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_0_07 (conv_q_src_c034_0_07 conv_q_c034_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_08 (conv_i_src_c034_0_08 0 conv_bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_0_08 (conv_i_src_c034_0_08 conv_i_c034_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_08 (conv_q_src_c034_0_08 0 conv_bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_0_08 (conv_q_src_c034_0_08 conv_q_c034_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_09 (conv_i_src_c034_0_09 0 conv_bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_0_09 (conv_i_src_c034_0_09 conv_i_c034_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_09 (conv_q_src_c034_0_09 0 conv_bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_0_09 (conv_q_src_c034_0_09 conv_q_c034_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_10 (conv_i_src_c034_0_10 0 conv_bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_0_10 (conv_i_src_c034_0_10 conv_i_c034_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_10 (conv_q_src_c034_0_10 0 conv_bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_0_10 (conv_q_src_c034_0_10 conv_q_c034_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_11 (conv_i_src_c034_0_11 0 conv_bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_0_11 (conv_i_src_c034_0_11 conv_i_c034_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_11 (conv_q_src_c034_0_11 0 conv_bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_0_11 (conv_q_src_c034_0_11 conv_q_c034_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_12 (conv_i_src_c034_0_12 0 conv_bpf_c034_0 0) vcvs gain=1.950903220161e-01
SCONVI_c034_0_12 (conv_i_src_c034_0_12 conv_i_c034_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_12 (conv_q_src_c034_0_12 0 conv_bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_0_12 (conv_q_src_c034_0_12 conv_q_c034_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_13 (conv_i_src_c034_0_13 0 conv_bpf_c034_0 0) vcvs gain=5.555702330196e-01
SCONVI_c034_0_13 (conv_i_src_c034_0_13 conv_i_c034_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_13 (conv_q_src_c034_0_13 0 conv_bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_0_13 (conv_q_src_c034_0_13 conv_q_c034_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_14 (conv_i_src_c034_0_14 0 conv_bpf_c034_0 0) vcvs gain=8.314696123025e-01
SCONVI_c034_0_14 (conv_i_src_c034_0_14 conv_i_c034_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_14 (conv_q_src_c034_0_14 0 conv_bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_0_14 (conv_q_src_c034_0_14 conv_q_c034_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_0_15 (conv_i_src_c034_0_15 0 conv_bpf_c034_0 0) vcvs gain=9.807852804032e-01
SCONVI_c034_0_15 (conv_i_src_c034_0_15 conv_i_c034_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_0_15 (conv_q_src_c034_0_15 0 conv_bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_0_15 (conv_q_src_c034_0_15 conv_q_c034_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c034_0 (conv_i_c034_0 0) resistor r=1G
RCONVQ_c034_0 (conv_q_c034_0 0) resistor r=1G
RCONVINTI_c034_0 (conv_i_c034_0 ConvIcar_c034_0) resistor r=1k
CCONVINTI_c034_0 (ConvIcar_c034_0 0) capacitor c=80p
RCONVINTQ_c034_0 (conv_q_c034_0 ConvQcar_c034_0) resistor r=1k
CCONVINTQ_c034_0 (ConvQcar_c034_0 0) capacitor c=80p
save conv_bpf_c034_0 ConvIcar_c034_0 ConvQcar_c034_0

// conventional mixed baseline bl034, carrier_1: 500000000 Hz
CCONVBPF_c034_1 (bl034 n_conv_cbpf_c034_1) capacitor c=1.013211836423e-13
LCONVBPF_c034_1 (n_conv_cbpf_c034_1 conv_bpf_c034_1) inductor l=1.000000000000e-06
RCONVBPF_c034_1 (conv_bpf_c034_1 0) resistor r=1.570796326795e+02
ECONVI_c034_1_00 (conv_i_src_c034_1_00 0 conv_bpf_c034_1 0) vcvs gain=9.807852804032e-01
SCONVI_c034_1_00 (conv_i_src_c034_1_00 conv_i_c034_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_00 (conv_q_src_c034_1_00 0 conv_bpf_c034_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_1_00 (conv_q_src_c034_1_00 conv_q_c034_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_01 (conv_i_src_c034_1_01 0 conv_bpf_c034_1 0) vcvs gain=8.314696123025e-01
SCONVI_c034_1_01 (conv_i_src_c034_1_01 conv_i_c034_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_01 (conv_q_src_c034_1_01 0 conv_bpf_c034_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_1_01 (conv_q_src_c034_1_01 conv_q_c034_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_02 (conv_i_src_c034_1_02 0 conv_bpf_c034_1 0) vcvs gain=5.555702330196e-01
SCONVI_c034_1_02 (conv_i_src_c034_1_02 conv_i_c034_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_02 (conv_q_src_c034_1_02 0 conv_bpf_c034_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_1_02 (conv_q_src_c034_1_02 conv_q_c034_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_03 (conv_i_src_c034_1_03 0 conv_bpf_c034_1 0) vcvs gain=1.950903220161e-01
SCONVI_c034_1_03 (conv_i_src_c034_1_03 conv_i_c034_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_03 (conv_q_src_c034_1_03 0 conv_bpf_c034_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_1_03 (conv_q_src_c034_1_03 conv_q_c034_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_04 (conv_i_src_c034_1_04 0 conv_bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_1_04 (conv_i_src_c034_1_04 conv_i_c034_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_04 (conv_q_src_c034_1_04 0 conv_bpf_c034_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_1_04 (conv_q_src_c034_1_04 conv_q_c034_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_05 (conv_i_src_c034_1_05 0 conv_bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_1_05 (conv_i_src_c034_1_05 conv_i_c034_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_05 (conv_q_src_c034_1_05 0 conv_bpf_c034_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_1_05 (conv_q_src_c034_1_05 conv_q_c034_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_06 (conv_i_src_c034_1_06 0 conv_bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_1_06 (conv_i_src_c034_1_06 conv_i_c034_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_06 (conv_q_src_c034_1_06 0 conv_bpf_c034_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_1_06 (conv_q_src_c034_1_06 conv_q_c034_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_07 (conv_i_src_c034_1_07 0 conv_bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_1_07 (conv_i_src_c034_1_07 conv_i_c034_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_07 (conv_q_src_c034_1_07 0 conv_bpf_c034_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_1_07 (conv_q_src_c034_1_07 conv_q_c034_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_08 (conv_i_src_c034_1_08 0 conv_bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_1_08 (conv_i_src_c034_1_08 conv_i_c034_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_08 (conv_q_src_c034_1_08 0 conv_bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_1_08 (conv_q_src_c034_1_08 conv_q_c034_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_09 (conv_i_src_c034_1_09 0 conv_bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_1_09 (conv_i_src_c034_1_09 conv_i_c034_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_09 (conv_q_src_c034_1_09 0 conv_bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_1_09 (conv_q_src_c034_1_09 conv_q_c034_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_10 (conv_i_src_c034_1_10 0 conv_bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_1_10 (conv_i_src_c034_1_10 conv_i_c034_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_10 (conv_q_src_c034_1_10 0 conv_bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_1_10 (conv_q_src_c034_1_10 conv_q_c034_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_11 (conv_i_src_c034_1_11 0 conv_bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_1_11 (conv_i_src_c034_1_11 conv_i_c034_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_11 (conv_q_src_c034_1_11 0 conv_bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_1_11 (conv_q_src_c034_1_11 conv_q_c034_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_12 (conv_i_src_c034_1_12 0 conv_bpf_c034_1 0) vcvs gain=1.950903220161e-01
SCONVI_c034_1_12 (conv_i_src_c034_1_12 conv_i_c034_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_12 (conv_q_src_c034_1_12 0 conv_bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_1_12 (conv_q_src_c034_1_12 conv_q_c034_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_13 (conv_i_src_c034_1_13 0 conv_bpf_c034_1 0) vcvs gain=5.555702330196e-01
SCONVI_c034_1_13 (conv_i_src_c034_1_13 conv_i_c034_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_13 (conv_q_src_c034_1_13 0 conv_bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_1_13 (conv_q_src_c034_1_13 conv_q_c034_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_14 (conv_i_src_c034_1_14 0 conv_bpf_c034_1 0) vcvs gain=8.314696123025e-01
SCONVI_c034_1_14 (conv_i_src_c034_1_14 conv_i_c034_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_14 (conv_q_src_c034_1_14 0 conv_bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_1_14 (conv_q_src_c034_1_14 conv_q_c034_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_1_15 (conv_i_src_c034_1_15 0 conv_bpf_c034_1 0) vcvs gain=9.807852804032e-01
SCONVI_c034_1_15 (conv_i_src_c034_1_15 conv_i_c034_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_1_15 (conv_q_src_c034_1_15 0 conv_bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_1_15 (conv_q_src_c034_1_15 conv_q_c034_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c034_1 (conv_i_c034_1 0) resistor r=1G
RCONVQ_c034_1 (conv_q_c034_1 0) resistor r=1G
RCONVINTI_c034_1 (conv_i_c034_1 ConvIcar_c034_1) resistor r=1k
CCONVINTI_c034_1 (ConvIcar_c034_1 0) capacitor c=80p
RCONVINTQ_c034_1 (conv_q_c034_1 ConvQcar_c034_1) resistor r=1k
CCONVINTQ_c034_1 (ConvQcar_c034_1 0) capacitor c=80p
save conv_bpf_c034_1 ConvIcar_c034_1 ConvQcar_c034_1

// conventional mixed baseline bl034, carrier_2: 750000000 Hz
CCONVBPF_c034_2 (bl034 n_conv_cbpf_c034_2) capacitor c=4.503163717437e-14
LCONVBPF_c034_2 (n_conv_cbpf_c034_2 conv_bpf_c034_2) inductor l=1.000000000000e-06
RCONVBPF_c034_2 (conv_bpf_c034_2 0) resistor r=2.356194490192e+02
ECONVI_c034_2_00 (conv_i_src_c034_2_00 0 conv_bpf_c034_2 0) vcvs gain=9.807852804032e-01
SCONVI_c034_2_00 (conv_i_src_c034_2_00 conv_i_c034_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_00 (conv_q_src_c034_2_00 0 conv_bpf_c034_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_2_00 (conv_q_src_c034_2_00 conv_q_c034_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_01 (conv_i_src_c034_2_01 0 conv_bpf_c034_2 0) vcvs gain=8.314696123025e-01
SCONVI_c034_2_01 (conv_i_src_c034_2_01 conv_i_c034_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_01 (conv_q_src_c034_2_01 0 conv_bpf_c034_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_2_01 (conv_q_src_c034_2_01 conv_q_c034_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_02 (conv_i_src_c034_2_02 0 conv_bpf_c034_2 0) vcvs gain=5.555702330196e-01
SCONVI_c034_2_02 (conv_i_src_c034_2_02 conv_i_c034_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_02 (conv_q_src_c034_2_02 0 conv_bpf_c034_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_2_02 (conv_q_src_c034_2_02 conv_q_c034_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_03 (conv_i_src_c034_2_03 0 conv_bpf_c034_2 0) vcvs gain=1.950903220161e-01
SCONVI_c034_2_03 (conv_i_src_c034_2_03 conv_i_c034_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_03 (conv_q_src_c034_2_03 0 conv_bpf_c034_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_2_03 (conv_q_src_c034_2_03 conv_q_c034_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_04 (conv_i_src_c034_2_04 0 conv_bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_2_04 (conv_i_src_c034_2_04 conv_i_c034_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_04 (conv_q_src_c034_2_04 0 conv_bpf_c034_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_2_04 (conv_q_src_c034_2_04 conv_q_c034_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_05 (conv_i_src_c034_2_05 0 conv_bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_2_05 (conv_i_src_c034_2_05 conv_i_c034_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_05 (conv_q_src_c034_2_05 0 conv_bpf_c034_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_2_05 (conv_q_src_c034_2_05 conv_q_c034_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_06 (conv_i_src_c034_2_06 0 conv_bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_2_06 (conv_i_src_c034_2_06 conv_i_c034_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_06 (conv_q_src_c034_2_06 0 conv_bpf_c034_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_2_06 (conv_q_src_c034_2_06 conv_q_c034_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_07 (conv_i_src_c034_2_07 0 conv_bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_2_07 (conv_i_src_c034_2_07 conv_i_c034_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_07 (conv_q_src_c034_2_07 0 conv_bpf_c034_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_2_07 (conv_q_src_c034_2_07 conv_q_c034_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_08 (conv_i_src_c034_2_08 0 conv_bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_2_08 (conv_i_src_c034_2_08 conv_i_c034_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_08 (conv_q_src_c034_2_08 0 conv_bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_2_08 (conv_q_src_c034_2_08 conv_q_c034_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_09 (conv_i_src_c034_2_09 0 conv_bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_2_09 (conv_i_src_c034_2_09 conv_i_c034_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_09 (conv_q_src_c034_2_09 0 conv_bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_2_09 (conv_q_src_c034_2_09 conv_q_c034_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_10 (conv_i_src_c034_2_10 0 conv_bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_2_10 (conv_i_src_c034_2_10 conv_i_c034_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_10 (conv_q_src_c034_2_10 0 conv_bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_2_10 (conv_q_src_c034_2_10 conv_q_c034_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_11 (conv_i_src_c034_2_11 0 conv_bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_2_11 (conv_i_src_c034_2_11 conv_i_c034_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_11 (conv_q_src_c034_2_11 0 conv_bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_2_11 (conv_q_src_c034_2_11 conv_q_c034_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_12 (conv_i_src_c034_2_12 0 conv_bpf_c034_2 0) vcvs gain=1.950903220161e-01
SCONVI_c034_2_12 (conv_i_src_c034_2_12 conv_i_c034_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_12 (conv_q_src_c034_2_12 0 conv_bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_2_12 (conv_q_src_c034_2_12 conv_q_c034_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_13 (conv_i_src_c034_2_13 0 conv_bpf_c034_2 0) vcvs gain=5.555702330196e-01
SCONVI_c034_2_13 (conv_i_src_c034_2_13 conv_i_c034_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_13 (conv_q_src_c034_2_13 0 conv_bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_2_13 (conv_q_src_c034_2_13 conv_q_c034_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_14 (conv_i_src_c034_2_14 0 conv_bpf_c034_2 0) vcvs gain=8.314696123025e-01
SCONVI_c034_2_14 (conv_i_src_c034_2_14 conv_i_c034_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_14 (conv_q_src_c034_2_14 0 conv_bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_2_14 (conv_q_src_c034_2_14 conv_q_c034_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_2_15 (conv_i_src_c034_2_15 0 conv_bpf_c034_2 0) vcvs gain=9.807852804032e-01
SCONVI_c034_2_15 (conv_i_src_c034_2_15 conv_i_c034_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_2_15 (conv_q_src_c034_2_15 0 conv_bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_2_15 (conv_q_src_c034_2_15 conv_q_c034_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c034_2 (conv_i_c034_2 0) resistor r=1G
RCONVQ_c034_2 (conv_q_c034_2 0) resistor r=1G
RCONVINTI_c034_2 (conv_i_c034_2 ConvIcar_c034_2) resistor r=1k
CCONVINTI_c034_2 (ConvIcar_c034_2 0) capacitor c=80p
RCONVINTQ_c034_2 (conv_q_c034_2 ConvQcar_c034_2) resistor r=1k
CCONVINTQ_c034_2 (ConvQcar_c034_2 0) capacitor c=80p
save conv_bpf_c034_2 ConvIcar_c034_2 ConvQcar_c034_2

// conventional mixed baseline bl034, carrier_3: 1000000000 Hz
CCONVBPF_c034_3 (bl034 n_conv_cbpf_c034_3) capacitor c=2.533029591058e-14
LCONVBPF_c034_3 (n_conv_cbpf_c034_3 conv_bpf_c034_3) inductor l=1.000000000000e-06
RCONVBPF_c034_3 (conv_bpf_c034_3 0) resistor r=3.141592653590e+02
ECONVI_c034_3_00 (conv_i_src_c034_3_00 0 conv_bpf_c034_3 0) vcvs gain=9.807852804032e-01
SCONVI_c034_3_00 (conv_i_src_c034_3_00 conv_i_c034_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_00 (conv_q_src_c034_3_00 0 conv_bpf_c034_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_3_00 (conv_q_src_c034_3_00 conv_q_c034_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_01 (conv_i_src_c034_3_01 0 conv_bpf_c034_3 0) vcvs gain=8.314696123025e-01
SCONVI_c034_3_01 (conv_i_src_c034_3_01 conv_i_c034_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_01 (conv_q_src_c034_3_01 0 conv_bpf_c034_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_3_01 (conv_q_src_c034_3_01 conv_q_c034_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_02 (conv_i_src_c034_3_02 0 conv_bpf_c034_3 0) vcvs gain=5.555702330196e-01
SCONVI_c034_3_02 (conv_i_src_c034_3_02 conv_i_c034_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_02 (conv_q_src_c034_3_02 0 conv_bpf_c034_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_3_02 (conv_q_src_c034_3_02 conv_q_c034_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_03 (conv_i_src_c034_3_03 0 conv_bpf_c034_3 0) vcvs gain=1.950903220161e-01
SCONVI_c034_3_03 (conv_i_src_c034_3_03 conv_i_c034_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_03 (conv_q_src_c034_3_03 0 conv_bpf_c034_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_3_03 (conv_q_src_c034_3_03 conv_q_c034_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_04 (conv_i_src_c034_3_04 0 conv_bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_3_04 (conv_i_src_c034_3_04 conv_i_c034_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_04 (conv_q_src_c034_3_04 0 conv_bpf_c034_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c034_3_04 (conv_q_src_c034_3_04 conv_q_c034_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_05 (conv_i_src_c034_3_05 0 conv_bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_3_05 (conv_i_src_c034_3_05 conv_i_c034_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_05 (conv_q_src_c034_3_05 0 conv_bpf_c034_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c034_3_05 (conv_q_src_c034_3_05 conv_q_c034_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_06 (conv_i_src_c034_3_06 0 conv_bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_3_06 (conv_i_src_c034_3_06 conv_i_c034_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_06 (conv_q_src_c034_3_06 0 conv_bpf_c034_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c034_3_06 (conv_q_src_c034_3_06 conv_q_c034_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_07 (conv_i_src_c034_3_07 0 conv_bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_3_07 (conv_i_src_c034_3_07 conv_i_c034_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_07 (conv_q_src_c034_3_07 0 conv_bpf_c034_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c034_3_07 (conv_q_src_c034_3_07 conv_q_c034_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_08 (conv_i_src_c034_3_08 0 conv_bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c034_3_08 (conv_i_src_c034_3_08 conv_i_c034_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_08 (conv_q_src_c034_3_08 0 conv_bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_3_08 (conv_q_src_c034_3_08 conv_q_c034_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_09 (conv_i_src_c034_3_09 0 conv_bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c034_3_09 (conv_i_src_c034_3_09 conv_i_c034_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_09 (conv_q_src_c034_3_09 0 conv_bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_3_09 (conv_q_src_c034_3_09 conv_q_c034_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_10 (conv_i_src_c034_3_10 0 conv_bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c034_3_10 (conv_i_src_c034_3_10 conv_i_c034_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_10 (conv_q_src_c034_3_10 0 conv_bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_3_10 (conv_q_src_c034_3_10 conv_q_c034_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_11 (conv_i_src_c034_3_11 0 conv_bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c034_3_11 (conv_i_src_c034_3_11 conv_i_c034_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_11 (conv_q_src_c034_3_11 0 conv_bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_3_11 (conv_q_src_c034_3_11 conv_q_c034_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_12 (conv_i_src_c034_3_12 0 conv_bpf_c034_3 0) vcvs gain=1.950903220161e-01
SCONVI_c034_3_12 (conv_i_src_c034_3_12 conv_i_c034_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_12 (conv_q_src_c034_3_12 0 conv_bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c034_3_12 (conv_q_src_c034_3_12 conv_q_c034_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_13 (conv_i_src_c034_3_13 0 conv_bpf_c034_3 0) vcvs gain=5.555702330196e-01
SCONVI_c034_3_13 (conv_i_src_c034_3_13 conv_i_c034_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_13 (conv_q_src_c034_3_13 0 conv_bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c034_3_13 (conv_q_src_c034_3_13 conv_q_c034_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_14 (conv_i_src_c034_3_14 0 conv_bpf_c034_3 0) vcvs gain=8.314696123025e-01
SCONVI_c034_3_14 (conv_i_src_c034_3_14 conv_i_c034_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_14 (conv_q_src_c034_3_14 0 conv_bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c034_3_14 (conv_q_src_c034_3_14 conv_q_c034_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c034_3_15 (conv_i_src_c034_3_15 0 conv_bpf_c034_3 0) vcvs gain=9.807852804032e-01
SCONVI_c034_3_15 (conv_i_src_c034_3_15 conv_i_c034_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c034_3_15 (conv_q_src_c034_3_15 0 conv_bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c034_3_15 (conv_q_src_c034_3_15 conv_q_c034_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c034_3 (conv_i_c034_3 0) resistor r=1G
RCONVQ_c034_3 (conv_q_c034_3 0) resistor r=1G
RCONVINTI_c034_3 (conv_i_c034_3 ConvIcar_c034_3) resistor r=1k
CCONVINTI_c034_3 (ConvIcar_c034_3 0) capacitor c=80p
RCONVINTQ_c034_3 (conv_q_c034_3 ConvQcar_c034_3) resistor r=1k
CCONVINTQ_c034_3 (ConvQcar_c034_3 0) capacitor c=80p
save conv_bpf_c034_3 ConvIcar_c034_3 ConvQcar_c034_3

// conventional mixed baseline bl035, carrier_0: 250000000 Hz
CCONVBPF_c035_0 (bl035 n_conv_cbpf_c035_0) capacitor c=4.052847345694e-13
LCONVBPF_c035_0 (n_conv_cbpf_c035_0 conv_bpf_c035_0) inductor l=1.000000000000e-06
RCONVBPF_c035_0 (conv_bpf_c035_0 0) resistor r=7.853981633974e+01
ECONVI_c035_0_00 (conv_i_src_c035_0_00 0 conv_bpf_c035_0 0) vcvs gain=9.807852804032e-01
SCONVI_c035_0_00 (conv_i_src_c035_0_00 conv_i_c035_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_00 (conv_q_src_c035_0_00 0 conv_bpf_c035_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_0_00 (conv_q_src_c035_0_00 conv_q_c035_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_01 (conv_i_src_c035_0_01 0 conv_bpf_c035_0 0) vcvs gain=8.314696123025e-01
SCONVI_c035_0_01 (conv_i_src_c035_0_01 conv_i_c035_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_01 (conv_q_src_c035_0_01 0 conv_bpf_c035_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_0_01 (conv_q_src_c035_0_01 conv_q_c035_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_02 (conv_i_src_c035_0_02 0 conv_bpf_c035_0 0) vcvs gain=5.555702330196e-01
SCONVI_c035_0_02 (conv_i_src_c035_0_02 conv_i_c035_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_02 (conv_q_src_c035_0_02 0 conv_bpf_c035_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_0_02 (conv_q_src_c035_0_02 conv_q_c035_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_03 (conv_i_src_c035_0_03 0 conv_bpf_c035_0 0) vcvs gain=1.950903220161e-01
SCONVI_c035_0_03 (conv_i_src_c035_0_03 conv_i_c035_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_03 (conv_q_src_c035_0_03 0 conv_bpf_c035_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_0_03 (conv_q_src_c035_0_03 conv_q_c035_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_04 (conv_i_src_c035_0_04 0 conv_bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_0_04 (conv_i_src_c035_0_04 conv_i_c035_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_04 (conv_q_src_c035_0_04 0 conv_bpf_c035_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_0_04 (conv_q_src_c035_0_04 conv_q_c035_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_05 (conv_i_src_c035_0_05 0 conv_bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_0_05 (conv_i_src_c035_0_05 conv_i_c035_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_05 (conv_q_src_c035_0_05 0 conv_bpf_c035_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_0_05 (conv_q_src_c035_0_05 conv_q_c035_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_06 (conv_i_src_c035_0_06 0 conv_bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_0_06 (conv_i_src_c035_0_06 conv_i_c035_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_06 (conv_q_src_c035_0_06 0 conv_bpf_c035_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_0_06 (conv_q_src_c035_0_06 conv_q_c035_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_07 (conv_i_src_c035_0_07 0 conv_bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_0_07 (conv_i_src_c035_0_07 conv_i_c035_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_07 (conv_q_src_c035_0_07 0 conv_bpf_c035_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_0_07 (conv_q_src_c035_0_07 conv_q_c035_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_08 (conv_i_src_c035_0_08 0 conv_bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_0_08 (conv_i_src_c035_0_08 conv_i_c035_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_08 (conv_q_src_c035_0_08 0 conv_bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_0_08 (conv_q_src_c035_0_08 conv_q_c035_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_09 (conv_i_src_c035_0_09 0 conv_bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_0_09 (conv_i_src_c035_0_09 conv_i_c035_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_09 (conv_q_src_c035_0_09 0 conv_bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_0_09 (conv_q_src_c035_0_09 conv_q_c035_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_10 (conv_i_src_c035_0_10 0 conv_bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_0_10 (conv_i_src_c035_0_10 conv_i_c035_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_10 (conv_q_src_c035_0_10 0 conv_bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_0_10 (conv_q_src_c035_0_10 conv_q_c035_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_11 (conv_i_src_c035_0_11 0 conv_bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_0_11 (conv_i_src_c035_0_11 conv_i_c035_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_11 (conv_q_src_c035_0_11 0 conv_bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_0_11 (conv_q_src_c035_0_11 conv_q_c035_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_12 (conv_i_src_c035_0_12 0 conv_bpf_c035_0 0) vcvs gain=1.950903220161e-01
SCONVI_c035_0_12 (conv_i_src_c035_0_12 conv_i_c035_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_12 (conv_q_src_c035_0_12 0 conv_bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_0_12 (conv_q_src_c035_0_12 conv_q_c035_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_13 (conv_i_src_c035_0_13 0 conv_bpf_c035_0 0) vcvs gain=5.555702330196e-01
SCONVI_c035_0_13 (conv_i_src_c035_0_13 conv_i_c035_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_13 (conv_q_src_c035_0_13 0 conv_bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_0_13 (conv_q_src_c035_0_13 conv_q_c035_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_14 (conv_i_src_c035_0_14 0 conv_bpf_c035_0 0) vcvs gain=8.314696123025e-01
SCONVI_c035_0_14 (conv_i_src_c035_0_14 conv_i_c035_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_14 (conv_q_src_c035_0_14 0 conv_bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_0_14 (conv_q_src_c035_0_14 conv_q_c035_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_0_15 (conv_i_src_c035_0_15 0 conv_bpf_c035_0 0) vcvs gain=9.807852804032e-01
SCONVI_c035_0_15 (conv_i_src_c035_0_15 conv_i_c035_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_0_15 (conv_q_src_c035_0_15 0 conv_bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_0_15 (conv_q_src_c035_0_15 conv_q_c035_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c035_0 (conv_i_c035_0 0) resistor r=1G
RCONVQ_c035_0 (conv_q_c035_0 0) resistor r=1G
RCONVINTI_c035_0 (conv_i_c035_0 ConvIcar_c035_0) resistor r=1k
CCONVINTI_c035_0 (ConvIcar_c035_0 0) capacitor c=80p
RCONVINTQ_c035_0 (conv_q_c035_0 ConvQcar_c035_0) resistor r=1k
CCONVINTQ_c035_0 (ConvQcar_c035_0 0) capacitor c=80p
save conv_bpf_c035_0 ConvIcar_c035_0 ConvQcar_c035_0

// conventional mixed baseline bl035, carrier_1: 500000000 Hz
CCONVBPF_c035_1 (bl035 n_conv_cbpf_c035_1) capacitor c=1.013211836423e-13
LCONVBPF_c035_1 (n_conv_cbpf_c035_1 conv_bpf_c035_1) inductor l=1.000000000000e-06
RCONVBPF_c035_1 (conv_bpf_c035_1 0) resistor r=1.570796326795e+02
ECONVI_c035_1_00 (conv_i_src_c035_1_00 0 conv_bpf_c035_1 0) vcvs gain=9.807852804032e-01
SCONVI_c035_1_00 (conv_i_src_c035_1_00 conv_i_c035_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_00 (conv_q_src_c035_1_00 0 conv_bpf_c035_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_1_00 (conv_q_src_c035_1_00 conv_q_c035_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_01 (conv_i_src_c035_1_01 0 conv_bpf_c035_1 0) vcvs gain=8.314696123025e-01
SCONVI_c035_1_01 (conv_i_src_c035_1_01 conv_i_c035_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_01 (conv_q_src_c035_1_01 0 conv_bpf_c035_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_1_01 (conv_q_src_c035_1_01 conv_q_c035_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_02 (conv_i_src_c035_1_02 0 conv_bpf_c035_1 0) vcvs gain=5.555702330196e-01
SCONVI_c035_1_02 (conv_i_src_c035_1_02 conv_i_c035_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_02 (conv_q_src_c035_1_02 0 conv_bpf_c035_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_1_02 (conv_q_src_c035_1_02 conv_q_c035_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_03 (conv_i_src_c035_1_03 0 conv_bpf_c035_1 0) vcvs gain=1.950903220161e-01
SCONVI_c035_1_03 (conv_i_src_c035_1_03 conv_i_c035_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_03 (conv_q_src_c035_1_03 0 conv_bpf_c035_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_1_03 (conv_q_src_c035_1_03 conv_q_c035_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_04 (conv_i_src_c035_1_04 0 conv_bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_1_04 (conv_i_src_c035_1_04 conv_i_c035_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_04 (conv_q_src_c035_1_04 0 conv_bpf_c035_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_1_04 (conv_q_src_c035_1_04 conv_q_c035_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_05 (conv_i_src_c035_1_05 0 conv_bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_1_05 (conv_i_src_c035_1_05 conv_i_c035_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_05 (conv_q_src_c035_1_05 0 conv_bpf_c035_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_1_05 (conv_q_src_c035_1_05 conv_q_c035_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_06 (conv_i_src_c035_1_06 0 conv_bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_1_06 (conv_i_src_c035_1_06 conv_i_c035_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_06 (conv_q_src_c035_1_06 0 conv_bpf_c035_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_1_06 (conv_q_src_c035_1_06 conv_q_c035_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_07 (conv_i_src_c035_1_07 0 conv_bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_1_07 (conv_i_src_c035_1_07 conv_i_c035_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_07 (conv_q_src_c035_1_07 0 conv_bpf_c035_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_1_07 (conv_q_src_c035_1_07 conv_q_c035_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_08 (conv_i_src_c035_1_08 0 conv_bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_1_08 (conv_i_src_c035_1_08 conv_i_c035_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_08 (conv_q_src_c035_1_08 0 conv_bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_1_08 (conv_q_src_c035_1_08 conv_q_c035_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_09 (conv_i_src_c035_1_09 0 conv_bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_1_09 (conv_i_src_c035_1_09 conv_i_c035_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_09 (conv_q_src_c035_1_09 0 conv_bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_1_09 (conv_q_src_c035_1_09 conv_q_c035_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_10 (conv_i_src_c035_1_10 0 conv_bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_1_10 (conv_i_src_c035_1_10 conv_i_c035_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_10 (conv_q_src_c035_1_10 0 conv_bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_1_10 (conv_q_src_c035_1_10 conv_q_c035_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_11 (conv_i_src_c035_1_11 0 conv_bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_1_11 (conv_i_src_c035_1_11 conv_i_c035_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_11 (conv_q_src_c035_1_11 0 conv_bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_1_11 (conv_q_src_c035_1_11 conv_q_c035_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_12 (conv_i_src_c035_1_12 0 conv_bpf_c035_1 0) vcvs gain=1.950903220161e-01
SCONVI_c035_1_12 (conv_i_src_c035_1_12 conv_i_c035_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_12 (conv_q_src_c035_1_12 0 conv_bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_1_12 (conv_q_src_c035_1_12 conv_q_c035_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_13 (conv_i_src_c035_1_13 0 conv_bpf_c035_1 0) vcvs gain=5.555702330196e-01
SCONVI_c035_1_13 (conv_i_src_c035_1_13 conv_i_c035_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_13 (conv_q_src_c035_1_13 0 conv_bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_1_13 (conv_q_src_c035_1_13 conv_q_c035_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_14 (conv_i_src_c035_1_14 0 conv_bpf_c035_1 0) vcvs gain=8.314696123025e-01
SCONVI_c035_1_14 (conv_i_src_c035_1_14 conv_i_c035_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_14 (conv_q_src_c035_1_14 0 conv_bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_1_14 (conv_q_src_c035_1_14 conv_q_c035_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_1_15 (conv_i_src_c035_1_15 0 conv_bpf_c035_1 0) vcvs gain=9.807852804032e-01
SCONVI_c035_1_15 (conv_i_src_c035_1_15 conv_i_c035_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_1_15 (conv_q_src_c035_1_15 0 conv_bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_1_15 (conv_q_src_c035_1_15 conv_q_c035_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c035_1 (conv_i_c035_1 0) resistor r=1G
RCONVQ_c035_1 (conv_q_c035_1 0) resistor r=1G
RCONVINTI_c035_1 (conv_i_c035_1 ConvIcar_c035_1) resistor r=1k
CCONVINTI_c035_1 (ConvIcar_c035_1 0) capacitor c=80p
RCONVINTQ_c035_1 (conv_q_c035_1 ConvQcar_c035_1) resistor r=1k
CCONVINTQ_c035_1 (ConvQcar_c035_1 0) capacitor c=80p
save conv_bpf_c035_1 ConvIcar_c035_1 ConvQcar_c035_1

// conventional mixed baseline bl035, carrier_2: 750000000 Hz
CCONVBPF_c035_2 (bl035 n_conv_cbpf_c035_2) capacitor c=4.503163717437e-14
LCONVBPF_c035_2 (n_conv_cbpf_c035_2 conv_bpf_c035_2) inductor l=1.000000000000e-06
RCONVBPF_c035_2 (conv_bpf_c035_2 0) resistor r=2.356194490192e+02
ECONVI_c035_2_00 (conv_i_src_c035_2_00 0 conv_bpf_c035_2 0) vcvs gain=9.807852804032e-01
SCONVI_c035_2_00 (conv_i_src_c035_2_00 conv_i_c035_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_00 (conv_q_src_c035_2_00 0 conv_bpf_c035_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_2_00 (conv_q_src_c035_2_00 conv_q_c035_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_01 (conv_i_src_c035_2_01 0 conv_bpf_c035_2 0) vcvs gain=8.314696123025e-01
SCONVI_c035_2_01 (conv_i_src_c035_2_01 conv_i_c035_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_01 (conv_q_src_c035_2_01 0 conv_bpf_c035_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_2_01 (conv_q_src_c035_2_01 conv_q_c035_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_02 (conv_i_src_c035_2_02 0 conv_bpf_c035_2 0) vcvs gain=5.555702330196e-01
SCONVI_c035_2_02 (conv_i_src_c035_2_02 conv_i_c035_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_02 (conv_q_src_c035_2_02 0 conv_bpf_c035_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_2_02 (conv_q_src_c035_2_02 conv_q_c035_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_03 (conv_i_src_c035_2_03 0 conv_bpf_c035_2 0) vcvs gain=1.950903220161e-01
SCONVI_c035_2_03 (conv_i_src_c035_2_03 conv_i_c035_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_03 (conv_q_src_c035_2_03 0 conv_bpf_c035_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_2_03 (conv_q_src_c035_2_03 conv_q_c035_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_04 (conv_i_src_c035_2_04 0 conv_bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_2_04 (conv_i_src_c035_2_04 conv_i_c035_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_04 (conv_q_src_c035_2_04 0 conv_bpf_c035_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_2_04 (conv_q_src_c035_2_04 conv_q_c035_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_05 (conv_i_src_c035_2_05 0 conv_bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_2_05 (conv_i_src_c035_2_05 conv_i_c035_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_05 (conv_q_src_c035_2_05 0 conv_bpf_c035_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_2_05 (conv_q_src_c035_2_05 conv_q_c035_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_06 (conv_i_src_c035_2_06 0 conv_bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_2_06 (conv_i_src_c035_2_06 conv_i_c035_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_06 (conv_q_src_c035_2_06 0 conv_bpf_c035_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_2_06 (conv_q_src_c035_2_06 conv_q_c035_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_07 (conv_i_src_c035_2_07 0 conv_bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_2_07 (conv_i_src_c035_2_07 conv_i_c035_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_07 (conv_q_src_c035_2_07 0 conv_bpf_c035_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_2_07 (conv_q_src_c035_2_07 conv_q_c035_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_08 (conv_i_src_c035_2_08 0 conv_bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_2_08 (conv_i_src_c035_2_08 conv_i_c035_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_08 (conv_q_src_c035_2_08 0 conv_bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_2_08 (conv_q_src_c035_2_08 conv_q_c035_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_09 (conv_i_src_c035_2_09 0 conv_bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_2_09 (conv_i_src_c035_2_09 conv_i_c035_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_09 (conv_q_src_c035_2_09 0 conv_bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_2_09 (conv_q_src_c035_2_09 conv_q_c035_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_10 (conv_i_src_c035_2_10 0 conv_bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_2_10 (conv_i_src_c035_2_10 conv_i_c035_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_10 (conv_q_src_c035_2_10 0 conv_bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_2_10 (conv_q_src_c035_2_10 conv_q_c035_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_11 (conv_i_src_c035_2_11 0 conv_bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_2_11 (conv_i_src_c035_2_11 conv_i_c035_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_11 (conv_q_src_c035_2_11 0 conv_bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_2_11 (conv_q_src_c035_2_11 conv_q_c035_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_12 (conv_i_src_c035_2_12 0 conv_bpf_c035_2 0) vcvs gain=1.950903220161e-01
SCONVI_c035_2_12 (conv_i_src_c035_2_12 conv_i_c035_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_12 (conv_q_src_c035_2_12 0 conv_bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_2_12 (conv_q_src_c035_2_12 conv_q_c035_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_13 (conv_i_src_c035_2_13 0 conv_bpf_c035_2 0) vcvs gain=5.555702330196e-01
SCONVI_c035_2_13 (conv_i_src_c035_2_13 conv_i_c035_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_13 (conv_q_src_c035_2_13 0 conv_bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_2_13 (conv_q_src_c035_2_13 conv_q_c035_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_14 (conv_i_src_c035_2_14 0 conv_bpf_c035_2 0) vcvs gain=8.314696123025e-01
SCONVI_c035_2_14 (conv_i_src_c035_2_14 conv_i_c035_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_14 (conv_q_src_c035_2_14 0 conv_bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_2_14 (conv_q_src_c035_2_14 conv_q_c035_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_2_15 (conv_i_src_c035_2_15 0 conv_bpf_c035_2 0) vcvs gain=9.807852804032e-01
SCONVI_c035_2_15 (conv_i_src_c035_2_15 conv_i_c035_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_2_15 (conv_q_src_c035_2_15 0 conv_bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_2_15 (conv_q_src_c035_2_15 conv_q_c035_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c035_2 (conv_i_c035_2 0) resistor r=1G
RCONVQ_c035_2 (conv_q_c035_2 0) resistor r=1G
RCONVINTI_c035_2 (conv_i_c035_2 ConvIcar_c035_2) resistor r=1k
CCONVINTI_c035_2 (ConvIcar_c035_2 0) capacitor c=80p
RCONVINTQ_c035_2 (conv_q_c035_2 ConvQcar_c035_2) resistor r=1k
CCONVINTQ_c035_2 (ConvQcar_c035_2 0) capacitor c=80p
save conv_bpf_c035_2 ConvIcar_c035_2 ConvQcar_c035_2

// conventional mixed baseline bl035, carrier_3: 1000000000 Hz
CCONVBPF_c035_3 (bl035 n_conv_cbpf_c035_3) capacitor c=2.533029591058e-14
LCONVBPF_c035_3 (n_conv_cbpf_c035_3 conv_bpf_c035_3) inductor l=1.000000000000e-06
RCONVBPF_c035_3 (conv_bpf_c035_3 0) resistor r=3.141592653590e+02
ECONVI_c035_3_00 (conv_i_src_c035_3_00 0 conv_bpf_c035_3 0) vcvs gain=9.807852804032e-01
SCONVI_c035_3_00 (conv_i_src_c035_3_00 conv_i_c035_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_00 (conv_q_src_c035_3_00 0 conv_bpf_c035_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_3_00 (conv_q_src_c035_3_00 conv_q_c035_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_01 (conv_i_src_c035_3_01 0 conv_bpf_c035_3 0) vcvs gain=8.314696123025e-01
SCONVI_c035_3_01 (conv_i_src_c035_3_01 conv_i_c035_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_01 (conv_q_src_c035_3_01 0 conv_bpf_c035_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_3_01 (conv_q_src_c035_3_01 conv_q_c035_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_02 (conv_i_src_c035_3_02 0 conv_bpf_c035_3 0) vcvs gain=5.555702330196e-01
SCONVI_c035_3_02 (conv_i_src_c035_3_02 conv_i_c035_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_02 (conv_q_src_c035_3_02 0 conv_bpf_c035_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_3_02 (conv_q_src_c035_3_02 conv_q_c035_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_03 (conv_i_src_c035_3_03 0 conv_bpf_c035_3 0) vcvs gain=1.950903220161e-01
SCONVI_c035_3_03 (conv_i_src_c035_3_03 conv_i_c035_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_03 (conv_q_src_c035_3_03 0 conv_bpf_c035_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_3_03 (conv_q_src_c035_3_03 conv_q_c035_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_04 (conv_i_src_c035_3_04 0 conv_bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_3_04 (conv_i_src_c035_3_04 conv_i_c035_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_04 (conv_q_src_c035_3_04 0 conv_bpf_c035_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c035_3_04 (conv_q_src_c035_3_04 conv_q_c035_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_05 (conv_i_src_c035_3_05 0 conv_bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_3_05 (conv_i_src_c035_3_05 conv_i_c035_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_05 (conv_q_src_c035_3_05 0 conv_bpf_c035_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c035_3_05 (conv_q_src_c035_3_05 conv_q_c035_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_06 (conv_i_src_c035_3_06 0 conv_bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_3_06 (conv_i_src_c035_3_06 conv_i_c035_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_06 (conv_q_src_c035_3_06 0 conv_bpf_c035_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c035_3_06 (conv_q_src_c035_3_06 conv_q_c035_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_07 (conv_i_src_c035_3_07 0 conv_bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_3_07 (conv_i_src_c035_3_07 conv_i_c035_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_07 (conv_q_src_c035_3_07 0 conv_bpf_c035_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c035_3_07 (conv_q_src_c035_3_07 conv_q_c035_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_08 (conv_i_src_c035_3_08 0 conv_bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c035_3_08 (conv_i_src_c035_3_08 conv_i_c035_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_08 (conv_q_src_c035_3_08 0 conv_bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_3_08 (conv_q_src_c035_3_08 conv_q_c035_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_09 (conv_i_src_c035_3_09 0 conv_bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c035_3_09 (conv_i_src_c035_3_09 conv_i_c035_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_09 (conv_q_src_c035_3_09 0 conv_bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_3_09 (conv_q_src_c035_3_09 conv_q_c035_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_10 (conv_i_src_c035_3_10 0 conv_bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c035_3_10 (conv_i_src_c035_3_10 conv_i_c035_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_10 (conv_q_src_c035_3_10 0 conv_bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_3_10 (conv_q_src_c035_3_10 conv_q_c035_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_11 (conv_i_src_c035_3_11 0 conv_bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c035_3_11 (conv_i_src_c035_3_11 conv_i_c035_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_11 (conv_q_src_c035_3_11 0 conv_bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_3_11 (conv_q_src_c035_3_11 conv_q_c035_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_12 (conv_i_src_c035_3_12 0 conv_bpf_c035_3 0) vcvs gain=1.950903220161e-01
SCONVI_c035_3_12 (conv_i_src_c035_3_12 conv_i_c035_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_12 (conv_q_src_c035_3_12 0 conv_bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c035_3_12 (conv_q_src_c035_3_12 conv_q_c035_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_13 (conv_i_src_c035_3_13 0 conv_bpf_c035_3 0) vcvs gain=5.555702330196e-01
SCONVI_c035_3_13 (conv_i_src_c035_3_13 conv_i_c035_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_13 (conv_q_src_c035_3_13 0 conv_bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c035_3_13 (conv_q_src_c035_3_13 conv_q_c035_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_14 (conv_i_src_c035_3_14 0 conv_bpf_c035_3 0) vcvs gain=8.314696123025e-01
SCONVI_c035_3_14 (conv_i_src_c035_3_14 conv_i_c035_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_14 (conv_q_src_c035_3_14 0 conv_bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c035_3_14 (conv_q_src_c035_3_14 conv_q_c035_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c035_3_15 (conv_i_src_c035_3_15 0 conv_bpf_c035_3 0) vcvs gain=9.807852804032e-01
SCONVI_c035_3_15 (conv_i_src_c035_3_15 conv_i_c035_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c035_3_15 (conv_q_src_c035_3_15 0 conv_bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c035_3_15 (conv_q_src_c035_3_15 conv_q_c035_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c035_3 (conv_i_c035_3 0) resistor r=1G
RCONVQ_c035_3 (conv_q_c035_3 0) resistor r=1G
RCONVINTI_c035_3 (conv_i_c035_3 ConvIcar_c035_3) resistor r=1k
CCONVINTI_c035_3 (ConvIcar_c035_3 0) capacitor c=80p
RCONVINTQ_c035_3 (conv_q_c035_3 ConvQcar_c035_3) resistor r=1k
CCONVINTQ_c035_3 (ConvQcar_c035_3 0) capacitor c=80p
save conv_bpf_c035_3 ConvIcar_c035_3 ConvQcar_c035_3

// conventional mixed baseline bl036, carrier_0: 250000000 Hz
CCONVBPF_c036_0 (bl036 n_conv_cbpf_c036_0) capacitor c=4.052847345694e-13
LCONVBPF_c036_0 (n_conv_cbpf_c036_0 conv_bpf_c036_0) inductor l=1.000000000000e-06
RCONVBPF_c036_0 (conv_bpf_c036_0 0) resistor r=7.853981633974e+01
ECONVI_c036_0_00 (conv_i_src_c036_0_00 0 conv_bpf_c036_0 0) vcvs gain=9.807852804032e-01
SCONVI_c036_0_00 (conv_i_src_c036_0_00 conv_i_c036_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_00 (conv_q_src_c036_0_00 0 conv_bpf_c036_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_0_00 (conv_q_src_c036_0_00 conv_q_c036_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_01 (conv_i_src_c036_0_01 0 conv_bpf_c036_0 0) vcvs gain=8.314696123025e-01
SCONVI_c036_0_01 (conv_i_src_c036_0_01 conv_i_c036_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_01 (conv_q_src_c036_0_01 0 conv_bpf_c036_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_0_01 (conv_q_src_c036_0_01 conv_q_c036_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_02 (conv_i_src_c036_0_02 0 conv_bpf_c036_0 0) vcvs gain=5.555702330196e-01
SCONVI_c036_0_02 (conv_i_src_c036_0_02 conv_i_c036_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_02 (conv_q_src_c036_0_02 0 conv_bpf_c036_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_0_02 (conv_q_src_c036_0_02 conv_q_c036_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_03 (conv_i_src_c036_0_03 0 conv_bpf_c036_0 0) vcvs gain=1.950903220161e-01
SCONVI_c036_0_03 (conv_i_src_c036_0_03 conv_i_c036_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_03 (conv_q_src_c036_0_03 0 conv_bpf_c036_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_0_03 (conv_q_src_c036_0_03 conv_q_c036_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_04 (conv_i_src_c036_0_04 0 conv_bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_0_04 (conv_i_src_c036_0_04 conv_i_c036_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_04 (conv_q_src_c036_0_04 0 conv_bpf_c036_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_0_04 (conv_q_src_c036_0_04 conv_q_c036_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_05 (conv_i_src_c036_0_05 0 conv_bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_0_05 (conv_i_src_c036_0_05 conv_i_c036_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_05 (conv_q_src_c036_0_05 0 conv_bpf_c036_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_0_05 (conv_q_src_c036_0_05 conv_q_c036_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_06 (conv_i_src_c036_0_06 0 conv_bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_0_06 (conv_i_src_c036_0_06 conv_i_c036_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_06 (conv_q_src_c036_0_06 0 conv_bpf_c036_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_0_06 (conv_q_src_c036_0_06 conv_q_c036_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_07 (conv_i_src_c036_0_07 0 conv_bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_0_07 (conv_i_src_c036_0_07 conv_i_c036_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_07 (conv_q_src_c036_0_07 0 conv_bpf_c036_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_0_07 (conv_q_src_c036_0_07 conv_q_c036_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_08 (conv_i_src_c036_0_08 0 conv_bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_0_08 (conv_i_src_c036_0_08 conv_i_c036_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_08 (conv_q_src_c036_0_08 0 conv_bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_0_08 (conv_q_src_c036_0_08 conv_q_c036_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_09 (conv_i_src_c036_0_09 0 conv_bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_0_09 (conv_i_src_c036_0_09 conv_i_c036_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_09 (conv_q_src_c036_0_09 0 conv_bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_0_09 (conv_q_src_c036_0_09 conv_q_c036_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_10 (conv_i_src_c036_0_10 0 conv_bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_0_10 (conv_i_src_c036_0_10 conv_i_c036_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_10 (conv_q_src_c036_0_10 0 conv_bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_0_10 (conv_q_src_c036_0_10 conv_q_c036_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_11 (conv_i_src_c036_0_11 0 conv_bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_0_11 (conv_i_src_c036_0_11 conv_i_c036_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_11 (conv_q_src_c036_0_11 0 conv_bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_0_11 (conv_q_src_c036_0_11 conv_q_c036_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_12 (conv_i_src_c036_0_12 0 conv_bpf_c036_0 0) vcvs gain=1.950903220161e-01
SCONVI_c036_0_12 (conv_i_src_c036_0_12 conv_i_c036_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_12 (conv_q_src_c036_0_12 0 conv_bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_0_12 (conv_q_src_c036_0_12 conv_q_c036_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_13 (conv_i_src_c036_0_13 0 conv_bpf_c036_0 0) vcvs gain=5.555702330196e-01
SCONVI_c036_0_13 (conv_i_src_c036_0_13 conv_i_c036_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_13 (conv_q_src_c036_0_13 0 conv_bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_0_13 (conv_q_src_c036_0_13 conv_q_c036_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_14 (conv_i_src_c036_0_14 0 conv_bpf_c036_0 0) vcvs gain=8.314696123025e-01
SCONVI_c036_0_14 (conv_i_src_c036_0_14 conv_i_c036_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_14 (conv_q_src_c036_0_14 0 conv_bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_0_14 (conv_q_src_c036_0_14 conv_q_c036_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_0_15 (conv_i_src_c036_0_15 0 conv_bpf_c036_0 0) vcvs gain=9.807852804032e-01
SCONVI_c036_0_15 (conv_i_src_c036_0_15 conv_i_c036_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_0_15 (conv_q_src_c036_0_15 0 conv_bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_0_15 (conv_q_src_c036_0_15 conv_q_c036_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c036_0 (conv_i_c036_0 0) resistor r=1G
RCONVQ_c036_0 (conv_q_c036_0 0) resistor r=1G
RCONVINTI_c036_0 (conv_i_c036_0 ConvIcar_c036_0) resistor r=1k
CCONVINTI_c036_0 (ConvIcar_c036_0 0) capacitor c=80p
RCONVINTQ_c036_0 (conv_q_c036_0 ConvQcar_c036_0) resistor r=1k
CCONVINTQ_c036_0 (ConvQcar_c036_0 0) capacitor c=80p
save conv_bpf_c036_0 ConvIcar_c036_0 ConvQcar_c036_0

// conventional mixed baseline bl036, carrier_1: 500000000 Hz
CCONVBPF_c036_1 (bl036 n_conv_cbpf_c036_1) capacitor c=1.013211836423e-13
LCONVBPF_c036_1 (n_conv_cbpf_c036_1 conv_bpf_c036_1) inductor l=1.000000000000e-06
RCONVBPF_c036_1 (conv_bpf_c036_1 0) resistor r=1.570796326795e+02
ECONVI_c036_1_00 (conv_i_src_c036_1_00 0 conv_bpf_c036_1 0) vcvs gain=9.807852804032e-01
SCONVI_c036_1_00 (conv_i_src_c036_1_00 conv_i_c036_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_00 (conv_q_src_c036_1_00 0 conv_bpf_c036_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_1_00 (conv_q_src_c036_1_00 conv_q_c036_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_01 (conv_i_src_c036_1_01 0 conv_bpf_c036_1 0) vcvs gain=8.314696123025e-01
SCONVI_c036_1_01 (conv_i_src_c036_1_01 conv_i_c036_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_01 (conv_q_src_c036_1_01 0 conv_bpf_c036_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_1_01 (conv_q_src_c036_1_01 conv_q_c036_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_02 (conv_i_src_c036_1_02 0 conv_bpf_c036_1 0) vcvs gain=5.555702330196e-01
SCONVI_c036_1_02 (conv_i_src_c036_1_02 conv_i_c036_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_02 (conv_q_src_c036_1_02 0 conv_bpf_c036_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_1_02 (conv_q_src_c036_1_02 conv_q_c036_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_03 (conv_i_src_c036_1_03 0 conv_bpf_c036_1 0) vcvs gain=1.950903220161e-01
SCONVI_c036_1_03 (conv_i_src_c036_1_03 conv_i_c036_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_03 (conv_q_src_c036_1_03 0 conv_bpf_c036_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_1_03 (conv_q_src_c036_1_03 conv_q_c036_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_04 (conv_i_src_c036_1_04 0 conv_bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_1_04 (conv_i_src_c036_1_04 conv_i_c036_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_04 (conv_q_src_c036_1_04 0 conv_bpf_c036_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_1_04 (conv_q_src_c036_1_04 conv_q_c036_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_05 (conv_i_src_c036_1_05 0 conv_bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_1_05 (conv_i_src_c036_1_05 conv_i_c036_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_05 (conv_q_src_c036_1_05 0 conv_bpf_c036_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_1_05 (conv_q_src_c036_1_05 conv_q_c036_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_06 (conv_i_src_c036_1_06 0 conv_bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_1_06 (conv_i_src_c036_1_06 conv_i_c036_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_06 (conv_q_src_c036_1_06 0 conv_bpf_c036_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_1_06 (conv_q_src_c036_1_06 conv_q_c036_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_07 (conv_i_src_c036_1_07 0 conv_bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_1_07 (conv_i_src_c036_1_07 conv_i_c036_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_07 (conv_q_src_c036_1_07 0 conv_bpf_c036_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_1_07 (conv_q_src_c036_1_07 conv_q_c036_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_08 (conv_i_src_c036_1_08 0 conv_bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_1_08 (conv_i_src_c036_1_08 conv_i_c036_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_08 (conv_q_src_c036_1_08 0 conv_bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_1_08 (conv_q_src_c036_1_08 conv_q_c036_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_09 (conv_i_src_c036_1_09 0 conv_bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_1_09 (conv_i_src_c036_1_09 conv_i_c036_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_09 (conv_q_src_c036_1_09 0 conv_bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_1_09 (conv_q_src_c036_1_09 conv_q_c036_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_10 (conv_i_src_c036_1_10 0 conv_bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_1_10 (conv_i_src_c036_1_10 conv_i_c036_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_10 (conv_q_src_c036_1_10 0 conv_bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_1_10 (conv_q_src_c036_1_10 conv_q_c036_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_11 (conv_i_src_c036_1_11 0 conv_bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_1_11 (conv_i_src_c036_1_11 conv_i_c036_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_11 (conv_q_src_c036_1_11 0 conv_bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_1_11 (conv_q_src_c036_1_11 conv_q_c036_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_12 (conv_i_src_c036_1_12 0 conv_bpf_c036_1 0) vcvs gain=1.950903220161e-01
SCONVI_c036_1_12 (conv_i_src_c036_1_12 conv_i_c036_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_12 (conv_q_src_c036_1_12 0 conv_bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_1_12 (conv_q_src_c036_1_12 conv_q_c036_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_13 (conv_i_src_c036_1_13 0 conv_bpf_c036_1 0) vcvs gain=5.555702330196e-01
SCONVI_c036_1_13 (conv_i_src_c036_1_13 conv_i_c036_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_13 (conv_q_src_c036_1_13 0 conv_bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_1_13 (conv_q_src_c036_1_13 conv_q_c036_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_14 (conv_i_src_c036_1_14 0 conv_bpf_c036_1 0) vcvs gain=8.314696123025e-01
SCONVI_c036_1_14 (conv_i_src_c036_1_14 conv_i_c036_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_14 (conv_q_src_c036_1_14 0 conv_bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_1_14 (conv_q_src_c036_1_14 conv_q_c036_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_1_15 (conv_i_src_c036_1_15 0 conv_bpf_c036_1 0) vcvs gain=9.807852804032e-01
SCONVI_c036_1_15 (conv_i_src_c036_1_15 conv_i_c036_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_1_15 (conv_q_src_c036_1_15 0 conv_bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_1_15 (conv_q_src_c036_1_15 conv_q_c036_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c036_1 (conv_i_c036_1 0) resistor r=1G
RCONVQ_c036_1 (conv_q_c036_1 0) resistor r=1G
RCONVINTI_c036_1 (conv_i_c036_1 ConvIcar_c036_1) resistor r=1k
CCONVINTI_c036_1 (ConvIcar_c036_1 0) capacitor c=80p
RCONVINTQ_c036_1 (conv_q_c036_1 ConvQcar_c036_1) resistor r=1k
CCONVINTQ_c036_1 (ConvQcar_c036_1 0) capacitor c=80p
save conv_bpf_c036_1 ConvIcar_c036_1 ConvQcar_c036_1

// conventional mixed baseline bl036, carrier_2: 750000000 Hz
CCONVBPF_c036_2 (bl036 n_conv_cbpf_c036_2) capacitor c=4.503163717437e-14
LCONVBPF_c036_2 (n_conv_cbpf_c036_2 conv_bpf_c036_2) inductor l=1.000000000000e-06
RCONVBPF_c036_2 (conv_bpf_c036_2 0) resistor r=2.356194490192e+02
ECONVI_c036_2_00 (conv_i_src_c036_2_00 0 conv_bpf_c036_2 0) vcvs gain=9.807852804032e-01
SCONVI_c036_2_00 (conv_i_src_c036_2_00 conv_i_c036_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_00 (conv_q_src_c036_2_00 0 conv_bpf_c036_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_2_00 (conv_q_src_c036_2_00 conv_q_c036_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_01 (conv_i_src_c036_2_01 0 conv_bpf_c036_2 0) vcvs gain=8.314696123025e-01
SCONVI_c036_2_01 (conv_i_src_c036_2_01 conv_i_c036_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_01 (conv_q_src_c036_2_01 0 conv_bpf_c036_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_2_01 (conv_q_src_c036_2_01 conv_q_c036_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_02 (conv_i_src_c036_2_02 0 conv_bpf_c036_2 0) vcvs gain=5.555702330196e-01
SCONVI_c036_2_02 (conv_i_src_c036_2_02 conv_i_c036_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_02 (conv_q_src_c036_2_02 0 conv_bpf_c036_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_2_02 (conv_q_src_c036_2_02 conv_q_c036_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_03 (conv_i_src_c036_2_03 0 conv_bpf_c036_2 0) vcvs gain=1.950903220161e-01
SCONVI_c036_2_03 (conv_i_src_c036_2_03 conv_i_c036_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_03 (conv_q_src_c036_2_03 0 conv_bpf_c036_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_2_03 (conv_q_src_c036_2_03 conv_q_c036_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_04 (conv_i_src_c036_2_04 0 conv_bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_2_04 (conv_i_src_c036_2_04 conv_i_c036_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_04 (conv_q_src_c036_2_04 0 conv_bpf_c036_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_2_04 (conv_q_src_c036_2_04 conv_q_c036_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_05 (conv_i_src_c036_2_05 0 conv_bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_2_05 (conv_i_src_c036_2_05 conv_i_c036_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_05 (conv_q_src_c036_2_05 0 conv_bpf_c036_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_2_05 (conv_q_src_c036_2_05 conv_q_c036_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_06 (conv_i_src_c036_2_06 0 conv_bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_2_06 (conv_i_src_c036_2_06 conv_i_c036_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_06 (conv_q_src_c036_2_06 0 conv_bpf_c036_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_2_06 (conv_q_src_c036_2_06 conv_q_c036_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_07 (conv_i_src_c036_2_07 0 conv_bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_2_07 (conv_i_src_c036_2_07 conv_i_c036_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_07 (conv_q_src_c036_2_07 0 conv_bpf_c036_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_2_07 (conv_q_src_c036_2_07 conv_q_c036_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_08 (conv_i_src_c036_2_08 0 conv_bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_2_08 (conv_i_src_c036_2_08 conv_i_c036_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_08 (conv_q_src_c036_2_08 0 conv_bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_2_08 (conv_q_src_c036_2_08 conv_q_c036_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_09 (conv_i_src_c036_2_09 0 conv_bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_2_09 (conv_i_src_c036_2_09 conv_i_c036_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_09 (conv_q_src_c036_2_09 0 conv_bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_2_09 (conv_q_src_c036_2_09 conv_q_c036_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_10 (conv_i_src_c036_2_10 0 conv_bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_2_10 (conv_i_src_c036_2_10 conv_i_c036_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_10 (conv_q_src_c036_2_10 0 conv_bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_2_10 (conv_q_src_c036_2_10 conv_q_c036_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_11 (conv_i_src_c036_2_11 0 conv_bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_2_11 (conv_i_src_c036_2_11 conv_i_c036_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_11 (conv_q_src_c036_2_11 0 conv_bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_2_11 (conv_q_src_c036_2_11 conv_q_c036_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_12 (conv_i_src_c036_2_12 0 conv_bpf_c036_2 0) vcvs gain=1.950903220161e-01
SCONVI_c036_2_12 (conv_i_src_c036_2_12 conv_i_c036_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_12 (conv_q_src_c036_2_12 0 conv_bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_2_12 (conv_q_src_c036_2_12 conv_q_c036_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_13 (conv_i_src_c036_2_13 0 conv_bpf_c036_2 0) vcvs gain=5.555702330196e-01
SCONVI_c036_2_13 (conv_i_src_c036_2_13 conv_i_c036_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_13 (conv_q_src_c036_2_13 0 conv_bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_2_13 (conv_q_src_c036_2_13 conv_q_c036_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_14 (conv_i_src_c036_2_14 0 conv_bpf_c036_2 0) vcvs gain=8.314696123025e-01
SCONVI_c036_2_14 (conv_i_src_c036_2_14 conv_i_c036_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_14 (conv_q_src_c036_2_14 0 conv_bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_2_14 (conv_q_src_c036_2_14 conv_q_c036_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_2_15 (conv_i_src_c036_2_15 0 conv_bpf_c036_2 0) vcvs gain=9.807852804032e-01
SCONVI_c036_2_15 (conv_i_src_c036_2_15 conv_i_c036_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_2_15 (conv_q_src_c036_2_15 0 conv_bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_2_15 (conv_q_src_c036_2_15 conv_q_c036_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c036_2 (conv_i_c036_2 0) resistor r=1G
RCONVQ_c036_2 (conv_q_c036_2 0) resistor r=1G
RCONVINTI_c036_2 (conv_i_c036_2 ConvIcar_c036_2) resistor r=1k
CCONVINTI_c036_2 (ConvIcar_c036_2 0) capacitor c=80p
RCONVINTQ_c036_2 (conv_q_c036_2 ConvQcar_c036_2) resistor r=1k
CCONVINTQ_c036_2 (ConvQcar_c036_2 0) capacitor c=80p
save conv_bpf_c036_2 ConvIcar_c036_2 ConvQcar_c036_2

// conventional mixed baseline bl036, carrier_3: 1000000000 Hz
CCONVBPF_c036_3 (bl036 n_conv_cbpf_c036_3) capacitor c=2.533029591058e-14
LCONVBPF_c036_3 (n_conv_cbpf_c036_3 conv_bpf_c036_3) inductor l=1.000000000000e-06
RCONVBPF_c036_3 (conv_bpf_c036_3 0) resistor r=3.141592653590e+02
ECONVI_c036_3_00 (conv_i_src_c036_3_00 0 conv_bpf_c036_3 0) vcvs gain=9.807852804032e-01
SCONVI_c036_3_00 (conv_i_src_c036_3_00 conv_i_c036_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_00 (conv_q_src_c036_3_00 0 conv_bpf_c036_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_3_00 (conv_q_src_c036_3_00 conv_q_c036_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_01 (conv_i_src_c036_3_01 0 conv_bpf_c036_3 0) vcvs gain=8.314696123025e-01
SCONVI_c036_3_01 (conv_i_src_c036_3_01 conv_i_c036_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_01 (conv_q_src_c036_3_01 0 conv_bpf_c036_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_3_01 (conv_q_src_c036_3_01 conv_q_c036_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_02 (conv_i_src_c036_3_02 0 conv_bpf_c036_3 0) vcvs gain=5.555702330196e-01
SCONVI_c036_3_02 (conv_i_src_c036_3_02 conv_i_c036_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_02 (conv_q_src_c036_3_02 0 conv_bpf_c036_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_3_02 (conv_q_src_c036_3_02 conv_q_c036_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_03 (conv_i_src_c036_3_03 0 conv_bpf_c036_3 0) vcvs gain=1.950903220161e-01
SCONVI_c036_3_03 (conv_i_src_c036_3_03 conv_i_c036_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_03 (conv_q_src_c036_3_03 0 conv_bpf_c036_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_3_03 (conv_q_src_c036_3_03 conv_q_c036_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_04 (conv_i_src_c036_3_04 0 conv_bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_3_04 (conv_i_src_c036_3_04 conv_i_c036_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_04 (conv_q_src_c036_3_04 0 conv_bpf_c036_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c036_3_04 (conv_q_src_c036_3_04 conv_q_c036_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_05 (conv_i_src_c036_3_05 0 conv_bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_3_05 (conv_i_src_c036_3_05 conv_i_c036_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_05 (conv_q_src_c036_3_05 0 conv_bpf_c036_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c036_3_05 (conv_q_src_c036_3_05 conv_q_c036_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_06 (conv_i_src_c036_3_06 0 conv_bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_3_06 (conv_i_src_c036_3_06 conv_i_c036_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_06 (conv_q_src_c036_3_06 0 conv_bpf_c036_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c036_3_06 (conv_q_src_c036_3_06 conv_q_c036_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_07 (conv_i_src_c036_3_07 0 conv_bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_3_07 (conv_i_src_c036_3_07 conv_i_c036_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_07 (conv_q_src_c036_3_07 0 conv_bpf_c036_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c036_3_07 (conv_q_src_c036_3_07 conv_q_c036_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_08 (conv_i_src_c036_3_08 0 conv_bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c036_3_08 (conv_i_src_c036_3_08 conv_i_c036_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_08 (conv_q_src_c036_3_08 0 conv_bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_3_08 (conv_q_src_c036_3_08 conv_q_c036_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_09 (conv_i_src_c036_3_09 0 conv_bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c036_3_09 (conv_i_src_c036_3_09 conv_i_c036_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_09 (conv_q_src_c036_3_09 0 conv_bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_3_09 (conv_q_src_c036_3_09 conv_q_c036_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_10 (conv_i_src_c036_3_10 0 conv_bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c036_3_10 (conv_i_src_c036_3_10 conv_i_c036_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_10 (conv_q_src_c036_3_10 0 conv_bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_3_10 (conv_q_src_c036_3_10 conv_q_c036_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_11 (conv_i_src_c036_3_11 0 conv_bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c036_3_11 (conv_i_src_c036_3_11 conv_i_c036_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_11 (conv_q_src_c036_3_11 0 conv_bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_3_11 (conv_q_src_c036_3_11 conv_q_c036_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_12 (conv_i_src_c036_3_12 0 conv_bpf_c036_3 0) vcvs gain=1.950903220161e-01
SCONVI_c036_3_12 (conv_i_src_c036_3_12 conv_i_c036_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_12 (conv_q_src_c036_3_12 0 conv_bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c036_3_12 (conv_q_src_c036_3_12 conv_q_c036_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_13 (conv_i_src_c036_3_13 0 conv_bpf_c036_3 0) vcvs gain=5.555702330196e-01
SCONVI_c036_3_13 (conv_i_src_c036_3_13 conv_i_c036_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_13 (conv_q_src_c036_3_13 0 conv_bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c036_3_13 (conv_q_src_c036_3_13 conv_q_c036_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_14 (conv_i_src_c036_3_14 0 conv_bpf_c036_3 0) vcvs gain=8.314696123025e-01
SCONVI_c036_3_14 (conv_i_src_c036_3_14 conv_i_c036_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_14 (conv_q_src_c036_3_14 0 conv_bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c036_3_14 (conv_q_src_c036_3_14 conv_q_c036_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c036_3_15 (conv_i_src_c036_3_15 0 conv_bpf_c036_3 0) vcvs gain=9.807852804032e-01
SCONVI_c036_3_15 (conv_i_src_c036_3_15 conv_i_c036_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c036_3_15 (conv_q_src_c036_3_15 0 conv_bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c036_3_15 (conv_q_src_c036_3_15 conv_q_c036_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c036_3 (conv_i_c036_3 0) resistor r=1G
RCONVQ_c036_3 (conv_q_c036_3 0) resistor r=1G
RCONVINTI_c036_3 (conv_i_c036_3 ConvIcar_c036_3) resistor r=1k
CCONVINTI_c036_3 (ConvIcar_c036_3 0) capacitor c=80p
RCONVINTQ_c036_3 (conv_q_c036_3 ConvQcar_c036_3) resistor r=1k
CCONVINTQ_c036_3 (ConvQcar_c036_3 0) capacitor c=80p
save conv_bpf_c036_3 ConvIcar_c036_3 ConvQcar_c036_3

// conventional mixed baseline bl037, carrier_0: 250000000 Hz
CCONVBPF_c037_0 (bl037 n_conv_cbpf_c037_0) capacitor c=4.052847345694e-13
LCONVBPF_c037_0 (n_conv_cbpf_c037_0 conv_bpf_c037_0) inductor l=1.000000000000e-06
RCONVBPF_c037_0 (conv_bpf_c037_0 0) resistor r=7.853981633974e+01
ECONVI_c037_0_00 (conv_i_src_c037_0_00 0 conv_bpf_c037_0 0) vcvs gain=9.807852804032e-01
SCONVI_c037_0_00 (conv_i_src_c037_0_00 conv_i_c037_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_00 (conv_q_src_c037_0_00 0 conv_bpf_c037_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_0_00 (conv_q_src_c037_0_00 conv_q_c037_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_01 (conv_i_src_c037_0_01 0 conv_bpf_c037_0 0) vcvs gain=8.314696123025e-01
SCONVI_c037_0_01 (conv_i_src_c037_0_01 conv_i_c037_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_01 (conv_q_src_c037_0_01 0 conv_bpf_c037_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_0_01 (conv_q_src_c037_0_01 conv_q_c037_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_02 (conv_i_src_c037_0_02 0 conv_bpf_c037_0 0) vcvs gain=5.555702330196e-01
SCONVI_c037_0_02 (conv_i_src_c037_0_02 conv_i_c037_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_02 (conv_q_src_c037_0_02 0 conv_bpf_c037_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_0_02 (conv_q_src_c037_0_02 conv_q_c037_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_03 (conv_i_src_c037_0_03 0 conv_bpf_c037_0 0) vcvs gain=1.950903220161e-01
SCONVI_c037_0_03 (conv_i_src_c037_0_03 conv_i_c037_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_03 (conv_q_src_c037_0_03 0 conv_bpf_c037_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_0_03 (conv_q_src_c037_0_03 conv_q_c037_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_04 (conv_i_src_c037_0_04 0 conv_bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_0_04 (conv_i_src_c037_0_04 conv_i_c037_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_04 (conv_q_src_c037_0_04 0 conv_bpf_c037_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_0_04 (conv_q_src_c037_0_04 conv_q_c037_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_05 (conv_i_src_c037_0_05 0 conv_bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_0_05 (conv_i_src_c037_0_05 conv_i_c037_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_05 (conv_q_src_c037_0_05 0 conv_bpf_c037_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_0_05 (conv_q_src_c037_0_05 conv_q_c037_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_06 (conv_i_src_c037_0_06 0 conv_bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_0_06 (conv_i_src_c037_0_06 conv_i_c037_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_06 (conv_q_src_c037_0_06 0 conv_bpf_c037_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_0_06 (conv_q_src_c037_0_06 conv_q_c037_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_07 (conv_i_src_c037_0_07 0 conv_bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_0_07 (conv_i_src_c037_0_07 conv_i_c037_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_07 (conv_q_src_c037_0_07 0 conv_bpf_c037_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_0_07 (conv_q_src_c037_0_07 conv_q_c037_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_08 (conv_i_src_c037_0_08 0 conv_bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_0_08 (conv_i_src_c037_0_08 conv_i_c037_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_08 (conv_q_src_c037_0_08 0 conv_bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_0_08 (conv_q_src_c037_0_08 conv_q_c037_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_09 (conv_i_src_c037_0_09 0 conv_bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_0_09 (conv_i_src_c037_0_09 conv_i_c037_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_09 (conv_q_src_c037_0_09 0 conv_bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_0_09 (conv_q_src_c037_0_09 conv_q_c037_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_10 (conv_i_src_c037_0_10 0 conv_bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_0_10 (conv_i_src_c037_0_10 conv_i_c037_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_10 (conv_q_src_c037_0_10 0 conv_bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_0_10 (conv_q_src_c037_0_10 conv_q_c037_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_11 (conv_i_src_c037_0_11 0 conv_bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_0_11 (conv_i_src_c037_0_11 conv_i_c037_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_11 (conv_q_src_c037_0_11 0 conv_bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_0_11 (conv_q_src_c037_0_11 conv_q_c037_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_12 (conv_i_src_c037_0_12 0 conv_bpf_c037_0 0) vcvs gain=1.950903220161e-01
SCONVI_c037_0_12 (conv_i_src_c037_0_12 conv_i_c037_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_12 (conv_q_src_c037_0_12 0 conv_bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_0_12 (conv_q_src_c037_0_12 conv_q_c037_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_13 (conv_i_src_c037_0_13 0 conv_bpf_c037_0 0) vcvs gain=5.555702330196e-01
SCONVI_c037_0_13 (conv_i_src_c037_0_13 conv_i_c037_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_13 (conv_q_src_c037_0_13 0 conv_bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_0_13 (conv_q_src_c037_0_13 conv_q_c037_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_14 (conv_i_src_c037_0_14 0 conv_bpf_c037_0 0) vcvs gain=8.314696123025e-01
SCONVI_c037_0_14 (conv_i_src_c037_0_14 conv_i_c037_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_14 (conv_q_src_c037_0_14 0 conv_bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_0_14 (conv_q_src_c037_0_14 conv_q_c037_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_0_15 (conv_i_src_c037_0_15 0 conv_bpf_c037_0 0) vcvs gain=9.807852804032e-01
SCONVI_c037_0_15 (conv_i_src_c037_0_15 conv_i_c037_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_0_15 (conv_q_src_c037_0_15 0 conv_bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_0_15 (conv_q_src_c037_0_15 conv_q_c037_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c037_0 (conv_i_c037_0 0) resistor r=1G
RCONVQ_c037_0 (conv_q_c037_0 0) resistor r=1G
RCONVINTI_c037_0 (conv_i_c037_0 ConvIcar_c037_0) resistor r=1k
CCONVINTI_c037_0 (ConvIcar_c037_0 0) capacitor c=80p
RCONVINTQ_c037_0 (conv_q_c037_0 ConvQcar_c037_0) resistor r=1k
CCONVINTQ_c037_0 (ConvQcar_c037_0 0) capacitor c=80p
save conv_bpf_c037_0 ConvIcar_c037_0 ConvQcar_c037_0

// conventional mixed baseline bl037, carrier_1: 500000000 Hz
CCONVBPF_c037_1 (bl037 n_conv_cbpf_c037_1) capacitor c=1.013211836423e-13
LCONVBPF_c037_1 (n_conv_cbpf_c037_1 conv_bpf_c037_1) inductor l=1.000000000000e-06
RCONVBPF_c037_1 (conv_bpf_c037_1 0) resistor r=1.570796326795e+02
ECONVI_c037_1_00 (conv_i_src_c037_1_00 0 conv_bpf_c037_1 0) vcvs gain=9.807852804032e-01
SCONVI_c037_1_00 (conv_i_src_c037_1_00 conv_i_c037_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_00 (conv_q_src_c037_1_00 0 conv_bpf_c037_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_1_00 (conv_q_src_c037_1_00 conv_q_c037_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_01 (conv_i_src_c037_1_01 0 conv_bpf_c037_1 0) vcvs gain=8.314696123025e-01
SCONVI_c037_1_01 (conv_i_src_c037_1_01 conv_i_c037_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_01 (conv_q_src_c037_1_01 0 conv_bpf_c037_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_1_01 (conv_q_src_c037_1_01 conv_q_c037_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_02 (conv_i_src_c037_1_02 0 conv_bpf_c037_1 0) vcvs gain=5.555702330196e-01
SCONVI_c037_1_02 (conv_i_src_c037_1_02 conv_i_c037_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_02 (conv_q_src_c037_1_02 0 conv_bpf_c037_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_1_02 (conv_q_src_c037_1_02 conv_q_c037_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_03 (conv_i_src_c037_1_03 0 conv_bpf_c037_1 0) vcvs gain=1.950903220161e-01
SCONVI_c037_1_03 (conv_i_src_c037_1_03 conv_i_c037_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_03 (conv_q_src_c037_1_03 0 conv_bpf_c037_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_1_03 (conv_q_src_c037_1_03 conv_q_c037_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_04 (conv_i_src_c037_1_04 0 conv_bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_1_04 (conv_i_src_c037_1_04 conv_i_c037_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_04 (conv_q_src_c037_1_04 0 conv_bpf_c037_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_1_04 (conv_q_src_c037_1_04 conv_q_c037_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_05 (conv_i_src_c037_1_05 0 conv_bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_1_05 (conv_i_src_c037_1_05 conv_i_c037_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_05 (conv_q_src_c037_1_05 0 conv_bpf_c037_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_1_05 (conv_q_src_c037_1_05 conv_q_c037_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_06 (conv_i_src_c037_1_06 0 conv_bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_1_06 (conv_i_src_c037_1_06 conv_i_c037_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_06 (conv_q_src_c037_1_06 0 conv_bpf_c037_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_1_06 (conv_q_src_c037_1_06 conv_q_c037_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_07 (conv_i_src_c037_1_07 0 conv_bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_1_07 (conv_i_src_c037_1_07 conv_i_c037_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_07 (conv_q_src_c037_1_07 0 conv_bpf_c037_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_1_07 (conv_q_src_c037_1_07 conv_q_c037_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_08 (conv_i_src_c037_1_08 0 conv_bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_1_08 (conv_i_src_c037_1_08 conv_i_c037_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_08 (conv_q_src_c037_1_08 0 conv_bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_1_08 (conv_q_src_c037_1_08 conv_q_c037_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_09 (conv_i_src_c037_1_09 0 conv_bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_1_09 (conv_i_src_c037_1_09 conv_i_c037_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_09 (conv_q_src_c037_1_09 0 conv_bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_1_09 (conv_q_src_c037_1_09 conv_q_c037_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_10 (conv_i_src_c037_1_10 0 conv_bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_1_10 (conv_i_src_c037_1_10 conv_i_c037_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_10 (conv_q_src_c037_1_10 0 conv_bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_1_10 (conv_q_src_c037_1_10 conv_q_c037_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_11 (conv_i_src_c037_1_11 0 conv_bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_1_11 (conv_i_src_c037_1_11 conv_i_c037_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_11 (conv_q_src_c037_1_11 0 conv_bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_1_11 (conv_q_src_c037_1_11 conv_q_c037_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_12 (conv_i_src_c037_1_12 0 conv_bpf_c037_1 0) vcvs gain=1.950903220161e-01
SCONVI_c037_1_12 (conv_i_src_c037_1_12 conv_i_c037_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_12 (conv_q_src_c037_1_12 0 conv_bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_1_12 (conv_q_src_c037_1_12 conv_q_c037_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_13 (conv_i_src_c037_1_13 0 conv_bpf_c037_1 0) vcvs gain=5.555702330196e-01
SCONVI_c037_1_13 (conv_i_src_c037_1_13 conv_i_c037_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_13 (conv_q_src_c037_1_13 0 conv_bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_1_13 (conv_q_src_c037_1_13 conv_q_c037_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_14 (conv_i_src_c037_1_14 0 conv_bpf_c037_1 0) vcvs gain=8.314696123025e-01
SCONVI_c037_1_14 (conv_i_src_c037_1_14 conv_i_c037_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_14 (conv_q_src_c037_1_14 0 conv_bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_1_14 (conv_q_src_c037_1_14 conv_q_c037_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_1_15 (conv_i_src_c037_1_15 0 conv_bpf_c037_1 0) vcvs gain=9.807852804032e-01
SCONVI_c037_1_15 (conv_i_src_c037_1_15 conv_i_c037_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_1_15 (conv_q_src_c037_1_15 0 conv_bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_1_15 (conv_q_src_c037_1_15 conv_q_c037_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c037_1 (conv_i_c037_1 0) resistor r=1G
RCONVQ_c037_1 (conv_q_c037_1 0) resistor r=1G
RCONVINTI_c037_1 (conv_i_c037_1 ConvIcar_c037_1) resistor r=1k
CCONVINTI_c037_1 (ConvIcar_c037_1 0) capacitor c=80p
RCONVINTQ_c037_1 (conv_q_c037_1 ConvQcar_c037_1) resistor r=1k
CCONVINTQ_c037_1 (ConvQcar_c037_1 0) capacitor c=80p
save conv_bpf_c037_1 ConvIcar_c037_1 ConvQcar_c037_1

// conventional mixed baseline bl037, carrier_2: 750000000 Hz
CCONVBPF_c037_2 (bl037 n_conv_cbpf_c037_2) capacitor c=4.503163717437e-14
LCONVBPF_c037_2 (n_conv_cbpf_c037_2 conv_bpf_c037_2) inductor l=1.000000000000e-06
RCONVBPF_c037_2 (conv_bpf_c037_2 0) resistor r=2.356194490192e+02
ECONVI_c037_2_00 (conv_i_src_c037_2_00 0 conv_bpf_c037_2 0) vcvs gain=9.807852804032e-01
SCONVI_c037_2_00 (conv_i_src_c037_2_00 conv_i_c037_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_00 (conv_q_src_c037_2_00 0 conv_bpf_c037_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_2_00 (conv_q_src_c037_2_00 conv_q_c037_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_01 (conv_i_src_c037_2_01 0 conv_bpf_c037_2 0) vcvs gain=8.314696123025e-01
SCONVI_c037_2_01 (conv_i_src_c037_2_01 conv_i_c037_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_01 (conv_q_src_c037_2_01 0 conv_bpf_c037_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_2_01 (conv_q_src_c037_2_01 conv_q_c037_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_02 (conv_i_src_c037_2_02 0 conv_bpf_c037_2 0) vcvs gain=5.555702330196e-01
SCONVI_c037_2_02 (conv_i_src_c037_2_02 conv_i_c037_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_02 (conv_q_src_c037_2_02 0 conv_bpf_c037_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_2_02 (conv_q_src_c037_2_02 conv_q_c037_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_03 (conv_i_src_c037_2_03 0 conv_bpf_c037_2 0) vcvs gain=1.950903220161e-01
SCONVI_c037_2_03 (conv_i_src_c037_2_03 conv_i_c037_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_03 (conv_q_src_c037_2_03 0 conv_bpf_c037_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_2_03 (conv_q_src_c037_2_03 conv_q_c037_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_04 (conv_i_src_c037_2_04 0 conv_bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_2_04 (conv_i_src_c037_2_04 conv_i_c037_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_04 (conv_q_src_c037_2_04 0 conv_bpf_c037_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_2_04 (conv_q_src_c037_2_04 conv_q_c037_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_05 (conv_i_src_c037_2_05 0 conv_bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_2_05 (conv_i_src_c037_2_05 conv_i_c037_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_05 (conv_q_src_c037_2_05 0 conv_bpf_c037_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_2_05 (conv_q_src_c037_2_05 conv_q_c037_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_06 (conv_i_src_c037_2_06 0 conv_bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_2_06 (conv_i_src_c037_2_06 conv_i_c037_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_06 (conv_q_src_c037_2_06 0 conv_bpf_c037_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_2_06 (conv_q_src_c037_2_06 conv_q_c037_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_07 (conv_i_src_c037_2_07 0 conv_bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_2_07 (conv_i_src_c037_2_07 conv_i_c037_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_07 (conv_q_src_c037_2_07 0 conv_bpf_c037_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_2_07 (conv_q_src_c037_2_07 conv_q_c037_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_08 (conv_i_src_c037_2_08 0 conv_bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_2_08 (conv_i_src_c037_2_08 conv_i_c037_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_08 (conv_q_src_c037_2_08 0 conv_bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_2_08 (conv_q_src_c037_2_08 conv_q_c037_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_09 (conv_i_src_c037_2_09 0 conv_bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_2_09 (conv_i_src_c037_2_09 conv_i_c037_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_09 (conv_q_src_c037_2_09 0 conv_bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_2_09 (conv_q_src_c037_2_09 conv_q_c037_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_10 (conv_i_src_c037_2_10 0 conv_bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_2_10 (conv_i_src_c037_2_10 conv_i_c037_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_10 (conv_q_src_c037_2_10 0 conv_bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_2_10 (conv_q_src_c037_2_10 conv_q_c037_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_11 (conv_i_src_c037_2_11 0 conv_bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_2_11 (conv_i_src_c037_2_11 conv_i_c037_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_11 (conv_q_src_c037_2_11 0 conv_bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_2_11 (conv_q_src_c037_2_11 conv_q_c037_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_12 (conv_i_src_c037_2_12 0 conv_bpf_c037_2 0) vcvs gain=1.950903220161e-01
SCONVI_c037_2_12 (conv_i_src_c037_2_12 conv_i_c037_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_12 (conv_q_src_c037_2_12 0 conv_bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_2_12 (conv_q_src_c037_2_12 conv_q_c037_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_13 (conv_i_src_c037_2_13 0 conv_bpf_c037_2 0) vcvs gain=5.555702330196e-01
SCONVI_c037_2_13 (conv_i_src_c037_2_13 conv_i_c037_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_13 (conv_q_src_c037_2_13 0 conv_bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_2_13 (conv_q_src_c037_2_13 conv_q_c037_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_14 (conv_i_src_c037_2_14 0 conv_bpf_c037_2 0) vcvs gain=8.314696123025e-01
SCONVI_c037_2_14 (conv_i_src_c037_2_14 conv_i_c037_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_14 (conv_q_src_c037_2_14 0 conv_bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_2_14 (conv_q_src_c037_2_14 conv_q_c037_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_2_15 (conv_i_src_c037_2_15 0 conv_bpf_c037_2 0) vcvs gain=9.807852804032e-01
SCONVI_c037_2_15 (conv_i_src_c037_2_15 conv_i_c037_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_2_15 (conv_q_src_c037_2_15 0 conv_bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_2_15 (conv_q_src_c037_2_15 conv_q_c037_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c037_2 (conv_i_c037_2 0) resistor r=1G
RCONVQ_c037_2 (conv_q_c037_2 0) resistor r=1G
RCONVINTI_c037_2 (conv_i_c037_2 ConvIcar_c037_2) resistor r=1k
CCONVINTI_c037_2 (ConvIcar_c037_2 0) capacitor c=80p
RCONVINTQ_c037_2 (conv_q_c037_2 ConvQcar_c037_2) resistor r=1k
CCONVINTQ_c037_2 (ConvQcar_c037_2 0) capacitor c=80p
save conv_bpf_c037_2 ConvIcar_c037_2 ConvQcar_c037_2

// conventional mixed baseline bl037, carrier_3: 1000000000 Hz
CCONVBPF_c037_3 (bl037 n_conv_cbpf_c037_3) capacitor c=2.533029591058e-14
LCONVBPF_c037_3 (n_conv_cbpf_c037_3 conv_bpf_c037_3) inductor l=1.000000000000e-06
RCONVBPF_c037_3 (conv_bpf_c037_3 0) resistor r=3.141592653590e+02
ECONVI_c037_3_00 (conv_i_src_c037_3_00 0 conv_bpf_c037_3 0) vcvs gain=9.807852804032e-01
SCONVI_c037_3_00 (conv_i_src_c037_3_00 conv_i_c037_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_00 (conv_q_src_c037_3_00 0 conv_bpf_c037_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_3_00 (conv_q_src_c037_3_00 conv_q_c037_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_01 (conv_i_src_c037_3_01 0 conv_bpf_c037_3 0) vcvs gain=8.314696123025e-01
SCONVI_c037_3_01 (conv_i_src_c037_3_01 conv_i_c037_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_01 (conv_q_src_c037_3_01 0 conv_bpf_c037_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_3_01 (conv_q_src_c037_3_01 conv_q_c037_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_02 (conv_i_src_c037_3_02 0 conv_bpf_c037_3 0) vcvs gain=5.555702330196e-01
SCONVI_c037_3_02 (conv_i_src_c037_3_02 conv_i_c037_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_02 (conv_q_src_c037_3_02 0 conv_bpf_c037_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_3_02 (conv_q_src_c037_3_02 conv_q_c037_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_03 (conv_i_src_c037_3_03 0 conv_bpf_c037_3 0) vcvs gain=1.950903220161e-01
SCONVI_c037_3_03 (conv_i_src_c037_3_03 conv_i_c037_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_03 (conv_q_src_c037_3_03 0 conv_bpf_c037_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_3_03 (conv_q_src_c037_3_03 conv_q_c037_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_04 (conv_i_src_c037_3_04 0 conv_bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_3_04 (conv_i_src_c037_3_04 conv_i_c037_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_04 (conv_q_src_c037_3_04 0 conv_bpf_c037_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c037_3_04 (conv_q_src_c037_3_04 conv_q_c037_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_05 (conv_i_src_c037_3_05 0 conv_bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_3_05 (conv_i_src_c037_3_05 conv_i_c037_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_05 (conv_q_src_c037_3_05 0 conv_bpf_c037_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c037_3_05 (conv_q_src_c037_3_05 conv_q_c037_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_06 (conv_i_src_c037_3_06 0 conv_bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_3_06 (conv_i_src_c037_3_06 conv_i_c037_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_06 (conv_q_src_c037_3_06 0 conv_bpf_c037_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c037_3_06 (conv_q_src_c037_3_06 conv_q_c037_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_07 (conv_i_src_c037_3_07 0 conv_bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_3_07 (conv_i_src_c037_3_07 conv_i_c037_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_07 (conv_q_src_c037_3_07 0 conv_bpf_c037_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c037_3_07 (conv_q_src_c037_3_07 conv_q_c037_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_08 (conv_i_src_c037_3_08 0 conv_bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c037_3_08 (conv_i_src_c037_3_08 conv_i_c037_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_08 (conv_q_src_c037_3_08 0 conv_bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_3_08 (conv_q_src_c037_3_08 conv_q_c037_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_09 (conv_i_src_c037_3_09 0 conv_bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c037_3_09 (conv_i_src_c037_3_09 conv_i_c037_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_09 (conv_q_src_c037_3_09 0 conv_bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_3_09 (conv_q_src_c037_3_09 conv_q_c037_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_10 (conv_i_src_c037_3_10 0 conv_bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c037_3_10 (conv_i_src_c037_3_10 conv_i_c037_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_10 (conv_q_src_c037_3_10 0 conv_bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_3_10 (conv_q_src_c037_3_10 conv_q_c037_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_11 (conv_i_src_c037_3_11 0 conv_bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c037_3_11 (conv_i_src_c037_3_11 conv_i_c037_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_11 (conv_q_src_c037_3_11 0 conv_bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_3_11 (conv_q_src_c037_3_11 conv_q_c037_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_12 (conv_i_src_c037_3_12 0 conv_bpf_c037_3 0) vcvs gain=1.950903220161e-01
SCONVI_c037_3_12 (conv_i_src_c037_3_12 conv_i_c037_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_12 (conv_q_src_c037_3_12 0 conv_bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c037_3_12 (conv_q_src_c037_3_12 conv_q_c037_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_13 (conv_i_src_c037_3_13 0 conv_bpf_c037_3 0) vcvs gain=5.555702330196e-01
SCONVI_c037_3_13 (conv_i_src_c037_3_13 conv_i_c037_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_13 (conv_q_src_c037_3_13 0 conv_bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c037_3_13 (conv_q_src_c037_3_13 conv_q_c037_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_14 (conv_i_src_c037_3_14 0 conv_bpf_c037_3 0) vcvs gain=8.314696123025e-01
SCONVI_c037_3_14 (conv_i_src_c037_3_14 conv_i_c037_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_14 (conv_q_src_c037_3_14 0 conv_bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c037_3_14 (conv_q_src_c037_3_14 conv_q_c037_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c037_3_15 (conv_i_src_c037_3_15 0 conv_bpf_c037_3 0) vcvs gain=9.807852804032e-01
SCONVI_c037_3_15 (conv_i_src_c037_3_15 conv_i_c037_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c037_3_15 (conv_q_src_c037_3_15 0 conv_bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c037_3_15 (conv_q_src_c037_3_15 conv_q_c037_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c037_3 (conv_i_c037_3 0) resistor r=1G
RCONVQ_c037_3 (conv_q_c037_3 0) resistor r=1G
RCONVINTI_c037_3 (conv_i_c037_3 ConvIcar_c037_3) resistor r=1k
CCONVINTI_c037_3 (ConvIcar_c037_3 0) capacitor c=80p
RCONVINTQ_c037_3 (conv_q_c037_3 ConvQcar_c037_3) resistor r=1k
CCONVINTQ_c037_3 (ConvQcar_c037_3 0) capacitor c=80p
save conv_bpf_c037_3 ConvIcar_c037_3 ConvQcar_c037_3

// conventional mixed baseline bl038, carrier_0: 250000000 Hz
CCONVBPF_c038_0 (bl038 n_conv_cbpf_c038_0) capacitor c=4.052847345694e-13
LCONVBPF_c038_0 (n_conv_cbpf_c038_0 conv_bpf_c038_0) inductor l=1.000000000000e-06
RCONVBPF_c038_0 (conv_bpf_c038_0 0) resistor r=7.853981633974e+01
ECONVI_c038_0_00 (conv_i_src_c038_0_00 0 conv_bpf_c038_0 0) vcvs gain=9.807852804032e-01
SCONVI_c038_0_00 (conv_i_src_c038_0_00 conv_i_c038_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_00 (conv_q_src_c038_0_00 0 conv_bpf_c038_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_0_00 (conv_q_src_c038_0_00 conv_q_c038_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_01 (conv_i_src_c038_0_01 0 conv_bpf_c038_0 0) vcvs gain=8.314696123025e-01
SCONVI_c038_0_01 (conv_i_src_c038_0_01 conv_i_c038_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_01 (conv_q_src_c038_0_01 0 conv_bpf_c038_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_0_01 (conv_q_src_c038_0_01 conv_q_c038_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_02 (conv_i_src_c038_0_02 0 conv_bpf_c038_0 0) vcvs gain=5.555702330196e-01
SCONVI_c038_0_02 (conv_i_src_c038_0_02 conv_i_c038_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_02 (conv_q_src_c038_0_02 0 conv_bpf_c038_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_0_02 (conv_q_src_c038_0_02 conv_q_c038_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_03 (conv_i_src_c038_0_03 0 conv_bpf_c038_0 0) vcvs gain=1.950903220161e-01
SCONVI_c038_0_03 (conv_i_src_c038_0_03 conv_i_c038_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_03 (conv_q_src_c038_0_03 0 conv_bpf_c038_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_0_03 (conv_q_src_c038_0_03 conv_q_c038_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_04 (conv_i_src_c038_0_04 0 conv_bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_0_04 (conv_i_src_c038_0_04 conv_i_c038_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_04 (conv_q_src_c038_0_04 0 conv_bpf_c038_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_0_04 (conv_q_src_c038_0_04 conv_q_c038_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_05 (conv_i_src_c038_0_05 0 conv_bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_0_05 (conv_i_src_c038_0_05 conv_i_c038_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_05 (conv_q_src_c038_0_05 0 conv_bpf_c038_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_0_05 (conv_q_src_c038_0_05 conv_q_c038_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_06 (conv_i_src_c038_0_06 0 conv_bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_0_06 (conv_i_src_c038_0_06 conv_i_c038_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_06 (conv_q_src_c038_0_06 0 conv_bpf_c038_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_0_06 (conv_q_src_c038_0_06 conv_q_c038_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_07 (conv_i_src_c038_0_07 0 conv_bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_0_07 (conv_i_src_c038_0_07 conv_i_c038_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_07 (conv_q_src_c038_0_07 0 conv_bpf_c038_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_0_07 (conv_q_src_c038_0_07 conv_q_c038_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_08 (conv_i_src_c038_0_08 0 conv_bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_0_08 (conv_i_src_c038_0_08 conv_i_c038_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_08 (conv_q_src_c038_0_08 0 conv_bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_0_08 (conv_q_src_c038_0_08 conv_q_c038_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_09 (conv_i_src_c038_0_09 0 conv_bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_0_09 (conv_i_src_c038_0_09 conv_i_c038_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_09 (conv_q_src_c038_0_09 0 conv_bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_0_09 (conv_q_src_c038_0_09 conv_q_c038_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_10 (conv_i_src_c038_0_10 0 conv_bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_0_10 (conv_i_src_c038_0_10 conv_i_c038_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_10 (conv_q_src_c038_0_10 0 conv_bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_0_10 (conv_q_src_c038_0_10 conv_q_c038_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_11 (conv_i_src_c038_0_11 0 conv_bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_0_11 (conv_i_src_c038_0_11 conv_i_c038_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_11 (conv_q_src_c038_0_11 0 conv_bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_0_11 (conv_q_src_c038_0_11 conv_q_c038_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_12 (conv_i_src_c038_0_12 0 conv_bpf_c038_0 0) vcvs gain=1.950903220161e-01
SCONVI_c038_0_12 (conv_i_src_c038_0_12 conv_i_c038_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_12 (conv_q_src_c038_0_12 0 conv_bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_0_12 (conv_q_src_c038_0_12 conv_q_c038_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_13 (conv_i_src_c038_0_13 0 conv_bpf_c038_0 0) vcvs gain=5.555702330196e-01
SCONVI_c038_0_13 (conv_i_src_c038_0_13 conv_i_c038_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_13 (conv_q_src_c038_0_13 0 conv_bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_0_13 (conv_q_src_c038_0_13 conv_q_c038_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_14 (conv_i_src_c038_0_14 0 conv_bpf_c038_0 0) vcvs gain=8.314696123025e-01
SCONVI_c038_0_14 (conv_i_src_c038_0_14 conv_i_c038_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_14 (conv_q_src_c038_0_14 0 conv_bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_0_14 (conv_q_src_c038_0_14 conv_q_c038_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_0_15 (conv_i_src_c038_0_15 0 conv_bpf_c038_0 0) vcvs gain=9.807852804032e-01
SCONVI_c038_0_15 (conv_i_src_c038_0_15 conv_i_c038_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_0_15 (conv_q_src_c038_0_15 0 conv_bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_0_15 (conv_q_src_c038_0_15 conv_q_c038_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c038_0 (conv_i_c038_0 0) resistor r=1G
RCONVQ_c038_0 (conv_q_c038_0 0) resistor r=1G
RCONVINTI_c038_0 (conv_i_c038_0 ConvIcar_c038_0) resistor r=1k
CCONVINTI_c038_0 (ConvIcar_c038_0 0) capacitor c=80p
RCONVINTQ_c038_0 (conv_q_c038_0 ConvQcar_c038_0) resistor r=1k
CCONVINTQ_c038_0 (ConvQcar_c038_0 0) capacitor c=80p
save conv_bpf_c038_0 ConvIcar_c038_0 ConvQcar_c038_0

// conventional mixed baseline bl038, carrier_1: 500000000 Hz
CCONVBPF_c038_1 (bl038 n_conv_cbpf_c038_1) capacitor c=1.013211836423e-13
LCONVBPF_c038_1 (n_conv_cbpf_c038_1 conv_bpf_c038_1) inductor l=1.000000000000e-06
RCONVBPF_c038_1 (conv_bpf_c038_1 0) resistor r=1.570796326795e+02
ECONVI_c038_1_00 (conv_i_src_c038_1_00 0 conv_bpf_c038_1 0) vcvs gain=9.807852804032e-01
SCONVI_c038_1_00 (conv_i_src_c038_1_00 conv_i_c038_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_00 (conv_q_src_c038_1_00 0 conv_bpf_c038_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_1_00 (conv_q_src_c038_1_00 conv_q_c038_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_01 (conv_i_src_c038_1_01 0 conv_bpf_c038_1 0) vcvs gain=8.314696123025e-01
SCONVI_c038_1_01 (conv_i_src_c038_1_01 conv_i_c038_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_01 (conv_q_src_c038_1_01 0 conv_bpf_c038_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_1_01 (conv_q_src_c038_1_01 conv_q_c038_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_02 (conv_i_src_c038_1_02 0 conv_bpf_c038_1 0) vcvs gain=5.555702330196e-01
SCONVI_c038_1_02 (conv_i_src_c038_1_02 conv_i_c038_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_02 (conv_q_src_c038_1_02 0 conv_bpf_c038_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_1_02 (conv_q_src_c038_1_02 conv_q_c038_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_03 (conv_i_src_c038_1_03 0 conv_bpf_c038_1 0) vcvs gain=1.950903220161e-01
SCONVI_c038_1_03 (conv_i_src_c038_1_03 conv_i_c038_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_03 (conv_q_src_c038_1_03 0 conv_bpf_c038_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_1_03 (conv_q_src_c038_1_03 conv_q_c038_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_04 (conv_i_src_c038_1_04 0 conv_bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_1_04 (conv_i_src_c038_1_04 conv_i_c038_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_04 (conv_q_src_c038_1_04 0 conv_bpf_c038_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_1_04 (conv_q_src_c038_1_04 conv_q_c038_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_05 (conv_i_src_c038_1_05 0 conv_bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_1_05 (conv_i_src_c038_1_05 conv_i_c038_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_05 (conv_q_src_c038_1_05 0 conv_bpf_c038_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_1_05 (conv_q_src_c038_1_05 conv_q_c038_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_06 (conv_i_src_c038_1_06 0 conv_bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_1_06 (conv_i_src_c038_1_06 conv_i_c038_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_06 (conv_q_src_c038_1_06 0 conv_bpf_c038_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_1_06 (conv_q_src_c038_1_06 conv_q_c038_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_07 (conv_i_src_c038_1_07 0 conv_bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_1_07 (conv_i_src_c038_1_07 conv_i_c038_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_07 (conv_q_src_c038_1_07 0 conv_bpf_c038_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_1_07 (conv_q_src_c038_1_07 conv_q_c038_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_08 (conv_i_src_c038_1_08 0 conv_bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_1_08 (conv_i_src_c038_1_08 conv_i_c038_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_08 (conv_q_src_c038_1_08 0 conv_bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_1_08 (conv_q_src_c038_1_08 conv_q_c038_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_09 (conv_i_src_c038_1_09 0 conv_bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_1_09 (conv_i_src_c038_1_09 conv_i_c038_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_09 (conv_q_src_c038_1_09 0 conv_bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_1_09 (conv_q_src_c038_1_09 conv_q_c038_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_10 (conv_i_src_c038_1_10 0 conv_bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_1_10 (conv_i_src_c038_1_10 conv_i_c038_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_10 (conv_q_src_c038_1_10 0 conv_bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_1_10 (conv_q_src_c038_1_10 conv_q_c038_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_11 (conv_i_src_c038_1_11 0 conv_bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_1_11 (conv_i_src_c038_1_11 conv_i_c038_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_11 (conv_q_src_c038_1_11 0 conv_bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_1_11 (conv_q_src_c038_1_11 conv_q_c038_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_12 (conv_i_src_c038_1_12 0 conv_bpf_c038_1 0) vcvs gain=1.950903220161e-01
SCONVI_c038_1_12 (conv_i_src_c038_1_12 conv_i_c038_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_12 (conv_q_src_c038_1_12 0 conv_bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_1_12 (conv_q_src_c038_1_12 conv_q_c038_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_13 (conv_i_src_c038_1_13 0 conv_bpf_c038_1 0) vcvs gain=5.555702330196e-01
SCONVI_c038_1_13 (conv_i_src_c038_1_13 conv_i_c038_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_13 (conv_q_src_c038_1_13 0 conv_bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_1_13 (conv_q_src_c038_1_13 conv_q_c038_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_14 (conv_i_src_c038_1_14 0 conv_bpf_c038_1 0) vcvs gain=8.314696123025e-01
SCONVI_c038_1_14 (conv_i_src_c038_1_14 conv_i_c038_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_14 (conv_q_src_c038_1_14 0 conv_bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_1_14 (conv_q_src_c038_1_14 conv_q_c038_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_1_15 (conv_i_src_c038_1_15 0 conv_bpf_c038_1 0) vcvs gain=9.807852804032e-01
SCONVI_c038_1_15 (conv_i_src_c038_1_15 conv_i_c038_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_1_15 (conv_q_src_c038_1_15 0 conv_bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_1_15 (conv_q_src_c038_1_15 conv_q_c038_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c038_1 (conv_i_c038_1 0) resistor r=1G
RCONVQ_c038_1 (conv_q_c038_1 0) resistor r=1G
RCONVINTI_c038_1 (conv_i_c038_1 ConvIcar_c038_1) resistor r=1k
CCONVINTI_c038_1 (ConvIcar_c038_1 0) capacitor c=80p
RCONVINTQ_c038_1 (conv_q_c038_1 ConvQcar_c038_1) resistor r=1k
CCONVINTQ_c038_1 (ConvQcar_c038_1 0) capacitor c=80p
save conv_bpf_c038_1 ConvIcar_c038_1 ConvQcar_c038_1

// conventional mixed baseline bl038, carrier_2: 750000000 Hz
CCONVBPF_c038_2 (bl038 n_conv_cbpf_c038_2) capacitor c=4.503163717437e-14
LCONVBPF_c038_2 (n_conv_cbpf_c038_2 conv_bpf_c038_2) inductor l=1.000000000000e-06
RCONVBPF_c038_2 (conv_bpf_c038_2 0) resistor r=2.356194490192e+02
ECONVI_c038_2_00 (conv_i_src_c038_2_00 0 conv_bpf_c038_2 0) vcvs gain=9.807852804032e-01
SCONVI_c038_2_00 (conv_i_src_c038_2_00 conv_i_c038_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_00 (conv_q_src_c038_2_00 0 conv_bpf_c038_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_2_00 (conv_q_src_c038_2_00 conv_q_c038_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_01 (conv_i_src_c038_2_01 0 conv_bpf_c038_2 0) vcvs gain=8.314696123025e-01
SCONVI_c038_2_01 (conv_i_src_c038_2_01 conv_i_c038_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_01 (conv_q_src_c038_2_01 0 conv_bpf_c038_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_2_01 (conv_q_src_c038_2_01 conv_q_c038_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_02 (conv_i_src_c038_2_02 0 conv_bpf_c038_2 0) vcvs gain=5.555702330196e-01
SCONVI_c038_2_02 (conv_i_src_c038_2_02 conv_i_c038_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_02 (conv_q_src_c038_2_02 0 conv_bpf_c038_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_2_02 (conv_q_src_c038_2_02 conv_q_c038_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_03 (conv_i_src_c038_2_03 0 conv_bpf_c038_2 0) vcvs gain=1.950903220161e-01
SCONVI_c038_2_03 (conv_i_src_c038_2_03 conv_i_c038_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_03 (conv_q_src_c038_2_03 0 conv_bpf_c038_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_2_03 (conv_q_src_c038_2_03 conv_q_c038_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_04 (conv_i_src_c038_2_04 0 conv_bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_2_04 (conv_i_src_c038_2_04 conv_i_c038_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_04 (conv_q_src_c038_2_04 0 conv_bpf_c038_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_2_04 (conv_q_src_c038_2_04 conv_q_c038_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_05 (conv_i_src_c038_2_05 0 conv_bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_2_05 (conv_i_src_c038_2_05 conv_i_c038_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_05 (conv_q_src_c038_2_05 0 conv_bpf_c038_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_2_05 (conv_q_src_c038_2_05 conv_q_c038_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_06 (conv_i_src_c038_2_06 0 conv_bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_2_06 (conv_i_src_c038_2_06 conv_i_c038_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_06 (conv_q_src_c038_2_06 0 conv_bpf_c038_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_2_06 (conv_q_src_c038_2_06 conv_q_c038_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_07 (conv_i_src_c038_2_07 0 conv_bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_2_07 (conv_i_src_c038_2_07 conv_i_c038_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_07 (conv_q_src_c038_2_07 0 conv_bpf_c038_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_2_07 (conv_q_src_c038_2_07 conv_q_c038_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_08 (conv_i_src_c038_2_08 0 conv_bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_2_08 (conv_i_src_c038_2_08 conv_i_c038_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_08 (conv_q_src_c038_2_08 0 conv_bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_2_08 (conv_q_src_c038_2_08 conv_q_c038_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_09 (conv_i_src_c038_2_09 0 conv_bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_2_09 (conv_i_src_c038_2_09 conv_i_c038_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_09 (conv_q_src_c038_2_09 0 conv_bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_2_09 (conv_q_src_c038_2_09 conv_q_c038_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_10 (conv_i_src_c038_2_10 0 conv_bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_2_10 (conv_i_src_c038_2_10 conv_i_c038_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_10 (conv_q_src_c038_2_10 0 conv_bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_2_10 (conv_q_src_c038_2_10 conv_q_c038_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_11 (conv_i_src_c038_2_11 0 conv_bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_2_11 (conv_i_src_c038_2_11 conv_i_c038_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_11 (conv_q_src_c038_2_11 0 conv_bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_2_11 (conv_q_src_c038_2_11 conv_q_c038_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_12 (conv_i_src_c038_2_12 0 conv_bpf_c038_2 0) vcvs gain=1.950903220161e-01
SCONVI_c038_2_12 (conv_i_src_c038_2_12 conv_i_c038_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_12 (conv_q_src_c038_2_12 0 conv_bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_2_12 (conv_q_src_c038_2_12 conv_q_c038_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_13 (conv_i_src_c038_2_13 0 conv_bpf_c038_2 0) vcvs gain=5.555702330196e-01
SCONVI_c038_2_13 (conv_i_src_c038_2_13 conv_i_c038_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_13 (conv_q_src_c038_2_13 0 conv_bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_2_13 (conv_q_src_c038_2_13 conv_q_c038_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_14 (conv_i_src_c038_2_14 0 conv_bpf_c038_2 0) vcvs gain=8.314696123025e-01
SCONVI_c038_2_14 (conv_i_src_c038_2_14 conv_i_c038_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_14 (conv_q_src_c038_2_14 0 conv_bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_2_14 (conv_q_src_c038_2_14 conv_q_c038_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_2_15 (conv_i_src_c038_2_15 0 conv_bpf_c038_2 0) vcvs gain=9.807852804032e-01
SCONVI_c038_2_15 (conv_i_src_c038_2_15 conv_i_c038_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_2_15 (conv_q_src_c038_2_15 0 conv_bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_2_15 (conv_q_src_c038_2_15 conv_q_c038_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c038_2 (conv_i_c038_2 0) resistor r=1G
RCONVQ_c038_2 (conv_q_c038_2 0) resistor r=1G
RCONVINTI_c038_2 (conv_i_c038_2 ConvIcar_c038_2) resistor r=1k
CCONVINTI_c038_2 (ConvIcar_c038_2 0) capacitor c=80p
RCONVINTQ_c038_2 (conv_q_c038_2 ConvQcar_c038_2) resistor r=1k
CCONVINTQ_c038_2 (ConvQcar_c038_2 0) capacitor c=80p
save conv_bpf_c038_2 ConvIcar_c038_2 ConvQcar_c038_2

// conventional mixed baseline bl038, carrier_3: 1000000000 Hz
CCONVBPF_c038_3 (bl038 n_conv_cbpf_c038_3) capacitor c=2.533029591058e-14
LCONVBPF_c038_3 (n_conv_cbpf_c038_3 conv_bpf_c038_3) inductor l=1.000000000000e-06
RCONVBPF_c038_3 (conv_bpf_c038_3 0) resistor r=3.141592653590e+02
ECONVI_c038_3_00 (conv_i_src_c038_3_00 0 conv_bpf_c038_3 0) vcvs gain=9.807852804032e-01
SCONVI_c038_3_00 (conv_i_src_c038_3_00 conv_i_c038_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_00 (conv_q_src_c038_3_00 0 conv_bpf_c038_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_3_00 (conv_q_src_c038_3_00 conv_q_c038_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_01 (conv_i_src_c038_3_01 0 conv_bpf_c038_3 0) vcvs gain=8.314696123025e-01
SCONVI_c038_3_01 (conv_i_src_c038_3_01 conv_i_c038_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_01 (conv_q_src_c038_3_01 0 conv_bpf_c038_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_3_01 (conv_q_src_c038_3_01 conv_q_c038_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_02 (conv_i_src_c038_3_02 0 conv_bpf_c038_3 0) vcvs gain=5.555702330196e-01
SCONVI_c038_3_02 (conv_i_src_c038_3_02 conv_i_c038_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_02 (conv_q_src_c038_3_02 0 conv_bpf_c038_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_3_02 (conv_q_src_c038_3_02 conv_q_c038_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_03 (conv_i_src_c038_3_03 0 conv_bpf_c038_3 0) vcvs gain=1.950903220161e-01
SCONVI_c038_3_03 (conv_i_src_c038_3_03 conv_i_c038_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_03 (conv_q_src_c038_3_03 0 conv_bpf_c038_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_3_03 (conv_q_src_c038_3_03 conv_q_c038_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_04 (conv_i_src_c038_3_04 0 conv_bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_3_04 (conv_i_src_c038_3_04 conv_i_c038_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_04 (conv_q_src_c038_3_04 0 conv_bpf_c038_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c038_3_04 (conv_q_src_c038_3_04 conv_q_c038_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_05 (conv_i_src_c038_3_05 0 conv_bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_3_05 (conv_i_src_c038_3_05 conv_i_c038_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_05 (conv_q_src_c038_3_05 0 conv_bpf_c038_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c038_3_05 (conv_q_src_c038_3_05 conv_q_c038_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_06 (conv_i_src_c038_3_06 0 conv_bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_3_06 (conv_i_src_c038_3_06 conv_i_c038_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_06 (conv_q_src_c038_3_06 0 conv_bpf_c038_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c038_3_06 (conv_q_src_c038_3_06 conv_q_c038_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_07 (conv_i_src_c038_3_07 0 conv_bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_3_07 (conv_i_src_c038_3_07 conv_i_c038_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_07 (conv_q_src_c038_3_07 0 conv_bpf_c038_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c038_3_07 (conv_q_src_c038_3_07 conv_q_c038_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_08 (conv_i_src_c038_3_08 0 conv_bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c038_3_08 (conv_i_src_c038_3_08 conv_i_c038_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_08 (conv_q_src_c038_3_08 0 conv_bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_3_08 (conv_q_src_c038_3_08 conv_q_c038_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_09 (conv_i_src_c038_3_09 0 conv_bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c038_3_09 (conv_i_src_c038_3_09 conv_i_c038_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_09 (conv_q_src_c038_3_09 0 conv_bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_3_09 (conv_q_src_c038_3_09 conv_q_c038_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_10 (conv_i_src_c038_3_10 0 conv_bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c038_3_10 (conv_i_src_c038_3_10 conv_i_c038_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_10 (conv_q_src_c038_3_10 0 conv_bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_3_10 (conv_q_src_c038_3_10 conv_q_c038_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_11 (conv_i_src_c038_3_11 0 conv_bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c038_3_11 (conv_i_src_c038_3_11 conv_i_c038_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_11 (conv_q_src_c038_3_11 0 conv_bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_3_11 (conv_q_src_c038_3_11 conv_q_c038_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_12 (conv_i_src_c038_3_12 0 conv_bpf_c038_3 0) vcvs gain=1.950903220161e-01
SCONVI_c038_3_12 (conv_i_src_c038_3_12 conv_i_c038_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_12 (conv_q_src_c038_3_12 0 conv_bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c038_3_12 (conv_q_src_c038_3_12 conv_q_c038_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_13 (conv_i_src_c038_3_13 0 conv_bpf_c038_3 0) vcvs gain=5.555702330196e-01
SCONVI_c038_3_13 (conv_i_src_c038_3_13 conv_i_c038_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_13 (conv_q_src_c038_3_13 0 conv_bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c038_3_13 (conv_q_src_c038_3_13 conv_q_c038_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_14 (conv_i_src_c038_3_14 0 conv_bpf_c038_3 0) vcvs gain=8.314696123025e-01
SCONVI_c038_3_14 (conv_i_src_c038_3_14 conv_i_c038_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_14 (conv_q_src_c038_3_14 0 conv_bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c038_3_14 (conv_q_src_c038_3_14 conv_q_c038_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c038_3_15 (conv_i_src_c038_3_15 0 conv_bpf_c038_3 0) vcvs gain=9.807852804032e-01
SCONVI_c038_3_15 (conv_i_src_c038_3_15 conv_i_c038_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c038_3_15 (conv_q_src_c038_3_15 0 conv_bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c038_3_15 (conv_q_src_c038_3_15 conv_q_c038_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c038_3 (conv_i_c038_3 0) resistor r=1G
RCONVQ_c038_3 (conv_q_c038_3 0) resistor r=1G
RCONVINTI_c038_3 (conv_i_c038_3 ConvIcar_c038_3) resistor r=1k
CCONVINTI_c038_3 (ConvIcar_c038_3 0) capacitor c=80p
RCONVINTQ_c038_3 (conv_q_c038_3 ConvQcar_c038_3) resistor r=1k
CCONVINTQ_c038_3 (ConvQcar_c038_3 0) capacitor c=80p
save conv_bpf_c038_3 ConvIcar_c038_3 ConvQcar_c038_3

// conventional mixed baseline bl039, carrier_0: 250000000 Hz
CCONVBPF_c039_0 (bl039 n_conv_cbpf_c039_0) capacitor c=4.052847345694e-13
LCONVBPF_c039_0 (n_conv_cbpf_c039_0 conv_bpf_c039_0) inductor l=1.000000000000e-06
RCONVBPF_c039_0 (conv_bpf_c039_0 0) resistor r=7.853981633974e+01
ECONVI_c039_0_00 (conv_i_src_c039_0_00 0 conv_bpf_c039_0 0) vcvs gain=9.807852804032e-01
SCONVI_c039_0_00 (conv_i_src_c039_0_00 conv_i_c039_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_00 (conv_q_src_c039_0_00 0 conv_bpf_c039_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_0_00 (conv_q_src_c039_0_00 conv_q_c039_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_01 (conv_i_src_c039_0_01 0 conv_bpf_c039_0 0) vcvs gain=8.314696123025e-01
SCONVI_c039_0_01 (conv_i_src_c039_0_01 conv_i_c039_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_01 (conv_q_src_c039_0_01 0 conv_bpf_c039_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_0_01 (conv_q_src_c039_0_01 conv_q_c039_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_02 (conv_i_src_c039_0_02 0 conv_bpf_c039_0 0) vcvs gain=5.555702330196e-01
SCONVI_c039_0_02 (conv_i_src_c039_0_02 conv_i_c039_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_02 (conv_q_src_c039_0_02 0 conv_bpf_c039_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_0_02 (conv_q_src_c039_0_02 conv_q_c039_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_03 (conv_i_src_c039_0_03 0 conv_bpf_c039_0 0) vcvs gain=1.950903220161e-01
SCONVI_c039_0_03 (conv_i_src_c039_0_03 conv_i_c039_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_03 (conv_q_src_c039_0_03 0 conv_bpf_c039_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_0_03 (conv_q_src_c039_0_03 conv_q_c039_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_04 (conv_i_src_c039_0_04 0 conv_bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c039_0_04 (conv_i_src_c039_0_04 conv_i_c039_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_04 (conv_q_src_c039_0_04 0 conv_bpf_c039_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c039_0_04 (conv_q_src_c039_0_04 conv_q_c039_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_05 (conv_i_src_c039_0_05 0 conv_bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c039_0_05 (conv_i_src_c039_0_05 conv_i_c039_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_05 (conv_q_src_c039_0_05 0 conv_bpf_c039_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c039_0_05 (conv_q_src_c039_0_05 conv_q_c039_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_06 (conv_i_src_c039_0_06 0 conv_bpf_c039_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c039_0_06 (conv_i_src_c039_0_06 conv_i_c039_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_06 (conv_q_src_c039_0_06 0 conv_bpf_c039_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c039_0_06 (conv_q_src_c039_0_06 conv_q_c039_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_07 (conv_i_src_c039_0_07 0 conv_bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_0_07 (conv_i_src_c039_0_07 conv_i_c039_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_07 (conv_q_src_c039_0_07 0 conv_bpf_c039_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c039_0_07 (conv_q_src_c039_0_07 conv_q_c039_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_08 (conv_i_src_c039_0_08 0 conv_bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c039_0_08 (conv_i_src_c039_0_08 conv_i_c039_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c039_0_08 (conv_q_src_c039_0_08 0 conv_bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c039_0_08 (conv_q_src_c039_0_08 conv_q_c039_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c039_0_09 (conv_i_src_c039_0_09 0 conv_bpf_c039_0 0) vcvs gain=-8.314696123025e-01
