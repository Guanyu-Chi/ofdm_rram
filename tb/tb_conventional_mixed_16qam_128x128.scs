// Matched conventional mixed 16-QAM read-path baseline testbench
// Same crossbar, carriers, BPFs, phase-window verification demodulator, and integration window.
simulator lang=spectre
include "../netlist/clean_128x128_crossbar.scs"

parameters rclosed_mix=1 ropen_mix=1G

VREFI_0 (conv_ref_i_0 0) vsource type=sine freq=250000000 ampl=1 phase=90
VREFQ_0 (conv_ref_q_0 0) vsource type=sine freq=250000000 ampl=1 phase=0
RREFI_0 (conv_ref_i_0 0) resistor r=1G
RREFQ_0 (conv_ref_q_0 0) resistor r=1G
VCONVWIN_0_00 (conv_win_0_00 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=0.000000000000e+00 rise=1p fall=1p
VCONVWIN_0_01 (conv_win_0_01 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=2.500000000000e-10 rise=1p fall=1p
VCONVWIN_0_02 (conv_win_0_02 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=5.000000000000e-10 rise=1p fall=1p
VCONVWIN_0_03 (conv_win_0_03 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=7.500000000000e-10 rise=1p fall=1p
VCONVWIN_0_04 (conv_win_0_04 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=1.000000000000e-09 rise=1p fall=1p
VCONVWIN_0_05 (conv_win_0_05 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=1.250000000000e-09 rise=1p fall=1p
VCONVWIN_0_06 (conv_win_0_06 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=1.500000000000e-09 rise=1p fall=1p
VCONVWIN_0_07 (conv_win_0_07 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=1.750000000000e-09 rise=1p fall=1p
VCONVWIN_0_08 (conv_win_0_08 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=2.000000000000e-09 rise=1p fall=1p
VCONVWIN_0_09 (conv_win_0_09 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=2.250000000000e-09 rise=1p fall=1p
VCONVWIN_0_10 (conv_win_0_10 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=2.500000000000e-09 rise=1p fall=1p
VCONVWIN_0_11 (conv_win_0_11 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=2.750000000000e-09 rise=1p fall=1p
VCONVWIN_0_12 (conv_win_0_12 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=3.000000000000e-09 rise=1p fall=1p
VCONVWIN_0_13 (conv_win_0_13 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=3.250000000000e-09 rise=1p fall=1p
VCONVWIN_0_14 (conv_win_0_14 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=3.500000000000e-09 rise=1p fall=1p
VCONVWIN_0_15 (conv_win_0_15 0) vsource type=pulse val0=-1 val1=1 period=4.000000000000e-09 width=2.500000000000e-10 delay=3.750000000000e-09 rise=1p fall=1p

VREFI_1 (conv_ref_i_1 0) vsource type=sine freq=500000000 ampl=1 phase=90
VREFQ_1 (conv_ref_q_1 0) vsource type=sine freq=500000000 ampl=1 phase=0
RREFI_1 (conv_ref_i_1 0) resistor r=1G
RREFQ_1 (conv_ref_q_1 0) resistor r=1G
VCONVWIN_1_00 (conv_win_1_00 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=0.000000000000e+00 rise=1p fall=1p
VCONVWIN_1_01 (conv_win_1_01 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.250000000000e-10 rise=1p fall=1p
VCONVWIN_1_02 (conv_win_1_02 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=2.500000000000e-10 rise=1p fall=1p
VCONVWIN_1_03 (conv_win_1_03 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=3.750000000000e-10 rise=1p fall=1p
VCONVWIN_1_04 (conv_win_1_04 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=5.000000000000e-10 rise=1p fall=1p
VCONVWIN_1_05 (conv_win_1_05 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=6.250000000000e-10 rise=1p fall=1p
VCONVWIN_1_06 (conv_win_1_06 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=7.500000000000e-10 rise=1p fall=1p
VCONVWIN_1_07 (conv_win_1_07 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=8.750000000000e-10 rise=1p fall=1p
VCONVWIN_1_08 (conv_win_1_08 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.000000000000e-09 rise=1p fall=1p
VCONVWIN_1_09 (conv_win_1_09 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.125000000000e-09 rise=1p fall=1p
VCONVWIN_1_10 (conv_win_1_10 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.250000000000e-09 rise=1p fall=1p
VCONVWIN_1_11 (conv_win_1_11 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.375000000000e-09 rise=1p fall=1p
VCONVWIN_1_12 (conv_win_1_12 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.500000000000e-09 rise=1p fall=1p
VCONVWIN_1_13 (conv_win_1_13 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.625000000000e-09 rise=1p fall=1p
VCONVWIN_1_14 (conv_win_1_14 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.750000000000e-09 rise=1p fall=1p
VCONVWIN_1_15 (conv_win_1_15 0) vsource type=pulse val0=-1 val1=1 period=2.000000000000e-09 width=1.250000000000e-10 delay=1.875000000000e-09 rise=1p fall=1p

VREFI_2 (conv_ref_i_2 0) vsource type=sine freq=750000000 ampl=1 phase=90
VREFQ_2 (conv_ref_q_2 0) vsource type=sine freq=750000000 ampl=1 phase=0
RREFI_2 (conv_ref_i_2 0) resistor r=1G
RREFQ_2 (conv_ref_q_2 0) resistor r=1G
VCONVWIN_2_00 (conv_win_2_00 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=0.000000000000e+00 rise=1p fall=1p
VCONVWIN_2_01 (conv_win_2_01 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=8.333333333333e-11 rise=1p fall=1p
VCONVWIN_2_02 (conv_win_2_02 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=1.666666666667e-10 rise=1p fall=1p
VCONVWIN_2_03 (conv_win_2_03 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=2.500000000000e-10 rise=1p fall=1p
VCONVWIN_2_04 (conv_win_2_04 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=3.333333333333e-10 rise=1p fall=1p
VCONVWIN_2_05 (conv_win_2_05 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=4.166666666667e-10 rise=1p fall=1p
VCONVWIN_2_06 (conv_win_2_06 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=5.000000000000e-10 rise=1p fall=1p
VCONVWIN_2_07 (conv_win_2_07 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=5.833333333333e-10 rise=1p fall=1p
VCONVWIN_2_08 (conv_win_2_08 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=6.666666666667e-10 rise=1p fall=1p
VCONVWIN_2_09 (conv_win_2_09 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=7.500000000000e-10 rise=1p fall=1p
VCONVWIN_2_10 (conv_win_2_10 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=8.333333333333e-10 rise=1p fall=1p
VCONVWIN_2_11 (conv_win_2_11 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=9.166666666667e-10 rise=1p fall=1p
VCONVWIN_2_12 (conv_win_2_12 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=1.000000000000e-09 rise=1p fall=1p
VCONVWIN_2_13 (conv_win_2_13 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=1.083333333333e-09 rise=1p fall=1p
VCONVWIN_2_14 (conv_win_2_14 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=1.166666666667e-09 rise=1p fall=1p
VCONVWIN_2_15 (conv_win_2_15 0) vsource type=pulse val0=-1 val1=1 period=1.333333333333e-09 width=8.333333333333e-11 delay=1.250000000000e-09 rise=1p fall=1p

VREFI_3 (conv_ref_i_3 0) vsource type=sine freq=1000000000 ampl=1 phase=90
VREFQ_3 (conv_ref_q_3 0) vsource type=sine freq=1000000000 ampl=1 phase=0
RREFI_3 (conv_ref_i_3 0) resistor r=1G
RREFQ_3 (conv_ref_q_3 0) resistor r=1G
VCONVWIN_3_00 (conv_win_3_00 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=0.000000000000e+00 rise=1p fall=1p
VCONVWIN_3_01 (conv_win_3_01 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=6.250000000000e-11 rise=1p fall=1p
VCONVWIN_3_02 (conv_win_3_02 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=1.250000000000e-10 rise=1p fall=1p
VCONVWIN_3_03 (conv_win_3_03 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=1.875000000000e-10 rise=1p fall=1p
VCONVWIN_3_04 (conv_win_3_04 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=2.500000000000e-10 rise=1p fall=1p
VCONVWIN_3_05 (conv_win_3_05 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=3.125000000000e-10 rise=1p fall=1p
VCONVWIN_3_06 (conv_win_3_06 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=3.750000000000e-10 rise=1p fall=1p
VCONVWIN_3_07 (conv_win_3_07 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=4.375000000000e-10 rise=1p fall=1p
VCONVWIN_3_08 (conv_win_3_08 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=5.000000000000e-10 rise=1p fall=1p
VCONVWIN_3_09 (conv_win_3_09 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=5.625000000000e-10 rise=1p fall=1p
VCONVWIN_3_10 (conv_win_3_10 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=6.250000000000e-10 rise=1p fall=1p
VCONVWIN_3_11 (conv_win_3_11 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=6.875000000000e-10 rise=1p fall=1p
VCONVWIN_3_12 (conv_win_3_12 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=7.500000000000e-10 rise=1p fall=1p
VCONVWIN_3_13 (conv_win_3_13 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=8.125000000000e-10 rise=1p fall=1p
VCONVWIN_3_14 (conv_win_3_14 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=8.750000000000e-10 rise=1p fall=1p
VCONVWIN_3_15 (conv_win_3_15 0) vsource type=pulse val0=-1 val1=1 period=1.000000000000e-09 width=6.250000000000e-11 delay=9.375000000000e-10 rise=1p fall=1p

// conventional mixed baseline bl000, carrier_0: 250000000 Hz
CCONVBPF_c000_0 (bl000 n_conv_cbpf_c000_0) capacitor c=4.052847345694e-13
LCONVBPF_c000_0 (n_conv_cbpf_c000_0 conv_bpf_c000_0) inductor l=1.000000000000e-06
RCONVBPF_c000_0 (conv_bpf_c000_0 0) resistor r=7.853981633974e+01
ECONVI_c000_0_00 (conv_i_src_c000_0_00 0 conv_bpf_c000_0 0) vcvs gain=9.807852804032e-01
SCONVI_c000_0_00 (conv_i_src_c000_0_00 conv_i_c000_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_00 (conv_q_src_c000_0_00 0 conv_bpf_c000_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_0_00 (conv_q_src_c000_0_00 conv_q_c000_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_01 (conv_i_src_c000_0_01 0 conv_bpf_c000_0 0) vcvs gain=8.314696123025e-01
SCONVI_c000_0_01 (conv_i_src_c000_0_01 conv_i_c000_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_01 (conv_q_src_c000_0_01 0 conv_bpf_c000_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_0_01 (conv_q_src_c000_0_01 conv_q_c000_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_02 (conv_i_src_c000_0_02 0 conv_bpf_c000_0 0) vcvs gain=5.555702330196e-01
SCONVI_c000_0_02 (conv_i_src_c000_0_02 conv_i_c000_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_02 (conv_q_src_c000_0_02 0 conv_bpf_c000_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_0_02 (conv_q_src_c000_0_02 conv_q_c000_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_03 (conv_i_src_c000_0_03 0 conv_bpf_c000_0 0) vcvs gain=1.950903220161e-01
SCONVI_c000_0_03 (conv_i_src_c000_0_03 conv_i_c000_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_03 (conv_q_src_c000_0_03 0 conv_bpf_c000_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_0_03 (conv_q_src_c000_0_03 conv_q_c000_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_04 (conv_i_src_c000_0_04 0 conv_bpf_c000_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_0_04 (conv_i_src_c000_0_04 conv_i_c000_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_04 (conv_q_src_c000_0_04 0 conv_bpf_c000_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_0_04 (conv_q_src_c000_0_04 conv_q_c000_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_05 (conv_i_src_c000_0_05 0 conv_bpf_c000_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_0_05 (conv_i_src_c000_0_05 conv_i_c000_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_05 (conv_q_src_c000_0_05 0 conv_bpf_c000_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_0_05 (conv_q_src_c000_0_05 conv_q_c000_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_06 (conv_i_src_c000_0_06 0 conv_bpf_c000_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_0_06 (conv_i_src_c000_0_06 conv_i_c000_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_06 (conv_q_src_c000_0_06 0 conv_bpf_c000_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_0_06 (conv_q_src_c000_0_06 conv_q_c000_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_07 (conv_i_src_c000_0_07 0 conv_bpf_c000_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_0_07 (conv_i_src_c000_0_07 conv_i_c000_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_07 (conv_q_src_c000_0_07 0 conv_bpf_c000_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_0_07 (conv_q_src_c000_0_07 conv_q_c000_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_08 (conv_i_src_c000_0_08 0 conv_bpf_c000_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_0_08 (conv_i_src_c000_0_08 conv_i_c000_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_08 (conv_q_src_c000_0_08 0 conv_bpf_c000_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_0_08 (conv_q_src_c000_0_08 conv_q_c000_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_09 (conv_i_src_c000_0_09 0 conv_bpf_c000_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_0_09 (conv_i_src_c000_0_09 conv_i_c000_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_09 (conv_q_src_c000_0_09 0 conv_bpf_c000_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_0_09 (conv_q_src_c000_0_09 conv_q_c000_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_10 (conv_i_src_c000_0_10 0 conv_bpf_c000_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_0_10 (conv_i_src_c000_0_10 conv_i_c000_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_10 (conv_q_src_c000_0_10 0 conv_bpf_c000_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_0_10 (conv_q_src_c000_0_10 conv_q_c000_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_11 (conv_i_src_c000_0_11 0 conv_bpf_c000_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_0_11 (conv_i_src_c000_0_11 conv_i_c000_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_11 (conv_q_src_c000_0_11 0 conv_bpf_c000_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_0_11 (conv_q_src_c000_0_11 conv_q_c000_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_12 (conv_i_src_c000_0_12 0 conv_bpf_c000_0 0) vcvs gain=1.950903220161e-01
SCONVI_c000_0_12 (conv_i_src_c000_0_12 conv_i_c000_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_12 (conv_q_src_c000_0_12 0 conv_bpf_c000_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_0_12 (conv_q_src_c000_0_12 conv_q_c000_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_13 (conv_i_src_c000_0_13 0 conv_bpf_c000_0 0) vcvs gain=5.555702330196e-01
SCONVI_c000_0_13 (conv_i_src_c000_0_13 conv_i_c000_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_13 (conv_q_src_c000_0_13 0 conv_bpf_c000_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_0_13 (conv_q_src_c000_0_13 conv_q_c000_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_14 (conv_i_src_c000_0_14 0 conv_bpf_c000_0 0) vcvs gain=8.314696123025e-01
SCONVI_c000_0_14 (conv_i_src_c000_0_14 conv_i_c000_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_14 (conv_q_src_c000_0_14 0 conv_bpf_c000_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_0_14 (conv_q_src_c000_0_14 conv_q_c000_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_0_15 (conv_i_src_c000_0_15 0 conv_bpf_c000_0 0) vcvs gain=9.807852804032e-01
SCONVI_c000_0_15 (conv_i_src_c000_0_15 conv_i_c000_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_0_15 (conv_q_src_c000_0_15 0 conv_bpf_c000_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_0_15 (conv_q_src_c000_0_15 conv_q_c000_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c000_0 (conv_i_c000_0 0) resistor r=1G
RCONVQ_c000_0 (conv_q_c000_0 0) resistor r=1G
RCONVINTI_c000_0 (conv_i_c000_0 ConvIcar_c000_0) resistor r=1k
CCONVINTI_c000_0 (ConvIcar_c000_0 0) capacitor c=80p
RCONVINTQ_c000_0 (conv_q_c000_0 ConvQcar_c000_0) resistor r=1k
CCONVINTQ_c000_0 (ConvQcar_c000_0 0) capacitor c=80p
save conv_bpf_c000_0 ConvIcar_c000_0 ConvQcar_c000_0

// conventional mixed baseline bl000, carrier_1: 500000000 Hz
CCONVBPF_c000_1 (bl000 n_conv_cbpf_c000_1) capacitor c=1.013211836423e-13
LCONVBPF_c000_1 (n_conv_cbpf_c000_1 conv_bpf_c000_1) inductor l=1.000000000000e-06
RCONVBPF_c000_1 (conv_bpf_c000_1 0) resistor r=1.570796326795e+02
ECONVI_c000_1_00 (conv_i_src_c000_1_00 0 conv_bpf_c000_1 0) vcvs gain=9.807852804032e-01
SCONVI_c000_1_00 (conv_i_src_c000_1_00 conv_i_c000_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_00 (conv_q_src_c000_1_00 0 conv_bpf_c000_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_1_00 (conv_q_src_c000_1_00 conv_q_c000_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_01 (conv_i_src_c000_1_01 0 conv_bpf_c000_1 0) vcvs gain=8.314696123025e-01
SCONVI_c000_1_01 (conv_i_src_c000_1_01 conv_i_c000_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_01 (conv_q_src_c000_1_01 0 conv_bpf_c000_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_1_01 (conv_q_src_c000_1_01 conv_q_c000_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_02 (conv_i_src_c000_1_02 0 conv_bpf_c000_1 0) vcvs gain=5.555702330196e-01
SCONVI_c000_1_02 (conv_i_src_c000_1_02 conv_i_c000_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_02 (conv_q_src_c000_1_02 0 conv_bpf_c000_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_1_02 (conv_q_src_c000_1_02 conv_q_c000_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_03 (conv_i_src_c000_1_03 0 conv_bpf_c000_1 0) vcvs gain=1.950903220161e-01
SCONVI_c000_1_03 (conv_i_src_c000_1_03 conv_i_c000_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_03 (conv_q_src_c000_1_03 0 conv_bpf_c000_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_1_03 (conv_q_src_c000_1_03 conv_q_c000_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_04 (conv_i_src_c000_1_04 0 conv_bpf_c000_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_1_04 (conv_i_src_c000_1_04 conv_i_c000_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_04 (conv_q_src_c000_1_04 0 conv_bpf_c000_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_1_04 (conv_q_src_c000_1_04 conv_q_c000_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_05 (conv_i_src_c000_1_05 0 conv_bpf_c000_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_1_05 (conv_i_src_c000_1_05 conv_i_c000_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_05 (conv_q_src_c000_1_05 0 conv_bpf_c000_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_1_05 (conv_q_src_c000_1_05 conv_q_c000_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_06 (conv_i_src_c000_1_06 0 conv_bpf_c000_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_1_06 (conv_i_src_c000_1_06 conv_i_c000_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_06 (conv_q_src_c000_1_06 0 conv_bpf_c000_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_1_06 (conv_q_src_c000_1_06 conv_q_c000_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_07 (conv_i_src_c000_1_07 0 conv_bpf_c000_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_1_07 (conv_i_src_c000_1_07 conv_i_c000_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_07 (conv_q_src_c000_1_07 0 conv_bpf_c000_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_1_07 (conv_q_src_c000_1_07 conv_q_c000_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_08 (conv_i_src_c000_1_08 0 conv_bpf_c000_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_1_08 (conv_i_src_c000_1_08 conv_i_c000_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_08 (conv_q_src_c000_1_08 0 conv_bpf_c000_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_1_08 (conv_q_src_c000_1_08 conv_q_c000_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_09 (conv_i_src_c000_1_09 0 conv_bpf_c000_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_1_09 (conv_i_src_c000_1_09 conv_i_c000_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_09 (conv_q_src_c000_1_09 0 conv_bpf_c000_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_1_09 (conv_q_src_c000_1_09 conv_q_c000_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_10 (conv_i_src_c000_1_10 0 conv_bpf_c000_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_1_10 (conv_i_src_c000_1_10 conv_i_c000_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_10 (conv_q_src_c000_1_10 0 conv_bpf_c000_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_1_10 (conv_q_src_c000_1_10 conv_q_c000_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_11 (conv_i_src_c000_1_11 0 conv_bpf_c000_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_1_11 (conv_i_src_c000_1_11 conv_i_c000_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_11 (conv_q_src_c000_1_11 0 conv_bpf_c000_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_1_11 (conv_q_src_c000_1_11 conv_q_c000_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_12 (conv_i_src_c000_1_12 0 conv_bpf_c000_1 0) vcvs gain=1.950903220161e-01
SCONVI_c000_1_12 (conv_i_src_c000_1_12 conv_i_c000_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_12 (conv_q_src_c000_1_12 0 conv_bpf_c000_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_1_12 (conv_q_src_c000_1_12 conv_q_c000_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_13 (conv_i_src_c000_1_13 0 conv_bpf_c000_1 0) vcvs gain=5.555702330196e-01
SCONVI_c000_1_13 (conv_i_src_c000_1_13 conv_i_c000_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_13 (conv_q_src_c000_1_13 0 conv_bpf_c000_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_1_13 (conv_q_src_c000_1_13 conv_q_c000_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_14 (conv_i_src_c000_1_14 0 conv_bpf_c000_1 0) vcvs gain=8.314696123025e-01
SCONVI_c000_1_14 (conv_i_src_c000_1_14 conv_i_c000_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_14 (conv_q_src_c000_1_14 0 conv_bpf_c000_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_1_14 (conv_q_src_c000_1_14 conv_q_c000_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_1_15 (conv_i_src_c000_1_15 0 conv_bpf_c000_1 0) vcvs gain=9.807852804032e-01
SCONVI_c000_1_15 (conv_i_src_c000_1_15 conv_i_c000_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_1_15 (conv_q_src_c000_1_15 0 conv_bpf_c000_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_1_15 (conv_q_src_c000_1_15 conv_q_c000_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c000_1 (conv_i_c000_1 0) resistor r=1G
RCONVQ_c000_1 (conv_q_c000_1 0) resistor r=1G
RCONVINTI_c000_1 (conv_i_c000_1 ConvIcar_c000_1) resistor r=1k
CCONVINTI_c000_1 (ConvIcar_c000_1 0) capacitor c=80p
RCONVINTQ_c000_1 (conv_q_c000_1 ConvQcar_c000_1) resistor r=1k
CCONVINTQ_c000_1 (ConvQcar_c000_1 0) capacitor c=80p
save conv_bpf_c000_1 ConvIcar_c000_1 ConvQcar_c000_1

// conventional mixed baseline bl000, carrier_2: 750000000 Hz
CCONVBPF_c000_2 (bl000 n_conv_cbpf_c000_2) capacitor c=4.503163717437e-14
LCONVBPF_c000_2 (n_conv_cbpf_c000_2 conv_bpf_c000_2) inductor l=1.000000000000e-06
RCONVBPF_c000_2 (conv_bpf_c000_2 0) resistor r=2.356194490192e+02
ECONVI_c000_2_00 (conv_i_src_c000_2_00 0 conv_bpf_c000_2 0) vcvs gain=9.807852804032e-01
SCONVI_c000_2_00 (conv_i_src_c000_2_00 conv_i_c000_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_00 (conv_q_src_c000_2_00 0 conv_bpf_c000_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_2_00 (conv_q_src_c000_2_00 conv_q_c000_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_01 (conv_i_src_c000_2_01 0 conv_bpf_c000_2 0) vcvs gain=8.314696123025e-01
SCONVI_c000_2_01 (conv_i_src_c000_2_01 conv_i_c000_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_01 (conv_q_src_c000_2_01 0 conv_bpf_c000_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_2_01 (conv_q_src_c000_2_01 conv_q_c000_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_02 (conv_i_src_c000_2_02 0 conv_bpf_c000_2 0) vcvs gain=5.555702330196e-01
SCONVI_c000_2_02 (conv_i_src_c000_2_02 conv_i_c000_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_02 (conv_q_src_c000_2_02 0 conv_bpf_c000_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_2_02 (conv_q_src_c000_2_02 conv_q_c000_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_03 (conv_i_src_c000_2_03 0 conv_bpf_c000_2 0) vcvs gain=1.950903220161e-01
SCONVI_c000_2_03 (conv_i_src_c000_2_03 conv_i_c000_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_03 (conv_q_src_c000_2_03 0 conv_bpf_c000_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_2_03 (conv_q_src_c000_2_03 conv_q_c000_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_04 (conv_i_src_c000_2_04 0 conv_bpf_c000_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_2_04 (conv_i_src_c000_2_04 conv_i_c000_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_04 (conv_q_src_c000_2_04 0 conv_bpf_c000_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_2_04 (conv_q_src_c000_2_04 conv_q_c000_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_05 (conv_i_src_c000_2_05 0 conv_bpf_c000_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_2_05 (conv_i_src_c000_2_05 conv_i_c000_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_05 (conv_q_src_c000_2_05 0 conv_bpf_c000_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_2_05 (conv_q_src_c000_2_05 conv_q_c000_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_06 (conv_i_src_c000_2_06 0 conv_bpf_c000_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_2_06 (conv_i_src_c000_2_06 conv_i_c000_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_06 (conv_q_src_c000_2_06 0 conv_bpf_c000_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_2_06 (conv_q_src_c000_2_06 conv_q_c000_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_07 (conv_i_src_c000_2_07 0 conv_bpf_c000_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_2_07 (conv_i_src_c000_2_07 conv_i_c000_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_07 (conv_q_src_c000_2_07 0 conv_bpf_c000_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_2_07 (conv_q_src_c000_2_07 conv_q_c000_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_08 (conv_i_src_c000_2_08 0 conv_bpf_c000_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_2_08 (conv_i_src_c000_2_08 conv_i_c000_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_08 (conv_q_src_c000_2_08 0 conv_bpf_c000_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_2_08 (conv_q_src_c000_2_08 conv_q_c000_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_09 (conv_i_src_c000_2_09 0 conv_bpf_c000_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_2_09 (conv_i_src_c000_2_09 conv_i_c000_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_09 (conv_q_src_c000_2_09 0 conv_bpf_c000_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_2_09 (conv_q_src_c000_2_09 conv_q_c000_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_10 (conv_i_src_c000_2_10 0 conv_bpf_c000_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_2_10 (conv_i_src_c000_2_10 conv_i_c000_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_10 (conv_q_src_c000_2_10 0 conv_bpf_c000_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_2_10 (conv_q_src_c000_2_10 conv_q_c000_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_11 (conv_i_src_c000_2_11 0 conv_bpf_c000_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_2_11 (conv_i_src_c000_2_11 conv_i_c000_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_11 (conv_q_src_c000_2_11 0 conv_bpf_c000_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_2_11 (conv_q_src_c000_2_11 conv_q_c000_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_12 (conv_i_src_c000_2_12 0 conv_bpf_c000_2 0) vcvs gain=1.950903220161e-01
SCONVI_c000_2_12 (conv_i_src_c000_2_12 conv_i_c000_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_12 (conv_q_src_c000_2_12 0 conv_bpf_c000_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_2_12 (conv_q_src_c000_2_12 conv_q_c000_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_13 (conv_i_src_c000_2_13 0 conv_bpf_c000_2 0) vcvs gain=5.555702330196e-01
SCONVI_c000_2_13 (conv_i_src_c000_2_13 conv_i_c000_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_13 (conv_q_src_c000_2_13 0 conv_bpf_c000_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_2_13 (conv_q_src_c000_2_13 conv_q_c000_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_14 (conv_i_src_c000_2_14 0 conv_bpf_c000_2 0) vcvs gain=8.314696123025e-01
SCONVI_c000_2_14 (conv_i_src_c000_2_14 conv_i_c000_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_14 (conv_q_src_c000_2_14 0 conv_bpf_c000_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_2_14 (conv_q_src_c000_2_14 conv_q_c000_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_2_15 (conv_i_src_c000_2_15 0 conv_bpf_c000_2 0) vcvs gain=9.807852804032e-01
SCONVI_c000_2_15 (conv_i_src_c000_2_15 conv_i_c000_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_2_15 (conv_q_src_c000_2_15 0 conv_bpf_c000_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_2_15 (conv_q_src_c000_2_15 conv_q_c000_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c000_2 (conv_i_c000_2 0) resistor r=1G
RCONVQ_c000_2 (conv_q_c000_2 0) resistor r=1G
RCONVINTI_c000_2 (conv_i_c000_2 ConvIcar_c000_2) resistor r=1k
CCONVINTI_c000_2 (ConvIcar_c000_2 0) capacitor c=80p
RCONVINTQ_c000_2 (conv_q_c000_2 ConvQcar_c000_2) resistor r=1k
CCONVINTQ_c000_2 (ConvQcar_c000_2 0) capacitor c=80p
save conv_bpf_c000_2 ConvIcar_c000_2 ConvQcar_c000_2

// conventional mixed baseline bl000, carrier_3: 1000000000 Hz
CCONVBPF_c000_3 (bl000 n_conv_cbpf_c000_3) capacitor c=2.533029591058e-14
LCONVBPF_c000_3 (n_conv_cbpf_c000_3 conv_bpf_c000_3) inductor l=1.000000000000e-06
RCONVBPF_c000_3 (conv_bpf_c000_3 0) resistor r=3.141592653590e+02
ECONVI_c000_3_00 (conv_i_src_c000_3_00 0 conv_bpf_c000_3 0) vcvs gain=9.807852804032e-01
SCONVI_c000_3_00 (conv_i_src_c000_3_00 conv_i_c000_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_00 (conv_q_src_c000_3_00 0 conv_bpf_c000_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_3_00 (conv_q_src_c000_3_00 conv_q_c000_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_01 (conv_i_src_c000_3_01 0 conv_bpf_c000_3 0) vcvs gain=8.314696123025e-01
SCONVI_c000_3_01 (conv_i_src_c000_3_01 conv_i_c000_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_01 (conv_q_src_c000_3_01 0 conv_bpf_c000_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_3_01 (conv_q_src_c000_3_01 conv_q_c000_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_02 (conv_i_src_c000_3_02 0 conv_bpf_c000_3 0) vcvs gain=5.555702330196e-01
SCONVI_c000_3_02 (conv_i_src_c000_3_02 conv_i_c000_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_02 (conv_q_src_c000_3_02 0 conv_bpf_c000_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_3_02 (conv_q_src_c000_3_02 conv_q_c000_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_03 (conv_i_src_c000_3_03 0 conv_bpf_c000_3 0) vcvs gain=1.950903220161e-01
SCONVI_c000_3_03 (conv_i_src_c000_3_03 conv_i_c000_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_03 (conv_q_src_c000_3_03 0 conv_bpf_c000_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_3_03 (conv_q_src_c000_3_03 conv_q_c000_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_04 (conv_i_src_c000_3_04 0 conv_bpf_c000_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_3_04 (conv_i_src_c000_3_04 conv_i_c000_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_04 (conv_q_src_c000_3_04 0 conv_bpf_c000_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c000_3_04 (conv_q_src_c000_3_04 conv_q_c000_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_05 (conv_i_src_c000_3_05 0 conv_bpf_c000_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_3_05 (conv_i_src_c000_3_05 conv_i_c000_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_05 (conv_q_src_c000_3_05 0 conv_bpf_c000_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c000_3_05 (conv_q_src_c000_3_05 conv_q_c000_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_06 (conv_i_src_c000_3_06 0 conv_bpf_c000_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_3_06 (conv_i_src_c000_3_06 conv_i_c000_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_06 (conv_q_src_c000_3_06 0 conv_bpf_c000_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c000_3_06 (conv_q_src_c000_3_06 conv_q_c000_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_07 (conv_i_src_c000_3_07 0 conv_bpf_c000_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_3_07 (conv_i_src_c000_3_07 conv_i_c000_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_07 (conv_q_src_c000_3_07 0 conv_bpf_c000_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c000_3_07 (conv_q_src_c000_3_07 conv_q_c000_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_08 (conv_i_src_c000_3_08 0 conv_bpf_c000_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c000_3_08 (conv_i_src_c000_3_08 conv_i_c000_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_08 (conv_q_src_c000_3_08 0 conv_bpf_c000_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_3_08 (conv_q_src_c000_3_08 conv_q_c000_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_09 (conv_i_src_c000_3_09 0 conv_bpf_c000_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c000_3_09 (conv_i_src_c000_3_09 conv_i_c000_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_09 (conv_q_src_c000_3_09 0 conv_bpf_c000_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_3_09 (conv_q_src_c000_3_09 conv_q_c000_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_10 (conv_i_src_c000_3_10 0 conv_bpf_c000_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c000_3_10 (conv_i_src_c000_3_10 conv_i_c000_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_10 (conv_q_src_c000_3_10 0 conv_bpf_c000_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_3_10 (conv_q_src_c000_3_10 conv_q_c000_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_11 (conv_i_src_c000_3_11 0 conv_bpf_c000_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c000_3_11 (conv_i_src_c000_3_11 conv_i_c000_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_11 (conv_q_src_c000_3_11 0 conv_bpf_c000_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_3_11 (conv_q_src_c000_3_11 conv_q_c000_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_12 (conv_i_src_c000_3_12 0 conv_bpf_c000_3 0) vcvs gain=1.950903220161e-01
SCONVI_c000_3_12 (conv_i_src_c000_3_12 conv_i_c000_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_12 (conv_q_src_c000_3_12 0 conv_bpf_c000_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c000_3_12 (conv_q_src_c000_3_12 conv_q_c000_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_13 (conv_i_src_c000_3_13 0 conv_bpf_c000_3 0) vcvs gain=5.555702330196e-01
SCONVI_c000_3_13 (conv_i_src_c000_3_13 conv_i_c000_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_13 (conv_q_src_c000_3_13 0 conv_bpf_c000_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c000_3_13 (conv_q_src_c000_3_13 conv_q_c000_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_14 (conv_i_src_c000_3_14 0 conv_bpf_c000_3 0) vcvs gain=8.314696123025e-01
SCONVI_c000_3_14 (conv_i_src_c000_3_14 conv_i_c000_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_14 (conv_q_src_c000_3_14 0 conv_bpf_c000_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c000_3_14 (conv_q_src_c000_3_14 conv_q_c000_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c000_3_15 (conv_i_src_c000_3_15 0 conv_bpf_c000_3 0) vcvs gain=9.807852804032e-01
SCONVI_c000_3_15 (conv_i_src_c000_3_15 conv_i_c000_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c000_3_15 (conv_q_src_c000_3_15 0 conv_bpf_c000_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c000_3_15 (conv_q_src_c000_3_15 conv_q_c000_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c000_3 (conv_i_c000_3 0) resistor r=1G
RCONVQ_c000_3 (conv_q_c000_3 0) resistor r=1G
RCONVINTI_c000_3 (conv_i_c000_3 ConvIcar_c000_3) resistor r=1k
CCONVINTI_c000_3 (ConvIcar_c000_3 0) capacitor c=80p
RCONVINTQ_c000_3 (conv_q_c000_3 ConvQcar_c000_3) resistor r=1k
CCONVINTQ_c000_3 (ConvQcar_c000_3 0) capacitor c=80p
save conv_bpf_c000_3 ConvIcar_c000_3 ConvQcar_c000_3

// conventional mixed baseline bl001, carrier_0: 250000000 Hz
CCONVBPF_c001_0 (bl001 n_conv_cbpf_c001_0) capacitor c=4.052847345694e-13
LCONVBPF_c001_0 (n_conv_cbpf_c001_0 conv_bpf_c001_0) inductor l=1.000000000000e-06
RCONVBPF_c001_0 (conv_bpf_c001_0 0) resistor r=7.853981633974e+01
ECONVI_c001_0_00 (conv_i_src_c001_0_00 0 conv_bpf_c001_0 0) vcvs gain=9.807852804032e-01
SCONVI_c001_0_00 (conv_i_src_c001_0_00 conv_i_c001_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_00 (conv_q_src_c001_0_00 0 conv_bpf_c001_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_0_00 (conv_q_src_c001_0_00 conv_q_c001_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_01 (conv_i_src_c001_0_01 0 conv_bpf_c001_0 0) vcvs gain=8.314696123025e-01
SCONVI_c001_0_01 (conv_i_src_c001_0_01 conv_i_c001_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_01 (conv_q_src_c001_0_01 0 conv_bpf_c001_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_0_01 (conv_q_src_c001_0_01 conv_q_c001_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_02 (conv_i_src_c001_0_02 0 conv_bpf_c001_0 0) vcvs gain=5.555702330196e-01
SCONVI_c001_0_02 (conv_i_src_c001_0_02 conv_i_c001_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_02 (conv_q_src_c001_0_02 0 conv_bpf_c001_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_0_02 (conv_q_src_c001_0_02 conv_q_c001_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_03 (conv_i_src_c001_0_03 0 conv_bpf_c001_0 0) vcvs gain=1.950903220161e-01
SCONVI_c001_0_03 (conv_i_src_c001_0_03 conv_i_c001_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_03 (conv_q_src_c001_0_03 0 conv_bpf_c001_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_0_03 (conv_q_src_c001_0_03 conv_q_c001_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_04 (conv_i_src_c001_0_04 0 conv_bpf_c001_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_0_04 (conv_i_src_c001_0_04 conv_i_c001_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_04 (conv_q_src_c001_0_04 0 conv_bpf_c001_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_0_04 (conv_q_src_c001_0_04 conv_q_c001_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_05 (conv_i_src_c001_0_05 0 conv_bpf_c001_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_0_05 (conv_i_src_c001_0_05 conv_i_c001_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_05 (conv_q_src_c001_0_05 0 conv_bpf_c001_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_0_05 (conv_q_src_c001_0_05 conv_q_c001_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_06 (conv_i_src_c001_0_06 0 conv_bpf_c001_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_0_06 (conv_i_src_c001_0_06 conv_i_c001_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_06 (conv_q_src_c001_0_06 0 conv_bpf_c001_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_0_06 (conv_q_src_c001_0_06 conv_q_c001_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_07 (conv_i_src_c001_0_07 0 conv_bpf_c001_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_0_07 (conv_i_src_c001_0_07 conv_i_c001_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_07 (conv_q_src_c001_0_07 0 conv_bpf_c001_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_0_07 (conv_q_src_c001_0_07 conv_q_c001_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_08 (conv_i_src_c001_0_08 0 conv_bpf_c001_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_0_08 (conv_i_src_c001_0_08 conv_i_c001_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_08 (conv_q_src_c001_0_08 0 conv_bpf_c001_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_0_08 (conv_q_src_c001_0_08 conv_q_c001_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_09 (conv_i_src_c001_0_09 0 conv_bpf_c001_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_0_09 (conv_i_src_c001_0_09 conv_i_c001_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_09 (conv_q_src_c001_0_09 0 conv_bpf_c001_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_0_09 (conv_q_src_c001_0_09 conv_q_c001_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_10 (conv_i_src_c001_0_10 0 conv_bpf_c001_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_0_10 (conv_i_src_c001_0_10 conv_i_c001_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_10 (conv_q_src_c001_0_10 0 conv_bpf_c001_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_0_10 (conv_q_src_c001_0_10 conv_q_c001_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_11 (conv_i_src_c001_0_11 0 conv_bpf_c001_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_0_11 (conv_i_src_c001_0_11 conv_i_c001_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_11 (conv_q_src_c001_0_11 0 conv_bpf_c001_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_0_11 (conv_q_src_c001_0_11 conv_q_c001_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_12 (conv_i_src_c001_0_12 0 conv_bpf_c001_0 0) vcvs gain=1.950903220161e-01
SCONVI_c001_0_12 (conv_i_src_c001_0_12 conv_i_c001_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_12 (conv_q_src_c001_0_12 0 conv_bpf_c001_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_0_12 (conv_q_src_c001_0_12 conv_q_c001_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_13 (conv_i_src_c001_0_13 0 conv_bpf_c001_0 0) vcvs gain=5.555702330196e-01
SCONVI_c001_0_13 (conv_i_src_c001_0_13 conv_i_c001_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_13 (conv_q_src_c001_0_13 0 conv_bpf_c001_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_0_13 (conv_q_src_c001_0_13 conv_q_c001_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_14 (conv_i_src_c001_0_14 0 conv_bpf_c001_0 0) vcvs gain=8.314696123025e-01
SCONVI_c001_0_14 (conv_i_src_c001_0_14 conv_i_c001_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_14 (conv_q_src_c001_0_14 0 conv_bpf_c001_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_0_14 (conv_q_src_c001_0_14 conv_q_c001_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_0_15 (conv_i_src_c001_0_15 0 conv_bpf_c001_0 0) vcvs gain=9.807852804032e-01
SCONVI_c001_0_15 (conv_i_src_c001_0_15 conv_i_c001_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_0_15 (conv_q_src_c001_0_15 0 conv_bpf_c001_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_0_15 (conv_q_src_c001_0_15 conv_q_c001_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c001_0 (conv_i_c001_0 0) resistor r=1G
RCONVQ_c001_0 (conv_q_c001_0 0) resistor r=1G
RCONVINTI_c001_0 (conv_i_c001_0 ConvIcar_c001_0) resistor r=1k
CCONVINTI_c001_0 (ConvIcar_c001_0 0) capacitor c=80p
RCONVINTQ_c001_0 (conv_q_c001_0 ConvQcar_c001_0) resistor r=1k
CCONVINTQ_c001_0 (ConvQcar_c001_0 0) capacitor c=80p
save conv_bpf_c001_0 ConvIcar_c001_0 ConvQcar_c001_0

// conventional mixed baseline bl001, carrier_1: 500000000 Hz
CCONVBPF_c001_1 (bl001 n_conv_cbpf_c001_1) capacitor c=1.013211836423e-13
LCONVBPF_c001_1 (n_conv_cbpf_c001_1 conv_bpf_c001_1) inductor l=1.000000000000e-06
RCONVBPF_c001_1 (conv_bpf_c001_1 0) resistor r=1.570796326795e+02
ECONVI_c001_1_00 (conv_i_src_c001_1_00 0 conv_bpf_c001_1 0) vcvs gain=9.807852804032e-01
SCONVI_c001_1_00 (conv_i_src_c001_1_00 conv_i_c001_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_00 (conv_q_src_c001_1_00 0 conv_bpf_c001_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_1_00 (conv_q_src_c001_1_00 conv_q_c001_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_01 (conv_i_src_c001_1_01 0 conv_bpf_c001_1 0) vcvs gain=8.314696123025e-01
SCONVI_c001_1_01 (conv_i_src_c001_1_01 conv_i_c001_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_01 (conv_q_src_c001_1_01 0 conv_bpf_c001_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_1_01 (conv_q_src_c001_1_01 conv_q_c001_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_02 (conv_i_src_c001_1_02 0 conv_bpf_c001_1 0) vcvs gain=5.555702330196e-01
SCONVI_c001_1_02 (conv_i_src_c001_1_02 conv_i_c001_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_02 (conv_q_src_c001_1_02 0 conv_bpf_c001_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_1_02 (conv_q_src_c001_1_02 conv_q_c001_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_03 (conv_i_src_c001_1_03 0 conv_bpf_c001_1 0) vcvs gain=1.950903220161e-01
SCONVI_c001_1_03 (conv_i_src_c001_1_03 conv_i_c001_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_03 (conv_q_src_c001_1_03 0 conv_bpf_c001_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_1_03 (conv_q_src_c001_1_03 conv_q_c001_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_04 (conv_i_src_c001_1_04 0 conv_bpf_c001_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_1_04 (conv_i_src_c001_1_04 conv_i_c001_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_04 (conv_q_src_c001_1_04 0 conv_bpf_c001_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_1_04 (conv_q_src_c001_1_04 conv_q_c001_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_05 (conv_i_src_c001_1_05 0 conv_bpf_c001_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_1_05 (conv_i_src_c001_1_05 conv_i_c001_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_05 (conv_q_src_c001_1_05 0 conv_bpf_c001_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_1_05 (conv_q_src_c001_1_05 conv_q_c001_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_06 (conv_i_src_c001_1_06 0 conv_bpf_c001_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_1_06 (conv_i_src_c001_1_06 conv_i_c001_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_06 (conv_q_src_c001_1_06 0 conv_bpf_c001_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_1_06 (conv_q_src_c001_1_06 conv_q_c001_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_07 (conv_i_src_c001_1_07 0 conv_bpf_c001_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_1_07 (conv_i_src_c001_1_07 conv_i_c001_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_07 (conv_q_src_c001_1_07 0 conv_bpf_c001_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_1_07 (conv_q_src_c001_1_07 conv_q_c001_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_08 (conv_i_src_c001_1_08 0 conv_bpf_c001_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_1_08 (conv_i_src_c001_1_08 conv_i_c001_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_08 (conv_q_src_c001_1_08 0 conv_bpf_c001_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_1_08 (conv_q_src_c001_1_08 conv_q_c001_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_09 (conv_i_src_c001_1_09 0 conv_bpf_c001_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_1_09 (conv_i_src_c001_1_09 conv_i_c001_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_09 (conv_q_src_c001_1_09 0 conv_bpf_c001_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_1_09 (conv_q_src_c001_1_09 conv_q_c001_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_10 (conv_i_src_c001_1_10 0 conv_bpf_c001_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_1_10 (conv_i_src_c001_1_10 conv_i_c001_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_10 (conv_q_src_c001_1_10 0 conv_bpf_c001_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_1_10 (conv_q_src_c001_1_10 conv_q_c001_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_11 (conv_i_src_c001_1_11 0 conv_bpf_c001_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_1_11 (conv_i_src_c001_1_11 conv_i_c001_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_11 (conv_q_src_c001_1_11 0 conv_bpf_c001_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_1_11 (conv_q_src_c001_1_11 conv_q_c001_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_12 (conv_i_src_c001_1_12 0 conv_bpf_c001_1 0) vcvs gain=1.950903220161e-01
SCONVI_c001_1_12 (conv_i_src_c001_1_12 conv_i_c001_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_12 (conv_q_src_c001_1_12 0 conv_bpf_c001_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_1_12 (conv_q_src_c001_1_12 conv_q_c001_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_13 (conv_i_src_c001_1_13 0 conv_bpf_c001_1 0) vcvs gain=5.555702330196e-01
SCONVI_c001_1_13 (conv_i_src_c001_1_13 conv_i_c001_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_13 (conv_q_src_c001_1_13 0 conv_bpf_c001_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_1_13 (conv_q_src_c001_1_13 conv_q_c001_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_14 (conv_i_src_c001_1_14 0 conv_bpf_c001_1 0) vcvs gain=8.314696123025e-01
SCONVI_c001_1_14 (conv_i_src_c001_1_14 conv_i_c001_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_14 (conv_q_src_c001_1_14 0 conv_bpf_c001_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_1_14 (conv_q_src_c001_1_14 conv_q_c001_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_1_15 (conv_i_src_c001_1_15 0 conv_bpf_c001_1 0) vcvs gain=9.807852804032e-01
SCONVI_c001_1_15 (conv_i_src_c001_1_15 conv_i_c001_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_1_15 (conv_q_src_c001_1_15 0 conv_bpf_c001_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_1_15 (conv_q_src_c001_1_15 conv_q_c001_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c001_1 (conv_i_c001_1 0) resistor r=1G
RCONVQ_c001_1 (conv_q_c001_1 0) resistor r=1G
RCONVINTI_c001_1 (conv_i_c001_1 ConvIcar_c001_1) resistor r=1k
CCONVINTI_c001_1 (ConvIcar_c001_1 0) capacitor c=80p
RCONVINTQ_c001_1 (conv_q_c001_1 ConvQcar_c001_1) resistor r=1k
CCONVINTQ_c001_1 (ConvQcar_c001_1 0) capacitor c=80p
save conv_bpf_c001_1 ConvIcar_c001_1 ConvQcar_c001_1

// conventional mixed baseline bl001, carrier_2: 750000000 Hz
CCONVBPF_c001_2 (bl001 n_conv_cbpf_c001_2) capacitor c=4.503163717437e-14
LCONVBPF_c001_2 (n_conv_cbpf_c001_2 conv_bpf_c001_2) inductor l=1.000000000000e-06
RCONVBPF_c001_2 (conv_bpf_c001_2 0) resistor r=2.356194490192e+02
ECONVI_c001_2_00 (conv_i_src_c001_2_00 0 conv_bpf_c001_2 0) vcvs gain=9.807852804032e-01
SCONVI_c001_2_00 (conv_i_src_c001_2_00 conv_i_c001_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_00 (conv_q_src_c001_2_00 0 conv_bpf_c001_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_2_00 (conv_q_src_c001_2_00 conv_q_c001_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_01 (conv_i_src_c001_2_01 0 conv_bpf_c001_2 0) vcvs gain=8.314696123025e-01
SCONVI_c001_2_01 (conv_i_src_c001_2_01 conv_i_c001_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_01 (conv_q_src_c001_2_01 0 conv_bpf_c001_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_2_01 (conv_q_src_c001_2_01 conv_q_c001_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_02 (conv_i_src_c001_2_02 0 conv_bpf_c001_2 0) vcvs gain=5.555702330196e-01
SCONVI_c001_2_02 (conv_i_src_c001_2_02 conv_i_c001_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_02 (conv_q_src_c001_2_02 0 conv_bpf_c001_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_2_02 (conv_q_src_c001_2_02 conv_q_c001_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_03 (conv_i_src_c001_2_03 0 conv_bpf_c001_2 0) vcvs gain=1.950903220161e-01
SCONVI_c001_2_03 (conv_i_src_c001_2_03 conv_i_c001_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_03 (conv_q_src_c001_2_03 0 conv_bpf_c001_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_2_03 (conv_q_src_c001_2_03 conv_q_c001_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_04 (conv_i_src_c001_2_04 0 conv_bpf_c001_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_2_04 (conv_i_src_c001_2_04 conv_i_c001_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_04 (conv_q_src_c001_2_04 0 conv_bpf_c001_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_2_04 (conv_q_src_c001_2_04 conv_q_c001_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_05 (conv_i_src_c001_2_05 0 conv_bpf_c001_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_2_05 (conv_i_src_c001_2_05 conv_i_c001_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_05 (conv_q_src_c001_2_05 0 conv_bpf_c001_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_2_05 (conv_q_src_c001_2_05 conv_q_c001_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_06 (conv_i_src_c001_2_06 0 conv_bpf_c001_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_2_06 (conv_i_src_c001_2_06 conv_i_c001_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_06 (conv_q_src_c001_2_06 0 conv_bpf_c001_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_2_06 (conv_q_src_c001_2_06 conv_q_c001_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_07 (conv_i_src_c001_2_07 0 conv_bpf_c001_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_2_07 (conv_i_src_c001_2_07 conv_i_c001_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_07 (conv_q_src_c001_2_07 0 conv_bpf_c001_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_2_07 (conv_q_src_c001_2_07 conv_q_c001_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_08 (conv_i_src_c001_2_08 0 conv_bpf_c001_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_2_08 (conv_i_src_c001_2_08 conv_i_c001_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_08 (conv_q_src_c001_2_08 0 conv_bpf_c001_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_2_08 (conv_q_src_c001_2_08 conv_q_c001_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_09 (conv_i_src_c001_2_09 0 conv_bpf_c001_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_2_09 (conv_i_src_c001_2_09 conv_i_c001_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_09 (conv_q_src_c001_2_09 0 conv_bpf_c001_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_2_09 (conv_q_src_c001_2_09 conv_q_c001_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_10 (conv_i_src_c001_2_10 0 conv_bpf_c001_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_2_10 (conv_i_src_c001_2_10 conv_i_c001_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_10 (conv_q_src_c001_2_10 0 conv_bpf_c001_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_2_10 (conv_q_src_c001_2_10 conv_q_c001_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_11 (conv_i_src_c001_2_11 0 conv_bpf_c001_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_2_11 (conv_i_src_c001_2_11 conv_i_c001_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_11 (conv_q_src_c001_2_11 0 conv_bpf_c001_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_2_11 (conv_q_src_c001_2_11 conv_q_c001_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_12 (conv_i_src_c001_2_12 0 conv_bpf_c001_2 0) vcvs gain=1.950903220161e-01
SCONVI_c001_2_12 (conv_i_src_c001_2_12 conv_i_c001_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_12 (conv_q_src_c001_2_12 0 conv_bpf_c001_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_2_12 (conv_q_src_c001_2_12 conv_q_c001_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_13 (conv_i_src_c001_2_13 0 conv_bpf_c001_2 0) vcvs gain=5.555702330196e-01
SCONVI_c001_2_13 (conv_i_src_c001_2_13 conv_i_c001_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_13 (conv_q_src_c001_2_13 0 conv_bpf_c001_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_2_13 (conv_q_src_c001_2_13 conv_q_c001_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_14 (conv_i_src_c001_2_14 0 conv_bpf_c001_2 0) vcvs gain=8.314696123025e-01
SCONVI_c001_2_14 (conv_i_src_c001_2_14 conv_i_c001_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_14 (conv_q_src_c001_2_14 0 conv_bpf_c001_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_2_14 (conv_q_src_c001_2_14 conv_q_c001_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_2_15 (conv_i_src_c001_2_15 0 conv_bpf_c001_2 0) vcvs gain=9.807852804032e-01
SCONVI_c001_2_15 (conv_i_src_c001_2_15 conv_i_c001_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_2_15 (conv_q_src_c001_2_15 0 conv_bpf_c001_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_2_15 (conv_q_src_c001_2_15 conv_q_c001_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c001_2 (conv_i_c001_2 0) resistor r=1G
RCONVQ_c001_2 (conv_q_c001_2 0) resistor r=1G
RCONVINTI_c001_2 (conv_i_c001_2 ConvIcar_c001_2) resistor r=1k
CCONVINTI_c001_2 (ConvIcar_c001_2 0) capacitor c=80p
RCONVINTQ_c001_2 (conv_q_c001_2 ConvQcar_c001_2) resistor r=1k
CCONVINTQ_c001_2 (ConvQcar_c001_2 0) capacitor c=80p
save conv_bpf_c001_2 ConvIcar_c001_2 ConvQcar_c001_2

// conventional mixed baseline bl001, carrier_3: 1000000000 Hz
CCONVBPF_c001_3 (bl001 n_conv_cbpf_c001_3) capacitor c=2.533029591058e-14
LCONVBPF_c001_3 (n_conv_cbpf_c001_3 conv_bpf_c001_3) inductor l=1.000000000000e-06
RCONVBPF_c001_3 (conv_bpf_c001_3 0) resistor r=3.141592653590e+02
ECONVI_c001_3_00 (conv_i_src_c001_3_00 0 conv_bpf_c001_3 0) vcvs gain=9.807852804032e-01
SCONVI_c001_3_00 (conv_i_src_c001_3_00 conv_i_c001_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_00 (conv_q_src_c001_3_00 0 conv_bpf_c001_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_3_00 (conv_q_src_c001_3_00 conv_q_c001_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_01 (conv_i_src_c001_3_01 0 conv_bpf_c001_3 0) vcvs gain=8.314696123025e-01
SCONVI_c001_3_01 (conv_i_src_c001_3_01 conv_i_c001_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_01 (conv_q_src_c001_3_01 0 conv_bpf_c001_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_3_01 (conv_q_src_c001_3_01 conv_q_c001_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_02 (conv_i_src_c001_3_02 0 conv_bpf_c001_3 0) vcvs gain=5.555702330196e-01
SCONVI_c001_3_02 (conv_i_src_c001_3_02 conv_i_c001_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_02 (conv_q_src_c001_3_02 0 conv_bpf_c001_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_3_02 (conv_q_src_c001_3_02 conv_q_c001_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_03 (conv_i_src_c001_3_03 0 conv_bpf_c001_3 0) vcvs gain=1.950903220161e-01
SCONVI_c001_3_03 (conv_i_src_c001_3_03 conv_i_c001_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_03 (conv_q_src_c001_3_03 0 conv_bpf_c001_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_3_03 (conv_q_src_c001_3_03 conv_q_c001_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_04 (conv_i_src_c001_3_04 0 conv_bpf_c001_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_3_04 (conv_i_src_c001_3_04 conv_i_c001_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_04 (conv_q_src_c001_3_04 0 conv_bpf_c001_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c001_3_04 (conv_q_src_c001_3_04 conv_q_c001_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_05 (conv_i_src_c001_3_05 0 conv_bpf_c001_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_3_05 (conv_i_src_c001_3_05 conv_i_c001_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_05 (conv_q_src_c001_3_05 0 conv_bpf_c001_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c001_3_05 (conv_q_src_c001_3_05 conv_q_c001_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_06 (conv_i_src_c001_3_06 0 conv_bpf_c001_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_3_06 (conv_i_src_c001_3_06 conv_i_c001_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_06 (conv_q_src_c001_3_06 0 conv_bpf_c001_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c001_3_06 (conv_q_src_c001_3_06 conv_q_c001_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_07 (conv_i_src_c001_3_07 0 conv_bpf_c001_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_3_07 (conv_i_src_c001_3_07 conv_i_c001_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_07 (conv_q_src_c001_3_07 0 conv_bpf_c001_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c001_3_07 (conv_q_src_c001_3_07 conv_q_c001_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_08 (conv_i_src_c001_3_08 0 conv_bpf_c001_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c001_3_08 (conv_i_src_c001_3_08 conv_i_c001_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_08 (conv_q_src_c001_3_08 0 conv_bpf_c001_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_3_08 (conv_q_src_c001_3_08 conv_q_c001_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_09 (conv_i_src_c001_3_09 0 conv_bpf_c001_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c001_3_09 (conv_i_src_c001_3_09 conv_i_c001_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_09 (conv_q_src_c001_3_09 0 conv_bpf_c001_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_3_09 (conv_q_src_c001_3_09 conv_q_c001_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_10 (conv_i_src_c001_3_10 0 conv_bpf_c001_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c001_3_10 (conv_i_src_c001_3_10 conv_i_c001_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_10 (conv_q_src_c001_3_10 0 conv_bpf_c001_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_3_10 (conv_q_src_c001_3_10 conv_q_c001_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_11 (conv_i_src_c001_3_11 0 conv_bpf_c001_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c001_3_11 (conv_i_src_c001_3_11 conv_i_c001_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_11 (conv_q_src_c001_3_11 0 conv_bpf_c001_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_3_11 (conv_q_src_c001_3_11 conv_q_c001_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_12 (conv_i_src_c001_3_12 0 conv_bpf_c001_3 0) vcvs gain=1.950903220161e-01
SCONVI_c001_3_12 (conv_i_src_c001_3_12 conv_i_c001_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_12 (conv_q_src_c001_3_12 0 conv_bpf_c001_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c001_3_12 (conv_q_src_c001_3_12 conv_q_c001_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_13 (conv_i_src_c001_3_13 0 conv_bpf_c001_3 0) vcvs gain=5.555702330196e-01
SCONVI_c001_3_13 (conv_i_src_c001_3_13 conv_i_c001_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_13 (conv_q_src_c001_3_13 0 conv_bpf_c001_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c001_3_13 (conv_q_src_c001_3_13 conv_q_c001_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_14 (conv_i_src_c001_3_14 0 conv_bpf_c001_3 0) vcvs gain=8.314696123025e-01
SCONVI_c001_3_14 (conv_i_src_c001_3_14 conv_i_c001_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_14 (conv_q_src_c001_3_14 0 conv_bpf_c001_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c001_3_14 (conv_q_src_c001_3_14 conv_q_c001_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c001_3_15 (conv_i_src_c001_3_15 0 conv_bpf_c001_3 0) vcvs gain=9.807852804032e-01
SCONVI_c001_3_15 (conv_i_src_c001_3_15 conv_i_c001_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c001_3_15 (conv_q_src_c001_3_15 0 conv_bpf_c001_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c001_3_15 (conv_q_src_c001_3_15 conv_q_c001_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c001_3 (conv_i_c001_3 0) resistor r=1G
RCONVQ_c001_3 (conv_q_c001_3 0) resistor r=1G
RCONVINTI_c001_3 (conv_i_c001_3 ConvIcar_c001_3) resistor r=1k
CCONVINTI_c001_3 (ConvIcar_c001_3 0) capacitor c=80p
RCONVINTQ_c001_3 (conv_q_c001_3 ConvQcar_c001_3) resistor r=1k
CCONVINTQ_c001_3 (ConvQcar_c001_3 0) capacitor c=80p
save conv_bpf_c001_3 ConvIcar_c001_3 ConvQcar_c001_3

// conventional mixed baseline bl002, carrier_0: 250000000 Hz
CCONVBPF_c002_0 (bl002 n_conv_cbpf_c002_0) capacitor c=4.052847345694e-13
LCONVBPF_c002_0 (n_conv_cbpf_c002_0 conv_bpf_c002_0) inductor l=1.000000000000e-06
RCONVBPF_c002_0 (conv_bpf_c002_0 0) resistor r=7.853981633974e+01
ECONVI_c002_0_00 (conv_i_src_c002_0_00 0 conv_bpf_c002_0 0) vcvs gain=9.807852804032e-01
SCONVI_c002_0_00 (conv_i_src_c002_0_00 conv_i_c002_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_00 (conv_q_src_c002_0_00 0 conv_bpf_c002_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_0_00 (conv_q_src_c002_0_00 conv_q_c002_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_01 (conv_i_src_c002_0_01 0 conv_bpf_c002_0 0) vcvs gain=8.314696123025e-01
SCONVI_c002_0_01 (conv_i_src_c002_0_01 conv_i_c002_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_01 (conv_q_src_c002_0_01 0 conv_bpf_c002_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_0_01 (conv_q_src_c002_0_01 conv_q_c002_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_02 (conv_i_src_c002_0_02 0 conv_bpf_c002_0 0) vcvs gain=5.555702330196e-01
SCONVI_c002_0_02 (conv_i_src_c002_0_02 conv_i_c002_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_02 (conv_q_src_c002_0_02 0 conv_bpf_c002_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_0_02 (conv_q_src_c002_0_02 conv_q_c002_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_03 (conv_i_src_c002_0_03 0 conv_bpf_c002_0 0) vcvs gain=1.950903220161e-01
SCONVI_c002_0_03 (conv_i_src_c002_0_03 conv_i_c002_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_03 (conv_q_src_c002_0_03 0 conv_bpf_c002_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_0_03 (conv_q_src_c002_0_03 conv_q_c002_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_04 (conv_i_src_c002_0_04 0 conv_bpf_c002_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_0_04 (conv_i_src_c002_0_04 conv_i_c002_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_04 (conv_q_src_c002_0_04 0 conv_bpf_c002_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_0_04 (conv_q_src_c002_0_04 conv_q_c002_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_05 (conv_i_src_c002_0_05 0 conv_bpf_c002_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_0_05 (conv_i_src_c002_0_05 conv_i_c002_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_05 (conv_q_src_c002_0_05 0 conv_bpf_c002_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_0_05 (conv_q_src_c002_0_05 conv_q_c002_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_06 (conv_i_src_c002_0_06 0 conv_bpf_c002_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_0_06 (conv_i_src_c002_0_06 conv_i_c002_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_06 (conv_q_src_c002_0_06 0 conv_bpf_c002_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_0_06 (conv_q_src_c002_0_06 conv_q_c002_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_07 (conv_i_src_c002_0_07 0 conv_bpf_c002_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_0_07 (conv_i_src_c002_0_07 conv_i_c002_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_07 (conv_q_src_c002_0_07 0 conv_bpf_c002_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_0_07 (conv_q_src_c002_0_07 conv_q_c002_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_08 (conv_i_src_c002_0_08 0 conv_bpf_c002_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_0_08 (conv_i_src_c002_0_08 conv_i_c002_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_08 (conv_q_src_c002_0_08 0 conv_bpf_c002_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_0_08 (conv_q_src_c002_0_08 conv_q_c002_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_09 (conv_i_src_c002_0_09 0 conv_bpf_c002_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_0_09 (conv_i_src_c002_0_09 conv_i_c002_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_09 (conv_q_src_c002_0_09 0 conv_bpf_c002_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_0_09 (conv_q_src_c002_0_09 conv_q_c002_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_10 (conv_i_src_c002_0_10 0 conv_bpf_c002_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_0_10 (conv_i_src_c002_0_10 conv_i_c002_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_10 (conv_q_src_c002_0_10 0 conv_bpf_c002_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_0_10 (conv_q_src_c002_0_10 conv_q_c002_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_11 (conv_i_src_c002_0_11 0 conv_bpf_c002_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_0_11 (conv_i_src_c002_0_11 conv_i_c002_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_11 (conv_q_src_c002_0_11 0 conv_bpf_c002_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_0_11 (conv_q_src_c002_0_11 conv_q_c002_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_12 (conv_i_src_c002_0_12 0 conv_bpf_c002_0 0) vcvs gain=1.950903220161e-01
SCONVI_c002_0_12 (conv_i_src_c002_0_12 conv_i_c002_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_12 (conv_q_src_c002_0_12 0 conv_bpf_c002_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_0_12 (conv_q_src_c002_0_12 conv_q_c002_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_13 (conv_i_src_c002_0_13 0 conv_bpf_c002_0 0) vcvs gain=5.555702330196e-01
SCONVI_c002_0_13 (conv_i_src_c002_0_13 conv_i_c002_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_13 (conv_q_src_c002_0_13 0 conv_bpf_c002_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_0_13 (conv_q_src_c002_0_13 conv_q_c002_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_14 (conv_i_src_c002_0_14 0 conv_bpf_c002_0 0) vcvs gain=8.314696123025e-01
SCONVI_c002_0_14 (conv_i_src_c002_0_14 conv_i_c002_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_14 (conv_q_src_c002_0_14 0 conv_bpf_c002_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_0_14 (conv_q_src_c002_0_14 conv_q_c002_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_0_15 (conv_i_src_c002_0_15 0 conv_bpf_c002_0 0) vcvs gain=9.807852804032e-01
SCONVI_c002_0_15 (conv_i_src_c002_0_15 conv_i_c002_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_0_15 (conv_q_src_c002_0_15 0 conv_bpf_c002_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_0_15 (conv_q_src_c002_0_15 conv_q_c002_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c002_0 (conv_i_c002_0 0) resistor r=1G
RCONVQ_c002_0 (conv_q_c002_0 0) resistor r=1G
RCONVINTI_c002_0 (conv_i_c002_0 ConvIcar_c002_0) resistor r=1k
CCONVINTI_c002_0 (ConvIcar_c002_0 0) capacitor c=80p
RCONVINTQ_c002_0 (conv_q_c002_0 ConvQcar_c002_0) resistor r=1k
CCONVINTQ_c002_0 (ConvQcar_c002_0 0) capacitor c=80p
save conv_bpf_c002_0 ConvIcar_c002_0 ConvQcar_c002_0

// conventional mixed baseline bl002, carrier_1: 500000000 Hz
CCONVBPF_c002_1 (bl002 n_conv_cbpf_c002_1) capacitor c=1.013211836423e-13
LCONVBPF_c002_1 (n_conv_cbpf_c002_1 conv_bpf_c002_1) inductor l=1.000000000000e-06
RCONVBPF_c002_1 (conv_bpf_c002_1 0) resistor r=1.570796326795e+02
ECONVI_c002_1_00 (conv_i_src_c002_1_00 0 conv_bpf_c002_1 0) vcvs gain=9.807852804032e-01
SCONVI_c002_1_00 (conv_i_src_c002_1_00 conv_i_c002_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_00 (conv_q_src_c002_1_00 0 conv_bpf_c002_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_1_00 (conv_q_src_c002_1_00 conv_q_c002_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_01 (conv_i_src_c002_1_01 0 conv_bpf_c002_1 0) vcvs gain=8.314696123025e-01
SCONVI_c002_1_01 (conv_i_src_c002_1_01 conv_i_c002_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_01 (conv_q_src_c002_1_01 0 conv_bpf_c002_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_1_01 (conv_q_src_c002_1_01 conv_q_c002_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_02 (conv_i_src_c002_1_02 0 conv_bpf_c002_1 0) vcvs gain=5.555702330196e-01
SCONVI_c002_1_02 (conv_i_src_c002_1_02 conv_i_c002_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_02 (conv_q_src_c002_1_02 0 conv_bpf_c002_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_1_02 (conv_q_src_c002_1_02 conv_q_c002_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_03 (conv_i_src_c002_1_03 0 conv_bpf_c002_1 0) vcvs gain=1.950903220161e-01
SCONVI_c002_1_03 (conv_i_src_c002_1_03 conv_i_c002_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_03 (conv_q_src_c002_1_03 0 conv_bpf_c002_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_1_03 (conv_q_src_c002_1_03 conv_q_c002_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_04 (conv_i_src_c002_1_04 0 conv_bpf_c002_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_1_04 (conv_i_src_c002_1_04 conv_i_c002_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_04 (conv_q_src_c002_1_04 0 conv_bpf_c002_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_1_04 (conv_q_src_c002_1_04 conv_q_c002_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_05 (conv_i_src_c002_1_05 0 conv_bpf_c002_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_1_05 (conv_i_src_c002_1_05 conv_i_c002_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_05 (conv_q_src_c002_1_05 0 conv_bpf_c002_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_1_05 (conv_q_src_c002_1_05 conv_q_c002_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_06 (conv_i_src_c002_1_06 0 conv_bpf_c002_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_1_06 (conv_i_src_c002_1_06 conv_i_c002_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_06 (conv_q_src_c002_1_06 0 conv_bpf_c002_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_1_06 (conv_q_src_c002_1_06 conv_q_c002_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_07 (conv_i_src_c002_1_07 0 conv_bpf_c002_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_1_07 (conv_i_src_c002_1_07 conv_i_c002_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_07 (conv_q_src_c002_1_07 0 conv_bpf_c002_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_1_07 (conv_q_src_c002_1_07 conv_q_c002_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_08 (conv_i_src_c002_1_08 0 conv_bpf_c002_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_1_08 (conv_i_src_c002_1_08 conv_i_c002_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_08 (conv_q_src_c002_1_08 0 conv_bpf_c002_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_1_08 (conv_q_src_c002_1_08 conv_q_c002_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_09 (conv_i_src_c002_1_09 0 conv_bpf_c002_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_1_09 (conv_i_src_c002_1_09 conv_i_c002_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_09 (conv_q_src_c002_1_09 0 conv_bpf_c002_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_1_09 (conv_q_src_c002_1_09 conv_q_c002_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_10 (conv_i_src_c002_1_10 0 conv_bpf_c002_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_1_10 (conv_i_src_c002_1_10 conv_i_c002_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_10 (conv_q_src_c002_1_10 0 conv_bpf_c002_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_1_10 (conv_q_src_c002_1_10 conv_q_c002_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_11 (conv_i_src_c002_1_11 0 conv_bpf_c002_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_1_11 (conv_i_src_c002_1_11 conv_i_c002_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_11 (conv_q_src_c002_1_11 0 conv_bpf_c002_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_1_11 (conv_q_src_c002_1_11 conv_q_c002_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_12 (conv_i_src_c002_1_12 0 conv_bpf_c002_1 0) vcvs gain=1.950903220161e-01
SCONVI_c002_1_12 (conv_i_src_c002_1_12 conv_i_c002_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_12 (conv_q_src_c002_1_12 0 conv_bpf_c002_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_1_12 (conv_q_src_c002_1_12 conv_q_c002_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_13 (conv_i_src_c002_1_13 0 conv_bpf_c002_1 0) vcvs gain=5.555702330196e-01
SCONVI_c002_1_13 (conv_i_src_c002_1_13 conv_i_c002_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_13 (conv_q_src_c002_1_13 0 conv_bpf_c002_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_1_13 (conv_q_src_c002_1_13 conv_q_c002_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_14 (conv_i_src_c002_1_14 0 conv_bpf_c002_1 0) vcvs gain=8.314696123025e-01
SCONVI_c002_1_14 (conv_i_src_c002_1_14 conv_i_c002_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_14 (conv_q_src_c002_1_14 0 conv_bpf_c002_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_1_14 (conv_q_src_c002_1_14 conv_q_c002_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_1_15 (conv_i_src_c002_1_15 0 conv_bpf_c002_1 0) vcvs gain=9.807852804032e-01
SCONVI_c002_1_15 (conv_i_src_c002_1_15 conv_i_c002_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_1_15 (conv_q_src_c002_1_15 0 conv_bpf_c002_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_1_15 (conv_q_src_c002_1_15 conv_q_c002_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c002_1 (conv_i_c002_1 0) resistor r=1G
RCONVQ_c002_1 (conv_q_c002_1 0) resistor r=1G
RCONVINTI_c002_1 (conv_i_c002_1 ConvIcar_c002_1) resistor r=1k
CCONVINTI_c002_1 (ConvIcar_c002_1 0) capacitor c=80p
RCONVINTQ_c002_1 (conv_q_c002_1 ConvQcar_c002_1) resistor r=1k
CCONVINTQ_c002_1 (ConvQcar_c002_1 0) capacitor c=80p
save conv_bpf_c002_1 ConvIcar_c002_1 ConvQcar_c002_1

// conventional mixed baseline bl002, carrier_2: 750000000 Hz
CCONVBPF_c002_2 (bl002 n_conv_cbpf_c002_2) capacitor c=4.503163717437e-14
LCONVBPF_c002_2 (n_conv_cbpf_c002_2 conv_bpf_c002_2) inductor l=1.000000000000e-06
RCONVBPF_c002_2 (conv_bpf_c002_2 0) resistor r=2.356194490192e+02
ECONVI_c002_2_00 (conv_i_src_c002_2_00 0 conv_bpf_c002_2 0) vcvs gain=9.807852804032e-01
SCONVI_c002_2_00 (conv_i_src_c002_2_00 conv_i_c002_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_00 (conv_q_src_c002_2_00 0 conv_bpf_c002_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_2_00 (conv_q_src_c002_2_00 conv_q_c002_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_01 (conv_i_src_c002_2_01 0 conv_bpf_c002_2 0) vcvs gain=8.314696123025e-01
SCONVI_c002_2_01 (conv_i_src_c002_2_01 conv_i_c002_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_01 (conv_q_src_c002_2_01 0 conv_bpf_c002_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_2_01 (conv_q_src_c002_2_01 conv_q_c002_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_02 (conv_i_src_c002_2_02 0 conv_bpf_c002_2 0) vcvs gain=5.555702330196e-01
SCONVI_c002_2_02 (conv_i_src_c002_2_02 conv_i_c002_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_02 (conv_q_src_c002_2_02 0 conv_bpf_c002_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_2_02 (conv_q_src_c002_2_02 conv_q_c002_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_03 (conv_i_src_c002_2_03 0 conv_bpf_c002_2 0) vcvs gain=1.950903220161e-01
SCONVI_c002_2_03 (conv_i_src_c002_2_03 conv_i_c002_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_03 (conv_q_src_c002_2_03 0 conv_bpf_c002_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_2_03 (conv_q_src_c002_2_03 conv_q_c002_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_04 (conv_i_src_c002_2_04 0 conv_bpf_c002_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_2_04 (conv_i_src_c002_2_04 conv_i_c002_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_04 (conv_q_src_c002_2_04 0 conv_bpf_c002_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_2_04 (conv_q_src_c002_2_04 conv_q_c002_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_05 (conv_i_src_c002_2_05 0 conv_bpf_c002_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_2_05 (conv_i_src_c002_2_05 conv_i_c002_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_05 (conv_q_src_c002_2_05 0 conv_bpf_c002_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_2_05 (conv_q_src_c002_2_05 conv_q_c002_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_06 (conv_i_src_c002_2_06 0 conv_bpf_c002_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_2_06 (conv_i_src_c002_2_06 conv_i_c002_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_06 (conv_q_src_c002_2_06 0 conv_bpf_c002_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_2_06 (conv_q_src_c002_2_06 conv_q_c002_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_07 (conv_i_src_c002_2_07 0 conv_bpf_c002_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_2_07 (conv_i_src_c002_2_07 conv_i_c002_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_07 (conv_q_src_c002_2_07 0 conv_bpf_c002_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_2_07 (conv_q_src_c002_2_07 conv_q_c002_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_08 (conv_i_src_c002_2_08 0 conv_bpf_c002_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_2_08 (conv_i_src_c002_2_08 conv_i_c002_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_08 (conv_q_src_c002_2_08 0 conv_bpf_c002_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_2_08 (conv_q_src_c002_2_08 conv_q_c002_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_09 (conv_i_src_c002_2_09 0 conv_bpf_c002_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_2_09 (conv_i_src_c002_2_09 conv_i_c002_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_09 (conv_q_src_c002_2_09 0 conv_bpf_c002_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_2_09 (conv_q_src_c002_2_09 conv_q_c002_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_10 (conv_i_src_c002_2_10 0 conv_bpf_c002_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_2_10 (conv_i_src_c002_2_10 conv_i_c002_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_10 (conv_q_src_c002_2_10 0 conv_bpf_c002_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_2_10 (conv_q_src_c002_2_10 conv_q_c002_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_11 (conv_i_src_c002_2_11 0 conv_bpf_c002_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_2_11 (conv_i_src_c002_2_11 conv_i_c002_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_11 (conv_q_src_c002_2_11 0 conv_bpf_c002_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_2_11 (conv_q_src_c002_2_11 conv_q_c002_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_12 (conv_i_src_c002_2_12 0 conv_bpf_c002_2 0) vcvs gain=1.950903220161e-01
SCONVI_c002_2_12 (conv_i_src_c002_2_12 conv_i_c002_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_12 (conv_q_src_c002_2_12 0 conv_bpf_c002_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_2_12 (conv_q_src_c002_2_12 conv_q_c002_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_13 (conv_i_src_c002_2_13 0 conv_bpf_c002_2 0) vcvs gain=5.555702330196e-01
SCONVI_c002_2_13 (conv_i_src_c002_2_13 conv_i_c002_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_13 (conv_q_src_c002_2_13 0 conv_bpf_c002_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_2_13 (conv_q_src_c002_2_13 conv_q_c002_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_14 (conv_i_src_c002_2_14 0 conv_bpf_c002_2 0) vcvs gain=8.314696123025e-01
SCONVI_c002_2_14 (conv_i_src_c002_2_14 conv_i_c002_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_14 (conv_q_src_c002_2_14 0 conv_bpf_c002_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_2_14 (conv_q_src_c002_2_14 conv_q_c002_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_2_15 (conv_i_src_c002_2_15 0 conv_bpf_c002_2 0) vcvs gain=9.807852804032e-01
SCONVI_c002_2_15 (conv_i_src_c002_2_15 conv_i_c002_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_2_15 (conv_q_src_c002_2_15 0 conv_bpf_c002_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_2_15 (conv_q_src_c002_2_15 conv_q_c002_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c002_2 (conv_i_c002_2 0) resistor r=1G
RCONVQ_c002_2 (conv_q_c002_2 0) resistor r=1G
RCONVINTI_c002_2 (conv_i_c002_2 ConvIcar_c002_2) resistor r=1k
CCONVINTI_c002_2 (ConvIcar_c002_2 0) capacitor c=80p
RCONVINTQ_c002_2 (conv_q_c002_2 ConvQcar_c002_2) resistor r=1k
CCONVINTQ_c002_2 (ConvQcar_c002_2 0) capacitor c=80p
save conv_bpf_c002_2 ConvIcar_c002_2 ConvQcar_c002_2

// conventional mixed baseline bl002, carrier_3: 1000000000 Hz
CCONVBPF_c002_3 (bl002 n_conv_cbpf_c002_3) capacitor c=2.533029591058e-14
LCONVBPF_c002_3 (n_conv_cbpf_c002_3 conv_bpf_c002_3) inductor l=1.000000000000e-06
RCONVBPF_c002_3 (conv_bpf_c002_3 0) resistor r=3.141592653590e+02
ECONVI_c002_3_00 (conv_i_src_c002_3_00 0 conv_bpf_c002_3 0) vcvs gain=9.807852804032e-01
SCONVI_c002_3_00 (conv_i_src_c002_3_00 conv_i_c002_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_00 (conv_q_src_c002_3_00 0 conv_bpf_c002_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_3_00 (conv_q_src_c002_3_00 conv_q_c002_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_01 (conv_i_src_c002_3_01 0 conv_bpf_c002_3 0) vcvs gain=8.314696123025e-01
SCONVI_c002_3_01 (conv_i_src_c002_3_01 conv_i_c002_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_01 (conv_q_src_c002_3_01 0 conv_bpf_c002_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_3_01 (conv_q_src_c002_3_01 conv_q_c002_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_02 (conv_i_src_c002_3_02 0 conv_bpf_c002_3 0) vcvs gain=5.555702330196e-01
SCONVI_c002_3_02 (conv_i_src_c002_3_02 conv_i_c002_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_02 (conv_q_src_c002_3_02 0 conv_bpf_c002_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_3_02 (conv_q_src_c002_3_02 conv_q_c002_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_03 (conv_i_src_c002_3_03 0 conv_bpf_c002_3 0) vcvs gain=1.950903220161e-01
SCONVI_c002_3_03 (conv_i_src_c002_3_03 conv_i_c002_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_03 (conv_q_src_c002_3_03 0 conv_bpf_c002_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_3_03 (conv_q_src_c002_3_03 conv_q_c002_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_04 (conv_i_src_c002_3_04 0 conv_bpf_c002_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_3_04 (conv_i_src_c002_3_04 conv_i_c002_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_04 (conv_q_src_c002_3_04 0 conv_bpf_c002_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c002_3_04 (conv_q_src_c002_3_04 conv_q_c002_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_05 (conv_i_src_c002_3_05 0 conv_bpf_c002_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_3_05 (conv_i_src_c002_3_05 conv_i_c002_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_05 (conv_q_src_c002_3_05 0 conv_bpf_c002_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c002_3_05 (conv_q_src_c002_3_05 conv_q_c002_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_06 (conv_i_src_c002_3_06 0 conv_bpf_c002_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_3_06 (conv_i_src_c002_3_06 conv_i_c002_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_06 (conv_q_src_c002_3_06 0 conv_bpf_c002_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c002_3_06 (conv_q_src_c002_3_06 conv_q_c002_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_07 (conv_i_src_c002_3_07 0 conv_bpf_c002_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_3_07 (conv_i_src_c002_3_07 conv_i_c002_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_07 (conv_q_src_c002_3_07 0 conv_bpf_c002_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c002_3_07 (conv_q_src_c002_3_07 conv_q_c002_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_08 (conv_i_src_c002_3_08 0 conv_bpf_c002_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c002_3_08 (conv_i_src_c002_3_08 conv_i_c002_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_08 (conv_q_src_c002_3_08 0 conv_bpf_c002_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_3_08 (conv_q_src_c002_3_08 conv_q_c002_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_09 (conv_i_src_c002_3_09 0 conv_bpf_c002_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c002_3_09 (conv_i_src_c002_3_09 conv_i_c002_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_09 (conv_q_src_c002_3_09 0 conv_bpf_c002_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_3_09 (conv_q_src_c002_3_09 conv_q_c002_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_10 (conv_i_src_c002_3_10 0 conv_bpf_c002_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c002_3_10 (conv_i_src_c002_3_10 conv_i_c002_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_10 (conv_q_src_c002_3_10 0 conv_bpf_c002_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_3_10 (conv_q_src_c002_3_10 conv_q_c002_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_11 (conv_i_src_c002_3_11 0 conv_bpf_c002_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c002_3_11 (conv_i_src_c002_3_11 conv_i_c002_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_11 (conv_q_src_c002_3_11 0 conv_bpf_c002_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_3_11 (conv_q_src_c002_3_11 conv_q_c002_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_12 (conv_i_src_c002_3_12 0 conv_bpf_c002_3 0) vcvs gain=1.950903220161e-01
SCONVI_c002_3_12 (conv_i_src_c002_3_12 conv_i_c002_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_12 (conv_q_src_c002_3_12 0 conv_bpf_c002_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c002_3_12 (conv_q_src_c002_3_12 conv_q_c002_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_13 (conv_i_src_c002_3_13 0 conv_bpf_c002_3 0) vcvs gain=5.555702330196e-01
SCONVI_c002_3_13 (conv_i_src_c002_3_13 conv_i_c002_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_13 (conv_q_src_c002_3_13 0 conv_bpf_c002_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c002_3_13 (conv_q_src_c002_3_13 conv_q_c002_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_14 (conv_i_src_c002_3_14 0 conv_bpf_c002_3 0) vcvs gain=8.314696123025e-01
SCONVI_c002_3_14 (conv_i_src_c002_3_14 conv_i_c002_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_14 (conv_q_src_c002_3_14 0 conv_bpf_c002_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c002_3_14 (conv_q_src_c002_3_14 conv_q_c002_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c002_3_15 (conv_i_src_c002_3_15 0 conv_bpf_c002_3 0) vcvs gain=9.807852804032e-01
SCONVI_c002_3_15 (conv_i_src_c002_3_15 conv_i_c002_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c002_3_15 (conv_q_src_c002_3_15 0 conv_bpf_c002_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c002_3_15 (conv_q_src_c002_3_15 conv_q_c002_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c002_3 (conv_i_c002_3 0) resistor r=1G
RCONVQ_c002_3 (conv_q_c002_3 0) resistor r=1G
RCONVINTI_c002_3 (conv_i_c002_3 ConvIcar_c002_3) resistor r=1k
CCONVINTI_c002_3 (ConvIcar_c002_3 0) capacitor c=80p
RCONVINTQ_c002_3 (conv_q_c002_3 ConvQcar_c002_3) resistor r=1k
CCONVINTQ_c002_3 (ConvQcar_c002_3 0) capacitor c=80p
save conv_bpf_c002_3 ConvIcar_c002_3 ConvQcar_c002_3

// conventional mixed baseline bl003, carrier_0: 250000000 Hz
CCONVBPF_c003_0 (bl003 n_conv_cbpf_c003_0) capacitor c=4.052847345694e-13
LCONVBPF_c003_0 (n_conv_cbpf_c003_0 conv_bpf_c003_0) inductor l=1.000000000000e-06
RCONVBPF_c003_0 (conv_bpf_c003_0 0) resistor r=7.853981633974e+01
ECONVI_c003_0_00 (conv_i_src_c003_0_00 0 conv_bpf_c003_0 0) vcvs gain=9.807852804032e-01
SCONVI_c003_0_00 (conv_i_src_c003_0_00 conv_i_c003_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_00 (conv_q_src_c003_0_00 0 conv_bpf_c003_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_0_00 (conv_q_src_c003_0_00 conv_q_c003_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_01 (conv_i_src_c003_0_01 0 conv_bpf_c003_0 0) vcvs gain=8.314696123025e-01
SCONVI_c003_0_01 (conv_i_src_c003_0_01 conv_i_c003_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_01 (conv_q_src_c003_0_01 0 conv_bpf_c003_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_0_01 (conv_q_src_c003_0_01 conv_q_c003_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_02 (conv_i_src_c003_0_02 0 conv_bpf_c003_0 0) vcvs gain=5.555702330196e-01
SCONVI_c003_0_02 (conv_i_src_c003_0_02 conv_i_c003_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_02 (conv_q_src_c003_0_02 0 conv_bpf_c003_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_0_02 (conv_q_src_c003_0_02 conv_q_c003_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_03 (conv_i_src_c003_0_03 0 conv_bpf_c003_0 0) vcvs gain=1.950903220161e-01
SCONVI_c003_0_03 (conv_i_src_c003_0_03 conv_i_c003_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_03 (conv_q_src_c003_0_03 0 conv_bpf_c003_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_0_03 (conv_q_src_c003_0_03 conv_q_c003_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_04 (conv_i_src_c003_0_04 0 conv_bpf_c003_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_0_04 (conv_i_src_c003_0_04 conv_i_c003_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_04 (conv_q_src_c003_0_04 0 conv_bpf_c003_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_0_04 (conv_q_src_c003_0_04 conv_q_c003_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_05 (conv_i_src_c003_0_05 0 conv_bpf_c003_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_0_05 (conv_i_src_c003_0_05 conv_i_c003_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_05 (conv_q_src_c003_0_05 0 conv_bpf_c003_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_0_05 (conv_q_src_c003_0_05 conv_q_c003_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_06 (conv_i_src_c003_0_06 0 conv_bpf_c003_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_0_06 (conv_i_src_c003_0_06 conv_i_c003_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_06 (conv_q_src_c003_0_06 0 conv_bpf_c003_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_0_06 (conv_q_src_c003_0_06 conv_q_c003_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_07 (conv_i_src_c003_0_07 0 conv_bpf_c003_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_0_07 (conv_i_src_c003_0_07 conv_i_c003_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_07 (conv_q_src_c003_0_07 0 conv_bpf_c003_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_0_07 (conv_q_src_c003_0_07 conv_q_c003_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_08 (conv_i_src_c003_0_08 0 conv_bpf_c003_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_0_08 (conv_i_src_c003_0_08 conv_i_c003_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_08 (conv_q_src_c003_0_08 0 conv_bpf_c003_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_0_08 (conv_q_src_c003_0_08 conv_q_c003_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_09 (conv_i_src_c003_0_09 0 conv_bpf_c003_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_0_09 (conv_i_src_c003_0_09 conv_i_c003_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_09 (conv_q_src_c003_0_09 0 conv_bpf_c003_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_0_09 (conv_q_src_c003_0_09 conv_q_c003_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_10 (conv_i_src_c003_0_10 0 conv_bpf_c003_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_0_10 (conv_i_src_c003_0_10 conv_i_c003_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_10 (conv_q_src_c003_0_10 0 conv_bpf_c003_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_0_10 (conv_q_src_c003_0_10 conv_q_c003_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_11 (conv_i_src_c003_0_11 0 conv_bpf_c003_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_0_11 (conv_i_src_c003_0_11 conv_i_c003_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_11 (conv_q_src_c003_0_11 0 conv_bpf_c003_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_0_11 (conv_q_src_c003_0_11 conv_q_c003_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_12 (conv_i_src_c003_0_12 0 conv_bpf_c003_0 0) vcvs gain=1.950903220161e-01
SCONVI_c003_0_12 (conv_i_src_c003_0_12 conv_i_c003_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_12 (conv_q_src_c003_0_12 0 conv_bpf_c003_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_0_12 (conv_q_src_c003_0_12 conv_q_c003_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_13 (conv_i_src_c003_0_13 0 conv_bpf_c003_0 0) vcvs gain=5.555702330196e-01
SCONVI_c003_0_13 (conv_i_src_c003_0_13 conv_i_c003_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_13 (conv_q_src_c003_0_13 0 conv_bpf_c003_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_0_13 (conv_q_src_c003_0_13 conv_q_c003_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_14 (conv_i_src_c003_0_14 0 conv_bpf_c003_0 0) vcvs gain=8.314696123025e-01
SCONVI_c003_0_14 (conv_i_src_c003_0_14 conv_i_c003_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_14 (conv_q_src_c003_0_14 0 conv_bpf_c003_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_0_14 (conv_q_src_c003_0_14 conv_q_c003_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_0_15 (conv_i_src_c003_0_15 0 conv_bpf_c003_0 0) vcvs gain=9.807852804032e-01
SCONVI_c003_0_15 (conv_i_src_c003_0_15 conv_i_c003_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_0_15 (conv_q_src_c003_0_15 0 conv_bpf_c003_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_0_15 (conv_q_src_c003_0_15 conv_q_c003_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c003_0 (conv_i_c003_0 0) resistor r=1G
RCONVQ_c003_0 (conv_q_c003_0 0) resistor r=1G
RCONVINTI_c003_0 (conv_i_c003_0 ConvIcar_c003_0) resistor r=1k
CCONVINTI_c003_0 (ConvIcar_c003_0 0) capacitor c=80p
RCONVINTQ_c003_0 (conv_q_c003_0 ConvQcar_c003_0) resistor r=1k
CCONVINTQ_c003_0 (ConvQcar_c003_0 0) capacitor c=80p
save conv_bpf_c003_0 ConvIcar_c003_0 ConvQcar_c003_0

// conventional mixed baseline bl003, carrier_1: 500000000 Hz
CCONVBPF_c003_1 (bl003 n_conv_cbpf_c003_1) capacitor c=1.013211836423e-13
LCONVBPF_c003_1 (n_conv_cbpf_c003_1 conv_bpf_c003_1) inductor l=1.000000000000e-06
RCONVBPF_c003_1 (conv_bpf_c003_1 0) resistor r=1.570796326795e+02
ECONVI_c003_1_00 (conv_i_src_c003_1_00 0 conv_bpf_c003_1 0) vcvs gain=9.807852804032e-01
SCONVI_c003_1_00 (conv_i_src_c003_1_00 conv_i_c003_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_00 (conv_q_src_c003_1_00 0 conv_bpf_c003_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_1_00 (conv_q_src_c003_1_00 conv_q_c003_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_01 (conv_i_src_c003_1_01 0 conv_bpf_c003_1 0) vcvs gain=8.314696123025e-01
SCONVI_c003_1_01 (conv_i_src_c003_1_01 conv_i_c003_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_01 (conv_q_src_c003_1_01 0 conv_bpf_c003_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_1_01 (conv_q_src_c003_1_01 conv_q_c003_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_02 (conv_i_src_c003_1_02 0 conv_bpf_c003_1 0) vcvs gain=5.555702330196e-01
SCONVI_c003_1_02 (conv_i_src_c003_1_02 conv_i_c003_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_02 (conv_q_src_c003_1_02 0 conv_bpf_c003_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_1_02 (conv_q_src_c003_1_02 conv_q_c003_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_03 (conv_i_src_c003_1_03 0 conv_bpf_c003_1 0) vcvs gain=1.950903220161e-01
SCONVI_c003_1_03 (conv_i_src_c003_1_03 conv_i_c003_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_03 (conv_q_src_c003_1_03 0 conv_bpf_c003_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_1_03 (conv_q_src_c003_1_03 conv_q_c003_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_04 (conv_i_src_c003_1_04 0 conv_bpf_c003_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_1_04 (conv_i_src_c003_1_04 conv_i_c003_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_04 (conv_q_src_c003_1_04 0 conv_bpf_c003_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_1_04 (conv_q_src_c003_1_04 conv_q_c003_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_05 (conv_i_src_c003_1_05 0 conv_bpf_c003_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_1_05 (conv_i_src_c003_1_05 conv_i_c003_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_05 (conv_q_src_c003_1_05 0 conv_bpf_c003_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_1_05 (conv_q_src_c003_1_05 conv_q_c003_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_06 (conv_i_src_c003_1_06 0 conv_bpf_c003_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_1_06 (conv_i_src_c003_1_06 conv_i_c003_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_06 (conv_q_src_c003_1_06 0 conv_bpf_c003_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_1_06 (conv_q_src_c003_1_06 conv_q_c003_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_07 (conv_i_src_c003_1_07 0 conv_bpf_c003_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_1_07 (conv_i_src_c003_1_07 conv_i_c003_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_07 (conv_q_src_c003_1_07 0 conv_bpf_c003_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_1_07 (conv_q_src_c003_1_07 conv_q_c003_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_08 (conv_i_src_c003_1_08 0 conv_bpf_c003_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_1_08 (conv_i_src_c003_1_08 conv_i_c003_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_08 (conv_q_src_c003_1_08 0 conv_bpf_c003_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_1_08 (conv_q_src_c003_1_08 conv_q_c003_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_09 (conv_i_src_c003_1_09 0 conv_bpf_c003_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_1_09 (conv_i_src_c003_1_09 conv_i_c003_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_09 (conv_q_src_c003_1_09 0 conv_bpf_c003_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_1_09 (conv_q_src_c003_1_09 conv_q_c003_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_10 (conv_i_src_c003_1_10 0 conv_bpf_c003_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_1_10 (conv_i_src_c003_1_10 conv_i_c003_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_10 (conv_q_src_c003_1_10 0 conv_bpf_c003_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_1_10 (conv_q_src_c003_1_10 conv_q_c003_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_11 (conv_i_src_c003_1_11 0 conv_bpf_c003_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_1_11 (conv_i_src_c003_1_11 conv_i_c003_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_11 (conv_q_src_c003_1_11 0 conv_bpf_c003_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_1_11 (conv_q_src_c003_1_11 conv_q_c003_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_12 (conv_i_src_c003_1_12 0 conv_bpf_c003_1 0) vcvs gain=1.950903220161e-01
SCONVI_c003_1_12 (conv_i_src_c003_1_12 conv_i_c003_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_12 (conv_q_src_c003_1_12 0 conv_bpf_c003_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_1_12 (conv_q_src_c003_1_12 conv_q_c003_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_13 (conv_i_src_c003_1_13 0 conv_bpf_c003_1 0) vcvs gain=5.555702330196e-01
SCONVI_c003_1_13 (conv_i_src_c003_1_13 conv_i_c003_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_13 (conv_q_src_c003_1_13 0 conv_bpf_c003_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_1_13 (conv_q_src_c003_1_13 conv_q_c003_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_14 (conv_i_src_c003_1_14 0 conv_bpf_c003_1 0) vcvs gain=8.314696123025e-01
SCONVI_c003_1_14 (conv_i_src_c003_1_14 conv_i_c003_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_14 (conv_q_src_c003_1_14 0 conv_bpf_c003_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_1_14 (conv_q_src_c003_1_14 conv_q_c003_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_1_15 (conv_i_src_c003_1_15 0 conv_bpf_c003_1 0) vcvs gain=9.807852804032e-01
SCONVI_c003_1_15 (conv_i_src_c003_1_15 conv_i_c003_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_1_15 (conv_q_src_c003_1_15 0 conv_bpf_c003_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_1_15 (conv_q_src_c003_1_15 conv_q_c003_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c003_1 (conv_i_c003_1 0) resistor r=1G
RCONVQ_c003_1 (conv_q_c003_1 0) resistor r=1G
RCONVINTI_c003_1 (conv_i_c003_1 ConvIcar_c003_1) resistor r=1k
CCONVINTI_c003_1 (ConvIcar_c003_1 0) capacitor c=80p
RCONVINTQ_c003_1 (conv_q_c003_1 ConvQcar_c003_1) resistor r=1k
CCONVINTQ_c003_1 (ConvQcar_c003_1 0) capacitor c=80p
save conv_bpf_c003_1 ConvIcar_c003_1 ConvQcar_c003_1

// conventional mixed baseline bl003, carrier_2: 750000000 Hz
CCONVBPF_c003_2 (bl003 n_conv_cbpf_c003_2) capacitor c=4.503163717437e-14
LCONVBPF_c003_2 (n_conv_cbpf_c003_2 conv_bpf_c003_2) inductor l=1.000000000000e-06
RCONVBPF_c003_2 (conv_bpf_c003_2 0) resistor r=2.356194490192e+02
ECONVI_c003_2_00 (conv_i_src_c003_2_00 0 conv_bpf_c003_2 0) vcvs gain=9.807852804032e-01
SCONVI_c003_2_00 (conv_i_src_c003_2_00 conv_i_c003_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_00 (conv_q_src_c003_2_00 0 conv_bpf_c003_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_2_00 (conv_q_src_c003_2_00 conv_q_c003_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_01 (conv_i_src_c003_2_01 0 conv_bpf_c003_2 0) vcvs gain=8.314696123025e-01
SCONVI_c003_2_01 (conv_i_src_c003_2_01 conv_i_c003_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_01 (conv_q_src_c003_2_01 0 conv_bpf_c003_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_2_01 (conv_q_src_c003_2_01 conv_q_c003_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_02 (conv_i_src_c003_2_02 0 conv_bpf_c003_2 0) vcvs gain=5.555702330196e-01
SCONVI_c003_2_02 (conv_i_src_c003_2_02 conv_i_c003_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_02 (conv_q_src_c003_2_02 0 conv_bpf_c003_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_2_02 (conv_q_src_c003_2_02 conv_q_c003_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_03 (conv_i_src_c003_2_03 0 conv_bpf_c003_2 0) vcvs gain=1.950903220161e-01
SCONVI_c003_2_03 (conv_i_src_c003_2_03 conv_i_c003_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_03 (conv_q_src_c003_2_03 0 conv_bpf_c003_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_2_03 (conv_q_src_c003_2_03 conv_q_c003_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_04 (conv_i_src_c003_2_04 0 conv_bpf_c003_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_2_04 (conv_i_src_c003_2_04 conv_i_c003_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_04 (conv_q_src_c003_2_04 0 conv_bpf_c003_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_2_04 (conv_q_src_c003_2_04 conv_q_c003_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_05 (conv_i_src_c003_2_05 0 conv_bpf_c003_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_2_05 (conv_i_src_c003_2_05 conv_i_c003_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_05 (conv_q_src_c003_2_05 0 conv_bpf_c003_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_2_05 (conv_q_src_c003_2_05 conv_q_c003_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_06 (conv_i_src_c003_2_06 0 conv_bpf_c003_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_2_06 (conv_i_src_c003_2_06 conv_i_c003_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_06 (conv_q_src_c003_2_06 0 conv_bpf_c003_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_2_06 (conv_q_src_c003_2_06 conv_q_c003_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_07 (conv_i_src_c003_2_07 0 conv_bpf_c003_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_2_07 (conv_i_src_c003_2_07 conv_i_c003_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_07 (conv_q_src_c003_2_07 0 conv_bpf_c003_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_2_07 (conv_q_src_c003_2_07 conv_q_c003_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_08 (conv_i_src_c003_2_08 0 conv_bpf_c003_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_2_08 (conv_i_src_c003_2_08 conv_i_c003_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_08 (conv_q_src_c003_2_08 0 conv_bpf_c003_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_2_08 (conv_q_src_c003_2_08 conv_q_c003_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_09 (conv_i_src_c003_2_09 0 conv_bpf_c003_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_2_09 (conv_i_src_c003_2_09 conv_i_c003_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_09 (conv_q_src_c003_2_09 0 conv_bpf_c003_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_2_09 (conv_q_src_c003_2_09 conv_q_c003_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_10 (conv_i_src_c003_2_10 0 conv_bpf_c003_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_2_10 (conv_i_src_c003_2_10 conv_i_c003_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_10 (conv_q_src_c003_2_10 0 conv_bpf_c003_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_2_10 (conv_q_src_c003_2_10 conv_q_c003_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_11 (conv_i_src_c003_2_11 0 conv_bpf_c003_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_2_11 (conv_i_src_c003_2_11 conv_i_c003_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_11 (conv_q_src_c003_2_11 0 conv_bpf_c003_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_2_11 (conv_q_src_c003_2_11 conv_q_c003_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_12 (conv_i_src_c003_2_12 0 conv_bpf_c003_2 0) vcvs gain=1.950903220161e-01
SCONVI_c003_2_12 (conv_i_src_c003_2_12 conv_i_c003_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_12 (conv_q_src_c003_2_12 0 conv_bpf_c003_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_2_12 (conv_q_src_c003_2_12 conv_q_c003_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_13 (conv_i_src_c003_2_13 0 conv_bpf_c003_2 0) vcvs gain=5.555702330196e-01
SCONVI_c003_2_13 (conv_i_src_c003_2_13 conv_i_c003_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_13 (conv_q_src_c003_2_13 0 conv_bpf_c003_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_2_13 (conv_q_src_c003_2_13 conv_q_c003_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_14 (conv_i_src_c003_2_14 0 conv_bpf_c003_2 0) vcvs gain=8.314696123025e-01
SCONVI_c003_2_14 (conv_i_src_c003_2_14 conv_i_c003_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_14 (conv_q_src_c003_2_14 0 conv_bpf_c003_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_2_14 (conv_q_src_c003_2_14 conv_q_c003_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_2_15 (conv_i_src_c003_2_15 0 conv_bpf_c003_2 0) vcvs gain=9.807852804032e-01
SCONVI_c003_2_15 (conv_i_src_c003_2_15 conv_i_c003_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_2_15 (conv_q_src_c003_2_15 0 conv_bpf_c003_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_2_15 (conv_q_src_c003_2_15 conv_q_c003_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c003_2 (conv_i_c003_2 0) resistor r=1G
RCONVQ_c003_2 (conv_q_c003_2 0) resistor r=1G
RCONVINTI_c003_2 (conv_i_c003_2 ConvIcar_c003_2) resistor r=1k
CCONVINTI_c003_2 (ConvIcar_c003_2 0) capacitor c=80p
RCONVINTQ_c003_2 (conv_q_c003_2 ConvQcar_c003_2) resistor r=1k
CCONVINTQ_c003_2 (ConvQcar_c003_2 0) capacitor c=80p
save conv_bpf_c003_2 ConvIcar_c003_2 ConvQcar_c003_2

// conventional mixed baseline bl003, carrier_3: 1000000000 Hz
CCONVBPF_c003_3 (bl003 n_conv_cbpf_c003_3) capacitor c=2.533029591058e-14
LCONVBPF_c003_3 (n_conv_cbpf_c003_3 conv_bpf_c003_3) inductor l=1.000000000000e-06
RCONVBPF_c003_3 (conv_bpf_c003_3 0) resistor r=3.141592653590e+02
ECONVI_c003_3_00 (conv_i_src_c003_3_00 0 conv_bpf_c003_3 0) vcvs gain=9.807852804032e-01
SCONVI_c003_3_00 (conv_i_src_c003_3_00 conv_i_c003_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_00 (conv_q_src_c003_3_00 0 conv_bpf_c003_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_3_00 (conv_q_src_c003_3_00 conv_q_c003_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_01 (conv_i_src_c003_3_01 0 conv_bpf_c003_3 0) vcvs gain=8.314696123025e-01
SCONVI_c003_3_01 (conv_i_src_c003_3_01 conv_i_c003_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_01 (conv_q_src_c003_3_01 0 conv_bpf_c003_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_3_01 (conv_q_src_c003_3_01 conv_q_c003_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_02 (conv_i_src_c003_3_02 0 conv_bpf_c003_3 0) vcvs gain=5.555702330196e-01
SCONVI_c003_3_02 (conv_i_src_c003_3_02 conv_i_c003_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_02 (conv_q_src_c003_3_02 0 conv_bpf_c003_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_3_02 (conv_q_src_c003_3_02 conv_q_c003_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_03 (conv_i_src_c003_3_03 0 conv_bpf_c003_3 0) vcvs gain=1.950903220161e-01
SCONVI_c003_3_03 (conv_i_src_c003_3_03 conv_i_c003_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_03 (conv_q_src_c003_3_03 0 conv_bpf_c003_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_3_03 (conv_q_src_c003_3_03 conv_q_c003_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_04 (conv_i_src_c003_3_04 0 conv_bpf_c003_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_3_04 (conv_i_src_c003_3_04 conv_i_c003_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_04 (conv_q_src_c003_3_04 0 conv_bpf_c003_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c003_3_04 (conv_q_src_c003_3_04 conv_q_c003_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_05 (conv_i_src_c003_3_05 0 conv_bpf_c003_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_3_05 (conv_i_src_c003_3_05 conv_i_c003_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_05 (conv_q_src_c003_3_05 0 conv_bpf_c003_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c003_3_05 (conv_q_src_c003_3_05 conv_q_c003_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_06 (conv_i_src_c003_3_06 0 conv_bpf_c003_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_3_06 (conv_i_src_c003_3_06 conv_i_c003_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_06 (conv_q_src_c003_3_06 0 conv_bpf_c003_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c003_3_06 (conv_q_src_c003_3_06 conv_q_c003_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_07 (conv_i_src_c003_3_07 0 conv_bpf_c003_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_3_07 (conv_i_src_c003_3_07 conv_i_c003_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_07 (conv_q_src_c003_3_07 0 conv_bpf_c003_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c003_3_07 (conv_q_src_c003_3_07 conv_q_c003_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_08 (conv_i_src_c003_3_08 0 conv_bpf_c003_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c003_3_08 (conv_i_src_c003_3_08 conv_i_c003_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_08 (conv_q_src_c003_3_08 0 conv_bpf_c003_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_3_08 (conv_q_src_c003_3_08 conv_q_c003_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_09 (conv_i_src_c003_3_09 0 conv_bpf_c003_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c003_3_09 (conv_i_src_c003_3_09 conv_i_c003_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_09 (conv_q_src_c003_3_09 0 conv_bpf_c003_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_3_09 (conv_q_src_c003_3_09 conv_q_c003_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_10 (conv_i_src_c003_3_10 0 conv_bpf_c003_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c003_3_10 (conv_i_src_c003_3_10 conv_i_c003_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_10 (conv_q_src_c003_3_10 0 conv_bpf_c003_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_3_10 (conv_q_src_c003_3_10 conv_q_c003_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_11 (conv_i_src_c003_3_11 0 conv_bpf_c003_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c003_3_11 (conv_i_src_c003_3_11 conv_i_c003_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_11 (conv_q_src_c003_3_11 0 conv_bpf_c003_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_3_11 (conv_q_src_c003_3_11 conv_q_c003_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_12 (conv_i_src_c003_3_12 0 conv_bpf_c003_3 0) vcvs gain=1.950903220161e-01
SCONVI_c003_3_12 (conv_i_src_c003_3_12 conv_i_c003_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_12 (conv_q_src_c003_3_12 0 conv_bpf_c003_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c003_3_12 (conv_q_src_c003_3_12 conv_q_c003_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_13 (conv_i_src_c003_3_13 0 conv_bpf_c003_3 0) vcvs gain=5.555702330196e-01
SCONVI_c003_3_13 (conv_i_src_c003_3_13 conv_i_c003_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_13 (conv_q_src_c003_3_13 0 conv_bpf_c003_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c003_3_13 (conv_q_src_c003_3_13 conv_q_c003_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_14 (conv_i_src_c003_3_14 0 conv_bpf_c003_3 0) vcvs gain=8.314696123025e-01
SCONVI_c003_3_14 (conv_i_src_c003_3_14 conv_i_c003_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_14 (conv_q_src_c003_3_14 0 conv_bpf_c003_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c003_3_14 (conv_q_src_c003_3_14 conv_q_c003_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c003_3_15 (conv_i_src_c003_3_15 0 conv_bpf_c003_3 0) vcvs gain=9.807852804032e-01
SCONVI_c003_3_15 (conv_i_src_c003_3_15 conv_i_c003_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c003_3_15 (conv_q_src_c003_3_15 0 conv_bpf_c003_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c003_3_15 (conv_q_src_c003_3_15 conv_q_c003_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c003_3 (conv_i_c003_3 0) resistor r=1G
RCONVQ_c003_3 (conv_q_c003_3 0) resistor r=1G
RCONVINTI_c003_3 (conv_i_c003_3 ConvIcar_c003_3) resistor r=1k
CCONVINTI_c003_3 (ConvIcar_c003_3 0) capacitor c=80p
RCONVINTQ_c003_3 (conv_q_c003_3 ConvQcar_c003_3) resistor r=1k
CCONVINTQ_c003_3 (ConvQcar_c003_3 0) capacitor c=80p
save conv_bpf_c003_3 ConvIcar_c003_3 ConvQcar_c003_3

// conventional mixed baseline bl004, carrier_0: 250000000 Hz
CCONVBPF_c004_0 (bl004 n_conv_cbpf_c004_0) capacitor c=4.052847345694e-13
LCONVBPF_c004_0 (n_conv_cbpf_c004_0 conv_bpf_c004_0) inductor l=1.000000000000e-06
RCONVBPF_c004_0 (conv_bpf_c004_0 0) resistor r=7.853981633974e+01
ECONVI_c004_0_00 (conv_i_src_c004_0_00 0 conv_bpf_c004_0 0) vcvs gain=9.807852804032e-01
SCONVI_c004_0_00 (conv_i_src_c004_0_00 conv_i_c004_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_00 (conv_q_src_c004_0_00 0 conv_bpf_c004_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_0_00 (conv_q_src_c004_0_00 conv_q_c004_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_01 (conv_i_src_c004_0_01 0 conv_bpf_c004_0 0) vcvs gain=8.314696123025e-01
SCONVI_c004_0_01 (conv_i_src_c004_0_01 conv_i_c004_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_01 (conv_q_src_c004_0_01 0 conv_bpf_c004_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_0_01 (conv_q_src_c004_0_01 conv_q_c004_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_02 (conv_i_src_c004_0_02 0 conv_bpf_c004_0 0) vcvs gain=5.555702330196e-01
SCONVI_c004_0_02 (conv_i_src_c004_0_02 conv_i_c004_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_02 (conv_q_src_c004_0_02 0 conv_bpf_c004_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_0_02 (conv_q_src_c004_0_02 conv_q_c004_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_03 (conv_i_src_c004_0_03 0 conv_bpf_c004_0 0) vcvs gain=1.950903220161e-01
SCONVI_c004_0_03 (conv_i_src_c004_0_03 conv_i_c004_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_03 (conv_q_src_c004_0_03 0 conv_bpf_c004_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_0_03 (conv_q_src_c004_0_03 conv_q_c004_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_04 (conv_i_src_c004_0_04 0 conv_bpf_c004_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_0_04 (conv_i_src_c004_0_04 conv_i_c004_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_04 (conv_q_src_c004_0_04 0 conv_bpf_c004_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_0_04 (conv_q_src_c004_0_04 conv_q_c004_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_05 (conv_i_src_c004_0_05 0 conv_bpf_c004_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_0_05 (conv_i_src_c004_0_05 conv_i_c004_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_05 (conv_q_src_c004_0_05 0 conv_bpf_c004_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_0_05 (conv_q_src_c004_0_05 conv_q_c004_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_06 (conv_i_src_c004_0_06 0 conv_bpf_c004_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_0_06 (conv_i_src_c004_0_06 conv_i_c004_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_06 (conv_q_src_c004_0_06 0 conv_bpf_c004_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_0_06 (conv_q_src_c004_0_06 conv_q_c004_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_07 (conv_i_src_c004_0_07 0 conv_bpf_c004_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_0_07 (conv_i_src_c004_0_07 conv_i_c004_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_07 (conv_q_src_c004_0_07 0 conv_bpf_c004_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_0_07 (conv_q_src_c004_0_07 conv_q_c004_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_08 (conv_i_src_c004_0_08 0 conv_bpf_c004_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_0_08 (conv_i_src_c004_0_08 conv_i_c004_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_08 (conv_q_src_c004_0_08 0 conv_bpf_c004_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_0_08 (conv_q_src_c004_0_08 conv_q_c004_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_09 (conv_i_src_c004_0_09 0 conv_bpf_c004_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_0_09 (conv_i_src_c004_0_09 conv_i_c004_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_09 (conv_q_src_c004_0_09 0 conv_bpf_c004_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_0_09 (conv_q_src_c004_0_09 conv_q_c004_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_10 (conv_i_src_c004_0_10 0 conv_bpf_c004_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_0_10 (conv_i_src_c004_0_10 conv_i_c004_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_10 (conv_q_src_c004_0_10 0 conv_bpf_c004_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_0_10 (conv_q_src_c004_0_10 conv_q_c004_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_11 (conv_i_src_c004_0_11 0 conv_bpf_c004_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_0_11 (conv_i_src_c004_0_11 conv_i_c004_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_11 (conv_q_src_c004_0_11 0 conv_bpf_c004_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_0_11 (conv_q_src_c004_0_11 conv_q_c004_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_12 (conv_i_src_c004_0_12 0 conv_bpf_c004_0 0) vcvs gain=1.950903220161e-01
SCONVI_c004_0_12 (conv_i_src_c004_0_12 conv_i_c004_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_12 (conv_q_src_c004_0_12 0 conv_bpf_c004_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_0_12 (conv_q_src_c004_0_12 conv_q_c004_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_13 (conv_i_src_c004_0_13 0 conv_bpf_c004_0 0) vcvs gain=5.555702330196e-01
SCONVI_c004_0_13 (conv_i_src_c004_0_13 conv_i_c004_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_13 (conv_q_src_c004_0_13 0 conv_bpf_c004_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_0_13 (conv_q_src_c004_0_13 conv_q_c004_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_14 (conv_i_src_c004_0_14 0 conv_bpf_c004_0 0) vcvs gain=8.314696123025e-01
SCONVI_c004_0_14 (conv_i_src_c004_0_14 conv_i_c004_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_14 (conv_q_src_c004_0_14 0 conv_bpf_c004_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_0_14 (conv_q_src_c004_0_14 conv_q_c004_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_0_15 (conv_i_src_c004_0_15 0 conv_bpf_c004_0 0) vcvs gain=9.807852804032e-01
SCONVI_c004_0_15 (conv_i_src_c004_0_15 conv_i_c004_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_0_15 (conv_q_src_c004_0_15 0 conv_bpf_c004_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_0_15 (conv_q_src_c004_0_15 conv_q_c004_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c004_0 (conv_i_c004_0 0) resistor r=1G
RCONVQ_c004_0 (conv_q_c004_0 0) resistor r=1G
RCONVINTI_c004_0 (conv_i_c004_0 ConvIcar_c004_0) resistor r=1k
CCONVINTI_c004_0 (ConvIcar_c004_0 0) capacitor c=80p
RCONVINTQ_c004_0 (conv_q_c004_0 ConvQcar_c004_0) resistor r=1k
CCONVINTQ_c004_0 (ConvQcar_c004_0 0) capacitor c=80p
save conv_bpf_c004_0 ConvIcar_c004_0 ConvQcar_c004_0

// conventional mixed baseline bl004, carrier_1: 500000000 Hz
CCONVBPF_c004_1 (bl004 n_conv_cbpf_c004_1) capacitor c=1.013211836423e-13
LCONVBPF_c004_1 (n_conv_cbpf_c004_1 conv_bpf_c004_1) inductor l=1.000000000000e-06
RCONVBPF_c004_1 (conv_bpf_c004_1 0) resistor r=1.570796326795e+02
ECONVI_c004_1_00 (conv_i_src_c004_1_00 0 conv_bpf_c004_1 0) vcvs gain=9.807852804032e-01
SCONVI_c004_1_00 (conv_i_src_c004_1_00 conv_i_c004_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_00 (conv_q_src_c004_1_00 0 conv_bpf_c004_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_1_00 (conv_q_src_c004_1_00 conv_q_c004_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_01 (conv_i_src_c004_1_01 0 conv_bpf_c004_1 0) vcvs gain=8.314696123025e-01
SCONVI_c004_1_01 (conv_i_src_c004_1_01 conv_i_c004_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_01 (conv_q_src_c004_1_01 0 conv_bpf_c004_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_1_01 (conv_q_src_c004_1_01 conv_q_c004_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_02 (conv_i_src_c004_1_02 0 conv_bpf_c004_1 0) vcvs gain=5.555702330196e-01
SCONVI_c004_1_02 (conv_i_src_c004_1_02 conv_i_c004_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_02 (conv_q_src_c004_1_02 0 conv_bpf_c004_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_1_02 (conv_q_src_c004_1_02 conv_q_c004_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_03 (conv_i_src_c004_1_03 0 conv_bpf_c004_1 0) vcvs gain=1.950903220161e-01
SCONVI_c004_1_03 (conv_i_src_c004_1_03 conv_i_c004_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_03 (conv_q_src_c004_1_03 0 conv_bpf_c004_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_1_03 (conv_q_src_c004_1_03 conv_q_c004_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_04 (conv_i_src_c004_1_04 0 conv_bpf_c004_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_1_04 (conv_i_src_c004_1_04 conv_i_c004_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_04 (conv_q_src_c004_1_04 0 conv_bpf_c004_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_1_04 (conv_q_src_c004_1_04 conv_q_c004_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_05 (conv_i_src_c004_1_05 0 conv_bpf_c004_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_1_05 (conv_i_src_c004_1_05 conv_i_c004_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_05 (conv_q_src_c004_1_05 0 conv_bpf_c004_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_1_05 (conv_q_src_c004_1_05 conv_q_c004_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_06 (conv_i_src_c004_1_06 0 conv_bpf_c004_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_1_06 (conv_i_src_c004_1_06 conv_i_c004_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_06 (conv_q_src_c004_1_06 0 conv_bpf_c004_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_1_06 (conv_q_src_c004_1_06 conv_q_c004_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_07 (conv_i_src_c004_1_07 0 conv_bpf_c004_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_1_07 (conv_i_src_c004_1_07 conv_i_c004_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_07 (conv_q_src_c004_1_07 0 conv_bpf_c004_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_1_07 (conv_q_src_c004_1_07 conv_q_c004_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_08 (conv_i_src_c004_1_08 0 conv_bpf_c004_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_1_08 (conv_i_src_c004_1_08 conv_i_c004_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_08 (conv_q_src_c004_1_08 0 conv_bpf_c004_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_1_08 (conv_q_src_c004_1_08 conv_q_c004_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_09 (conv_i_src_c004_1_09 0 conv_bpf_c004_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_1_09 (conv_i_src_c004_1_09 conv_i_c004_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_09 (conv_q_src_c004_1_09 0 conv_bpf_c004_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_1_09 (conv_q_src_c004_1_09 conv_q_c004_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_10 (conv_i_src_c004_1_10 0 conv_bpf_c004_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_1_10 (conv_i_src_c004_1_10 conv_i_c004_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_10 (conv_q_src_c004_1_10 0 conv_bpf_c004_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_1_10 (conv_q_src_c004_1_10 conv_q_c004_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_11 (conv_i_src_c004_1_11 0 conv_bpf_c004_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_1_11 (conv_i_src_c004_1_11 conv_i_c004_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_11 (conv_q_src_c004_1_11 0 conv_bpf_c004_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_1_11 (conv_q_src_c004_1_11 conv_q_c004_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_12 (conv_i_src_c004_1_12 0 conv_bpf_c004_1 0) vcvs gain=1.950903220161e-01
SCONVI_c004_1_12 (conv_i_src_c004_1_12 conv_i_c004_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_12 (conv_q_src_c004_1_12 0 conv_bpf_c004_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_1_12 (conv_q_src_c004_1_12 conv_q_c004_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_13 (conv_i_src_c004_1_13 0 conv_bpf_c004_1 0) vcvs gain=5.555702330196e-01
SCONVI_c004_1_13 (conv_i_src_c004_1_13 conv_i_c004_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_13 (conv_q_src_c004_1_13 0 conv_bpf_c004_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_1_13 (conv_q_src_c004_1_13 conv_q_c004_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_14 (conv_i_src_c004_1_14 0 conv_bpf_c004_1 0) vcvs gain=8.314696123025e-01
SCONVI_c004_1_14 (conv_i_src_c004_1_14 conv_i_c004_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_14 (conv_q_src_c004_1_14 0 conv_bpf_c004_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_1_14 (conv_q_src_c004_1_14 conv_q_c004_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_1_15 (conv_i_src_c004_1_15 0 conv_bpf_c004_1 0) vcvs gain=9.807852804032e-01
SCONVI_c004_1_15 (conv_i_src_c004_1_15 conv_i_c004_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_1_15 (conv_q_src_c004_1_15 0 conv_bpf_c004_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_1_15 (conv_q_src_c004_1_15 conv_q_c004_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c004_1 (conv_i_c004_1 0) resistor r=1G
RCONVQ_c004_1 (conv_q_c004_1 0) resistor r=1G
RCONVINTI_c004_1 (conv_i_c004_1 ConvIcar_c004_1) resistor r=1k
CCONVINTI_c004_1 (ConvIcar_c004_1 0) capacitor c=80p
RCONVINTQ_c004_1 (conv_q_c004_1 ConvQcar_c004_1) resistor r=1k
CCONVINTQ_c004_1 (ConvQcar_c004_1 0) capacitor c=80p
save conv_bpf_c004_1 ConvIcar_c004_1 ConvQcar_c004_1

// conventional mixed baseline bl004, carrier_2: 750000000 Hz
CCONVBPF_c004_2 (bl004 n_conv_cbpf_c004_2) capacitor c=4.503163717437e-14
LCONVBPF_c004_2 (n_conv_cbpf_c004_2 conv_bpf_c004_2) inductor l=1.000000000000e-06
RCONVBPF_c004_2 (conv_bpf_c004_2 0) resistor r=2.356194490192e+02
ECONVI_c004_2_00 (conv_i_src_c004_2_00 0 conv_bpf_c004_2 0) vcvs gain=9.807852804032e-01
SCONVI_c004_2_00 (conv_i_src_c004_2_00 conv_i_c004_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_00 (conv_q_src_c004_2_00 0 conv_bpf_c004_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_2_00 (conv_q_src_c004_2_00 conv_q_c004_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_01 (conv_i_src_c004_2_01 0 conv_bpf_c004_2 0) vcvs gain=8.314696123025e-01
SCONVI_c004_2_01 (conv_i_src_c004_2_01 conv_i_c004_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_01 (conv_q_src_c004_2_01 0 conv_bpf_c004_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_2_01 (conv_q_src_c004_2_01 conv_q_c004_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_02 (conv_i_src_c004_2_02 0 conv_bpf_c004_2 0) vcvs gain=5.555702330196e-01
SCONVI_c004_2_02 (conv_i_src_c004_2_02 conv_i_c004_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_02 (conv_q_src_c004_2_02 0 conv_bpf_c004_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_2_02 (conv_q_src_c004_2_02 conv_q_c004_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_03 (conv_i_src_c004_2_03 0 conv_bpf_c004_2 0) vcvs gain=1.950903220161e-01
SCONVI_c004_2_03 (conv_i_src_c004_2_03 conv_i_c004_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_03 (conv_q_src_c004_2_03 0 conv_bpf_c004_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_2_03 (conv_q_src_c004_2_03 conv_q_c004_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_04 (conv_i_src_c004_2_04 0 conv_bpf_c004_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_2_04 (conv_i_src_c004_2_04 conv_i_c004_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_04 (conv_q_src_c004_2_04 0 conv_bpf_c004_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_2_04 (conv_q_src_c004_2_04 conv_q_c004_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_05 (conv_i_src_c004_2_05 0 conv_bpf_c004_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_2_05 (conv_i_src_c004_2_05 conv_i_c004_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_05 (conv_q_src_c004_2_05 0 conv_bpf_c004_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_2_05 (conv_q_src_c004_2_05 conv_q_c004_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_06 (conv_i_src_c004_2_06 0 conv_bpf_c004_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_2_06 (conv_i_src_c004_2_06 conv_i_c004_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_06 (conv_q_src_c004_2_06 0 conv_bpf_c004_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_2_06 (conv_q_src_c004_2_06 conv_q_c004_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_07 (conv_i_src_c004_2_07 0 conv_bpf_c004_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_2_07 (conv_i_src_c004_2_07 conv_i_c004_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_07 (conv_q_src_c004_2_07 0 conv_bpf_c004_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_2_07 (conv_q_src_c004_2_07 conv_q_c004_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_08 (conv_i_src_c004_2_08 0 conv_bpf_c004_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_2_08 (conv_i_src_c004_2_08 conv_i_c004_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_08 (conv_q_src_c004_2_08 0 conv_bpf_c004_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_2_08 (conv_q_src_c004_2_08 conv_q_c004_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_09 (conv_i_src_c004_2_09 0 conv_bpf_c004_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_2_09 (conv_i_src_c004_2_09 conv_i_c004_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_09 (conv_q_src_c004_2_09 0 conv_bpf_c004_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_2_09 (conv_q_src_c004_2_09 conv_q_c004_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_10 (conv_i_src_c004_2_10 0 conv_bpf_c004_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_2_10 (conv_i_src_c004_2_10 conv_i_c004_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_10 (conv_q_src_c004_2_10 0 conv_bpf_c004_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_2_10 (conv_q_src_c004_2_10 conv_q_c004_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_11 (conv_i_src_c004_2_11 0 conv_bpf_c004_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_2_11 (conv_i_src_c004_2_11 conv_i_c004_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_11 (conv_q_src_c004_2_11 0 conv_bpf_c004_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_2_11 (conv_q_src_c004_2_11 conv_q_c004_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_12 (conv_i_src_c004_2_12 0 conv_bpf_c004_2 0) vcvs gain=1.950903220161e-01
SCONVI_c004_2_12 (conv_i_src_c004_2_12 conv_i_c004_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_12 (conv_q_src_c004_2_12 0 conv_bpf_c004_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_2_12 (conv_q_src_c004_2_12 conv_q_c004_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_13 (conv_i_src_c004_2_13 0 conv_bpf_c004_2 0) vcvs gain=5.555702330196e-01
SCONVI_c004_2_13 (conv_i_src_c004_2_13 conv_i_c004_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_13 (conv_q_src_c004_2_13 0 conv_bpf_c004_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_2_13 (conv_q_src_c004_2_13 conv_q_c004_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_14 (conv_i_src_c004_2_14 0 conv_bpf_c004_2 0) vcvs gain=8.314696123025e-01
SCONVI_c004_2_14 (conv_i_src_c004_2_14 conv_i_c004_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_14 (conv_q_src_c004_2_14 0 conv_bpf_c004_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_2_14 (conv_q_src_c004_2_14 conv_q_c004_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_2_15 (conv_i_src_c004_2_15 0 conv_bpf_c004_2 0) vcvs gain=9.807852804032e-01
SCONVI_c004_2_15 (conv_i_src_c004_2_15 conv_i_c004_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_2_15 (conv_q_src_c004_2_15 0 conv_bpf_c004_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_2_15 (conv_q_src_c004_2_15 conv_q_c004_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c004_2 (conv_i_c004_2 0) resistor r=1G
RCONVQ_c004_2 (conv_q_c004_2 0) resistor r=1G
RCONVINTI_c004_2 (conv_i_c004_2 ConvIcar_c004_2) resistor r=1k
CCONVINTI_c004_2 (ConvIcar_c004_2 0) capacitor c=80p
RCONVINTQ_c004_2 (conv_q_c004_2 ConvQcar_c004_2) resistor r=1k
CCONVINTQ_c004_2 (ConvQcar_c004_2 0) capacitor c=80p
save conv_bpf_c004_2 ConvIcar_c004_2 ConvQcar_c004_2

// conventional mixed baseline bl004, carrier_3: 1000000000 Hz
CCONVBPF_c004_3 (bl004 n_conv_cbpf_c004_3) capacitor c=2.533029591058e-14
LCONVBPF_c004_3 (n_conv_cbpf_c004_3 conv_bpf_c004_3) inductor l=1.000000000000e-06
RCONVBPF_c004_3 (conv_bpf_c004_3 0) resistor r=3.141592653590e+02
ECONVI_c004_3_00 (conv_i_src_c004_3_00 0 conv_bpf_c004_3 0) vcvs gain=9.807852804032e-01
SCONVI_c004_3_00 (conv_i_src_c004_3_00 conv_i_c004_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_00 (conv_q_src_c004_3_00 0 conv_bpf_c004_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_3_00 (conv_q_src_c004_3_00 conv_q_c004_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_01 (conv_i_src_c004_3_01 0 conv_bpf_c004_3 0) vcvs gain=8.314696123025e-01
SCONVI_c004_3_01 (conv_i_src_c004_3_01 conv_i_c004_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_01 (conv_q_src_c004_3_01 0 conv_bpf_c004_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_3_01 (conv_q_src_c004_3_01 conv_q_c004_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_02 (conv_i_src_c004_3_02 0 conv_bpf_c004_3 0) vcvs gain=5.555702330196e-01
SCONVI_c004_3_02 (conv_i_src_c004_3_02 conv_i_c004_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_02 (conv_q_src_c004_3_02 0 conv_bpf_c004_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_3_02 (conv_q_src_c004_3_02 conv_q_c004_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_03 (conv_i_src_c004_3_03 0 conv_bpf_c004_3 0) vcvs gain=1.950903220161e-01
SCONVI_c004_3_03 (conv_i_src_c004_3_03 conv_i_c004_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_03 (conv_q_src_c004_3_03 0 conv_bpf_c004_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_3_03 (conv_q_src_c004_3_03 conv_q_c004_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_04 (conv_i_src_c004_3_04 0 conv_bpf_c004_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_3_04 (conv_i_src_c004_3_04 conv_i_c004_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_04 (conv_q_src_c004_3_04 0 conv_bpf_c004_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c004_3_04 (conv_q_src_c004_3_04 conv_q_c004_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_05 (conv_i_src_c004_3_05 0 conv_bpf_c004_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_3_05 (conv_i_src_c004_3_05 conv_i_c004_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_05 (conv_q_src_c004_3_05 0 conv_bpf_c004_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c004_3_05 (conv_q_src_c004_3_05 conv_q_c004_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_06 (conv_i_src_c004_3_06 0 conv_bpf_c004_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_3_06 (conv_i_src_c004_3_06 conv_i_c004_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_06 (conv_q_src_c004_3_06 0 conv_bpf_c004_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c004_3_06 (conv_q_src_c004_3_06 conv_q_c004_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_07 (conv_i_src_c004_3_07 0 conv_bpf_c004_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_3_07 (conv_i_src_c004_3_07 conv_i_c004_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_07 (conv_q_src_c004_3_07 0 conv_bpf_c004_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c004_3_07 (conv_q_src_c004_3_07 conv_q_c004_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_08 (conv_i_src_c004_3_08 0 conv_bpf_c004_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c004_3_08 (conv_i_src_c004_3_08 conv_i_c004_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_08 (conv_q_src_c004_3_08 0 conv_bpf_c004_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_3_08 (conv_q_src_c004_3_08 conv_q_c004_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_09 (conv_i_src_c004_3_09 0 conv_bpf_c004_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c004_3_09 (conv_i_src_c004_3_09 conv_i_c004_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_09 (conv_q_src_c004_3_09 0 conv_bpf_c004_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_3_09 (conv_q_src_c004_3_09 conv_q_c004_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_10 (conv_i_src_c004_3_10 0 conv_bpf_c004_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c004_3_10 (conv_i_src_c004_3_10 conv_i_c004_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_10 (conv_q_src_c004_3_10 0 conv_bpf_c004_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_3_10 (conv_q_src_c004_3_10 conv_q_c004_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_11 (conv_i_src_c004_3_11 0 conv_bpf_c004_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c004_3_11 (conv_i_src_c004_3_11 conv_i_c004_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_11 (conv_q_src_c004_3_11 0 conv_bpf_c004_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_3_11 (conv_q_src_c004_3_11 conv_q_c004_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_12 (conv_i_src_c004_3_12 0 conv_bpf_c004_3 0) vcvs gain=1.950903220161e-01
SCONVI_c004_3_12 (conv_i_src_c004_3_12 conv_i_c004_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_12 (conv_q_src_c004_3_12 0 conv_bpf_c004_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c004_3_12 (conv_q_src_c004_3_12 conv_q_c004_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_13 (conv_i_src_c004_3_13 0 conv_bpf_c004_3 0) vcvs gain=5.555702330196e-01
SCONVI_c004_3_13 (conv_i_src_c004_3_13 conv_i_c004_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_13 (conv_q_src_c004_3_13 0 conv_bpf_c004_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c004_3_13 (conv_q_src_c004_3_13 conv_q_c004_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_14 (conv_i_src_c004_3_14 0 conv_bpf_c004_3 0) vcvs gain=8.314696123025e-01
SCONVI_c004_3_14 (conv_i_src_c004_3_14 conv_i_c004_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_14 (conv_q_src_c004_3_14 0 conv_bpf_c004_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c004_3_14 (conv_q_src_c004_3_14 conv_q_c004_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c004_3_15 (conv_i_src_c004_3_15 0 conv_bpf_c004_3 0) vcvs gain=9.807852804032e-01
SCONVI_c004_3_15 (conv_i_src_c004_3_15 conv_i_c004_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c004_3_15 (conv_q_src_c004_3_15 0 conv_bpf_c004_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c004_3_15 (conv_q_src_c004_3_15 conv_q_c004_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c004_3 (conv_i_c004_3 0) resistor r=1G
RCONVQ_c004_3 (conv_q_c004_3 0) resistor r=1G
RCONVINTI_c004_3 (conv_i_c004_3 ConvIcar_c004_3) resistor r=1k
CCONVINTI_c004_3 (ConvIcar_c004_3 0) capacitor c=80p
RCONVINTQ_c004_3 (conv_q_c004_3 ConvQcar_c004_3) resistor r=1k
CCONVINTQ_c004_3 (ConvQcar_c004_3 0) capacitor c=80p
save conv_bpf_c004_3 ConvIcar_c004_3 ConvQcar_c004_3

// conventional mixed baseline bl005, carrier_0: 250000000 Hz
CCONVBPF_c005_0 (bl005 n_conv_cbpf_c005_0) capacitor c=4.052847345694e-13
LCONVBPF_c005_0 (n_conv_cbpf_c005_0 conv_bpf_c005_0) inductor l=1.000000000000e-06
RCONVBPF_c005_0 (conv_bpf_c005_0 0) resistor r=7.853981633974e+01
ECONVI_c005_0_00 (conv_i_src_c005_0_00 0 conv_bpf_c005_0 0) vcvs gain=9.807852804032e-01
SCONVI_c005_0_00 (conv_i_src_c005_0_00 conv_i_c005_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_00 (conv_q_src_c005_0_00 0 conv_bpf_c005_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_0_00 (conv_q_src_c005_0_00 conv_q_c005_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_01 (conv_i_src_c005_0_01 0 conv_bpf_c005_0 0) vcvs gain=8.314696123025e-01
SCONVI_c005_0_01 (conv_i_src_c005_0_01 conv_i_c005_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_01 (conv_q_src_c005_0_01 0 conv_bpf_c005_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_0_01 (conv_q_src_c005_0_01 conv_q_c005_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_02 (conv_i_src_c005_0_02 0 conv_bpf_c005_0 0) vcvs gain=5.555702330196e-01
SCONVI_c005_0_02 (conv_i_src_c005_0_02 conv_i_c005_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_02 (conv_q_src_c005_0_02 0 conv_bpf_c005_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_0_02 (conv_q_src_c005_0_02 conv_q_c005_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_03 (conv_i_src_c005_0_03 0 conv_bpf_c005_0 0) vcvs gain=1.950903220161e-01
SCONVI_c005_0_03 (conv_i_src_c005_0_03 conv_i_c005_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_03 (conv_q_src_c005_0_03 0 conv_bpf_c005_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_0_03 (conv_q_src_c005_0_03 conv_q_c005_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_04 (conv_i_src_c005_0_04 0 conv_bpf_c005_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_0_04 (conv_i_src_c005_0_04 conv_i_c005_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_04 (conv_q_src_c005_0_04 0 conv_bpf_c005_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_0_04 (conv_q_src_c005_0_04 conv_q_c005_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_05 (conv_i_src_c005_0_05 0 conv_bpf_c005_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_0_05 (conv_i_src_c005_0_05 conv_i_c005_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_05 (conv_q_src_c005_0_05 0 conv_bpf_c005_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_0_05 (conv_q_src_c005_0_05 conv_q_c005_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_06 (conv_i_src_c005_0_06 0 conv_bpf_c005_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_0_06 (conv_i_src_c005_0_06 conv_i_c005_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_06 (conv_q_src_c005_0_06 0 conv_bpf_c005_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_0_06 (conv_q_src_c005_0_06 conv_q_c005_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_07 (conv_i_src_c005_0_07 0 conv_bpf_c005_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_0_07 (conv_i_src_c005_0_07 conv_i_c005_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_07 (conv_q_src_c005_0_07 0 conv_bpf_c005_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_0_07 (conv_q_src_c005_0_07 conv_q_c005_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_08 (conv_i_src_c005_0_08 0 conv_bpf_c005_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_0_08 (conv_i_src_c005_0_08 conv_i_c005_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_08 (conv_q_src_c005_0_08 0 conv_bpf_c005_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_0_08 (conv_q_src_c005_0_08 conv_q_c005_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_09 (conv_i_src_c005_0_09 0 conv_bpf_c005_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_0_09 (conv_i_src_c005_0_09 conv_i_c005_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_09 (conv_q_src_c005_0_09 0 conv_bpf_c005_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_0_09 (conv_q_src_c005_0_09 conv_q_c005_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_10 (conv_i_src_c005_0_10 0 conv_bpf_c005_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_0_10 (conv_i_src_c005_0_10 conv_i_c005_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_10 (conv_q_src_c005_0_10 0 conv_bpf_c005_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_0_10 (conv_q_src_c005_0_10 conv_q_c005_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_11 (conv_i_src_c005_0_11 0 conv_bpf_c005_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_0_11 (conv_i_src_c005_0_11 conv_i_c005_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_11 (conv_q_src_c005_0_11 0 conv_bpf_c005_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_0_11 (conv_q_src_c005_0_11 conv_q_c005_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_12 (conv_i_src_c005_0_12 0 conv_bpf_c005_0 0) vcvs gain=1.950903220161e-01
SCONVI_c005_0_12 (conv_i_src_c005_0_12 conv_i_c005_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_12 (conv_q_src_c005_0_12 0 conv_bpf_c005_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_0_12 (conv_q_src_c005_0_12 conv_q_c005_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_13 (conv_i_src_c005_0_13 0 conv_bpf_c005_0 0) vcvs gain=5.555702330196e-01
SCONVI_c005_0_13 (conv_i_src_c005_0_13 conv_i_c005_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_13 (conv_q_src_c005_0_13 0 conv_bpf_c005_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_0_13 (conv_q_src_c005_0_13 conv_q_c005_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_14 (conv_i_src_c005_0_14 0 conv_bpf_c005_0 0) vcvs gain=8.314696123025e-01
SCONVI_c005_0_14 (conv_i_src_c005_0_14 conv_i_c005_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_14 (conv_q_src_c005_0_14 0 conv_bpf_c005_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_0_14 (conv_q_src_c005_0_14 conv_q_c005_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_0_15 (conv_i_src_c005_0_15 0 conv_bpf_c005_0 0) vcvs gain=9.807852804032e-01
SCONVI_c005_0_15 (conv_i_src_c005_0_15 conv_i_c005_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_0_15 (conv_q_src_c005_0_15 0 conv_bpf_c005_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_0_15 (conv_q_src_c005_0_15 conv_q_c005_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c005_0 (conv_i_c005_0 0) resistor r=1G
RCONVQ_c005_0 (conv_q_c005_0 0) resistor r=1G
RCONVINTI_c005_0 (conv_i_c005_0 ConvIcar_c005_0) resistor r=1k
CCONVINTI_c005_0 (ConvIcar_c005_0 0) capacitor c=80p
RCONVINTQ_c005_0 (conv_q_c005_0 ConvQcar_c005_0) resistor r=1k
CCONVINTQ_c005_0 (ConvQcar_c005_0 0) capacitor c=80p
save conv_bpf_c005_0 ConvIcar_c005_0 ConvQcar_c005_0

// conventional mixed baseline bl005, carrier_1: 500000000 Hz
CCONVBPF_c005_1 (bl005 n_conv_cbpf_c005_1) capacitor c=1.013211836423e-13
LCONVBPF_c005_1 (n_conv_cbpf_c005_1 conv_bpf_c005_1) inductor l=1.000000000000e-06
RCONVBPF_c005_1 (conv_bpf_c005_1 0) resistor r=1.570796326795e+02
ECONVI_c005_1_00 (conv_i_src_c005_1_00 0 conv_bpf_c005_1 0) vcvs gain=9.807852804032e-01
SCONVI_c005_1_00 (conv_i_src_c005_1_00 conv_i_c005_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_00 (conv_q_src_c005_1_00 0 conv_bpf_c005_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_1_00 (conv_q_src_c005_1_00 conv_q_c005_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_01 (conv_i_src_c005_1_01 0 conv_bpf_c005_1 0) vcvs gain=8.314696123025e-01
SCONVI_c005_1_01 (conv_i_src_c005_1_01 conv_i_c005_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_01 (conv_q_src_c005_1_01 0 conv_bpf_c005_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_1_01 (conv_q_src_c005_1_01 conv_q_c005_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_02 (conv_i_src_c005_1_02 0 conv_bpf_c005_1 0) vcvs gain=5.555702330196e-01
SCONVI_c005_1_02 (conv_i_src_c005_1_02 conv_i_c005_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_02 (conv_q_src_c005_1_02 0 conv_bpf_c005_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_1_02 (conv_q_src_c005_1_02 conv_q_c005_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_03 (conv_i_src_c005_1_03 0 conv_bpf_c005_1 0) vcvs gain=1.950903220161e-01
SCONVI_c005_1_03 (conv_i_src_c005_1_03 conv_i_c005_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_03 (conv_q_src_c005_1_03 0 conv_bpf_c005_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_1_03 (conv_q_src_c005_1_03 conv_q_c005_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_04 (conv_i_src_c005_1_04 0 conv_bpf_c005_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_1_04 (conv_i_src_c005_1_04 conv_i_c005_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_04 (conv_q_src_c005_1_04 0 conv_bpf_c005_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_1_04 (conv_q_src_c005_1_04 conv_q_c005_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_05 (conv_i_src_c005_1_05 0 conv_bpf_c005_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_1_05 (conv_i_src_c005_1_05 conv_i_c005_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_05 (conv_q_src_c005_1_05 0 conv_bpf_c005_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_1_05 (conv_q_src_c005_1_05 conv_q_c005_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_06 (conv_i_src_c005_1_06 0 conv_bpf_c005_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_1_06 (conv_i_src_c005_1_06 conv_i_c005_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_06 (conv_q_src_c005_1_06 0 conv_bpf_c005_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_1_06 (conv_q_src_c005_1_06 conv_q_c005_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_07 (conv_i_src_c005_1_07 0 conv_bpf_c005_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_1_07 (conv_i_src_c005_1_07 conv_i_c005_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_07 (conv_q_src_c005_1_07 0 conv_bpf_c005_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_1_07 (conv_q_src_c005_1_07 conv_q_c005_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_08 (conv_i_src_c005_1_08 0 conv_bpf_c005_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_1_08 (conv_i_src_c005_1_08 conv_i_c005_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_08 (conv_q_src_c005_1_08 0 conv_bpf_c005_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_1_08 (conv_q_src_c005_1_08 conv_q_c005_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_09 (conv_i_src_c005_1_09 0 conv_bpf_c005_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_1_09 (conv_i_src_c005_1_09 conv_i_c005_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_09 (conv_q_src_c005_1_09 0 conv_bpf_c005_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_1_09 (conv_q_src_c005_1_09 conv_q_c005_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_10 (conv_i_src_c005_1_10 0 conv_bpf_c005_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_1_10 (conv_i_src_c005_1_10 conv_i_c005_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_10 (conv_q_src_c005_1_10 0 conv_bpf_c005_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_1_10 (conv_q_src_c005_1_10 conv_q_c005_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_11 (conv_i_src_c005_1_11 0 conv_bpf_c005_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_1_11 (conv_i_src_c005_1_11 conv_i_c005_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_11 (conv_q_src_c005_1_11 0 conv_bpf_c005_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_1_11 (conv_q_src_c005_1_11 conv_q_c005_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_12 (conv_i_src_c005_1_12 0 conv_bpf_c005_1 0) vcvs gain=1.950903220161e-01
SCONVI_c005_1_12 (conv_i_src_c005_1_12 conv_i_c005_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_12 (conv_q_src_c005_1_12 0 conv_bpf_c005_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_1_12 (conv_q_src_c005_1_12 conv_q_c005_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_13 (conv_i_src_c005_1_13 0 conv_bpf_c005_1 0) vcvs gain=5.555702330196e-01
SCONVI_c005_1_13 (conv_i_src_c005_1_13 conv_i_c005_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_13 (conv_q_src_c005_1_13 0 conv_bpf_c005_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_1_13 (conv_q_src_c005_1_13 conv_q_c005_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_14 (conv_i_src_c005_1_14 0 conv_bpf_c005_1 0) vcvs gain=8.314696123025e-01
SCONVI_c005_1_14 (conv_i_src_c005_1_14 conv_i_c005_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_14 (conv_q_src_c005_1_14 0 conv_bpf_c005_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_1_14 (conv_q_src_c005_1_14 conv_q_c005_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_1_15 (conv_i_src_c005_1_15 0 conv_bpf_c005_1 0) vcvs gain=9.807852804032e-01
SCONVI_c005_1_15 (conv_i_src_c005_1_15 conv_i_c005_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_1_15 (conv_q_src_c005_1_15 0 conv_bpf_c005_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_1_15 (conv_q_src_c005_1_15 conv_q_c005_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c005_1 (conv_i_c005_1 0) resistor r=1G
RCONVQ_c005_1 (conv_q_c005_1 0) resistor r=1G
RCONVINTI_c005_1 (conv_i_c005_1 ConvIcar_c005_1) resistor r=1k
CCONVINTI_c005_1 (ConvIcar_c005_1 0) capacitor c=80p
RCONVINTQ_c005_1 (conv_q_c005_1 ConvQcar_c005_1) resistor r=1k
CCONVINTQ_c005_1 (ConvQcar_c005_1 0) capacitor c=80p
save conv_bpf_c005_1 ConvIcar_c005_1 ConvQcar_c005_1

// conventional mixed baseline bl005, carrier_2: 750000000 Hz
CCONVBPF_c005_2 (bl005 n_conv_cbpf_c005_2) capacitor c=4.503163717437e-14
LCONVBPF_c005_2 (n_conv_cbpf_c005_2 conv_bpf_c005_2) inductor l=1.000000000000e-06
RCONVBPF_c005_2 (conv_bpf_c005_2 0) resistor r=2.356194490192e+02
ECONVI_c005_2_00 (conv_i_src_c005_2_00 0 conv_bpf_c005_2 0) vcvs gain=9.807852804032e-01
SCONVI_c005_2_00 (conv_i_src_c005_2_00 conv_i_c005_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_00 (conv_q_src_c005_2_00 0 conv_bpf_c005_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_2_00 (conv_q_src_c005_2_00 conv_q_c005_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_01 (conv_i_src_c005_2_01 0 conv_bpf_c005_2 0) vcvs gain=8.314696123025e-01
SCONVI_c005_2_01 (conv_i_src_c005_2_01 conv_i_c005_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_01 (conv_q_src_c005_2_01 0 conv_bpf_c005_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_2_01 (conv_q_src_c005_2_01 conv_q_c005_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_02 (conv_i_src_c005_2_02 0 conv_bpf_c005_2 0) vcvs gain=5.555702330196e-01
SCONVI_c005_2_02 (conv_i_src_c005_2_02 conv_i_c005_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_02 (conv_q_src_c005_2_02 0 conv_bpf_c005_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_2_02 (conv_q_src_c005_2_02 conv_q_c005_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_03 (conv_i_src_c005_2_03 0 conv_bpf_c005_2 0) vcvs gain=1.950903220161e-01
SCONVI_c005_2_03 (conv_i_src_c005_2_03 conv_i_c005_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_03 (conv_q_src_c005_2_03 0 conv_bpf_c005_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_2_03 (conv_q_src_c005_2_03 conv_q_c005_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_04 (conv_i_src_c005_2_04 0 conv_bpf_c005_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_2_04 (conv_i_src_c005_2_04 conv_i_c005_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_04 (conv_q_src_c005_2_04 0 conv_bpf_c005_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_2_04 (conv_q_src_c005_2_04 conv_q_c005_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_05 (conv_i_src_c005_2_05 0 conv_bpf_c005_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_2_05 (conv_i_src_c005_2_05 conv_i_c005_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_05 (conv_q_src_c005_2_05 0 conv_bpf_c005_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_2_05 (conv_q_src_c005_2_05 conv_q_c005_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_06 (conv_i_src_c005_2_06 0 conv_bpf_c005_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_2_06 (conv_i_src_c005_2_06 conv_i_c005_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_06 (conv_q_src_c005_2_06 0 conv_bpf_c005_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_2_06 (conv_q_src_c005_2_06 conv_q_c005_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_07 (conv_i_src_c005_2_07 0 conv_bpf_c005_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_2_07 (conv_i_src_c005_2_07 conv_i_c005_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_07 (conv_q_src_c005_2_07 0 conv_bpf_c005_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_2_07 (conv_q_src_c005_2_07 conv_q_c005_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_08 (conv_i_src_c005_2_08 0 conv_bpf_c005_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_2_08 (conv_i_src_c005_2_08 conv_i_c005_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_08 (conv_q_src_c005_2_08 0 conv_bpf_c005_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_2_08 (conv_q_src_c005_2_08 conv_q_c005_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_09 (conv_i_src_c005_2_09 0 conv_bpf_c005_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_2_09 (conv_i_src_c005_2_09 conv_i_c005_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_09 (conv_q_src_c005_2_09 0 conv_bpf_c005_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_2_09 (conv_q_src_c005_2_09 conv_q_c005_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_10 (conv_i_src_c005_2_10 0 conv_bpf_c005_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_2_10 (conv_i_src_c005_2_10 conv_i_c005_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_10 (conv_q_src_c005_2_10 0 conv_bpf_c005_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_2_10 (conv_q_src_c005_2_10 conv_q_c005_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_11 (conv_i_src_c005_2_11 0 conv_bpf_c005_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_2_11 (conv_i_src_c005_2_11 conv_i_c005_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_11 (conv_q_src_c005_2_11 0 conv_bpf_c005_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_2_11 (conv_q_src_c005_2_11 conv_q_c005_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_12 (conv_i_src_c005_2_12 0 conv_bpf_c005_2 0) vcvs gain=1.950903220161e-01
SCONVI_c005_2_12 (conv_i_src_c005_2_12 conv_i_c005_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_12 (conv_q_src_c005_2_12 0 conv_bpf_c005_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_2_12 (conv_q_src_c005_2_12 conv_q_c005_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_13 (conv_i_src_c005_2_13 0 conv_bpf_c005_2 0) vcvs gain=5.555702330196e-01
SCONVI_c005_2_13 (conv_i_src_c005_2_13 conv_i_c005_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_13 (conv_q_src_c005_2_13 0 conv_bpf_c005_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_2_13 (conv_q_src_c005_2_13 conv_q_c005_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_14 (conv_i_src_c005_2_14 0 conv_bpf_c005_2 0) vcvs gain=8.314696123025e-01
SCONVI_c005_2_14 (conv_i_src_c005_2_14 conv_i_c005_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_14 (conv_q_src_c005_2_14 0 conv_bpf_c005_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_2_14 (conv_q_src_c005_2_14 conv_q_c005_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_2_15 (conv_i_src_c005_2_15 0 conv_bpf_c005_2 0) vcvs gain=9.807852804032e-01
SCONVI_c005_2_15 (conv_i_src_c005_2_15 conv_i_c005_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_2_15 (conv_q_src_c005_2_15 0 conv_bpf_c005_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_2_15 (conv_q_src_c005_2_15 conv_q_c005_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c005_2 (conv_i_c005_2 0) resistor r=1G
RCONVQ_c005_2 (conv_q_c005_2 0) resistor r=1G
RCONVINTI_c005_2 (conv_i_c005_2 ConvIcar_c005_2) resistor r=1k
CCONVINTI_c005_2 (ConvIcar_c005_2 0) capacitor c=80p
RCONVINTQ_c005_2 (conv_q_c005_2 ConvQcar_c005_2) resistor r=1k
CCONVINTQ_c005_2 (ConvQcar_c005_2 0) capacitor c=80p
save conv_bpf_c005_2 ConvIcar_c005_2 ConvQcar_c005_2

// conventional mixed baseline bl005, carrier_3: 1000000000 Hz
CCONVBPF_c005_3 (bl005 n_conv_cbpf_c005_3) capacitor c=2.533029591058e-14
LCONVBPF_c005_3 (n_conv_cbpf_c005_3 conv_bpf_c005_3) inductor l=1.000000000000e-06
RCONVBPF_c005_3 (conv_bpf_c005_3 0) resistor r=3.141592653590e+02
ECONVI_c005_3_00 (conv_i_src_c005_3_00 0 conv_bpf_c005_3 0) vcvs gain=9.807852804032e-01
SCONVI_c005_3_00 (conv_i_src_c005_3_00 conv_i_c005_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_00 (conv_q_src_c005_3_00 0 conv_bpf_c005_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_3_00 (conv_q_src_c005_3_00 conv_q_c005_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_01 (conv_i_src_c005_3_01 0 conv_bpf_c005_3 0) vcvs gain=8.314696123025e-01
SCONVI_c005_3_01 (conv_i_src_c005_3_01 conv_i_c005_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_01 (conv_q_src_c005_3_01 0 conv_bpf_c005_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_3_01 (conv_q_src_c005_3_01 conv_q_c005_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_02 (conv_i_src_c005_3_02 0 conv_bpf_c005_3 0) vcvs gain=5.555702330196e-01
SCONVI_c005_3_02 (conv_i_src_c005_3_02 conv_i_c005_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_02 (conv_q_src_c005_3_02 0 conv_bpf_c005_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_3_02 (conv_q_src_c005_3_02 conv_q_c005_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_03 (conv_i_src_c005_3_03 0 conv_bpf_c005_3 0) vcvs gain=1.950903220161e-01
SCONVI_c005_3_03 (conv_i_src_c005_3_03 conv_i_c005_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_03 (conv_q_src_c005_3_03 0 conv_bpf_c005_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_3_03 (conv_q_src_c005_3_03 conv_q_c005_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_04 (conv_i_src_c005_3_04 0 conv_bpf_c005_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_3_04 (conv_i_src_c005_3_04 conv_i_c005_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_04 (conv_q_src_c005_3_04 0 conv_bpf_c005_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c005_3_04 (conv_q_src_c005_3_04 conv_q_c005_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_05 (conv_i_src_c005_3_05 0 conv_bpf_c005_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_3_05 (conv_i_src_c005_3_05 conv_i_c005_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_05 (conv_q_src_c005_3_05 0 conv_bpf_c005_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c005_3_05 (conv_q_src_c005_3_05 conv_q_c005_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_06 (conv_i_src_c005_3_06 0 conv_bpf_c005_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_3_06 (conv_i_src_c005_3_06 conv_i_c005_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_06 (conv_q_src_c005_3_06 0 conv_bpf_c005_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c005_3_06 (conv_q_src_c005_3_06 conv_q_c005_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_07 (conv_i_src_c005_3_07 0 conv_bpf_c005_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_3_07 (conv_i_src_c005_3_07 conv_i_c005_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_07 (conv_q_src_c005_3_07 0 conv_bpf_c005_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c005_3_07 (conv_q_src_c005_3_07 conv_q_c005_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_08 (conv_i_src_c005_3_08 0 conv_bpf_c005_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c005_3_08 (conv_i_src_c005_3_08 conv_i_c005_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_08 (conv_q_src_c005_3_08 0 conv_bpf_c005_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_3_08 (conv_q_src_c005_3_08 conv_q_c005_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_09 (conv_i_src_c005_3_09 0 conv_bpf_c005_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c005_3_09 (conv_i_src_c005_3_09 conv_i_c005_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_09 (conv_q_src_c005_3_09 0 conv_bpf_c005_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_3_09 (conv_q_src_c005_3_09 conv_q_c005_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_10 (conv_i_src_c005_3_10 0 conv_bpf_c005_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c005_3_10 (conv_i_src_c005_3_10 conv_i_c005_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_10 (conv_q_src_c005_3_10 0 conv_bpf_c005_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_3_10 (conv_q_src_c005_3_10 conv_q_c005_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_11 (conv_i_src_c005_3_11 0 conv_bpf_c005_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c005_3_11 (conv_i_src_c005_3_11 conv_i_c005_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_11 (conv_q_src_c005_3_11 0 conv_bpf_c005_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_3_11 (conv_q_src_c005_3_11 conv_q_c005_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_12 (conv_i_src_c005_3_12 0 conv_bpf_c005_3 0) vcvs gain=1.950903220161e-01
SCONVI_c005_3_12 (conv_i_src_c005_3_12 conv_i_c005_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_12 (conv_q_src_c005_3_12 0 conv_bpf_c005_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c005_3_12 (conv_q_src_c005_3_12 conv_q_c005_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_13 (conv_i_src_c005_3_13 0 conv_bpf_c005_3 0) vcvs gain=5.555702330196e-01
SCONVI_c005_3_13 (conv_i_src_c005_3_13 conv_i_c005_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_13 (conv_q_src_c005_3_13 0 conv_bpf_c005_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c005_3_13 (conv_q_src_c005_3_13 conv_q_c005_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_14 (conv_i_src_c005_3_14 0 conv_bpf_c005_3 0) vcvs gain=8.314696123025e-01
SCONVI_c005_3_14 (conv_i_src_c005_3_14 conv_i_c005_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_14 (conv_q_src_c005_3_14 0 conv_bpf_c005_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c005_3_14 (conv_q_src_c005_3_14 conv_q_c005_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c005_3_15 (conv_i_src_c005_3_15 0 conv_bpf_c005_3 0) vcvs gain=9.807852804032e-01
SCONVI_c005_3_15 (conv_i_src_c005_3_15 conv_i_c005_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c005_3_15 (conv_q_src_c005_3_15 0 conv_bpf_c005_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c005_3_15 (conv_q_src_c005_3_15 conv_q_c005_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c005_3 (conv_i_c005_3 0) resistor r=1G
RCONVQ_c005_3 (conv_q_c005_3 0) resistor r=1G
RCONVINTI_c005_3 (conv_i_c005_3 ConvIcar_c005_3) resistor r=1k
CCONVINTI_c005_3 (ConvIcar_c005_3 0) capacitor c=80p
RCONVINTQ_c005_3 (conv_q_c005_3 ConvQcar_c005_3) resistor r=1k
CCONVINTQ_c005_3 (ConvQcar_c005_3 0) capacitor c=80p
save conv_bpf_c005_3 ConvIcar_c005_3 ConvQcar_c005_3

// conventional mixed baseline bl006, carrier_0: 250000000 Hz
CCONVBPF_c006_0 (bl006 n_conv_cbpf_c006_0) capacitor c=4.052847345694e-13
LCONVBPF_c006_0 (n_conv_cbpf_c006_0 conv_bpf_c006_0) inductor l=1.000000000000e-06
RCONVBPF_c006_0 (conv_bpf_c006_0 0) resistor r=7.853981633974e+01
ECONVI_c006_0_00 (conv_i_src_c006_0_00 0 conv_bpf_c006_0 0) vcvs gain=9.807852804032e-01
SCONVI_c006_0_00 (conv_i_src_c006_0_00 conv_i_c006_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_00 (conv_q_src_c006_0_00 0 conv_bpf_c006_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_0_00 (conv_q_src_c006_0_00 conv_q_c006_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_01 (conv_i_src_c006_0_01 0 conv_bpf_c006_0 0) vcvs gain=8.314696123025e-01
SCONVI_c006_0_01 (conv_i_src_c006_0_01 conv_i_c006_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_01 (conv_q_src_c006_0_01 0 conv_bpf_c006_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_0_01 (conv_q_src_c006_0_01 conv_q_c006_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_02 (conv_i_src_c006_0_02 0 conv_bpf_c006_0 0) vcvs gain=5.555702330196e-01
SCONVI_c006_0_02 (conv_i_src_c006_0_02 conv_i_c006_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_02 (conv_q_src_c006_0_02 0 conv_bpf_c006_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_0_02 (conv_q_src_c006_0_02 conv_q_c006_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_03 (conv_i_src_c006_0_03 0 conv_bpf_c006_0 0) vcvs gain=1.950903220161e-01
SCONVI_c006_0_03 (conv_i_src_c006_0_03 conv_i_c006_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_03 (conv_q_src_c006_0_03 0 conv_bpf_c006_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_0_03 (conv_q_src_c006_0_03 conv_q_c006_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_04 (conv_i_src_c006_0_04 0 conv_bpf_c006_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_0_04 (conv_i_src_c006_0_04 conv_i_c006_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_04 (conv_q_src_c006_0_04 0 conv_bpf_c006_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_0_04 (conv_q_src_c006_0_04 conv_q_c006_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_05 (conv_i_src_c006_0_05 0 conv_bpf_c006_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_0_05 (conv_i_src_c006_0_05 conv_i_c006_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_05 (conv_q_src_c006_0_05 0 conv_bpf_c006_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_0_05 (conv_q_src_c006_0_05 conv_q_c006_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_06 (conv_i_src_c006_0_06 0 conv_bpf_c006_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_0_06 (conv_i_src_c006_0_06 conv_i_c006_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_06 (conv_q_src_c006_0_06 0 conv_bpf_c006_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_0_06 (conv_q_src_c006_0_06 conv_q_c006_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_07 (conv_i_src_c006_0_07 0 conv_bpf_c006_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_0_07 (conv_i_src_c006_0_07 conv_i_c006_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_07 (conv_q_src_c006_0_07 0 conv_bpf_c006_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_0_07 (conv_q_src_c006_0_07 conv_q_c006_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_08 (conv_i_src_c006_0_08 0 conv_bpf_c006_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_0_08 (conv_i_src_c006_0_08 conv_i_c006_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_08 (conv_q_src_c006_0_08 0 conv_bpf_c006_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_0_08 (conv_q_src_c006_0_08 conv_q_c006_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_09 (conv_i_src_c006_0_09 0 conv_bpf_c006_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_0_09 (conv_i_src_c006_0_09 conv_i_c006_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_09 (conv_q_src_c006_0_09 0 conv_bpf_c006_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_0_09 (conv_q_src_c006_0_09 conv_q_c006_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_10 (conv_i_src_c006_0_10 0 conv_bpf_c006_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_0_10 (conv_i_src_c006_0_10 conv_i_c006_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_10 (conv_q_src_c006_0_10 0 conv_bpf_c006_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_0_10 (conv_q_src_c006_0_10 conv_q_c006_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_11 (conv_i_src_c006_0_11 0 conv_bpf_c006_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_0_11 (conv_i_src_c006_0_11 conv_i_c006_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_11 (conv_q_src_c006_0_11 0 conv_bpf_c006_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_0_11 (conv_q_src_c006_0_11 conv_q_c006_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_12 (conv_i_src_c006_0_12 0 conv_bpf_c006_0 0) vcvs gain=1.950903220161e-01
SCONVI_c006_0_12 (conv_i_src_c006_0_12 conv_i_c006_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_12 (conv_q_src_c006_0_12 0 conv_bpf_c006_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_0_12 (conv_q_src_c006_0_12 conv_q_c006_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_13 (conv_i_src_c006_0_13 0 conv_bpf_c006_0 0) vcvs gain=5.555702330196e-01
SCONVI_c006_0_13 (conv_i_src_c006_0_13 conv_i_c006_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_13 (conv_q_src_c006_0_13 0 conv_bpf_c006_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_0_13 (conv_q_src_c006_0_13 conv_q_c006_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_14 (conv_i_src_c006_0_14 0 conv_bpf_c006_0 0) vcvs gain=8.314696123025e-01
SCONVI_c006_0_14 (conv_i_src_c006_0_14 conv_i_c006_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_14 (conv_q_src_c006_0_14 0 conv_bpf_c006_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_0_14 (conv_q_src_c006_0_14 conv_q_c006_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_0_15 (conv_i_src_c006_0_15 0 conv_bpf_c006_0 0) vcvs gain=9.807852804032e-01
SCONVI_c006_0_15 (conv_i_src_c006_0_15 conv_i_c006_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_0_15 (conv_q_src_c006_0_15 0 conv_bpf_c006_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_0_15 (conv_q_src_c006_0_15 conv_q_c006_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c006_0 (conv_i_c006_0 0) resistor r=1G
RCONVQ_c006_0 (conv_q_c006_0 0) resistor r=1G
RCONVINTI_c006_0 (conv_i_c006_0 ConvIcar_c006_0) resistor r=1k
CCONVINTI_c006_0 (ConvIcar_c006_0 0) capacitor c=80p
RCONVINTQ_c006_0 (conv_q_c006_0 ConvQcar_c006_0) resistor r=1k
CCONVINTQ_c006_0 (ConvQcar_c006_0 0) capacitor c=80p
save conv_bpf_c006_0 ConvIcar_c006_0 ConvQcar_c006_0

// conventional mixed baseline bl006, carrier_1: 500000000 Hz
CCONVBPF_c006_1 (bl006 n_conv_cbpf_c006_1) capacitor c=1.013211836423e-13
LCONVBPF_c006_1 (n_conv_cbpf_c006_1 conv_bpf_c006_1) inductor l=1.000000000000e-06
RCONVBPF_c006_1 (conv_bpf_c006_1 0) resistor r=1.570796326795e+02
ECONVI_c006_1_00 (conv_i_src_c006_1_00 0 conv_bpf_c006_1 0) vcvs gain=9.807852804032e-01
SCONVI_c006_1_00 (conv_i_src_c006_1_00 conv_i_c006_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_00 (conv_q_src_c006_1_00 0 conv_bpf_c006_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_1_00 (conv_q_src_c006_1_00 conv_q_c006_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_01 (conv_i_src_c006_1_01 0 conv_bpf_c006_1 0) vcvs gain=8.314696123025e-01
SCONVI_c006_1_01 (conv_i_src_c006_1_01 conv_i_c006_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_01 (conv_q_src_c006_1_01 0 conv_bpf_c006_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_1_01 (conv_q_src_c006_1_01 conv_q_c006_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_02 (conv_i_src_c006_1_02 0 conv_bpf_c006_1 0) vcvs gain=5.555702330196e-01
SCONVI_c006_1_02 (conv_i_src_c006_1_02 conv_i_c006_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_02 (conv_q_src_c006_1_02 0 conv_bpf_c006_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_1_02 (conv_q_src_c006_1_02 conv_q_c006_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_03 (conv_i_src_c006_1_03 0 conv_bpf_c006_1 0) vcvs gain=1.950903220161e-01
SCONVI_c006_1_03 (conv_i_src_c006_1_03 conv_i_c006_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_03 (conv_q_src_c006_1_03 0 conv_bpf_c006_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_1_03 (conv_q_src_c006_1_03 conv_q_c006_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_04 (conv_i_src_c006_1_04 0 conv_bpf_c006_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_1_04 (conv_i_src_c006_1_04 conv_i_c006_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_04 (conv_q_src_c006_1_04 0 conv_bpf_c006_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_1_04 (conv_q_src_c006_1_04 conv_q_c006_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_05 (conv_i_src_c006_1_05 0 conv_bpf_c006_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_1_05 (conv_i_src_c006_1_05 conv_i_c006_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_05 (conv_q_src_c006_1_05 0 conv_bpf_c006_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_1_05 (conv_q_src_c006_1_05 conv_q_c006_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_06 (conv_i_src_c006_1_06 0 conv_bpf_c006_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_1_06 (conv_i_src_c006_1_06 conv_i_c006_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_06 (conv_q_src_c006_1_06 0 conv_bpf_c006_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_1_06 (conv_q_src_c006_1_06 conv_q_c006_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_07 (conv_i_src_c006_1_07 0 conv_bpf_c006_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_1_07 (conv_i_src_c006_1_07 conv_i_c006_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_07 (conv_q_src_c006_1_07 0 conv_bpf_c006_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_1_07 (conv_q_src_c006_1_07 conv_q_c006_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_08 (conv_i_src_c006_1_08 0 conv_bpf_c006_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_1_08 (conv_i_src_c006_1_08 conv_i_c006_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_08 (conv_q_src_c006_1_08 0 conv_bpf_c006_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_1_08 (conv_q_src_c006_1_08 conv_q_c006_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_09 (conv_i_src_c006_1_09 0 conv_bpf_c006_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_1_09 (conv_i_src_c006_1_09 conv_i_c006_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_09 (conv_q_src_c006_1_09 0 conv_bpf_c006_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_1_09 (conv_q_src_c006_1_09 conv_q_c006_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_10 (conv_i_src_c006_1_10 0 conv_bpf_c006_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_1_10 (conv_i_src_c006_1_10 conv_i_c006_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_10 (conv_q_src_c006_1_10 0 conv_bpf_c006_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_1_10 (conv_q_src_c006_1_10 conv_q_c006_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_11 (conv_i_src_c006_1_11 0 conv_bpf_c006_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_1_11 (conv_i_src_c006_1_11 conv_i_c006_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_11 (conv_q_src_c006_1_11 0 conv_bpf_c006_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_1_11 (conv_q_src_c006_1_11 conv_q_c006_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_12 (conv_i_src_c006_1_12 0 conv_bpf_c006_1 0) vcvs gain=1.950903220161e-01
SCONVI_c006_1_12 (conv_i_src_c006_1_12 conv_i_c006_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_12 (conv_q_src_c006_1_12 0 conv_bpf_c006_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_1_12 (conv_q_src_c006_1_12 conv_q_c006_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_13 (conv_i_src_c006_1_13 0 conv_bpf_c006_1 0) vcvs gain=5.555702330196e-01
SCONVI_c006_1_13 (conv_i_src_c006_1_13 conv_i_c006_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_13 (conv_q_src_c006_1_13 0 conv_bpf_c006_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_1_13 (conv_q_src_c006_1_13 conv_q_c006_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_14 (conv_i_src_c006_1_14 0 conv_bpf_c006_1 0) vcvs gain=8.314696123025e-01
SCONVI_c006_1_14 (conv_i_src_c006_1_14 conv_i_c006_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_14 (conv_q_src_c006_1_14 0 conv_bpf_c006_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_1_14 (conv_q_src_c006_1_14 conv_q_c006_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_1_15 (conv_i_src_c006_1_15 0 conv_bpf_c006_1 0) vcvs gain=9.807852804032e-01
SCONVI_c006_1_15 (conv_i_src_c006_1_15 conv_i_c006_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_1_15 (conv_q_src_c006_1_15 0 conv_bpf_c006_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_1_15 (conv_q_src_c006_1_15 conv_q_c006_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c006_1 (conv_i_c006_1 0) resistor r=1G
RCONVQ_c006_1 (conv_q_c006_1 0) resistor r=1G
RCONVINTI_c006_1 (conv_i_c006_1 ConvIcar_c006_1) resistor r=1k
CCONVINTI_c006_1 (ConvIcar_c006_1 0) capacitor c=80p
RCONVINTQ_c006_1 (conv_q_c006_1 ConvQcar_c006_1) resistor r=1k
CCONVINTQ_c006_1 (ConvQcar_c006_1 0) capacitor c=80p
save conv_bpf_c006_1 ConvIcar_c006_1 ConvQcar_c006_1

// conventional mixed baseline bl006, carrier_2: 750000000 Hz
CCONVBPF_c006_2 (bl006 n_conv_cbpf_c006_2) capacitor c=4.503163717437e-14
LCONVBPF_c006_2 (n_conv_cbpf_c006_2 conv_bpf_c006_2) inductor l=1.000000000000e-06
RCONVBPF_c006_2 (conv_bpf_c006_2 0) resistor r=2.356194490192e+02
ECONVI_c006_2_00 (conv_i_src_c006_2_00 0 conv_bpf_c006_2 0) vcvs gain=9.807852804032e-01
SCONVI_c006_2_00 (conv_i_src_c006_2_00 conv_i_c006_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_00 (conv_q_src_c006_2_00 0 conv_bpf_c006_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_2_00 (conv_q_src_c006_2_00 conv_q_c006_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_01 (conv_i_src_c006_2_01 0 conv_bpf_c006_2 0) vcvs gain=8.314696123025e-01
SCONVI_c006_2_01 (conv_i_src_c006_2_01 conv_i_c006_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_01 (conv_q_src_c006_2_01 0 conv_bpf_c006_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_2_01 (conv_q_src_c006_2_01 conv_q_c006_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_02 (conv_i_src_c006_2_02 0 conv_bpf_c006_2 0) vcvs gain=5.555702330196e-01
SCONVI_c006_2_02 (conv_i_src_c006_2_02 conv_i_c006_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_02 (conv_q_src_c006_2_02 0 conv_bpf_c006_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_2_02 (conv_q_src_c006_2_02 conv_q_c006_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_03 (conv_i_src_c006_2_03 0 conv_bpf_c006_2 0) vcvs gain=1.950903220161e-01
SCONVI_c006_2_03 (conv_i_src_c006_2_03 conv_i_c006_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_03 (conv_q_src_c006_2_03 0 conv_bpf_c006_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_2_03 (conv_q_src_c006_2_03 conv_q_c006_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_04 (conv_i_src_c006_2_04 0 conv_bpf_c006_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_2_04 (conv_i_src_c006_2_04 conv_i_c006_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_04 (conv_q_src_c006_2_04 0 conv_bpf_c006_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_2_04 (conv_q_src_c006_2_04 conv_q_c006_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_05 (conv_i_src_c006_2_05 0 conv_bpf_c006_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_2_05 (conv_i_src_c006_2_05 conv_i_c006_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_05 (conv_q_src_c006_2_05 0 conv_bpf_c006_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_2_05 (conv_q_src_c006_2_05 conv_q_c006_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_06 (conv_i_src_c006_2_06 0 conv_bpf_c006_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_2_06 (conv_i_src_c006_2_06 conv_i_c006_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_06 (conv_q_src_c006_2_06 0 conv_bpf_c006_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_2_06 (conv_q_src_c006_2_06 conv_q_c006_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_07 (conv_i_src_c006_2_07 0 conv_bpf_c006_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_2_07 (conv_i_src_c006_2_07 conv_i_c006_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_07 (conv_q_src_c006_2_07 0 conv_bpf_c006_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_2_07 (conv_q_src_c006_2_07 conv_q_c006_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_08 (conv_i_src_c006_2_08 0 conv_bpf_c006_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_2_08 (conv_i_src_c006_2_08 conv_i_c006_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_08 (conv_q_src_c006_2_08 0 conv_bpf_c006_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_2_08 (conv_q_src_c006_2_08 conv_q_c006_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_09 (conv_i_src_c006_2_09 0 conv_bpf_c006_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_2_09 (conv_i_src_c006_2_09 conv_i_c006_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_09 (conv_q_src_c006_2_09 0 conv_bpf_c006_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_2_09 (conv_q_src_c006_2_09 conv_q_c006_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_10 (conv_i_src_c006_2_10 0 conv_bpf_c006_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_2_10 (conv_i_src_c006_2_10 conv_i_c006_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_10 (conv_q_src_c006_2_10 0 conv_bpf_c006_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_2_10 (conv_q_src_c006_2_10 conv_q_c006_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_11 (conv_i_src_c006_2_11 0 conv_bpf_c006_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_2_11 (conv_i_src_c006_2_11 conv_i_c006_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_11 (conv_q_src_c006_2_11 0 conv_bpf_c006_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_2_11 (conv_q_src_c006_2_11 conv_q_c006_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_12 (conv_i_src_c006_2_12 0 conv_bpf_c006_2 0) vcvs gain=1.950903220161e-01
SCONVI_c006_2_12 (conv_i_src_c006_2_12 conv_i_c006_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_12 (conv_q_src_c006_2_12 0 conv_bpf_c006_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_2_12 (conv_q_src_c006_2_12 conv_q_c006_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_13 (conv_i_src_c006_2_13 0 conv_bpf_c006_2 0) vcvs gain=5.555702330196e-01
SCONVI_c006_2_13 (conv_i_src_c006_2_13 conv_i_c006_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_13 (conv_q_src_c006_2_13 0 conv_bpf_c006_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_2_13 (conv_q_src_c006_2_13 conv_q_c006_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_14 (conv_i_src_c006_2_14 0 conv_bpf_c006_2 0) vcvs gain=8.314696123025e-01
SCONVI_c006_2_14 (conv_i_src_c006_2_14 conv_i_c006_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_14 (conv_q_src_c006_2_14 0 conv_bpf_c006_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_2_14 (conv_q_src_c006_2_14 conv_q_c006_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_2_15 (conv_i_src_c006_2_15 0 conv_bpf_c006_2 0) vcvs gain=9.807852804032e-01
SCONVI_c006_2_15 (conv_i_src_c006_2_15 conv_i_c006_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_2_15 (conv_q_src_c006_2_15 0 conv_bpf_c006_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_2_15 (conv_q_src_c006_2_15 conv_q_c006_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c006_2 (conv_i_c006_2 0) resistor r=1G
RCONVQ_c006_2 (conv_q_c006_2 0) resistor r=1G
RCONVINTI_c006_2 (conv_i_c006_2 ConvIcar_c006_2) resistor r=1k
CCONVINTI_c006_2 (ConvIcar_c006_2 0) capacitor c=80p
RCONVINTQ_c006_2 (conv_q_c006_2 ConvQcar_c006_2) resistor r=1k
CCONVINTQ_c006_2 (ConvQcar_c006_2 0) capacitor c=80p
save conv_bpf_c006_2 ConvIcar_c006_2 ConvQcar_c006_2

// conventional mixed baseline bl006, carrier_3: 1000000000 Hz
CCONVBPF_c006_3 (bl006 n_conv_cbpf_c006_3) capacitor c=2.533029591058e-14
LCONVBPF_c006_3 (n_conv_cbpf_c006_3 conv_bpf_c006_3) inductor l=1.000000000000e-06
RCONVBPF_c006_3 (conv_bpf_c006_3 0) resistor r=3.141592653590e+02
ECONVI_c006_3_00 (conv_i_src_c006_3_00 0 conv_bpf_c006_3 0) vcvs gain=9.807852804032e-01
SCONVI_c006_3_00 (conv_i_src_c006_3_00 conv_i_c006_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_00 (conv_q_src_c006_3_00 0 conv_bpf_c006_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_3_00 (conv_q_src_c006_3_00 conv_q_c006_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_01 (conv_i_src_c006_3_01 0 conv_bpf_c006_3 0) vcvs gain=8.314696123025e-01
SCONVI_c006_3_01 (conv_i_src_c006_3_01 conv_i_c006_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_01 (conv_q_src_c006_3_01 0 conv_bpf_c006_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_3_01 (conv_q_src_c006_3_01 conv_q_c006_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_02 (conv_i_src_c006_3_02 0 conv_bpf_c006_3 0) vcvs gain=5.555702330196e-01
SCONVI_c006_3_02 (conv_i_src_c006_3_02 conv_i_c006_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_02 (conv_q_src_c006_3_02 0 conv_bpf_c006_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_3_02 (conv_q_src_c006_3_02 conv_q_c006_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_03 (conv_i_src_c006_3_03 0 conv_bpf_c006_3 0) vcvs gain=1.950903220161e-01
SCONVI_c006_3_03 (conv_i_src_c006_3_03 conv_i_c006_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_03 (conv_q_src_c006_3_03 0 conv_bpf_c006_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_3_03 (conv_q_src_c006_3_03 conv_q_c006_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_04 (conv_i_src_c006_3_04 0 conv_bpf_c006_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_3_04 (conv_i_src_c006_3_04 conv_i_c006_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_04 (conv_q_src_c006_3_04 0 conv_bpf_c006_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c006_3_04 (conv_q_src_c006_3_04 conv_q_c006_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_05 (conv_i_src_c006_3_05 0 conv_bpf_c006_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_3_05 (conv_i_src_c006_3_05 conv_i_c006_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_05 (conv_q_src_c006_3_05 0 conv_bpf_c006_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c006_3_05 (conv_q_src_c006_3_05 conv_q_c006_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_06 (conv_i_src_c006_3_06 0 conv_bpf_c006_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_3_06 (conv_i_src_c006_3_06 conv_i_c006_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_06 (conv_q_src_c006_3_06 0 conv_bpf_c006_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c006_3_06 (conv_q_src_c006_3_06 conv_q_c006_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_07 (conv_i_src_c006_3_07 0 conv_bpf_c006_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_3_07 (conv_i_src_c006_3_07 conv_i_c006_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_07 (conv_q_src_c006_3_07 0 conv_bpf_c006_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c006_3_07 (conv_q_src_c006_3_07 conv_q_c006_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_08 (conv_i_src_c006_3_08 0 conv_bpf_c006_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c006_3_08 (conv_i_src_c006_3_08 conv_i_c006_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_08 (conv_q_src_c006_3_08 0 conv_bpf_c006_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_3_08 (conv_q_src_c006_3_08 conv_q_c006_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_09 (conv_i_src_c006_3_09 0 conv_bpf_c006_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c006_3_09 (conv_i_src_c006_3_09 conv_i_c006_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_09 (conv_q_src_c006_3_09 0 conv_bpf_c006_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_3_09 (conv_q_src_c006_3_09 conv_q_c006_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_10 (conv_i_src_c006_3_10 0 conv_bpf_c006_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c006_3_10 (conv_i_src_c006_3_10 conv_i_c006_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_10 (conv_q_src_c006_3_10 0 conv_bpf_c006_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_3_10 (conv_q_src_c006_3_10 conv_q_c006_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_11 (conv_i_src_c006_3_11 0 conv_bpf_c006_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c006_3_11 (conv_i_src_c006_3_11 conv_i_c006_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_11 (conv_q_src_c006_3_11 0 conv_bpf_c006_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_3_11 (conv_q_src_c006_3_11 conv_q_c006_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_12 (conv_i_src_c006_3_12 0 conv_bpf_c006_3 0) vcvs gain=1.950903220161e-01
SCONVI_c006_3_12 (conv_i_src_c006_3_12 conv_i_c006_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_12 (conv_q_src_c006_3_12 0 conv_bpf_c006_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c006_3_12 (conv_q_src_c006_3_12 conv_q_c006_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_13 (conv_i_src_c006_3_13 0 conv_bpf_c006_3 0) vcvs gain=5.555702330196e-01
SCONVI_c006_3_13 (conv_i_src_c006_3_13 conv_i_c006_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_13 (conv_q_src_c006_3_13 0 conv_bpf_c006_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c006_3_13 (conv_q_src_c006_3_13 conv_q_c006_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_14 (conv_i_src_c006_3_14 0 conv_bpf_c006_3 0) vcvs gain=8.314696123025e-01
SCONVI_c006_3_14 (conv_i_src_c006_3_14 conv_i_c006_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_14 (conv_q_src_c006_3_14 0 conv_bpf_c006_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c006_3_14 (conv_q_src_c006_3_14 conv_q_c006_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c006_3_15 (conv_i_src_c006_3_15 0 conv_bpf_c006_3 0) vcvs gain=9.807852804032e-01
SCONVI_c006_3_15 (conv_i_src_c006_3_15 conv_i_c006_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c006_3_15 (conv_q_src_c006_3_15 0 conv_bpf_c006_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c006_3_15 (conv_q_src_c006_3_15 conv_q_c006_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c006_3 (conv_i_c006_3 0) resistor r=1G
RCONVQ_c006_3 (conv_q_c006_3 0) resistor r=1G
RCONVINTI_c006_3 (conv_i_c006_3 ConvIcar_c006_3) resistor r=1k
CCONVINTI_c006_3 (ConvIcar_c006_3 0) capacitor c=80p
RCONVINTQ_c006_3 (conv_q_c006_3 ConvQcar_c006_3) resistor r=1k
CCONVINTQ_c006_3 (ConvQcar_c006_3 0) capacitor c=80p
save conv_bpf_c006_3 ConvIcar_c006_3 ConvQcar_c006_3

// conventional mixed baseline bl007, carrier_0: 250000000 Hz
CCONVBPF_c007_0 (bl007 n_conv_cbpf_c007_0) capacitor c=4.052847345694e-13
LCONVBPF_c007_0 (n_conv_cbpf_c007_0 conv_bpf_c007_0) inductor l=1.000000000000e-06
RCONVBPF_c007_0 (conv_bpf_c007_0 0) resistor r=7.853981633974e+01
ECONVI_c007_0_00 (conv_i_src_c007_0_00 0 conv_bpf_c007_0 0) vcvs gain=9.807852804032e-01
SCONVI_c007_0_00 (conv_i_src_c007_0_00 conv_i_c007_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_00 (conv_q_src_c007_0_00 0 conv_bpf_c007_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_0_00 (conv_q_src_c007_0_00 conv_q_c007_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_01 (conv_i_src_c007_0_01 0 conv_bpf_c007_0 0) vcvs gain=8.314696123025e-01
SCONVI_c007_0_01 (conv_i_src_c007_0_01 conv_i_c007_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_01 (conv_q_src_c007_0_01 0 conv_bpf_c007_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_0_01 (conv_q_src_c007_0_01 conv_q_c007_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_02 (conv_i_src_c007_0_02 0 conv_bpf_c007_0 0) vcvs gain=5.555702330196e-01
SCONVI_c007_0_02 (conv_i_src_c007_0_02 conv_i_c007_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_02 (conv_q_src_c007_0_02 0 conv_bpf_c007_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_0_02 (conv_q_src_c007_0_02 conv_q_c007_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_03 (conv_i_src_c007_0_03 0 conv_bpf_c007_0 0) vcvs gain=1.950903220161e-01
SCONVI_c007_0_03 (conv_i_src_c007_0_03 conv_i_c007_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_03 (conv_q_src_c007_0_03 0 conv_bpf_c007_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_0_03 (conv_q_src_c007_0_03 conv_q_c007_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_04 (conv_i_src_c007_0_04 0 conv_bpf_c007_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_0_04 (conv_i_src_c007_0_04 conv_i_c007_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_04 (conv_q_src_c007_0_04 0 conv_bpf_c007_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_0_04 (conv_q_src_c007_0_04 conv_q_c007_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_05 (conv_i_src_c007_0_05 0 conv_bpf_c007_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_0_05 (conv_i_src_c007_0_05 conv_i_c007_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_05 (conv_q_src_c007_0_05 0 conv_bpf_c007_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_0_05 (conv_q_src_c007_0_05 conv_q_c007_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_06 (conv_i_src_c007_0_06 0 conv_bpf_c007_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_0_06 (conv_i_src_c007_0_06 conv_i_c007_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_06 (conv_q_src_c007_0_06 0 conv_bpf_c007_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_0_06 (conv_q_src_c007_0_06 conv_q_c007_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_07 (conv_i_src_c007_0_07 0 conv_bpf_c007_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_0_07 (conv_i_src_c007_0_07 conv_i_c007_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_07 (conv_q_src_c007_0_07 0 conv_bpf_c007_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_0_07 (conv_q_src_c007_0_07 conv_q_c007_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_08 (conv_i_src_c007_0_08 0 conv_bpf_c007_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_0_08 (conv_i_src_c007_0_08 conv_i_c007_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_08 (conv_q_src_c007_0_08 0 conv_bpf_c007_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_0_08 (conv_q_src_c007_0_08 conv_q_c007_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_09 (conv_i_src_c007_0_09 0 conv_bpf_c007_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_0_09 (conv_i_src_c007_0_09 conv_i_c007_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_09 (conv_q_src_c007_0_09 0 conv_bpf_c007_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_0_09 (conv_q_src_c007_0_09 conv_q_c007_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_10 (conv_i_src_c007_0_10 0 conv_bpf_c007_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_0_10 (conv_i_src_c007_0_10 conv_i_c007_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_10 (conv_q_src_c007_0_10 0 conv_bpf_c007_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_0_10 (conv_q_src_c007_0_10 conv_q_c007_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_11 (conv_i_src_c007_0_11 0 conv_bpf_c007_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_0_11 (conv_i_src_c007_0_11 conv_i_c007_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_11 (conv_q_src_c007_0_11 0 conv_bpf_c007_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_0_11 (conv_q_src_c007_0_11 conv_q_c007_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_12 (conv_i_src_c007_0_12 0 conv_bpf_c007_0 0) vcvs gain=1.950903220161e-01
SCONVI_c007_0_12 (conv_i_src_c007_0_12 conv_i_c007_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_12 (conv_q_src_c007_0_12 0 conv_bpf_c007_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_0_12 (conv_q_src_c007_0_12 conv_q_c007_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_13 (conv_i_src_c007_0_13 0 conv_bpf_c007_0 0) vcvs gain=5.555702330196e-01
SCONVI_c007_0_13 (conv_i_src_c007_0_13 conv_i_c007_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_13 (conv_q_src_c007_0_13 0 conv_bpf_c007_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_0_13 (conv_q_src_c007_0_13 conv_q_c007_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_14 (conv_i_src_c007_0_14 0 conv_bpf_c007_0 0) vcvs gain=8.314696123025e-01
SCONVI_c007_0_14 (conv_i_src_c007_0_14 conv_i_c007_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_14 (conv_q_src_c007_0_14 0 conv_bpf_c007_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_0_14 (conv_q_src_c007_0_14 conv_q_c007_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_0_15 (conv_i_src_c007_0_15 0 conv_bpf_c007_0 0) vcvs gain=9.807852804032e-01
SCONVI_c007_0_15 (conv_i_src_c007_0_15 conv_i_c007_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_0_15 (conv_q_src_c007_0_15 0 conv_bpf_c007_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_0_15 (conv_q_src_c007_0_15 conv_q_c007_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c007_0 (conv_i_c007_0 0) resistor r=1G
RCONVQ_c007_0 (conv_q_c007_0 0) resistor r=1G
RCONVINTI_c007_0 (conv_i_c007_0 ConvIcar_c007_0) resistor r=1k
CCONVINTI_c007_0 (ConvIcar_c007_0 0) capacitor c=80p
RCONVINTQ_c007_0 (conv_q_c007_0 ConvQcar_c007_0) resistor r=1k
CCONVINTQ_c007_0 (ConvQcar_c007_0 0) capacitor c=80p
save conv_bpf_c007_0 ConvIcar_c007_0 ConvQcar_c007_0

// conventional mixed baseline bl007, carrier_1: 500000000 Hz
CCONVBPF_c007_1 (bl007 n_conv_cbpf_c007_1) capacitor c=1.013211836423e-13
LCONVBPF_c007_1 (n_conv_cbpf_c007_1 conv_bpf_c007_1) inductor l=1.000000000000e-06
RCONVBPF_c007_1 (conv_bpf_c007_1 0) resistor r=1.570796326795e+02
ECONVI_c007_1_00 (conv_i_src_c007_1_00 0 conv_bpf_c007_1 0) vcvs gain=9.807852804032e-01
SCONVI_c007_1_00 (conv_i_src_c007_1_00 conv_i_c007_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_00 (conv_q_src_c007_1_00 0 conv_bpf_c007_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_1_00 (conv_q_src_c007_1_00 conv_q_c007_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_01 (conv_i_src_c007_1_01 0 conv_bpf_c007_1 0) vcvs gain=8.314696123025e-01
SCONVI_c007_1_01 (conv_i_src_c007_1_01 conv_i_c007_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_01 (conv_q_src_c007_1_01 0 conv_bpf_c007_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_1_01 (conv_q_src_c007_1_01 conv_q_c007_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_02 (conv_i_src_c007_1_02 0 conv_bpf_c007_1 0) vcvs gain=5.555702330196e-01
SCONVI_c007_1_02 (conv_i_src_c007_1_02 conv_i_c007_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_02 (conv_q_src_c007_1_02 0 conv_bpf_c007_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_1_02 (conv_q_src_c007_1_02 conv_q_c007_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_03 (conv_i_src_c007_1_03 0 conv_bpf_c007_1 0) vcvs gain=1.950903220161e-01
SCONVI_c007_1_03 (conv_i_src_c007_1_03 conv_i_c007_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_03 (conv_q_src_c007_1_03 0 conv_bpf_c007_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_1_03 (conv_q_src_c007_1_03 conv_q_c007_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_04 (conv_i_src_c007_1_04 0 conv_bpf_c007_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_1_04 (conv_i_src_c007_1_04 conv_i_c007_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_04 (conv_q_src_c007_1_04 0 conv_bpf_c007_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_1_04 (conv_q_src_c007_1_04 conv_q_c007_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_05 (conv_i_src_c007_1_05 0 conv_bpf_c007_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_1_05 (conv_i_src_c007_1_05 conv_i_c007_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_05 (conv_q_src_c007_1_05 0 conv_bpf_c007_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_1_05 (conv_q_src_c007_1_05 conv_q_c007_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_06 (conv_i_src_c007_1_06 0 conv_bpf_c007_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_1_06 (conv_i_src_c007_1_06 conv_i_c007_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_06 (conv_q_src_c007_1_06 0 conv_bpf_c007_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_1_06 (conv_q_src_c007_1_06 conv_q_c007_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_07 (conv_i_src_c007_1_07 0 conv_bpf_c007_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_1_07 (conv_i_src_c007_1_07 conv_i_c007_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_07 (conv_q_src_c007_1_07 0 conv_bpf_c007_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_1_07 (conv_q_src_c007_1_07 conv_q_c007_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_08 (conv_i_src_c007_1_08 0 conv_bpf_c007_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_1_08 (conv_i_src_c007_1_08 conv_i_c007_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_08 (conv_q_src_c007_1_08 0 conv_bpf_c007_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_1_08 (conv_q_src_c007_1_08 conv_q_c007_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_09 (conv_i_src_c007_1_09 0 conv_bpf_c007_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_1_09 (conv_i_src_c007_1_09 conv_i_c007_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_09 (conv_q_src_c007_1_09 0 conv_bpf_c007_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_1_09 (conv_q_src_c007_1_09 conv_q_c007_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_10 (conv_i_src_c007_1_10 0 conv_bpf_c007_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_1_10 (conv_i_src_c007_1_10 conv_i_c007_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_10 (conv_q_src_c007_1_10 0 conv_bpf_c007_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_1_10 (conv_q_src_c007_1_10 conv_q_c007_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_11 (conv_i_src_c007_1_11 0 conv_bpf_c007_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_1_11 (conv_i_src_c007_1_11 conv_i_c007_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_11 (conv_q_src_c007_1_11 0 conv_bpf_c007_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_1_11 (conv_q_src_c007_1_11 conv_q_c007_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_12 (conv_i_src_c007_1_12 0 conv_bpf_c007_1 0) vcvs gain=1.950903220161e-01
SCONVI_c007_1_12 (conv_i_src_c007_1_12 conv_i_c007_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_12 (conv_q_src_c007_1_12 0 conv_bpf_c007_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_1_12 (conv_q_src_c007_1_12 conv_q_c007_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_13 (conv_i_src_c007_1_13 0 conv_bpf_c007_1 0) vcvs gain=5.555702330196e-01
SCONVI_c007_1_13 (conv_i_src_c007_1_13 conv_i_c007_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_13 (conv_q_src_c007_1_13 0 conv_bpf_c007_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_1_13 (conv_q_src_c007_1_13 conv_q_c007_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_14 (conv_i_src_c007_1_14 0 conv_bpf_c007_1 0) vcvs gain=8.314696123025e-01
SCONVI_c007_1_14 (conv_i_src_c007_1_14 conv_i_c007_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_14 (conv_q_src_c007_1_14 0 conv_bpf_c007_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_1_14 (conv_q_src_c007_1_14 conv_q_c007_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_1_15 (conv_i_src_c007_1_15 0 conv_bpf_c007_1 0) vcvs gain=9.807852804032e-01
SCONVI_c007_1_15 (conv_i_src_c007_1_15 conv_i_c007_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_1_15 (conv_q_src_c007_1_15 0 conv_bpf_c007_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_1_15 (conv_q_src_c007_1_15 conv_q_c007_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c007_1 (conv_i_c007_1 0) resistor r=1G
RCONVQ_c007_1 (conv_q_c007_1 0) resistor r=1G
RCONVINTI_c007_1 (conv_i_c007_1 ConvIcar_c007_1) resistor r=1k
CCONVINTI_c007_1 (ConvIcar_c007_1 0) capacitor c=80p
RCONVINTQ_c007_1 (conv_q_c007_1 ConvQcar_c007_1) resistor r=1k
CCONVINTQ_c007_1 (ConvQcar_c007_1 0) capacitor c=80p
save conv_bpf_c007_1 ConvIcar_c007_1 ConvQcar_c007_1

// conventional mixed baseline bl007, carrier_2: 750000000 Hz
CCONVBPF_c007_2 (bl007 n_conv_cbpf_c007_2) capacitor c=4.503163717437e-14
LCONVBPF_c007_2 (n_conv_cbpf_c007_2 conv_bpf_c007_2) inductor l=1.000000000000e-06
RCONVBPF_c007_2 (conv_bpf_c007_2 0) resistor r=2.356194490192e+02
ECONVI_c007_2_00 (conv_i_src_c007_2_00 0 conv_bpf_c007_2 0) vcvs gain=9.807852804032e-01
SCONVI_c007_2_00 (conv_i_src_c007_2_00 conv_i_c007_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_00 (conv_q_src_c007_2_00 0 conv_bpf_c007_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_2_00 (conv_q_src_c007_2_00 conv_q_c007_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_01 (conv_i_src_c007_2_01 0 conv_bpf_c007_2 0) vcvs gain=8.314696123025e-01
SCONVI_c007_2_01 (conv_i_src_c007_2_01 conv_i_c007_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_01 (conv_q_src_c007_2_01 0 conv_bpf_c007_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_2_01 (conv_q_src_c007_2_01 conv_q_c007_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_02 (conv_i_src_c007_2_02 0 conv_bpf_c007_2 0) vcvs gain=5.555702330196e-01
SCONVI_c007_2_02 (conv_i_src_c007_2_02 conv_i_c007_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_02 (conv_q_src_c007_2_02 0 conv_bpf_c007_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_2_02 (conv_q_src_c007_2_02 conv_q_c007_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_03 (conv_i_src_c007_2_03 0 conv_bpf_c007_2 0) vcvs gain=1.950903220161e-01
SCONVI_c007_2_03 (conv_i_src_c007_2_03 conv_i_c007_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_03 (conv_q_src_c007_2_03 0 conv_bpf_c007_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_2_03 (conv_q_src_c007_2_03 conv_q_c007_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_04 (conv_i_src_c007_2_04 0 conv_bpf_c007_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_2_04 (conv_i_src_c007_2_04 conv_i_c007_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_04 (conv_q_src_c007_2_04 0 conv_bpf_c007_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_2_04 (conv_q_src_c007_2_04 conv_q_c007_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_05 (conv_i_src_c007_2_05 0 conv_bpf_c007_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_2_05 (conv_i_src_c007_2_05 conv_i_c007_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_05 (conv_q_src_c007_2_05 0 conv_bpf_c007_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_2_05 (conv_q_src_c007_2_05 conv_q_c007_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_06 (conv_i_src_c007_2_06 0 conv_bpf_c007_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_2_06 (conv_i_src_c007_2_06 conv_i_c007_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_06 (conv_q_src_c007_2_06 0 conv_bpf_c007_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_2_06 (conv_q_src_c007_2_06 conv_q_c007_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_07 (conv_i_src_c007_2_07 0 conv_bpf_c007_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_2_07 (conv_i_src_c007_2_07 conv_i_c007_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_07 (conv_q_src_c007_2_07 0 conv_bpf_c007_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_2_07 (conv_q_src_c007_2_07 conv_q_c007_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_08 (conv_i_src_c007_2_08 0 conv_bpf_c007_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_2_08 (conv_i_src_c007_2_08 conv_i_c007_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_08 (conv_q_src_c007_2_08 0 conv_bpf_c007_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_2_08 (conv_q_src_c007_2_08 conv_q_c007_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_09 (conv_i_src_c007_2_09 0 conv_bpf_c007_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_2_09 (conv_i_src_c007_2_09 conv_i_c007_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_09 (conv_q_src_c007_2_09 0 conv_bpf_c007_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_2_09 (conv_q_src_c007_2_09 conv_q_c007_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_10 (conv_i_src_c007_2_10 0 conv_bpf_c007_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_2_10 (conv_i_src_c007_2_10 conv_i_c007_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_10 (conv_q_src_c007_2_10 0 conv_bpf_c007_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_2_10 (conv_q_src_c007_2_10 conv_q_c007_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_11 (conv_i_src_c007_2_11 0 conv_bpf_c007_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_2_11 (conv_i_src_c007_2_11 conv_i_c007_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_11 (conv_q_src_c007_2_11 0 conv_bpf_c007_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_2_11 (conv_q_src_c007_2_11 conv_q_c007_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_12 (conv_i_src_c007_2_12 0 conv_bpf_c007_2 0) vcvs gain=1.950903220161e-01
SCONVI_c007_2_12 (conv_i_src_c007_2_12 conv_i_c007_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_12 (conv_q_src_c007_2_12 0 conv_bpf_c007_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_2_12 (conv_q_src_c007_2_12 conv_q_c007_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_13 (conv_i_src_c007_2_13 0 conv_bpf_c007_2 0) vcvs gain=5.555702330196e-01
SCONVI_c007_2_13 (conv_i_src_c007_2_13 conv_i_c007_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_13 (conv_q_src_c007_2_13 0 conv_bpf_c007_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_2_13 (conv_q_src_c007_2_13 conv_q_c007_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_14 (conv_i_src_c007_2_14 0 conv_bpf_c007_2 0) vcvs gain=8.314696123025e-01
SCONVI_c007_2_14 (conv_i_src_c007_2_14 conv_i_c007_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_14 (conv_q_src_c007_2_14 0 conv_bpf_c007_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_2_14 (conv_q_src_c007_2_14 conv_q_c007_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_2_15 (conv_i_src_c007_2_15 0 conv_bpf_c007_2 0) vcvs gain=9.807852804032e-01
SCONVI_c007_2_15 (conv_i_src_c007_2_15 conv_i_c007_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_2_15 (conv_q_src_c007_2_15 0 conv_bpf_c007_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_2_15 (conv_q_src_c007_2_15 conv_q_c007_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c007_2 (conv_i_c007_2 0) resistor r=1G
RCONVQ_c007_2 (conv_q_c007_2 0) resistor r=1G
RCONVINTI_c007_2 (conv_i_c007_2 ConvIcar_c007_2) resistor r=1k
CCONVINTI_c007_2 (ConvIcar_c007_2 0) capacitor c=80p
RCONVINTQ_c007_2 (conv_q_c007_2 ConvQcar_c007_2) resistor r=1k
CCONVINTQ_c007_2 (ConvQcar_c007_2 0) capacitor c=80p
save conv_bpf_c007_2 ConvIcar_c007_2 ConvQcar_c007_2

// conventional mixed baseline bl007, carrier_3: 1000000000 Hz
CCONVBPF_c007_3 (bl007 n_conv_cbpf_c007_3) capacitor c=2.533029591058e-14
LCONVBPF_c007_3 (n_conv_cbpf_c007_3 conv_bpf_c007_3) inductor l=1.000000000000e-06
RCONVBPF_c007_3 (conv_bpf_c007_3 0) resistor r=3.141592653590e+02
ECONVI_c007_3_00 (conv_i_src_c007_3_00 0 conv_bpf_c007_3 0) vcvs gain=9.807852804032e-01
SCONVI_c007_3_00 (conv_i_src_c007_3_00 conv_i_c007_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_00 (conv_q_src_c007_3_00 0 conv_bpf_c007_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_3_00 (conv_q_src_c007_3_00 conv_q_c007_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_01 (conv_i_src_c007_3_01 0 conv_bpf_c007_3 0) vcvs gain=8.314696123025e-01
SCONVI_c007_3_01 (conv_i_src_c007_3_01 conv_i_c007_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_01 (conv_q_src_c007_3_01 0 conv_bpf_c007_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_3_01 (conv_q_src_c007_3_01 conv_q_c007_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_02 (conv_i_src_c007_3_02 0 conv_bpf_c007_3 0) vcvs gain=5.555702330196e-01
SCONVI_c007_3_02 (conv_i_src_c007_3_02 conv_i_c007_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_02 (conv_q_src_c007_3_02 0 conv_bpf_c007_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_3_02 (conv_q_src_c007_3_02 conv_q_c007_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_03 (conv_i_src_c007_3_03 0 conv_bpf_c007_3 0) vcvs gain=1.950903220161e-01
SCONVI_c007_3_03 (conv_i_src_c007_3_03 conv_i_c007_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_03 (conv_q_src_c007_3_03 0 conv_bpf_c007_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_3_03 (conv_q_src_c007_3_03 conv_q_c007_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_04 (conv_i_src_c007_3_04 0 conv_bpf_c007_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_3_04 (conv_i_src_c007_3_04 conv_i_c007_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_04 (conv_q_src_c007_3_04 0 conv_bpf_c007_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c007_3_04 (conv_q_src_c007_3_04 conv_q_c007_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_05 (conv_i_src_c007_3_05 0 conv_bpf_c007_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_3_05 (conv_i_src_c007_3_05 conv_i_c007_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_05 (conv_q_src_c007_3_05 0 conv_bpf_c007_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c007_3_05 (conv_q_src_c007_3_05 conv_q_c007_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_06 (conv_i_src_c007_3_06 0 conv_bpf_c007_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_3_06 (conv_i_src_c007_3_06 conv_i_c007_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_06 (conv_q_src_c007_3_06 0 conv_bpf_c007_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c007_3_06 (conv_q_src_c007_3_06 conv_q_c007_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_07 (conv_i_src_c007_3_07 0 conv_bpf_c007_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_3_07 (conv_i_src_c007_3_07 conv_i_c007_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_07 (conv_q_src_c007_3_07 0 conv_bpf_c007_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c007_3_07 (conv_q_src_c007_3_07 conv_q_c007_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_08 (conv_i_src_c007_3_08 0 conv_bpf_c007_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c007_3_08 (conv_i_src_c007_3_08 conv_i_c007_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_08 (conv_q_src_c007_3_08 0 conv_bpf_c007_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_3_08 (conv_q_src_c007_3_08 conv_q_c007_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_09 (conv_i_src_c007_3_09 0 conv_bpf_c007_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c007_3_09 (conv_i_src_c007_3_09 conv_i_c007_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_09 (conv_q_src_c007_3_09 0 conv_bpf_c007_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_3_09 (conv_q_src_c007_3_09 conv_q_c007_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_10 (conv_i_src_c007_3_10 0 conv_bpf_c007_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c007_3_10 (conv_i_src_c007_3_10 conv_i_c007_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_10 (conv_q_src_c007_3_10 0 conv_bpf_c007_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_3_10 (conv_q_src_c007_3_10 conv_q_c007_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_11 (conv_i_src_c007_3_11 0 conv_bpf_c007_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c007_3_11 (conv_i_src_c007_3_11 conv_i_c007_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_11 (conv_q_src_c007_3_11 0 conv_bpf_c007_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_3_11 (conv_q_src_c007_3_11 conv_q_c007_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_12 (conv_i_src_c007_3_12 0 conv_bpf_c007_3 0) vcvs gain=1.950903220161e-01
SCONVI_c007_3_12 (conv_i_src_c007_3_12 conv_i_c007_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_12 (conv_q_src_c007_3_12 0 conv_bpf_c007_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c007_3_12 (conv_q_src_c007_3_12 conv_q_c007_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_13 (conv_i_src_c007_3_13 0 conv_bpf_c007_3 0) vcvs gain=5.555702330196e-01
SCONVI_c007_3_13 (conv_i_src_c007_3_13 conv_i_c007_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_13 (conv_q_src_c007_3_13 0 conv_bpf_c007_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c007_3_13 (conv_q_src_c007_3_13 conv_q_c007_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_14 (conv_i_src_c007_3_14 0 conv_bpf_c007_3 0) vcvs gain=8.314696123025e-01
SCONVI_c007_3_14 (conv_i_src_c007_3_14 conv_i_c007_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_14 (conv_q_src_c007_3_14 0 conv_bpf_c007_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c007_3_14 (conv_q_src_c007_3_14 conv_q_c007_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c007_3_15 (conv_i_src_c007_3_15 0 conv_bpf_c007_3 0) vcvs gain=9.807852804032e-01
SCONVI_c007_3_15 (conv_i_src_c007_3_15 conv_i_c007_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c007_3_15 (conv_q_src_c007_3_15 0 conv_bpf_c007_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c007_3_15 (conv_q_src_c007_3_15 conv_q_c007_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c007_3 (conv_i_c007_3 0) resistor r=1G
RCONVQ_c007_3 (conv_q_c007_3 0) resistor r=1G
RCONVINTI_c007_3 (conv_i_c007_3 ConvIcar_c007_3) resistor r=1k
CCONVINTI_c007_3 (ConvIcar_c007_3 0) capacitor c=80p
RCONVINTQ_c007_3 (conv_q_c007_3 ConvQcar_c007_3) resistor r=1k
CCONVINTQ_c007_3 (ConvQcar_c007_3 0) capacitor c=80p
save conv_bpf_c007_3 ConvIcar_c007_3 ConvQcar_c007_3

// conventional mixed baseline bl008, carrier_0: 250000000 Hz
CCONVBPF_c008_0 (bl008 n_conv_cbpf_c008_0) capacitor c=4.052847345694e-13
LCONVBPF_c008_0 (n_conv_cbpf_c008_0 conv_bpf_c008_0) inductor l=1.000000000000e-06
RCONVBPF_c008_0 (conv_bpf_c008_0 0) resistor r=7.853981633974e+01
ECONVI_c008_0_00 (conv_i_src_c008_0_00 0 conv_bpf_c008_0 0) vcvs gain=9.807852804032e-01
SCONVI_c008_0_00 (conv_i_src_c008_0_00 conv_i_c008_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_00 (conv_q_src_c008_0_00 0 conv_bpf_c008_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_0_00 (conv_q_src_c008_0_00 conv_q_c008_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_01 (conv_i_src_c008_0_01 0 conv_bpf_c008_0 0) vcvs gain=8.314696123025e-01
SCONVI_c008_0_01 (conv_i_src_c008_0_01 conv_i_c008_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_01 (conv_q_src_c008_0_01 0 conv_bpf_c008_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_0_01 (conv_q_src_c008_0_01 conv_q_c008_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_02 (conv_i_src_c008_0_02 0 conv_bpf_c008_0 0) vcvs gain=5.555702330196e-01
SCONVI_c008_0_02 (conv_i_src_c008_0_02 conv_i_c008_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_02 (conv_q_src_c008_0_02 0 conv_bpf_c008_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_0_02 (conv_q_src_c008_0_02 conv_q_c008_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_03 (conv_i_src_c008_0_03 0 conv_bpf_c008_0 0) vcvs gain=1.950903220161e-01
SCONVI_c008_0_03 (conv_i_src_c008_0_03 conv_i_c008_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_03 (conv_q_src_c008_0_03 0 conv_bpf_c008_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_0_03 (conv_q_src_c008_0_03 conv_q_c008_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_04 (conv_i_src_c008_0_04 0 conv_bpf_c008_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_0_04 (conv_i_src_c008_0_04 conv_i_c008_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_04 (conv_q_src_c008_0_04 0 conv_bpf_c008_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_0_04 (conv_q_src_c008_0_04 conv_q_c008_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_05 (conv_i_src_c008_0_05 0 conv_bpf_c008_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_0_05 (conv_i_src_c008_0_05 conv_i_c008_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_05 (conv_q_src_c008_0_05 0 conv_bpf_c008_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_0_05 (conv_q_src_c008_0_05 conv_q_c008_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_06 (conv_i_src_c008_0_06 0 conv_bpf_c008_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_0_06 (conv_i_src_c008_0_06 conv_i_c008_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_06 (conv_q_src_c008_0_06 0 conv_bpf_c008_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_0_06 (conv_q_src_c008_0_06 conv_q_c008_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_07 (conv_i_src_c008_0_07 0 conv_bpf_c008_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_0_07 (conv_i_src_c008_0_07 conv_i_c008_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_07 (conv_q_src_c008_0_07 0 conv_bpf_c008_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_0_07 (conv_q_src_c008_0_07 conv_q_c008_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_08 (conv_i_src_c008_0_08 0 conv_bpf_c008_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_0_08 (conv_i_src_c008_0_08 conv_i_c008_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_08 (conv_q_src_c008_0_08 0 conv_bpf_c008_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_0_08 (conv_q_src_c008_0_08 conv_q_c008_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_09 (conv_i_src_c008_0_09 0 conv_bpf_c008_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_0_09 (conv_i_src_c008_0_09 conv_i_c008_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_09 (conv_q_src_c008_0_09 0 conv_bpf_c008_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_0_09 (conv_q_src_c008_0_09 conv_q_c008_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_10 (conv_i_src_c008_0_10 0 conv_bpf_c008_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_0_10 (conv_i_src_c008_0_10 conv_i_c008_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_10 (conv_q_src_c008_0_10 0 conv_bpf_c008_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_0_10 (conv_q_src_c008_0_10 conv_q_c008_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_11 (conv_i_src_c008_0_11 0 conv_bpf_c008_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_0_11 (conv_i_src_c008_0_11 conv_i_c008_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_11 (conv_q_src_c008_0_11 0 conv_bpf_c008_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_0_11 (conv_q_src_c008_0_11 conv_q_c008_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_12 (conv_i_src_c008_0_12 0 conv_bpf_c008_0 0) vcvs gain=1.950903220161e-01
SCONVI_c008_0_12 (conv_i_src_c008_0_12 conv_i_c008_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_12 (conv_q_src_c008_0_12 0 conv_bpf_c008_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_0_12 (conv_q_src_c008_0_12 conv_q_c008_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_13 (conv_i_src_c008_0_13 0 conv_bpf_c008_0 0) vcvs gain=5.555702330196e-01
SCONVI_c008_0_13 (conv_i_src_c008_0_13 conv_i_c008_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_13 (conv_q_src_c008_0_13 0 conv_bpf_c008_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_0_13 (conv_q_src_c008_0_13 conv_q_c008_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_14 (conv_i_src_c008_0_14 0 conv_bpf_c008_0 0) vcvs gain=8.314696123025e-01
SCONVI_c008_0_14 (conv_i_src_c008_0_14 conv_i_c008_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_14 (conv_q_src_c008_0_14 0 conv_bpf_c008_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_0_14 (conv_q_src_c008_0_14 conv_q_c008_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_0_15 (conv_i_src_c008_0_15 0 conv_bpf_c008_0 0) vcvs gain=9.807852804032e-01
SCONVI_c008_0_15 (conv_i_src_c008_0_15 conv_i_c008_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_0_15 (conv_q_src_c008_0_15 0 conv_bpf_c008_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_0_15 (conv_q_src_c008_0_15 conv_q_c008_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c008_0 (conv_i_c008_0 0) resistor r=1G
RCONVQ_c008_0 (conv_q_c008_0 0) resistor r=1G
RCONVINTI_c008_0 (conv_i_c008_0 ConvIcar_c008_0) resistor r=1k
CCONVINTI_c008_0 (ConvIcar_c008_0 0) capacitor c=80p
RCONVINTQ_c008_0 (conv_q_c008_0 ConvQcar_c008_0) resistor r=1k
CCONVINTQ_c008_0 (ConvQcar_c008_0 0) capacitor c=80p
save conv_bpf_c008_0 ConvIcar_c008_0 ConvQcar_c008_0

// conventional mixed baseline bl008, carrier_1: 500000000 Hz
CCONVBPF_c008_1 (bl008 n_conv_cbpf_c008_1) capacitor c=1.013211836423e-13
LCONVBPF_c008_1 (n_conv_cbpf_c008_1 conv_bpf_c008_1) inductor l=1.000000000000e-06
RCONVBPF_c008_1 (conv_bpf_c008_1 0) resistor r=1.570796326795e+02
ECONVI_c008_1_00 (conv_i_src_c008_1_00 0 conv_bpf_c008_1 0) vcvs gain=9.807852804032e-01
SCONVI_c008_1_00 (conv_i_src_c008_1_00 conv_i_c008_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_00 (conv_q_src_c008_1_00 0 conv_bpf_c008_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_1_00 (conv_q_src_c008_1_00 conv_q_c008_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_01 (conv_i_src_c008_1_01 0 conv_bpf_c008_1 0) vcvs gain=8.314696123025e-01
SCONVI_c008_1_01 (conv_i_src_c008_1_01 conv_i_c008_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_01 (conv_q_src_c008_1_01 0 conv_bpf_c008_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_1_01 (conv_q_src_c008_1_01 conv_q_c008_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_02 (conv_i_src_c008_1_02 0 conv_bpf_c008_1 0) vcvs gain=5.555702330196e-01
SCONVI_c008_1_02 (conv_i_src_c008_1_02 conv_i_c008_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_02 (conv_q_src_c008_1_02 0 conv_bpf_c008_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_1_02 (conv_q_src_c008_1_02 conv_q_c008_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_03 (conv_i_src_c008_1_03 0 conv_bpf_c008_1 0) vcvs gain=1.950903220161e-01
SCONVI_c008_1_03 (conv_i_src_c008_1_03 conv_i_c008_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_03 (conv_q_src_c008_1_03 0 conv_bpf_c008_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_1_03 (conv_q_src_c008_1_03 conv_q_c008_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_04 (conv_i_src_c008_1_04 0 conv_bpf_c008_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_1_04 (conv_i_src_c008_1_04 conv_i_c008_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_04 (conv_q_src_c008_1_04 0 conv_bpf_c008_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_1_04 (conv_q_src_c008_1_04 conv_q_c008_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_05 (conv_i_src_c008_1_05 0 conv_bpf_c008_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_1_05 (conv_i_src_c008_1_05 conv_i_c008_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_05 (conv_q_src_c008_1_05 0 conv_bpf_c008_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_1_05 (conv_q_src_c008_1_05 conv_q_c008_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_06 (conv_i_src_c008_1_06 0 conv_bpf_c008_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_1_06 (conv_i_src_c008_1_06 conv_i_c008_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_06 (conv_q_src_c008_1_06 0 conv_bpf_c008_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_1_06 (conv_q_src_c008_1_06 conv_q_c008_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_07 (conv_i_src_c008_1_07 0 conv_bpf_c008_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_1_07 (conv_i_src_c008_1_07 conv_i_c008_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_07 (conv_q_src_c008_1_07 0 conv_bpf_c008_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_1_07 (conv_q_src_c008_1_07 conv_q_c008_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_08 (conv_i_src_c008_1_08 0 conv_bpf_c008_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_1_08 (conv_i_src_c008_1_08 conv_i_c008_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_08 (conv_q_src_c008_1_08 0 conv_bpf_c008_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_1_08 (conv_q_src_c008_1_08 conv_q_c008_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_09 (conv_i_src_c008_1_09 0 conv_bpf_c008_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_1_09 (conv_i_src_c008_1_09 conv_i_c008_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_09 (conv_q_src_c008_1_09 0 conv_bpf_c008_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_1_09 (conv_q_src_c008_1_09 conv_q_c008_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_10 (conv_i_src_c008_1_10 0 conv_bpf_c008_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_1_10 (conv_i_src_c008_1_10 conv_i_c008_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_10 (conv_q_src_c008_1_10 0 conv_bpf_c008_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_1_10 (conv_q_src_c008_1_10 conv_q_c008_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_11 (conv_i_src_c008_1_11 0 conv_bpf_c008_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_1_11 (conv_i_src_c008_1_11 conv_i_c008_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_11 (conv_q_src_c008_1_11 0 conv_bpf_c008_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_1_11 (conv_q_src_c008_1_11 conv_q_c008_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_12 (conv_i_src_c008_1_12 0 conv_bpf_c008_1 0) vcvs gain=1.950903220161e-01
SCONVI_c008_1_12 (conv_i_src_c008_1_12 conv_i_c008_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_12 (conv_q_src_c008_1_12 0 conv_bpf_c008_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_1_12 (conv_q_src_c008_1_12 conv_q_c008_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_13 (conv_i_src_c008_1_13 0 conv_bpf_c008_1 0) vcvs gain=5.555702330196e-01
SCONVI_c008_1_13 (conv_i_src_c008_1_13 conv_i_c008_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_13 (conv_q_src_c008_1_13 0 conv_bpf_c008_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_1_13 (conv_q_src_c008_1_13 conv_q_c008_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_14 (conv_i_src_c008_1_14 0 conv_bpf_c008_1 0) vcvs gain=8.314696123025e-01
SCONVI_c008_1_14 (conv_i_src_c008_1_14 conv_i_c008_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_14 (conv_q_src_c008_1_14 0 conv_bpf_c008_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_1_14 (conv_q_src_c008_1_14 conv_q_c008_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_1_15 (conv_i_src_c008_1_15 0 conv_bpf_c008_1 0) vcvs gain=9.807852804032e-01
SCONVI_c008_1_15 (conv_i_src_c008_1_15 conv_i_c008_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_1_15 (conv_q_src_c008_1_15 0 conv_bpf_c008_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_1_15 (conv_q_src_c008_1_15 conv_q_c008_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c008_1 (conv_i_c008_1 0) resistor r=1G
RCONVQ_c008_1 (conv_q_c008_1 0) resistor r=1G
RCONVINTI_c008_1 (conv_i_c008_1 ConvIcar_c008_1) resistor r=1k
CCONVINTI_c008_1 (ConvIcar_c008_1 0) capacitor c=80p
RCONVINTQ_c008_1 (conv_q_c008_1 ConvQcar_c008_1) resistor r=1k
CCONVINTQ_c008_1 (ConvQcar_c008_1 0) capacitor c=80p
save conv_bpf_c008_1 ConvIcar_c008_1 ConvQcar_c008_1

// conventional mixed baseline bl008, carrier_2: 750000000 Hz
CCONVBPF_c008_2 (bl008 n_conv_cbpf_c008_2) capacitor c=4.503163717437e-14
LCONVBPF_c008_2 (n_conv_cbpf_c008_2 conv_bpf_c008_2) inductor l=1.000000000000e-06
RCONVBPF_c008_2 (conv_bpf_c008_2 0) resistor r=2.356194490192e+02
ECONVI_c008_2_00 (conv_i_src_c008_2_00 0 conv_bpf_c008_2 0) vcvs gain=9.807852804032e-01
SCONVI_c008_2_00 (conv_i_src_c008_2_00 conv_i_c008_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_00 (conv_q_src_c008_2_00 0 conv_bpf_c008_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_2_00 (conv_q_src_c008_2_00 conv_q_c008_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_01 (conv_i_src_c008_2_01 0 conv_bpf_c008_2 0) vcvs gain=8.314696123025e-01
SCONVI_c008_2_01 (conv_i_src_c008_2_01 conv_i_c008_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_01 (conv_q_src_c008_2_01 0 conv_bpf_c008_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_2_01 (conv_q_src_c008_2_01 conv_q_c008_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_02 (conv_i_src_c008_2_02 0 conv_bpf_c008_2 0) vcvs gain=5.555702330196e-01
SCONVI_c008_2_02 (conv_i_src_c008_2_02 conv_i_c008_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_02 (conv_q_src_c008_2_02 0 conv_bpf_c008_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_2_02 (conv_q_src_c008_2_02 conv_q_c008_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_03 (conv_i_src_c008_2_03 0 conv_bpf_c008_2 0) vcvs gain=1.950903220161e-01
SCONVI_c008_2_03 (conv_i_src_c008_2_03 conv_i_c008_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_03 (conv_q_src_c008_2_03 0 conv_bpf_c008_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_2_03 (conv_q_src_c008_2_03 conv_q_c008_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_04 (conv_i_src_c008_2_04 0 conv_bpf_c008_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_2_04 (conv_i_src_c008_2_04 conv_i_c008_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_04 (conv_q_src_c008_2_04 0 conv_bpf_c008_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_2_04 (conv_q_src_c008_2_04 conv_q_c008_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_05 (conv_i_src_c008_2_05 0 conv_bpf_c008_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_2_05 (conv_i_src_c008_2_05 conv_i_c008_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_05 (conv_q_src_c008_2_05 0 conv_bpf_c008_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_2_05 (conv_q_src_c008_2_05 conv_q_c008_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_06 (conv_i_src_c008_2_06 0 conv_bpf_c008_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_2_06 (conv_i_src_c008_2_06 conv_i_c008_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_06 (conv_q_src_c008_2_06 0 conv_bpf_c008_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_2_06 (conv_q_src_c008_2_06 conv_q_c008_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_07 (conv_i_src_c008_2_07 0 conv_bpf_c008_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_2_07 (conv_i_src_c008_2_07 conv_i_c008_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_07 (conv_q_src_c008_2_07 0 conv_bpf_c008_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_2_07 (conv_q_src_c008_2_07 conv_q_c008_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_08 (conv_i_src_c008_2_08 0 conv_bpf_c008_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_2_08 (conv_i_src_c008_2_08 conv_i_c008_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_08 (conv_q_src_c008_2_08 0 conv_bpf_c008_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_2_08 (conv_q_src_c008_2_08 conv_q_c008_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_09 (conv_i_src_c008_2_09 0 conv_bpf_c008_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_2_09 (conv_i_src_c008_2_09 conv_i_c008_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_09 (conv_q_src_c008_2_09 0 conv_bpf_c008_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_2_09 (conv_q_src_c008_2_09 conv_q_c008_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_10 (conv_i_src_c008_2_10 0 conv_bpf_c008_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_2_10 (conv_i_src_c008_2_10 conv_i_c008_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_10 (conv_q_src_c008_2_10 0 conv_bpf_c008_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_2_10 (conv_q_src_c008_2_10 conv_q_c008_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_11 (conv_i_src_c008_2_11 0 conv_bpf_c008_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_2_11 (conv_i_src_c008_2_11 conv_i_c008_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_11 (conv_q_src_c008_2_11 0 conv_bpf_c008_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_2_11 (conv_q_src_c008_2_11 conv_q_c008_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_12 (conv_i_src_c008_2_12 0 conv_bpf_c008_2 0) vcvs gain=1.950903220161e-01
SCONVI_c008_2_12 (conv_i_src_c008_2_12 conv_i_c008_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_12 (conv_q_src_c008_2_12 0 conv_bpf_c008_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_2_12 (conv_q_src_c008_2_12 conv_q_c008_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_13 (conv_i_src_c008_2_13 0 conv_bpf_c008_2 0) vcvs gain=5.555702330196e-01
SCONVI_c008_2_13 (conv_i_src_c008_2_13 conv_i_c008_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_13 (conv_q_src_c008_2_13 0 conv_bpf_c008_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_2_13 (conv_q_src_c008_2_13 conv_q_c008_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_14 (conv_i_src_c008_2_14 0 conv_bpf_c008_2 0) vcvs gain=8.314696123025e-01
SCONVI_c008_2_14 (conv_i_src_c008_2_14 conv_i_c008_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_14 (conv_q_src_c008_2_14 0 conv_bpf_c008_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_2_14 (conv_q_src_c008_2_14 conv_q_c008_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_2_15 (conv_i_src_c008_2_15 0 conv_bpf_c008_2 0) vcvs gain=9.807852804032e-01
SCONVI_c008_2_15 (conv_i_src_c008_2_15 conv_i_c008_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_2_15 (conv_q_src_c008_2_15 0 conv_bpf_c008_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_2_15 (conv_q_src_c008_2_15 conv_q_c008_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c008_2 (conv_i_c008_2 0) resistor r=1G
RCONVQ_c008_2 (conv_q_c008_2 0) resistor r=1G
RCONVINTI_c008_2 (conv_i_c008_2 ConvIcar_c008_2) resistor r=1k
CCONVINTI_c008_2 (ConvIcar_c008_2 0) capacitor c=80p
RCONVINTQ_c008_2 (conv_q_c008_2 ConvQcar_c008_2) resistor r=1k
CCONVINTQ_c008_2 (ConvQcar_c008_2 0) capacitor c=80p
save conv_bpf_c008_2 ConvIcar_c008_2 ConvQcar_c008_2

// conventional mixed baseline bl008, carrier_3: 1000000000 Hz
CCONVBPF_c008_3 (bl008 n_conv_cbpf_c008_3) capacitor c=2.533029591058e-14
LCONVBPF_c008_3 (n_conv_cbpf_c008_3 conv_bpf_c008_3) inductor l=1.000000000000e-06
RCONVBPF_c008_3 (conv_bpf_c008_3 0) resistor r=3.141592653590e+02
ECONVI_c008_3_00 (conv_i_src_c008_3_00 0 conv_bpf_c008_3 0) vcvs gain=9.807852804032e-01
SCONVI_c008_3_00 (conv_i_src_c008_3_00 conv_i_c008_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_00 (conv_q_src_c008_3_00 0 conv_bpf_c008_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_3_00 (conv_q_src_c008_3_00 conv_q_c008_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_01 (conv_i_src_c008_3_01 0 conv_bpf_c008_3 0) vcvs gain=8.314696123025e-01
SCONVI_c008_3_01 (conv_i_src_c008_3_01 conv_i_c008_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_01 (conv_q_src_c008_3_01 0 conv_bpf_c008_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_3_01 (conv_q_src_c008_3_01 conv_q_c008_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_02 (conv_i_src_c008_3_02 0 conv_bpf_c008_3 0) vcvs gain=5.555702330196e-01
SCONVI_c008_3_02 (conv_i_src_c008_3_02 conv_i_c008_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_02 (conv_q_src_c008_3_02 0 conv_bpf_c008_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_3_02 (conv_q_src_c008_3_02 conv_q_c008_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_03 (conv_i_src_c008_3_03 0 conv_bpf_c008_3 0) vcvs gain=1.950903220161e-01
SCONVI_c008_3_03 (conv_i_src_c008_3_03 conv_i_c008_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_03 (conv_q_src_c008_3_03 0 conv_bpf_c008_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_3_03 (conv_q_src_c008_3_03 conv_q_c008_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_04 (conv_i_src_c008_3_04 0 conv_bpf_c008_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_3_04 (conv_i_src_c008_3_04 conv_i_c008_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_04 (conv_q_src_c008_3_04 0 conv_bpf_c008_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c008_3_04 (conv_q_src_c008_3_04 conv_q_c008_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_05 (conv_i_src_c008_3_05 0 conv_bpf_c008_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_3_05 (conv_i_src_c008_3_05 conv_i_c008_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_05 (conv_q_src_c008_3_05 0 conv_bpf_c008_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c008_3_05 (conv_q_src_c008_3_05 conv_q_c008_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_06 (conv_i_src_c008_3_06 0 conv_bpf_c008_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_3_06 (conv_i_src_c008_3_06 conv_i_c008_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_06 (conv_q_src_c008_3_06 0 conv_bpf_c008_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c008_3_06 (conv_q_src_c008_3_06 conv_q_c008_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_07 (conv_i_src_c008_3_07 0 conv_bpf_c008_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_3_07 (conv_i_src_c008_3_07 conv_i_c008_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_07 (conv_q_src_c008_3_07 0 conv_bpf_c008_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c008_3_07 (conv_q_src_c008_3_07 conv_q_c008_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_08 (conv_i_src_c008_3_08 0 conv_bpf_c008_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c008_3_08 (conv_i_src_c008_3_08 conv_i_c008_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_08 (conv_q_src_c008_3_08 0 conv_bpf_c008_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_3_08 (conv_q_src_c008_3_08 conv_q_c008_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_09 (conv_i_src_c008_3_09 0 conv_bpf_c008_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c008_3_09 (conv_i_src_c008_3_09 conv_i_c008_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_09 (conv_q_src_c008_3_09 0 conv_bpf_c008_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_3_09 (conv_q_src_c008_3_09 conv_q_c008_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_10 (conv_i_src_c008_3_10 0 conv_bpf_c008_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c008_3_10 (conv_i_src_c008_3_10 conv_i_c008_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_10 (conv_q_src_c008_3_10 0 conv_bpf_c008_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_3_10 (conv_q_src_c008_3_10 conv_q_c008_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_11 (conv_i_src_c008_3_11 0 conv_bpf_c008_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c008_3_11 (conv_i_src_c008_3_11 conv_i_c008_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_11 (conv_q_src_c008_3_11 0 conv_bpf_c008_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_3_11 (conv_q_src_c008_3_11 conv_q_c008_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_12 (conv_i_src_c008_3_12 0 conv_bpf_c008_3 0) vcvs gain=1.950903220161e-01
SCONVI_c008_3_12 (conv_i_src_c008_3_12 conv_i_c008_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_12 (conv_q_src_c008_3_12 0 conv_bpf_c008_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c008_3_12 (conv_q_src_c008_3_12 conv_q_c008_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_13 (conv_i_src_c008_3_13 0 conv_bpf_c008_3 0) vcvs gain=5.555702330196e-01
SCONVI_c008_3_13 (conv_i_src_c008_3_13 conv_i_c008_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_13 (conv_q_src_c008_3_13 0 conv_bpf_c008_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c008_3_13 (conv_q_src_c008_3_13 conv_q_c008_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_14 (conv_i_src_c008_3_14 0 conv_bpf_c008_3 0) vcvs gain=8.314696123025e-01
SCONVI_c008_3_14 (conv_i_src_c008_3_14 conv_i_c008_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_14 (conv_q_src_c008_3_14 0 conv_bpf_c008_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c008_3_14 (conv_q_src_c008_3_14 conv_q_c008_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c008_3_15 (conv_i_src_c008_3_15 0 conv_bpf_c008_3 0) vcvs gain=9.807852804032e-01
SCONVI_c008_3_15 (conv_i_src_c008_3_15 conv_i_c008_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c008_3_15 (conv_q_src_c008_3_15 0 conv_bpf_c008_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c008_3_15 (conv_q_src_c008_3_15 conv_q_c008_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c008_3 (conv_i_c008_3 0) resistor r=1G
RCONVQ_c008_3 (conv_q_c008_3 0) resistor r=1G
RCONVINTI_c008_3 (conv_i_c008_3 ConvIcar_c008_3) resistor r=1k
CCONVINTI_c008_3 (ConvIcar_c008_3 0) capacitor c=80p
RCONVINTQ_c008_3 (conv_q_c008_3 ConvQcar_c008_3) resistor r=1k
CCONVINTQ_c008_3 (ConvQcar_c008_3 0) capacitor c=80p
save conv_bpf_c008_3 ConvIcar_c008_3 ConvQcar_c008_3

// conventional mixed baseline bl009, carrier_0: 250000000 Hz
CCONVBPF_c009_0 (bl009 n_conv_cbpf_c009_0) capacitor c=4.052847345694e-13
LCONVBPF_c009_0 (n_conv_cbpf_c009_0 conv_bpf_c009_0) inductor l=1.000000000000e-06
RCONVBPF_c009_0 (conv_bpf_c009_0 0) resistor r=7.853981633974e+01
ECONVI_c009_0_00 (conv_i_src_c009_0_00 0 conv_bpf_c009_0 0) vcvs gain=9.807852804032e-01
SCONVI_c009_0_00 (conv_i_src_c009_0_00 conv_i_c009_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_00 (conv_q_src_c009_0_00 0 conv_bpf_c009_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_0_00 (conv_q_src_c009_0_00 conv_q_c009_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_01 (conv_i_src_c009_0_01 0 conv_bpf_c009_0 0) vcvs gain=8.314696123025e-01
SCONVI_c009_0_01 (conv_i_src_c009_0_01 conv_i_c009_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_01 (conv_q_src_c009_0_01 0 conv_bpf_c009_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_0_01 (conv_q_src_c009_0_01 conv_q_c009_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_02 (conv_i_src_c009_0_02 0 conv_bpf_c009_0 0) vcvs gain=5.555702330196e-01
SCONVI_c009_0_02 (conv_i_src_c009_0_02 conv_i_c009_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_02 (conv_q_src_c009_0_02 0 conv_bpf_c009_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_0_02 (conv_q_src_c009_0_02 conv_q_c009_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_03 (conv_i_src_c009_0_03 0 conv_bpf_c009_0 0) vcvs gain=1.950903220161e-01
SCONVI_c009_0_03 (conv_i_src_c009_0_03 conv_i_c009_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_03 (conv_q_src_c009_0_03 0 conv_bpf_c009_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_0_03 (conv_q_src_c009_0_03 conv_q_c009_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_04 (conv_i_src_c009_0_04 0 conv_bpf_c009_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_0_04 (conv_i_src_c009_0_04 conv_i_c009_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_04 (conv_q_src_c009_0_04 0 conv_bpf_c009_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_0_04 (conv_q_src_c009_0_04 conv_q_c009_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_05 (conv_i_src_c009_0_05 0 conv_bpf_c009_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_0_05 (conv_i_src_c009_0_05 conv_i_c009_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_05 (conv_q_src_c009_0_05 0 conv_bpf_c009_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_0_05 (conv_q_src_c009_0_05 conv_q_c009_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_06 (conv_i_src_c009_0_06 0 conv_bpf_c009_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_0_06 (conv_i_src_c009_0_06 conv_i_c009_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_06 (conv_q_src_c009_0_06 0 conv_bpf_c009_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_0_06 (conv_q_src_c009_0_06 conv_q_c009_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_07 (conv_i_src_c009_0_07 0 conv_bpf_c009_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_0_07 (conv_i_src_c009_0_07 conv_i_c009_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_07 (conv_q_src_c009_0_07 0 conv_bpf_c009_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_0_07 (conv_q_src_c009_0_07 conv_q_c009_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_08 (conv_i_src_c009_0_08 0 conv_bpf_c009_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_0_08 (conv_i_src_c009_0_08 conv_i_c009_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_08 (conv_q_src_c009_0_08 0 conv_bpf_c009_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_0_08 (conv_q_src_c009_0_08 conv_q_c009_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_09 (conv_i_src_c009_0_09 0 conv_bpf_c009_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_0_09 (conv_i_src_c009_0_09 conv_i_c009_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_09 (conv_q_src_c009_0_09 0 conv_bpf_c009_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_0_09 (conv_q_src_c009_0_09 conv_q_c009_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_10 (conv_i_src_c009_0_10 0 conv_bpf_c009_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_0_10 (conv_i_src_c009_0_10 conv_i_c009_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_10 (conv_q_src_c009_0_10 0 conv_bpf_c009_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_0_10 (conv_q_src_c009_0_10 conv_q_c009_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_11 (conv_i_src_c009_0_11 0 conv_bpf_c009_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_0_11 (conv_i_src_c009_0_11 conv_i_c009_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_11 (conv_q_src_c009_0_11 0 conv_bpf_c009_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_0_11 (conv_q_src_c009_0_11 conv_q_c009_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_12 (conv_i_src_c009_0_12 0 conv_bpf_c009_0 0) vcvs gain=1.950903220161e-01
SCONVI_c009_0_12 (conv_i_src_c009_0_12 conv_i_c009_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_12 (conv_q_src_c009_0_12 0 conv_bpf_c009_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_0_12 (conv_q_src_c009_0_12 conv_q_c009_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_13 (conv_i_src_c009_0_13 0 conv_bpf_c009_0 0) vcvs gain=5.555702330196e-01
SCONVI_c009_0_13 (conv_i_src_c009_0_13 conv_i_c009_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_13 (conv_q_src_c009_0_13 0 conv_bpf_c009_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_0_13 (conv_q_src_c009_0_13 conv_q_c009_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_14 (conv_i_src_c009_0_14 0 conv_bpf_c009_0 0) vcvs gain=8.314696123025e-01
SCONVI_c009_0_14 (conv_i_src_c009_0_14 conv_i_c009_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_14 (conv_q_src_c009_0_14 0 conv_bpf_c009_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_0_14 (conv_q_src_c009_0_14 conv_q_c009_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_0_15 (conv_i_src_c009_0_15 0 conv_bpf_c009_0 0) vcvs gain=9.807852804032e-01
SCONVI_c009_0_15 (conv_i_src_c009_0_15 conv_i_c009_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_0_15 (conv_q_src_c009_0_15 0 conv_bpf_c009_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_0_15 (conv_q_src_c009_0_15 conv_q_c009_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c009_0 (conv_i_c009_0 0) resistor r=1G
RCONVQ_c009_0 (conv_q_c009_0 0) resistor r=1G
RCONVINTI_c009_0 (conv_i_c009_0 ConvIcar_c009_0) resistor r=1k
CCONVINTI_c009_0 (ConvIcar_c009_0 0) capacitor c=80p
RCONVINTQ_c009_0 (conv_q_c009_0 ConvQcar_c009_0) resistor r=1k
CCONVINTQ_c009_0 (ConvQcar_c009_0 0) capacitor c=80p
save conv_bpf_c009_0 ConvIcar_c009_0 ConvQcar_c009_0

// conventional mixed baseline bl009, carrier_1: 500000000 Hz
CCONVBPF_c009_1 (bl009 n_conv_cbpf_c009_1) capacitor c=1.013211836423e-13
LCONVBPF_c009_1 (n_conv_cbpf_c009_1 conv_bpf_c009_1) inductor l=1.000000000000e-06
RCONVBPF_c009_1 (conv_bpf_c009_1 0) resistor r=1.570796326795e+02
ECONVI_c009_1_00 (conv_i_src_c009_1_00 0 conv_bpf_c009_1 0) vcvs gain=9.807852804032e-01
SCONVI_c009_1_00 (conv_i_src_c009_1_00 conv_i_c009_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_00 (conv_q_src_c009_1_00 0 conv_bpf_c009_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_1_00 (conv_q_src_c009_1_00 conv_q_c009_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_01 (conv_i_src_c009_1_01 0 conv_bpf_c009_1 0) vcvs gain=8.314696123025e-01
SCONVI_c009_1_01 (conv_i_src_c009_1_01 conv_i_c009_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_01 (conv_q_src_c009_1_01 0 conv_bpf_c009_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_1_01 (conv_q_src_c009_1_01 conv_q_c009_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_02 (conv_i_src_c009_1_02 0 conv_bpf_c009_1 0) vcvs gain=5.555702330196e-01
SCONVI_c009_1_02 (conv_i_src_c009_1_02 conv_i_c009_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_02 (conv_q_src_c009_1_02 0 conv_bpf_c009_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_1_02 (conv_q_src_c009_1_02 conv_q_c009_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_03 (conv_i_src_c009_1_03 0 conv_bpf_c009_1 0) vcvs gain=1.950903220161e-01
SCONVI_c009_1_03 (conv_i_src_c009_1_03 conv_i_c009_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_03 (conv_q_src_c009_1_03 0 conv_bpf_c009_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_1_03 (conv_q_src_c009_1_03 conv_q_c009_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_04 (conv_i_src_c009_1_04 0 conv_bpf_c009_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_1_04 (conv_i_src_c009_1_04 conv_i_c009_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_04 (conv_q_src_c009_1_04 0 conv_bpf_c009_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_1_04 (conv_q_src_c009_1_04 conv_q_c009_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_05 (conv_i_src_c009_1_05 0 conv_bpf_c009_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_1_05 (conv_i_src_c009_1_05 conv_i_c009_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_05 (conv_q_src_c009_1_05 0 conv_bpf_c009_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_1_05 (conv_q_src_c009_1_05 conv_q_c009_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_06 (conv_i_src_c009_1_06 0 conv_bpf_c009_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_1_06 (conv_i_src_c009_1_06 conv_i_c009_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_06 (conv_q_src_c009_1_06 0 conv_bpf_c009_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_1_06 (conv_q_src_c009_1_06 conv_q_c009_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_07 (conv_i_src_c009_1_07 0 conv_bpf_c009_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_1_07 (conv_i_src_c009_1_07 conv_i_c009_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_07 (conv_q_src_c009_1_07 0 conv_bpf_c009_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_1_07 (conv_q_src_c009_1_07 conv_q_c009_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_08 (conv_i_src_c009_1_08 0 conv_bpf_c009_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_1_08 (conv_i_src_c009_1_08 conv_i_c009_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_08 (conv_q_src_c009_1_08 0 conv_bpf_c009_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_1_08 (conv_q_src_c009_1_08 conv_q_c009_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_09 (conv_i_src_c009_1_09 0 conv_bpf_c009_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_1_09 (conv_i_src_c009_1_09 conv_i_c009_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_09 (conv_q_src_c009_1_09 0 conv_bpf_c009_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_1_09 (conv_q_src_c009_1_09 conv_q_c009_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_10 (conv_i_src_c009_1_10 0 conv_bpf_c009_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_1_10 (conv_i_src_c009_1_10 conv_i_c009_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_10 (conv_q_src_c009_1_10 0 conv_bpf_c009_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_1_10 (conv_q_src_c009_1_10 conv_q_c009_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_11 (conv_i_src_c009_1_11 0 conv_bpf_c009_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_1_11 (conv_i_src_c009_1_11 conv_i_c009_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_11 (conv_q_src_c009_1_11 0 conv_bpf_c009_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_1_11 (conv_q_src_c009_1_11 conv_q_c009_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_12 (conv_i_src_c009_1_12 0 conv_bpf_c009_1 0) vcvs gain=1.950903220161e-01
SCONVI_c009_1_12 (conv_i_src_c009_1_12 conv_i_c009_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_12 (conv_q_src_c009_1_12 0 conv_bpf_c009_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_1_12 (conv_q_src_c009_1_12 conv_q_c009_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_13 (conv_i_src_c009_1_13 0 conv_bpf_c009_1 0) vcvs gain=5.555702330196e-01
SCONVI_c009_1_13 (conv_i_src_c009_1_13 conv_i_c009_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_13 (conv_q_src_c009_1_13 0 conv_bpf_c009_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_1_13 (conv_q_src_c009_1_13 conv_q_c009_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_14 (conv_i_src_c009_1_14 0 conv_bpf_c009_1 0) vcvs gain=8.314696123025e-01
SCONVI_c009_1_14 (conv_i_src_c009_1_14 conv_i_c009_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_14 (conv_q_src_c009_1_14 0 conv_bpf_c009_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_1_14 (conv_q_src_c009_1_14 conv_q_c009_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_1_15 (conv_i_src_c009_1_15 0 conv_bpf_c009_1 0) vcvs gain=9.807852804032e-01
SCONVI_c009_1_15 (conv_i_src_c009_1_15 conv_i_c009_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_1_15 (conv_q_src_c009_1_15 0 conv_bpf_c009_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_1_15 (conv_q_src_c009_1_15 conv_q_c009_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c009_1 (conv_i_c009_1 0) resistor r=1G
RCONVQ_c009_1 (conv_q_c009_1 0) resistor r=1G
RCONVINTI_c009_1 (conv_i_c009_1 ConvIcar_c009_1) resistor r=1k
CCONVINTI_c009_1 (ConvIcar_c009_1 0) capacitor c=80p
RCONVINTQ_c009_1 (conv_q_c009_1 ConvQcar_c009_1) resistor r=1k
CCONVINTQ_c009_1 (ConvQcar_c009_1 0) capacitor c=80p
save conv_bpf_c009_1 ConvIcar_c009_1 ConvQcar_c009_1

// conventional mixed baseline bl009, carrier_2: 750000000 Hz
CCONVBPF_c009_2 (bl009 n_conv_cbpf_c009_2) capacitor c=4.503163717437e-14
LCONVBPF_c009_2 (n_conv_cbpf_c009_2 conv_bpf_c009_2) inductor l=1.000000000000e-06
RCONVBPF_c009_2 (conv_bpf_c009_2 0) resistor r=2.356194490192e+02
ECONVI_c009_2_00 (conv_i_src_c009_2_00 0 conv_bpf_c009_2 0) vcvs gain=9.807852804032e-01
SCONVI_c009_2_00 (conv_i_src_c009_2_00 conv_i_c009_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_00 (conv_q_src_c009_2_00 0 conv_bpf_c009_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_2_00 (conv_q_src_c009_2_00 conv_q_c009_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_01 (conv_i_src_c009_2_01 0 conv_bpf_c009_2 0) vcvs gain=8.314696123025e-01
SCONVI_c009_2_01 (conv_i_src_c009_2_01 conv_i_c009_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_01 (conv_q_src_c009_2_01 0 conv_bpf_c009_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_2_01 (conv_q_src_c009_2_01 conv_q_c009_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_02 (conv_i_src_c009_2_02 0 conv_bpf_c009_2 0) vcvs gain=5.555702330196e-01
SCONVI_c009_2_02 (conv_i_src_c009_2_02 conv_i_c009_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_02 (conv_q_src_c009_2_02 0 conv_bpf_c009_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_2_02 (conv_q_src_c009_2_02 conv_q_c009_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_03 (conv_i_src_c009_2_03 0 conv_bpf_c009_2 0) vcvs gain=1.950903220161e-01
SCONVI_c009_2_03 (conv_i_src_c009_2_03 conv_i_c009_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_03 (conv_q_src_c009_2_03 0 conv_bpf_c009_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_2_03 (conv_q_src_c009_2_03 conv_q_c009_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_04 (conv_i_src_c009_2_04 0 conv_bpf_c009_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_2_04 (conv_i_src_c009_2_04 conv_i_c009_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_04 (conv_q_src_c009_2_04 0 conv_bpf_c009_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_2_04 (conv_q_src_c009_2_04 conv_q_c009_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_05 (conv_i_src_c009_2_05 0 conv_bpf_c009_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_2_05 (conv_i_src_c009_2_05 conv_i_c009_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_05 (conv_q_src_c009_2_05 0 conv_bpf_c009_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_2_05 (conv_q_src_c009_2_05 conv_q_c009_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_06 (conv_i_src_c009_2_06 0 conv_bpf_c009_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_2_06 (conv_i_src_c009_2_06 conv_i_c009_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_06 (conv_q_src_c009_2_06 0 conv_bpf_c009_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_2_06 (conv_q_src_c009_2_06 conv_q_c009_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_07 (conv_i_src_c009_2_07 0 conv_bpf_c009_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_2_07 (conv_i_src_c009_2_07 conv_i_c009_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_07 (conv_q_src_c009_2_07 0 conv_bpf_c009_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_2_07 (conv_q_src_c009_2_07 conv_q_c009_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_08 (conv_i_src_c009_2_08 0 conv_bpf_c009_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_2_08 (conv_i_src_c009_2_08 conv_i_c009_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_08 (conv_q_src_c009_2_08 0 conv_bpf_c009_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_2_08 (conv_q_src_c009_2_08 conv_q_c009_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_09 (conv_i_src_c009_2_09 0 conv_bpf_c009_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_2_09 (conv_i_src_c009_2_09 conv_i_c009_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_09 (conv_q_src_c009_2_09 0 conv_bpf_c009_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_2_09 (conv_q_src_c009_2_09 conv_q_c009_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_10 (conv_i_src_c009_2_10 0 conv_bpf_c009_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_2_10 (conv_i_src_c009_2_10 conv_i_c009_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_10 (conv_q_src_c009_2_10 0 conv_bpf_c009_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_2_10 (conv_q_src_c009_2_10 conv_q_c009_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_11 (conv_i_src_c009_2_11 0 conv_bpf_c009_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_2_11 (conv_i_src_c009_2_11 conv_i_c009_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_11 (conv_q_src_c009_2_11 0 conv_bpf_c009_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_2_11 (conv_q_src_c009_2_11 conv_q_c009_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_12 (conv_i_src_c009_2_12 0 conv_bpf_c009_2 0) vcvs gain=1.950903220161e-01
SCONVI_c009_2_12 (conv_i_src_c009_2_12 conv_i_c009_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_12 (conv_q_src_c009_2_12 0 conv_bpf_c009_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_2_12 (conv_q_src_c009_2_12 conv_q_c009_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_13 (conv_i_src_c009_2_13 0 conv_bpf_c009_2 0) vcvs gain=5.555702330196e-01
SCONVI_c009_2_13 (conv_i_src_c009_2_13 conv_i_c009_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_13 (conv_q_src_c009_2_13 0 conv_bpf_c009_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_2_13 (conv_q_src_c009_2_13 conv_q_c009_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_14 (conv_i_src_c009_2_14 0 conv_bpf_c009_2 0) vcvs gain=8.314696123025e-01
SCONVI_c009_2_14 (conv_i_src_c009_2_14 conv_i_c009_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_14 (conv_q_src_c009_2_14 0 conv_bpf_c009_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_2_14 (conv_q_src_c009_2_14 conv_q_c009_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_2_15 (conv_i_src_c009_2_15 0 conv_bpf_c009_2 0) vcvs gain=9.807852804032e-01
SCONVI_c009_2_15 (conv_i_src_c009_2_15 conv_i_c009_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_2_15 (conv_q_src_c009_2_15 0 conv_bpf_c009_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_2_15 (conv_q_src_c009_2_15 conv_q_c009_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c009_2 (conv_i_c009_2 0) resistor r=1G
RCONVQ_c009_2 (conv_q_c009_2 0) resistor r=1G
RCONVINTI_c009_2 (conv_i_c009_2 ConvIcar_c009_2) resistor r=1k
CCONVINTI_c009_2 (ConvIcar_c009_2 0) capacitor c=80p
RCONVINTQ_c009_2 (conv_q_c009_2 ConvQcar_c009_2) resistor r=1k
CCONVINTQ_c009_2 (ConvQcar_c009_2 0) capacitor c=80p
save conv_bpf_c009_2 ConvIcar_c009_2 ConvQcar_c009_2

// conventional mixed baseline bl009, carrier_3: 1000000000 Hz
CCONVBPF_c009_3 (bl009 n_conv_cbpf_c009_3) capacitor c=2.533029591058e-14
LCONVBPF_c009_3 (n_conv_cbpf_c009_3 conv_bpf_c009_3) inductor l=1.000000000000e-06
RCONVBPF_c009_3 (conv_bpf_c009_3 0) resistor r=3.141592653590e+02
ECONVI_c009_3_00 (conv_i_src_c009_3_00 0 conv_bpf_c009_3 0) vcvs gain=9.807852804032e-01
SCONVI_c009_3_00 (conv_i_src_c009_3_00 conv_i_c009_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_00 (conv_q_src_c009_3_00 0 conv_bpf_c009_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_3_00 (conv_q_src_c009_3_00 conv_q_c009_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_01 (conv_i_src_c009_3_01 0 conv_bpf_c009_3 0) vcvs gain=8.314696123025e-01
SCONVI_c009_3_01 (conv_i_src_c009_3_01 conv_i_c009_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_01 (conv_q_src_c009_3_01 0 conv_bpf_c009_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_3_01 (conv_q_src_c009_3_01 conv_q_c009_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_02 (conv_i_src_c009_3_02 0 conv_bpf_c009_3 0) vcvs gain=5.555702330196e-01
SCONVI_c009_3_02 (conv_i_src_c009_3_02 conv_i_c009_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_02 (conv_q_src_c009_3_02 0 conv_bpf_c009_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_3_02 (conv_q_src_c009_3_02 conv_q_c009_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_03 (conv_i_src_c009_3_03 0 conv_bpf_c009_3 0) vcvs gain=1.950903220161e-01
SCONVI_c009_3_03 (conv_i_src_c009_3_03 conv_i_c009_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_03 (conv_q_src_c009_3_03 0 conv_bpf_c009_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_3_03 (conv_q_src_c009_3_03 conv_q_c009_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_04 (conv_i_src_c009_3_04 0 conv_bpf_c009_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_3_04 (conv_i_src_c009_3_04 conv_i_c009_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_04 (conv_q_src_c009_3_04 0 conv_bpf_c009_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c009_3_04 (conv_q_src_c009_3_04 conv_q_c009_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_05 (conv_i_src_c009_3_05 0 conv_bpf_c009_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_3_05 (conv_i_src_c009_3_05 conv_i_c009_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_05 (conv_q_src_c009_3_05 0 conv_bpf_c009_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c009_3_05 (conv_q_src_c009_3_05 conv_q_c009_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_06 (conv_i_src_c009_3_06 0 conv_bpf_c009_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_3_06 (conv_i_src_c009_3_06 conv_i_c009_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_06 (conv_q_src_c009_3_06 0 conv_bpf_c009_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c009_3_06 (conv_q_src_c009_3_06 conv_q_c009_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_07 (conv_i_src_c009_3_07 0 conv_bpf_c009_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_3_07 (conv_i_src_c009_3_07 conv_i_c009_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_07 (conv_q_src_c009_3_07 0 conv_bpf_c009_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c009_3_07 (conv_q_src_c009_3_07 conv_q_c009_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_08 (conv_i_src_c009_3_08 0 conv_bpf_c009_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c009_3_08 (conv_i_src_c009_3_08 conv_i_c009_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_08 (conv_q_src_c009_3_08 0 conv_bpf_c009_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_3_08 (conv_q_src_c009_3_08 conv_q_c009_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_09 (conv_i_src_c009_3_09 0 conv_bpf_c009_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c009_3_09 (conv_i_src_c009_3_09 conv_i_c009_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_09 (conv_q_src_c009_3_09 0 conv_bpf_c009_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_3_09 (conv_q_src_c009_3_09 conv_q_c009_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_10 (conv_i_src_c009_3_10 0 conv_bpf_c009_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c009_3_10 (conv_i_src_c009_3_10 conv_i_c009_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_10 (conv_q_src_c009_3_10 0 conv_bpf_c009_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_3_10 (conv_q_src_c009_3_10 conv_q_c009_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_11 (conv_i_src_c009_3_11 0 conv_bpf_c009_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c009_3_11 (conv_i_src_c009_3_11 conv_i_c009_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_11 (conv_q_src_c009_3_11 0 conv_bpf_c009_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_3_11 (conv_q_src_c009_3_11 conv_q_c009_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_12 (conv_i_src_c009_3_12 0 conv_bpf_c009_3 0) vcvs gain=1.950903220161e-01
SCONVI_c009_3_12 (conv_i_src_c009_3_12 conv_i_c009_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_12 (conv_q_src_c009_3_12 0 conv_bpf_c009_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c009_3_12 (conv_q_src_c009_3_12 conv_q_c009_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_13 (conv_i_src_c009_3_13 0 conv_bpf_c009_3 0) vcvs gain=5.555702330196e-01
SCONVI_c009_3_13 (conv_i_src_c009_3_13 conv_i_c009_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_13 (conv_q_src_c009_3_13 0 conv_bpf_c009_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c009_3_13 (conv_q_src_c009_3_13 conv_q_c009_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_14 (conv_i_src_c009_3_14 0 conv_bpf_c009_3 0) vcvs gain=8.314696123025e-01
SCONVI_c009_3_14 (conv_i_src_c009_3_14 conv_i_c009_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_14 (conv_q_src_c009_3_14 0 conv_bpf_c009_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c009_3_14 (conv_q_src_c009_3_14 conv_q_c009_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c009_3_15 (conv_i_src_c009_3_15 0 conv_bpf_c009_3 0) vcvs gain=9.807852804032e-01
SCONVI_c009_3_15 (conv_i_src_c009_3_15 conv_i_c009_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c009_3_15 (conv_q_src_c009_3_15 0 conv_bpf_c009_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c009_3_15 (conv_q_src_c009_3_15 conv_q_c009_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c009_3 (conv_i_c009_3 0) resistor r=1G
RCONVQ_c009_3 (conv_q_c009_3 0) resistor r=1G
RCONVINTI_c009_3 (conv_i_c009_3 ConvIcar_c009_3) resistor r=1k
CCONVINTI_c009_3 (ConvIcar_c009_3 0) capacitor c=80p
RCONVINTQ_c009_3 (conv_q_c009_3 ConvQcar_c009_3) resistor r=1k
CCONVINTQ_c009_3 (ConvQcar_c009_3 0) capacitor c=80p
save conv_bpf_c009_3 ConvIcar_c009_3 ConvQcar_c009_3

// conventional mixed baseline bl010, carrier_0: 250000000 Hz
CCONVBPF_c010_0 (bl010 n_conv_cbpf_c010_0) capacitor c=4.052847345694e-13
LCONVBPF_c010_0 (n_conv_cbpf_c010_0 conv_bpf_c010_0) inductor l=1.000000000000e-06
RCONVBPF_c010_0 (conv_bpf_c010_0 0) resistor r=7.853981633974e+01
ECONVI_c010_0_00 (conv_i_src_c010_0_00 0 conv_bpf_c010_0 0) vcvs gain=9.807852804032e-01
SCONVI_c010_0_00 (conv_i_src_c010_0_00 conv_i_c010_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_00 (conv_q_src_c010_0_00 0 conv_bpf_c010_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_0_00 (conv_q_src_c010_0_00 conv_q_c010_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_01 (conv_i_src_c010_0_01 0 conv_bpf_c010_0 0) vcvs gain=8.314696123025e-01
SCONVI_c010_0_01 (conv_i_src_c010_0_01 conv_i_c010_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_01 (conv_q_src_c010_0_01 0 conv_bpf_c010_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_0_01 (conv_q_src_c010_0_01 conv_q_c010_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_02 (conv_i_src_c010_0_02 0 conv_bpf_c010_0 0) vcvs gain=5.555702330196e-01
SCONVI_c010_0_02 (conv_i_src_c010_0_02 conv_i_c010_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_02 (conv_q_src_c010_0_02 0 conv_bpf_c010_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_0_02 (conv_q_src_c010_0_02 conv_q_c010_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_03 (conv_i_src_c010_0_03 0 conv_bpf_c010_0 0) vcvs gain=1.950903220161e-01
SCONVI_c010_0_03 (conv_i_src_c010_0_03 conv_i_c010_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_03 (conv_q_src_c010_0_03 0 conv_bpf_c010_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_0_03 (conv_q_src_c010_0_03 conv_q_c010_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_04 (conv_i_src_c010_0_04 0 conv_bpf_c010_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_0_04 (conv_i_src_c010_0_04 conv_i_c010_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_04 (conv_q_src_c010_0_04 0 conv_bpf_c010_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_0_04 (conv_q_src_c010_0_04 conv_q_c010_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_05 (conv_i_src_c010_0_05 0 conv_bpf_c010_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_0_05 (conv_i_src_c010_0_05 conv_i_c010_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_05 (conv_q_src_c010_0_05 0 conv_bpf_c010_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_0_05 (conv_q_src_c010_0_05 conv_q_c010_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_06 (conv_i_src_c010_0_06 0 conv_bpf_c010_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_0_06 (conv_i_src_c010_0_06 conv_i_c010_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_06 (conv_q_src_c010_0_06 0 conv_bpf_c010_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_0_06 (conv_q_src_c010_0_06 conv_q_c010_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_07 (conv_i_src_c010_0_07 0 conv_bpf_c010_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_0_07 (conv_i_src_c010_0_07 conv_i_c010_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_07 (conv_q_src_c010_0_07 0 conv_bpf_c010_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_0_07 (conv_q_src_c010_0_07 conv_q_c010_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_08 (conv_i_src_c010_0_08 0 conv_bpf_c010_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_0_08 (conv_i_src_c010_0_08 conv_i_c010_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_08 (conv_q_src_c010_0_08 0 conv_bpf_c010_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_0_08 (conv_q_src_c010_0_08 conv_q_c010_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_09 (conv_i_src_c010_0_09 0 conv_bpf_c010_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_0_09 (conv_i_src_c010_0_09 conv_i_c010_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_09 (conv_q_src_c010_0_09 0 conv_bpf_c010_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_0_09 (conv_q_src_c010_0_09 conv_q_c010_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_10 (conv_i_src_c010_0_10 0 conv_bpf_c010_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_0_10 (conv_i_src_c010_0_10 conv_i_c010_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_10 (conv_q_src_c010_0_10 0 conv_bpf_c010_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_0_10 (conv_q_src_c010_0_10 conv_q_c010_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_11 (conv_i_src_c010_0_11 0 conv_bpf_c010_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_0_11 (conv_i_src_c010_0_11 conv_i_c010_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_11 (conv_q_src_c010_0_11 0 conv_bpf_c010_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_0_11 (conv_q_src_c010_0_11 conv_q_c010_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_12 (conv_i_src_c010_0_12 0 conv_bpf_c010_0 0) vcvs gain=1.950903220161e-01
SCONVI_c010_0_12 (conv_i_src_c010_0_12 conv_i_c010_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_12 (conv_q_src_c010_0_12 0 conv_bpf_c010_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_0_12 (conv_q_src_c010_0_12 conv_q_c010_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_13 (conv_i_src_c010_0_13 0 conv_bpf_c010_0 0) vcvs gain=5.555702330196e-01
SCONVI_c010_0_13 (conv_i_src_c010_0_13 conv_i_c010_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_13 (conv_q_src_c010_0_13 0 conv_bpf_c010_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_0_13 (conv_q_src_c010_0_13 conv_q_c010_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_14 (conv_i_src_c010_0_14 0 conv_bpf_c010_0 0) vcvs gain=8.314696123025e-01
SCONVI_c010_0_14 (conv_i_src_c010_0_14 conv_i_c010_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_14 (conv_q_src_c010_0_14 0 conv_bpf_c010_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_0_14 (conv_q_src_c010_0_14 conv_q_c010_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_0_15 (conv_i_src_c010_0_15 0 conv_bpf_c010_0 0) vcvs gain=9.807852804032e-01
SCONVI_c010_0_15 (conv_i_src_c010_0_15 conv_i_c010_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_0_15 (conv_q_src_c010_0_15 0 conv_bpf_c010_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_0_15 (conv_q_src_c010_0_15 conv_q_c010_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c010_0 (conv_i_c010_0 0) resistor r=1G
RCONVQ_c010_0 (conv_q_c010_0 0) resistor r=1G
RCONVINTI_c010_0 (conv_i_c010_0 ConvIcar_c010_0) resistor r=1k
CCONVINTI_c010_0 (ConvIcar_c010_0 0) capacitor c=80p
RCONVINTQ_c010_0 (conv_q_c010_0 ConvQcar_c010_0) resistor r=1k
CCONVINTQ_c010_0 (ConvQcar_c010_0 0) capacitor c=80p
save conv_bpf_c010_0 ConvIcar_c010_0 ConvQcar_c010_0

// conventional mixed baseline bl010, carrier_1: 500000000 Hz
CCONVBPF_c010_1 (bl010 n_conv_cbpf_c010_1) capacitor c=1.013211836423e-13
LCONVBPF_c010_1 (n_conv_cbpf_c010_1 conv_bpf_c010_1) inductor l=1.000000000000e-06
RCONVBPF_c010_1 (conv_bpf_c010_1 0) resistor r=1.570796326795e+02
ECONVI_c010_1_00 (conv_i_src_c010_1_00 0 conv_bpf_c010_1 0) vcvs gain=9.807852804032e-01
SCONVI_c010_1_00 (conv_i_src_c010_1_00 conv_i_c010_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_00 (conv_q_src_c010_1_00 0 conv_bpf_c010_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_1_00 (conv_q_src_c010_1_00 conv_q_c010_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_01 (conv_i_src_c010_1_01 0 conv_bpf_c010_1 0) vcvs gain=8.314696123025e-01
SCONVI_c010_1_01 (conv_i_src_c010_1_01 conv_i_c010_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_01 (conv_q_src_c010_1_01 0 conv_bpf_c010_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_1_01 (conv_q_src_c010_1_01 conv_q_c010_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_02 (conv_i_src_c010_1_02 0 conv_bpf_c010_1 0) vcvs gain=5.555702330196e-01
SCONVI_c010_1_02 (conv_i_src_c010_1_02 conv_i_c010_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_02 (conv_q_src_c010_1_02 0 conv_bpf_c010_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_1_02 (conv_q_src_c010_1_02 conv_q_c010_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_03 (conv_i_src_c010_1_03 0 conv_bpf_c010_1 0) vcvs gain=1.950903220161e-01
SCONVI_c010_1_03 (conv_i_src_c010_1_03 conv_i_c010_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_03 (conv_q_src_c010_1_03 0 conv_bpf_c010_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_1_03 (conv_q_src_c010_1_03 conv_q_c010_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_04 (conv_i_src_c010_1_04 0 conv_bpf_c010_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_1_04 (conv_i_src_c010_1_04 conv_i_c010_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_04 (conv_q_src_c010_1_04 0 conv_bpf_c010_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_1_04 (conv_q_src_c010_1_04 conv_q_c010_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_05 (conv_i_src_c010_1_05 0 conv_bpf_c010_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_1_05 (conv_i_src_c010_1_05 conv_i_c010_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_05 (conv_q_src_c010_1_05 0 conv_bpf_c010_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_1_05 (conv_q_src_c010_1_05 conv_q_c010_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_06 (conv_i_src_c010_1_06 0 conv_bpf_c010_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_1_06 (conv_i_src_c010_1_06 conv_i_c010_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_06 (conv_q_src_c010_1_06 0 conv_bpf_c010_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_1_06 (conv_q_src_c010_1_06 conv_q_c010_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_07 (conv_i_src_c010_1_07 0 conv_bpf_c010_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_1_07 (conv_i_src_c010_1_07 conv_i_c010_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_07 (conv_q_src_c010_1_07 0 conv_bpf_c010_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_1_07 (conv_q_src_c010_1_07 conv_q_c010_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_08 (conv_i_src_c010_1_08 0 conv_bpf_c010_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_1_08 (conv_i_src_c010_1_08 conv_i_c010_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_08 (conv_q_src_c010_1_08 0 conv_bpf_c010_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_1_08 (conv_q_src_c010_1_08 conv_q_c010_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_09 (conv_i_src_c010_1_09 0 conv_bpf_c010_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_1_09 (conv_i_src_c010_1_09 conv_i_c010_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_09 (conv_q_src_c010_1_09 0 conv_bpf_c010_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_1_09 (conv_q_src_c010_1_09 conv_q_c010_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_10 (conv_i_src_c010_1_10 0 conv_bpf_c010_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_1_10 (conv_i_src_c010_1_10 conv_i_c010_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_10 (conv_q_src_c010_1_10 0 conv_bpf_c010_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_1_10 (conv_q_src_c010_1_10 conv_q_c010_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_11 (conv_i_src_c010_1_11 0 conv_bpf_c010_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_1_11 (conv_i_src_c010_1_11 conv_i_c010_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_11 (conv_q_src_c010_1_11 0 conv_bpf_c010_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_1_11 (conv_q_src_c010_1_11 conv_q_c010_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_12 (conv_i_src_c010_1_12 0 conv_bpf_c010_1 0) vcvs gain=1.950903220161e-01
SCONVI_c010_1_12 (conv_i_src_c010_1_12 conv_i_c010_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_12 (conv_q_src_c010_1_12 0 conv_bpf_c010_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_1_12 (conv_q_src_c010_1_12 conv_q_c010_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_13 (conv_i_src_c010_1_13 0 conv_bpf_c010_1 0) vcvs gain=5.555702330196e-01
SCONVI_c010_1_13 (conv_i_src_c010_1_13 conv_i_c010_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_13 (conv_q_src_c010_1_13 0 conv_bpf_c010_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_1_13 (conv_q_src_c010_1_13 conv_q_c010_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_14 (conv_i_src_c010_1_14 0 conv_bpf_c010_1 0) vcvs gain=8.314696123025e-01
SCONVI_c010_1_14 (conv_i_src_c010_1_14 conv_i_c010_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_14 (conv_q_src_c010_1_14 0 conv_bpf_c010_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_1_14 (conv_q_src_c010_1_14 conv_q_c010_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_1_15 (conv_i_src_c010_1_15 0 conv_bpf_c010_1 0) vcvs gain=9.807852804032e-01
SCONVI_c010_1_15 (conv_i_src_c010_1_15 conv_i_c010_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_1_15 (conv_q_src_c010_1_15 0 conv_bpf_c010_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_1_15 (conv_q_src_c010_1_15 conv_q_c010_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c010_1 (conv_i_c010_1 0) resistor r=1G
RCONVQ_c010_1 (conv_q_c010_1 0) resistor r=1G
RCONVINTI_c010_1 (conv_i_c010_1 ConvIcar_c010_1) resistor r=1k
CCONVINTI_c010_1 (ConvIcar_c010_1 0) capacitor c=80p
RCONVINTQ_c010_1 (conv_q_c010_1 ConvQcar_c010_1) resistor r=1k
CCONVINTQ_c010_1 (ConvQcar_c010_1 0) capacitor c=80p
save conv_bpf_c010_1 ConvIcar_c010_1 ConvQcar_c010_1

// conventional mixed baseline bl010, carrier_2: 750000000 Hz
CCONVBPF_c010_2 (bl010 n_conv_cbpf_c010_2) capacitor c=4.503163717437e-14
LCONVBPF_c010_2 (n_conv_cbpf_c010_2 conv_bpf_c010_2) inductor l=1.000000000000e-06
RCONVBPF_c010_2 (conv_bpf_c010_2 0) resistor r=2.356194490192e+02
ECONVI_c010_2_00 (conv_i_src_c010_2_00 0 conv_bpf_c010_2 0) vcvs gain=9.807852804032e-01
SCONVI_c010_2_00 (conv_i_src_c010_2_00 conv_i_c010_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_00 (conv_q_src_c010_2_00 0 conv_bpf_c010_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_2_00 (conv_q_src_c010_2_00 conv_q_c010_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_01 (conv_i_src_c010_2_01 0 conv_bpf_c010_2 0) vcvs gain=8.314696123025e-01
SCONVI_c010_2_01 (conv_i_src_c010_2_01 conv_i_c010_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_01 (conv_q_src_c010_2_01 0 conv_bpf_c010_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_2_01 (conv_q_src_c010_2_01 conv_q_c010_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_02 (conv_i_src_c010_2_02 0 conv_bpf_c010_2 0) vcvs gain=5.555702330196e-01
SCONVI_c010_2_02 (conv_i_src_c010_2_02 conv_i_c010_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_02 (conv_q_src_c010_2_02 0 conv_bpf_c010_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_2_02 (conv_q_src_c010_2_02 conv_q_c010_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_03 (conv_i_src_c010_2_03 0 conv_bpf_c010_2 0) vcvs gain=1.950903220161e-01
SCONVI_c010_2_03 (conv_i_src_c010_2_03 conv_i_c010_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_03 (conv_q_src_c010_2_03 0 conv_bpf_c010_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_2_03 (conv_q_src_c010_2_03 conv_q_c010_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_04 (conv_i_src_c010_2_04 0 conv_bpf_c010_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_2_04 (conv_i_src_c010_2_04 conv_i_c010_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_04 (conv_q_src_c010_2_04 0 conv_bpf_c010_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_2_04 (conv_q_src_c010_2_04 conv_q_c010_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_05 (conv_i_src_c010_2_05 0 conv_bpf_c010_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_2_05 (conv_i_src_c010_2_05 conv_i_c010_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_05 (conv_q_src_c010_2_05 0 conv_bpf_c010_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_2_05 (conv_q_src_c010_2_05 conv_q_c010_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_06 (conv_i_src_c010_2_06 0 conv_bpf_c010_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_2_06 (conv_i_src_c010_2_06 conv_i_c010_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_06 (conv_q_src_c010_2_06 0 conv_bpf_c010_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_2_06 (conv_q_src_c010_2_06 conv_q_c010_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_07 (conv_i_src_c010_2_07 0 conv_bpf_c010_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_2_07 (conv_i_src_c010_2_07 conv_i_c010_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_07 (conv_q_src_c010_2_07 0 conv_bpf_c010_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_2_07 (conv_q_src_c010_2_07 conv_q_c010_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_08 (conv_i_src_c010_2_08 0 conv_bpf_c010_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_2_08 (conv_i_src_c010_2_08 conv_i_c010_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_08 (conv_q_src_c010_2_08 0 conv_bpf_c010_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_2_08 (conv_q_src_c010_2_08 conv_q_c010_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_09 (conv_i_src_c010_2_09 0 conv_bpf_c010_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_2_09 (conv_i_src_c010_2_09 conv_i_c010_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_09 (conv_q_src_c010_2_09 0 conv_bpf_c010_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_2_09 (conv_q_src_c010_2_09 conv_q_c010_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_10 (conv_i_src_c010_2_10 0 conv_bpf_c010_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_2_10 (conv_i_src_c010_2_10 conv_i_c010_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_10 (conv_q_src_c010_2_10 0 conv_bpf_c010_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_2_10 (conv_q_src_c010_2_10 conv_q_c010_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_11 (conv_i_src_c010_2_11 0 conv_bpf_c010_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_2_11 (conv_i_src_c010_2_11 conv_i_c010_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_11 (conv_q_src_c010_2_11 0 conv_bpf_c010_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_2_11 (conv_q_src_c010_2_11 conv_q_c010_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_12 (conv_i_src_c010_2_12 0 conv_bpf_c010_2 0) vcvs gain=1.950903220161e-01
SCONVI_c010_2_12 (conv_i_src_c010_2_12 conv_i_c010_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_12 (conv_q_src_c010_2_12 0 conv_bpf_c010_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_2_12 (conv_q_src_c010_2_12 conv_q_c010_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_13 (conv_i_src_c010_2_13 0 conv_bpf_c010_2 0) vcvs gain=5.555702330196e-01
SCONVI_c010_2_13 (conv_i_src_c010_2_13 conv_i_c010_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_13 (conv_q_src_c010_2_13 0 conv_bpf_c010_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_2_13 (conv_q_src_c010_2_13 conv_q_c010_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_14 (conv_i_src_c010_2_14 0 conv_bpf_c010_2 0) vcvs gain=8.314696123025e-01
SCONVI_c010_2_14 (conv_i_src_c010_2_14 conv_i_c010_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_14 (conv_q_src_c010_2_14 0 conv_bpf_c010_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_2_14 (conv_q_src_c010_2_14 conv_q_c010_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_2_15 (conv_i_src_c010_2_15 0 conv_bpf_c010_2 0) vcvs gain=9.807852804032e-01
SCONVI_c010_2_15 (conv_i_src_c010_2_15 conv_i_c010_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_2_15 (conv_q_src_c010_2_15 0 conv_bpf_c010_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_2_15 (conv_q_src_c010_2_15 conv_q_c010_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c010_2 (conv_i_c010_2 0) resistor r=1G
RCONVQ_c010_2 (conv_q_c010_2 0) resistor r=1G
RCONVINTI_c010_2 (conv_i_c010_2 ConvIcar_c010_2) resistor r=1k
CCONVINTI_c010_2 (ConvIcar_c010_2 0) capacitor c=80p
RCONVINTQ_c010_2 (conv_q_c010_2 ConvQcar_c010_2) resistor r=1k
CCONVINTQ_c010_2 (ConvQcar_c010_2 0) capacitor c=80p
save conv_bpf_c010_2 ConvIcar_c010_2 ConvQcar_c010_2

// conventional mixed baseline bl010, carrier_3: 1000000000 Hz
CCONVBPF_c010_3 (bl010 n_conv_cbpf_c010_3) capacitor c=2.533029591058e-14
LCONVBPF_c010_3 (n_conv_cbpf_c010_3 conv_bpf_c010_3) inductor l=1.000000000000e-06
RCONVBPF_c010_3 (conv_bpf_c010_3 0) resistor r=3.141592653590e+02
ECONVI_c010_3_00 (conv_i_src_c010_3_00 0 conv_bpf_c010_3 0) vcvs gain=9.807852804032e-01
SCONVI_c010_3_00 (conv_i_src_c010_3_00 conv_i_c010_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_00 (conv_q_src_c010_3_00 0 conv_bpf_c010_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_3_00 (conv_q_src_c010_3_00 conv_q_c010_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_01 (conv_i_src_c010_3_01 0 conv_bpf_c010_3 0) vcvs gain=8.314696123025e-01
SCONVI_c010_3_01 (conv_i_src_c010_3_01 conv_i_c010_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_01 (conv_q_src_c010_3_01 0 conv_bpf_c010_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_3_01 (conv_q_src_c010_3_01 conv_q_c010_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_02 (conv_i_src_c010_3_02 0 conv_bpf_c010_3 0) vcvs gain=5.555702330196e-01
SCONVI_c010_3_02 (conv_i_src_c010_3_02 conv_i_c010_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_02 (conv_q_src_c010_3_02 0 conv_bpf_c010_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_3_02 (conv_q_src_c010_3_02 conv_q_c010_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_03 (conv_i_src_c010_3_03 0 conv_bpf_c010_3 0) vcvs gain=1.950903220161e-01
SCONVI_c010_3_03 (conv_i_src_c010_3_03 conv_i_c010_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_03 (conv_q_src_c010_3_03 0 conv_bpf_c010_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_3_03 (conv_q_src_c010_3_03 conv_q_c010_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_04 (conv_i_src_c010_3_04 0 conv_bpf_c010_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_3_04 (conv_i_src_c010_3_04 conv_i_c010_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_04 (conv_q_src_c010_3_04 0 conv_bpf_c010_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c010_3_04 (conv_q_src_c010_3_04 conv_q_c010_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_05 (conv_i_src_c010_3_05 0 conv_bpf_c010_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_3_05 (conv_i_src_c010_3_05 conv_i_c010_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_05 (conv_q_src_c010_3_05 0 conv_bpf_c010_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c010_3_05 (conv_q_src_c010_3_05 conv_q_c010_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_06 (conv_i_src_c010_3_06 0 conv_bpf_c010_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_3_06 (conv_i_src_c010_3_06 conv_i_c010_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_06 (conv_q_src_c010_3_06 0 conv_bpf_c010_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c010_3_06 (conv_q_src_c010_3_06 conv_q_c010_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_07 (conv_i_src_c010_3_07 0 conv_bpf_c010_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_3_07 (conv_i_src_c010_3_07 conv_i_c010_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_07 (conv_q_src_c010_3_07 0 conv_bpf_c010_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c010_3_07 (conv_q_src_c010_3_07 conv_q_c010_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_08 (conv_i_src_c010_3_08 0 conv_bpf_c010_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c010_3_08 (conv_i_src_c010_3_08 conv_i_c010_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_08 (conv_q_src_c010_3_08 0 conv_bpf_c010_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_3_08 (conv_q_src_c010_3_08 conv_q_c010_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_09 (conv_i_src_c010_3_09 0 conv_bpf_c010_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c010_3_09 (conv_i_src_c010_3_09 conv_i_c010_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_09 (conv_q_src_c010_3_09 0 conv_bpf_c010_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_3_09 (conv_q_src_c010_3_09 conv_q_c010_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_10 (conv_i_src_c010_3_10 0 conv_bpf_c010_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c010_3_10 (conv_i_src_c010_3_10 conv_i_c010_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_10 (conv_q_src_c010_3_10 0 conv_bpf_c010_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_3_10 (conv_q_src_c010_3_10 conv_q_c010_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_11 (conv_i_src_c010_3_11 0 conv_bpf_c010_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c010_3_11 (conv_i_src_c010_3_11 conv_i_c010_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_11 (conv_q_src_c010_3_11 0 conv_bpf_c010_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_3_11 (conv_q_src_c010_3_11 conv_q_c010_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_12 (conv_i_src_c010_3_12 0 conv_bpf_c010_3 0) vcvs gain=1.950903220161e-01
SCONVI_c010_3_12 (conv_i_src_c010_3_12 conv_i_c010_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_12 (conv_q_src_c010_3_12 0 conv_bpf_c010_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c010_3_12 (conv_q_src_c010_3_12 conv_q_c010_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_13 (conv_i_src_c010_3_13 0 conv_bpf_c010_3 0) vcvs gain=5.555702330196e-01
SCONVI_c010_3_13 (conv_i_src_c010_3_13 conv_i_c010_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_13 (conv_q_src_c010_3_13 0 conv_bpf_c010_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c010_3_13 (conv_q_src_c010_3_13 conv_q_c010_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_14 (conv_i_src_c010_3_14 0 conv_bpf_c010_3 0) vcvs gain=8.314696123025e-01
SCONVI_c010_3_14 (conv_i_src_c010_3_14 conv_i_c010_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_14 (conv_q_src_c010_3_14 0 conv_bpf_c010_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c010_3_14 (conv_q_src_c010_3_14 conv_q_c010_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c010_3_15 (conv_i_src_c010_3_15 0 conv_bpf_c010_3 0) vcvs gain=9.807852804032e-01
SCONVI_c010_3_15 (conv_i_src_c010_3_15 conv_i_c010_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c010_3_15 (conv_q_src_c010_3_15 0 conv_bpf_c010_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c010_3_15 (conv_q_src_c010_3_15 conv_q_c010_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c010_3 (conv_i_c010_3 0) resistor r=1G
RCONVQ_c010_3 (conv_q_c010_3 0) resistor r=1G
RCONVINTI_c010_3 (conv_i_c010_3 ConvIcar_c010_3) resistor r=1k
CCONVINTI_c010_3 (ConvIcar_c010_3 0) capacitor c=80p
RCONVINTQ_c010_3 (conv_q_c010_3 ConvQcar_c010_3) resistor r=1k
CCONVINTQ_c010_3 (ConvQcar_c010_3 0) capacitor c=80p
save conv_bpf_c010_3 ConvIcar_c010_3 ConvQcar_c010_3

// conventional mixed baseline bl011, carrier_0: 250000000 Hz
CCONVBPF_c011_0 (bl011 n_conv_cbpf_c011_0) capacitor c=4.052847345694e-13
LCONVBPF_c011_0 (n_conv_cbpf_c011_0 conv_bpf_c011_0) inductor l=1.000000000000e-06
RCONVBPF_c011_0 (conv_bpf_c011_0 0) resistor r=7.853981633974e+01
ECONVI_c011_0_00 (conv_i_src_c011_0_00 0 conv_bpf_c011_0 0) vcvs gain=9.807852804032e-01
SCONVI_c011_0_00 (conv_i_src_c011_0_00 conv_i_c011_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_00 (conv_q_src_c011_0_00 0 conv_bpf_c011_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_0_00 (conv_q_src_c011_0_00 conv_q_c011_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_01 (conv_i_src_c011_0_01 0 conv_bpf_c011_0 0) vcvs gain=8.314696123025e-01
SCONVI_c011_0_01 (conv_i_src_c011_0_01 conv_i_c011_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_01 (conv_q_src_c011_0_01 0 conv_bpf_c011_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_0_01 (conv_q_src_c011_0_01 conv_q_c011_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_02 (conv_i_src_c011_0_02 0 conv_bpf_c011_0 0) vcvs gain=5.555702330196e-01
SCONVI_c011_0_02 (conv_i_src_c011_0_02 conv_i_c011_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_02 (conv_q_src_c011_0_02 0 conv_bpf_c011_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_0_02 (conv_q_src_c011_0_02 conv_q_c011_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_03 (conv_i_src_c011_0_03 0 conv_bpf_c011_0 0) vcvs gain=1.950903220161e-01
SCONVI_c011_0_03 (conv_i_src_c011_0_03 conv_i_c011_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_03 (conv_q_src_c011_0_03 0 conv_bpf_c011_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_0_03 (conv_q_src_c011_0_03 conv_q_c011_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_04 (conv_i_src_c011_0_04 0 conv_bpf_c011_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_0_04 (conv_i_src_c011_0_04 conv_i_c011_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_04 (conv_q_src_c011_0_04 0 conv_bpf_c011_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_0_04 (conv_q_src_c011_0_04 conv_q_c011_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_05 (conv_i_src_c011_0_05 0 conv_bpf_c011_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_0_05 (conv_i_src_c011_0_05 conv_i_c011_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_05 (conv_q_src_c011_0_05 0 conv_bpf_c011_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_0_05 (conv_q_src_c011_0_05 conv_q_c011_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_06 (conv_i_src_c011_0_06 0 conv_bpf_c011_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_0_06 (conv_i_src_c011_0_06 conv_i_c011_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_06 (conv_q_src_c011_0_06 0 conv_bpf_c011_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_0_06 (conv_q_src_c011_0_06 conv_q_c011_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_07 (conv_i_src_c011_0_07 0 conv_bpf_c011_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_0_07 (conv_i_src_c011_0_07 conv_i_c011_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_07 (conv_q_src_c011_0_07 0 conv_bpf_c011_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_0_07 (conv_q_src_c011_0_07 conv_q_c011_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_08 (conv_i_src_c011_0_08 0 conv_bpf_c011_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_0_08 (conv_i_src_c011_0_08 conv_i_c011_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_08 (conv_q_src_c011_0_08 0 conv_bpf_c011_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_0_08 (conv_q_src_c011_0_08 conv_q_c011_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_09 (conv_i_src_c011_0_09 0 conv_bpf_c011_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_0_09 (conv_i_src_c011_0_09 conv_i_c011_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_09 (conv_q_src_c011_0_09 0 conv_bpf_c011_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_0_09 (conv_q_src_c011_0_09 conv_q_c011_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_10 (conv_i_src_c011_0_10 0 conv_bpf_c011_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_0_10 (conv_i_src_c011_0_10 conv_i_c011_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_10 (conv_q_src_c011_0_10 0 conv_bpf_c011_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_0_10 (conv_q_src_c011_0_10 conv_q_c011_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_11 (conv_i_src_c011_0_11 0 conv_bpf_c011_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_0_11 (conv_i_src_c011_0_11 conv_i_c011_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_11 (conv_q_src_c011_0_11 0 conv_bpf_c011_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_0_11 (conv_q_src_c011_0_11 conv_q_c011_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_12 (conv_i_src_c011_0_12 0 conv_bpf_c011_0 0) vcvs gain=1.950903220161e-01
SCONVI_c011_0_12 (conv_i_src_c011_0_12 conv_i_c011_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_12 (conv_q_src_c011_0_12 0 conv_bpf_c011_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_0_12 (conv_q_src_c011_0_12 conv_q_c011_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_13 (conv_i_src_c011_0_13 0 conv_bpf_c011_0 0) vcvs gain=5.555702330196e-01
SCONVI_c011_0_13 (conv_i_src_c011_0_13 conv_i_c011_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_13 (conv_q_src_c011_0_13 0 conv_bpf_c011_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_0_13 (conv_q_src_c011_0_13 conv_q_c011_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_14 (conv_i_src_c011_0_14 0 conv_bpf_c011_0 0) vcvs gain=8.314696123025e-01
SCONVI_c011_0_14 (conv_i_src_c011_0_14 conv_i_c011_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_14 (conv_q_src_c011_0_14 0 conv_bpf_c011_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_0_14 (conv_q_src_c011_0_14 conv_q_c011_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_0_15 (conv_i_src_c011_0_15 0 conv_bpf_c011_0 0) vcvs gain=9.807852804032e-01
SCONVI_c011_0_15 (conv_i_src_c011_0_15 conv_i_c011_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_0_15 (conv_q_src_c011_0_15 0 conv_bpf_c011_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_0_15 (conv_q_src_c011_0_15 conv_q_c011_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c011_0 (conv_i_c011_0 0) resistor r=1G
RCONVQ_c011_0 (conv_q_c011_0 0) resistor r=1G
RCONVINTI_c011_0 (conv_i_c011_0 ConvIcar_c011_0) resistor r=1k
CCONVINTI_c011_0 (ConvIcar_c011_0 0) capacitor c=80p
RCONVINTQ_c011_0 (conv_q_c011_0 ConvQcar_c011_0) resistor r=1k
CCONVINTQ_c011_0 (ConvQcar_c011_0 0) capacitor c=80p
save conv_bpf_c011_0 ConvIcar_c011_0 ConvQcar_c011_0

// conventional mixed baseline bl011, carrier_1: 500000000 Hz
CCONVBPF_c011_1 (bl011 n_conv_cbpf_c011_1) capacitor c=1.013211836423e-13
LCONVBPF_c011_1 (n_conv_cbpf_c011_1 conv_bpf_c011_1) inductor l=1.000000000000e-06
RCONVBPF_c011_1 (conv_bpf_c011_1 0) resistor r=1.570796326795e+02
ECONVI_c011_1_00 (conv_i_src_c011_1_00 0 conv_bpf_c011_1 0) vcvs gain=9.807852804032e-01
SCONVI_c011_1_00 (conv_i_src_c011_1_00 conv_i_c011_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_00 (conv_q_src_c011_1_00 0 conv_bpf_c011_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_1_00 (conv_q_src_c011_1_00 conv_q_c011_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_01 (conv_i_src_c011_1_01 0 conv_bpf_c011_1 0) vcvs gain=8.314696123025e-01
SCONVI_c011_1_01 (conv_i_src_c011_1_01 conv_i_c011_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_01 (conv_q_src_c011_1_01 0 conv_bpf_c011_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_1_01 (conv_q_src_c011_1_01 conv_q_c011_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_02 (conv_i_src_c011_1_02 0 conv_bpf_c011_1 0) vcvs gain=5.555702330196e-01
SCONVI_c011_1_02 (conv_i_src_c011_1_02 conv_i_c011_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_02 (conv_q_src_c011_1_02 0 conv_bpf_c011_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_1_02 (conv_q_src_c011_1_02 conv_q_c011_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_03 (conv_i_src_c011_1_03 0 conv_bpf_c011_1 0) vcvs gain=1.950903220161e-01
SCONVI_c011_1_03 (conv_i_src_c011_1_03 conv_i_c011_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_03 (conv_q_src_c011_1_03 0 conv_bpf_c011_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_1_03 (conv_q_src_c011_1_03 conv_q_c011_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_04 (conv_i_src_c011_1_04 0 conv_bpf_c011_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_1_04 (conv_i_src_c011_1_04 conv_i_c011_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_04 (conv_q_src_c011_1_04 0 conv_bpf_c011_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_1_04 (conv_q_src_c011_1_04 conv_q_c011_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_05 (conv_i_src_c011_1_05 0 conv_bpf_c011_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_1_05 (conv_i_src_c011_1_05 conv_i_c011_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_05 (conv_q_src_c011_1_05 0 conv_bpf_c011_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_1_05 (conv_q_src_c011_1_05 conv_q_c011_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_06 (conv_i_src_c011_1_06 0 conv_bpf_c011_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_1_06 (conv_i_src_c011_1_06 conv_i_c011_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_06 (conv_q_src_c011_1_06 0 conv_bpf_c011_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_1_06 (conv_q_src_c011_1_06 conv_q_c011_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_07 (conv_i_src_c011_1_07 0 conv_bpf_c011_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_1_07 (conv_i_src_c011_1_07 conv_i_c011_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_07 (conv_q_src_c011_1_07 0 conv_bpf_c011_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_1_07 (conv_q_src_c011_1_07 conv_q_c011_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_08 (conv_i_src_c011_1_08 0 conv_bpf_c011_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_1_08 (conv_i_src_c011_1_08 conv_i_c011_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_08 (conv_q_src_c011_1_08 0 conv_bpf_c011_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_1_08 (conv_q_src_c011_1_08 conv_q_c011_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_09 (conv_i_src_c011_1_09 0 conv_bpf_c011_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_1_09 (conv_i_src_c011_1_09 conv_i_c011_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_09 (conv_q_src_c011_1_09 0 conv_bpf_c011_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_1_09 (conv_q_src_c011_1_09 conv_q_c011_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_10 (conv_i_src_c011_1_10 0 conv_bpf_c011_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_1_10 (conv_i_src_c011_1_10 conv_i_c011_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_10 (conv_q_src_c011_1_10 0 conv_bpf_c011_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_1_10 (conv_q_src_c011_1_10 conv_q_c011_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_11 (conv_i_src_c011_1_11 0 conv_bpf_c011_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_1_11 (conv_i_src_c011_1_11 conv_i_c011_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_11 (conv_q_src_c011_1_11 0 conv_bpf_c011_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_1_11 (conv_q_src_c011_1_11 conv_q_c011_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_12 (conv_i_src_c011_1_12 0 conv_bpf_c011_1 0) vcvs gain=1.950903220161e-01
SCONVI_c011_1_12 (conv_i_src_c011_1_12 conv_i_c011_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_12 (conv_q_src_c011_1_12 0 conv_bpf_c011_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_1_12 (conv_q_src_c011_1_12 conv_q_c011_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_13 (conv_i_src_c011_1_13 0 conv_bpf_c011_1 0) vcvs gain=5.555702330196e-01
SCONVI_c011_1_13 (conv_i_src_c011_1_13 conv_i_c011_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_13 (conv_q_src_c011_1_13 0 conv_bpf_c011_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_1_13 (conv_q_src_c011_1_13 conv_q_c011_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_14 (conv_i_src_c011_1_14 0 conv_bpf_c011_1 0) vcvs gain=8.314696123025e-01
SCONVI_c011_1_14 (conv_i_src_c011_1_14 conv_i_c011_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_14 (conv_q_src_c011_1_14 0 conv_bpf_c011_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_1_14 (conv_q_src_c011_1_14 conv_q_c011_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_1_15 (conv_i_src_c011_1_15 0 conv_bpf_c011_1 0) vcvs gain=9.807852804032e-01
SCONVI_c011_1_15 (conv_i_src_c011_1_15 conv_i_c011_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_1_15 (conv_q_src_c011_1_15 0 conv_bpf_c011_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_1_15 (conv_q_src_c011_1_15 conv_q_c011_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c011_1 (conv_i_c011_1 0) resistor r=1G
RCONVQ_c011_1 (conv_q_c011_1 0) resistor r=1G
RCONVINTI_c011_1 (conv_i_c011_1 ConvIcar_c011_1) resistor r=1k
CCONVINTI_c011_1 (ConvIcar_c011_1 0) capacitor c=80p
RCONVINTQ_c011_1 (conv_q_c011_1 ConvQcar_c011_1) resistor r=1k
CCONVINTQ_c011_1 (ConvQcar_c011_1 0) capacitor c=80p
save conv_bpf_c011_1 ConvIcar_c011_1 ConvQcar_c011_1

// conventional mixed baseline bl011, carrier_2: 750000000 Hz
CCONVBPF_c011_2 (bl011 n_conv_cbpf_c011_2) capacitor c=4.503163717437e-14
LCONVBPF_c011_2 (n_conv_cbpf_c011_2 conv_bpf_c011_2) inductor l=1.000000000000e-06
RCONVBPF_c011_2 (conv_bpf_c011_2 0) resistor r=2.356194490192e+02
ECONVI_c011_2_00 (conv_i_src_c011_2_00 0 conv_bpf_c011_2 0) vcvs gain=9.807852804032e-01
SCONVI_c011_2_00 (conv_i_src_c011_2_00 conv_i_c011_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_00 (conv_q_src_c011_2_00 0 conv_bpf_c011_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_2_00 (conv_q_src_c011_2_00 conv_q_c011_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_01 (conv_i_src_c011_2_01 0 conv_bpf_c011_2 0) vcvs gain=8.314696123025e-01
SCONVI_c011_2_01 (conv_i_src_c011_2_01 conv_i_c011_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_01 (conv_q_src_c011_2_01 0 conv_bpf_c011_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_2_01 (conv_q_src_c011_2_01 conv_q_c011_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_02 (conv_i_src_c011_2_02 0 conv_bpf_c011_2 0) vcvs gain=5.555702330196e-01
SCONVI_c011_2_02 (conv_i_src_c011_2_02 conv_i_c011_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_02 (conv_q_src_c011_2_02 0 conv_bpf_c011_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_2_02 (conv_q_src_c011_2_02 conv_q_c011_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_03 (conv_i_src_c011_2_03 0 conv_bpf_c011_2 0) vcvs gain=1.950903220161e-01
SCONVI_c011_2_03 (conv_i_src_c011_2_03 conv_i_c011_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_03 (conv_q_src_c011_2_03 0 conv_bpf_c011_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_2_03 (conv_q_src_c011_2_03 conv_q_c011_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_04 (conv_i_src_c011_2_04 0 conv_bpf_c011_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_2_04 (conv_i_src_c011_2_04 conv_i_c011_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_04 (conv_q_src_c011_2_04 0 conv_bpf_c011_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_2_04 (conv_q_src_c011_2_04 conv_q_c011_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_05 (conv_i_src_c011_2_05 0 conv_bpf_c011_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_2_05 (conv_i_src_c011_2_05 conv_i_c011_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_05 (conv_q_src_c011_2_05 0 conv_bpf_c011_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_2_05 (conv_q_src_c011_2_05 conv_q_c011_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_06 (conv_i_src_c011_2_06 0 conv_bpf_c011_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_2_06 (conv_i_src_c011_2_06 conv_i_c011_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_06 (conv_q_src_c011_2_06 0 conv_bpf_c011_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_2_06 (conv_q_src_c011_2_06 conv_q_c011_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_07 (conv_i_src_c011_2_07 0 conv_bpf_c011_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_2_07 (conv_i_src_c011_2_07 conv_i_c011_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_07 (conv_q_src_c011_2_07 0 conv_bpf_c011_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_2_07 (conv_q_src_c011_2_07 conv_q_c011_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_08 (conv_i_src_c011_2_08 0 conv_bpf_c011_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_2_08 (conv_i_src_c011_2_08 conv_i_c011_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_08 (conv_q_src_c011_2_08 0 conv_bpf_c011_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_2_08 (conv_q_src_c011_2_08 conv_q_c011_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_09 (conv_i_src_c011_2_09 0 conv_bpf_c011_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_2_09 (conv_i_src_c011_2_09 conv_i_c011_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_09 (conv_q_src_c011_2_09 0 conv_bpf_c011_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_2_09 (conv_q_src_c011_2_09 conv_q_c011_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_10 (conv_i_src_c011_2_10 0 conv_bpf_c011_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_2_10 (conv_i_src_c011_2_10 conv_i_c011_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_10 (conv_q_src_c011_2_10 0 conv_bpf_c011_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_2_10 (conv_q_src_c011_2_10 conv_q_c011_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_11 (conv_i_src_c011_2_11 0 conv_bpf_c011_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_2_11 (conv_i_src_c011_2_11 conv_i_c011_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_11 (conv_q_src_c011_2_11 0 conv_bpf_c011_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_2_11 (conv_q_src_c011_2_11 conv_q_c011_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_12 (conv_i_src_c011_2_12 0 conv_bpf_c011_2 0) vcvs gain=1.950903220161e-01
SCONVI_c011_2_12 (conv_i_src_c011_2_12 conv_i_c011_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_12 (conv_q_src_c011_2_12 0 conv_bpf_c011_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_2_12 (conv_q_src_c011_2_12 conv_q_c011_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_13 (conv_i_src_c011_2_13 0 conv_bpf_c011_2 0) vcvs gain=5.555702330196e-01
SCONVI_c011_2_13 (conv_i_src_c011_2_13 conv_i_c011_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_13 (conv_q_src_c011_2_13 0 conv_bpf_c011_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_2_13 (conv_q_src_c011_2_13 conv_q_c011_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_14 (conv_i_src_c011_2_14 0 conv_bpf_c011_2 0) vcvs gain=8.314696123025e-01
SCONVI_c011_2_14 (conv_i_src_c011_2_14 conv_i_c011_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_14 (conv_q_src_c011_2_14 0 conv_bpf_c011_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_2_14 (conv_q_src_c011_2_14 conv_q_c011_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_2_15 (conv_i_src_c011_2_15 0 conv_bpf_c011_2 0) vcvs gain=9.807852804032e-01
SCONVI_c011_2_15 (conv_i_src_c011_2_15 conv_i_c011_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_2_15 (conv_q_src_c011_2_15 0 conv_bpf_c011_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_2_15 (conv_q_src_c011_2_15 conv_q_c011_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c011_2 (conv_i_c011_2 0) resistor r=1G
RCONVQ_c011_2 (conv_q_c011_2 0) resistor r=1G
RCONVINTI_c011_2 (conv_i_c011_2 ConvIcar_c011_2) resistor r=1k
CCONVINTI_c011_2 (ConvIcar_c011_2 0) capacitor c=80p
RCONVINTQ_c011_2 (conv_q_c011_2 ConvQcar_c011_2) resistor r=1k
CCONVINTQ_c011_2 (ConvQcar_c011_2 0) capacitor c=80p
save conv_bpf_c011_2 ConvIcar_c011_2 ConvQcar_c011_2

// conventional mixed baseline bl011, carrier_3: 1000000000 Hz
CCONVBPF_c011_3 (bl011 n_conv_cbpf_c011_3) capacitor c=2.533029591058e-14
LCONVBPF_c011_3 (n_conv_cbpf_c011_3 conv_bpf_c011_3) inductor l=1.000000000000e-06
RCONVBPF_c011_3 (conv_bpf_c011_3 0) resistor r=3.141592653590e+02
ECONVI_c011_3_00 (conv_i_src_c011_3_00 0 conv_bpf_c011_3 0) vcvs gain=9.807852804032e-01
SCONVI_c011_3_00 (conv_i_src_c011_3_00 conv_i_c011_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_00 (conv_q_src_c011_3_00 0 conv_bpf_c011_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_3_00 (conv_q_src_c011_3_00 conv_q_c011_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_01 (conv_i_src_c011_3_01 0 conv_bpf_c011_3 0) vcvs gain=8.314696123025e-01
SCONVI_c011_3_01 (conv_i_src_c011_3_01 conv_i_c011_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_01 (conv_q_src_c011_3_01 0 conv_bpf_c011_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_3_01 (conv_q_src_c011_3_01 conv_q_c011_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_02 (conv_i_src_c011_3_02 0 conv_bpf_c011_3 0) vcvs gain=5.555702330196e-01
SCONVI_c011_3_02 (conv_i_src_c011_3_02 conv_i_c011_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_02 (conv_q_src_c011_3_02 0 conv_bpf_c011_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_3_02 (conv_q_src_c011_3_02 conv_q_c011_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_03 (conv_i_src_c011_3_03 0 conv_bpf_c011_3 0) vcvs gain=1.950903220161e-01
SCONVI_c011_3_03 (conv_i_src_c011_3_03 conv_i_c011_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_03 (conv_q_src_c011_3_03 0 conv_bpf_c011_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_3_03 (conv_q_src_c011_3_03 conv_q_c011_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_04 (conv_i_src_c011_3_04 0 conv_bpf_c011_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_3_04 (conv_i_src_c011_3_04 conv_i_c011_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_04 (conv_q_src_c011_3_04 0 conv_bpf_c011_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c011_3_04 (conv_q_src_c011_3_04 conv_q_c011_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_05 (conv_i_src_c011_3_05 0 conv_bpf_c011_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_3_05 (conv_i_src_c011_3_05 conv_i_c011_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_05 (conv_q_src_c011_3_05 0 conv_bpf_c011_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c011_3_05 (conv_q_src_c011_3_05 conv_q_c011_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_06 (conv_i_src_c011_3_06 0 conv_bpf_c011_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_3_06 (conv_i_src_c011_3_06 conv_i_c011_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_06 (conv_q_src_c011_3_06 0 conv_bpf_c011_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c011_3_06 (conv_q_src_c011_3_06 conv_q_c011_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_07 (conv_i_src_c011_3_07 0 conv_bpf_c011_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_3_07 (conv_i_src_c011_3_07 conv_i_c011_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_07 (conv_q_src_c011_3_07 0 conv_bpf_c011_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c011_3_07 (conv_q_src_c011_3_07 conv_q_c011_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_08 (conv_i_src_c011_3_08 0 conv_bpf_c011_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c011_3_08 (conv_i_src_c011_3_08 conv_i_c011_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_08 (conv_q_src_c011_3_08 0 conv_bpf_c011_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_3_08 (conv_q_src_c011_3_08 conv_q_c011_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_09 (conv_i_src_c011_3_09 0 conv_bpf_c011_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c011_3_09 (conv_i_src_c011_3_09 conv_i_c011_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_09 (conv_q_src_c011_3_09 0 conv_bpf_c011_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_3_09 (conv_q_src_c011_3_09 conv_q_c011_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_10 (conv_i_src_c011_3_10 0 conv_bpf_c011_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c011_3_10 (conv_i_src_c011_3_10 conv_i_c011_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_10 (conv_q_src_c011_3_10 0 conv_bpf_c011_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_3_10 (conv_q_src_c011_3_10 conv_q_c011_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_11 (conv_i_src_c011_3_11 0 conv_bpf_c011_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c011_3_11 (conv_i_src_c011_3_11 conv_i_c011_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_11 (conv_q_src_c011_3_11 0 conv_bpf_c011_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_3_11 (conv_q_src_c011_3_11 conv_q_c011_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_12 (conv_i_src_c011_3_12 0 conv_bpf_c011_3 0) vcvs gain=1.950903220161e-01
SCONVI_c011_3_12 (conv_i_src_c011_3_12 conv_i_c011_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_12 (conv_q_src_c011_3_12 0 conv_bpf_c011_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c011_3_12 (conv_q_src_c011_3_12 conv_q_c011_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_13 (conv_i_src_c011_3_13 0 conv_bpf_c011_3 0) vcvs gain=5.555702330196e-01
SCONVI_c011_3_13 (conv_i_src_c011_3_13 conv_i_c011_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_13 (conv_q_src_c011_3_13 0 conv_bpf_c011_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c011_3_13 (conv_q_src_c011_3_13 conv_q_c011_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_14 (conv_i_src_c011_3_14 0 conv_bpf_c011_3 0) vcvs gain=8.314696123025e-01
SCONVI_c011_3_14 (conv_i_src_c011_3_14 conv_i_c011_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_14 (conv_q_src_c011_3_14 0 conv_bpf_c011_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c011_3_14 (conv_q_src_c011_3_14 conv_q_c011_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c011_3_15 (conv_i_src_c011_3_15 0 conv_bpf_c011_3 0) vcvs gain=9.807852804032e-01
SCONVI_c011_3_15 (conv_i_src_c011_3_15 conv_i_c011_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c011_3_15 (conv_q_src_c011_3_15 0 conv_bpf_c011_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c011_3_15 (conv_q_src_c011_3_15 conv_q_c011_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c011_3 (conv_i_c011_3 0) resistor r=1G
RCONVQ_c011_3 (conv_q_c011_3 0) resistor r=1G
RCONVINTI_c011_3 (conv_i_c011_3 ConvIcar_c011_3) resistor r=1k
CCONVINTI_c011_3 (ConvIcar_c011_3 0) capacitor c=80p
RCONVINTQ_c011_3 (conv_q_c011_3 ConvQcar_c011_3) resistor r=1k
CCONVINTQ_c011_3 (ConvQcar_c011_3 0) capacitor c=80p
save conv_bpf_c011_3 ConvIcar_c011_3 ConvQcar_c011_3

// conventional mixed baseline bl012, carrier_0: 250000000 Hz
CCONVBPF_c012_0 (bl012 n_conv_cbpf_c012_0) capacitor c=4.052847345694e-13
LCONVBPF_c012_0 (n_conv_cbpf_c012_0 conv_bpf_c012_0) inductor l=1.000000000000e-06
RCONVBPF_c012_0 (conv_bpf_c012_0 0) resistor r=7.853981633974e+01
ECONVI_c012_0_00 (conv_i_src_c012_0_00 0 conv_bpf_c012_0 0) vcvs gain=9.807852804032e-01
SCONVI_c012_0_00 (conv_i_src_c012_0_00 conv_i_c012_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_00 (conv_q_src_c012_0_00 0 conv_bpf_c012_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_0_00 (conv_q_src_c012_0_00 conv_q_c012_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_01 (conv_i_src_c012_0_01 0 conv_bpf_c012_0 0) vcvs gain=8.314696123025e-01
SCONVI_c012_0_01 (conv_i_src_c012_0_01 conv_i_c012_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_01 (conv_q_src_c012_0_01 0 conv_bpf_c012_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_0_01 (conv_q_src_c012_0_01 conv_q_c012_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_02 (conv_i_src_c012_0_02 0 conv_bpf_c012_0 0) vcvs gain=5.555702330196e-01
SCONVI_c012_0_02 (conv_i_src_c012_0_02 conv_i_c012_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_02 (conv_q_src_c012_0_02 0 conv_bpf_c012_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c012_0_02 (conv_q_src_c012_0_02 conv_q_c012_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_03 (conv_i_src_c012_0_03 0 conv_bpf_c012_0 0) vcvs gain=1.950903220161e-01
SCONVI_c012_0_03 (conv_i_src_c012_0_03 conv_i_c012_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_03 (conv_q_src_c012_0_03 0 conv_bpf_c012_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_0_03 (conv_q_src_c012_0_03 conv_q_c012_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_04 (conv_i_src_c012_0_04 0 conv_bpf_c012_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_0_04 (conv_i_src_c012_0_04 conv_i_c012_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_04 (conv_q_src_c012_0_04 0 conv_bpf_c012_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_0_04 (conv_q_src_c012_0_04 conv_q_c012_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_05 (conv_i_src_c012_0_05 0 conv_bpf_c012_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_0_05 (conv_i_src_c012_0_05 conv_i_c012_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_05 (conv_q_src_c012_0_05 0 conv_bpf_c012_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c012_0_05 (conv_q_src_c012_0_05 conv_q_c012_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_06 (conv_i_src_c012_0_06 0 conv_bpf_c012_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_0_06 (conv_i_src_c012_0_06 conv_i_c012_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_06 (conv_q_src_c012_0_06 0 conv_bpf_c012_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_0_06 (conv_q_src_c012_0_06 conv_q_c012_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_07 (conv_i_src_c012_0_07 0 conv_bpf_c012_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_0_07 (conv_i_src_c012_0_07 conv_i_c012_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_07 (conv_q_src_c012_0_07 0 conv_bpf_c012_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_0_07 (conv_q_src_c012_0_07 conv_q_c012_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_08 (conv_i_src_c012_0_08 0 conv_bpf_c012_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_0_08 (conv_i_src_c012_0_08 conv_i_c012_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_08 (conv_q_src_c012_0_08 0 conv_bpf_c012_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_0_08 (conv_q_src_c012_0_08 conv_q_c012_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_09 (conv_i_src_c012_0_09 0 conv_bpf_c012_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_0_09 (conv_i_src_c012_0_09 conv_i_c012_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_09 (conv_q_src_c012_0_09 0 conv_bpf_c012_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_0_09 (conv_q_src_c012_0_09 conv_q_c012_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_10 (conv_i_src_c012_0_10 0 conv_bpf_c012_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_0_10 (conv_i_src_c012_0_10 conv_i_c012_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_10 (conv_q_src_c012_0_10 0 conv_bpf_c012_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_0_10 (conv_q_src_c012_0_10 conv_q_c012_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_11 (conv_i_src_c012_0_11 0 conv_bpf_c012_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_0_11 (conv_i_src_c012_0_11 conv_i_c012_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_11 (conv_q_src_c012_0_11 0 conv_bpf_c012_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_0_11 (conv_q_src_c012_0_11 conv_q_c012_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_12 (conv_i_src_c012_0_12 0 conv_bpf_c012_0 0) vcvs gain=1.950903220161e-01
SCONVI_c012_0_12 (conv_i_src_c012_0_12 conv_i_c012_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_12 (conv_q_src_c012_0_12 0 conv_bpf_c012_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_0_12 (conv_q_src_c012_0_12 conv_q_c012_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_13 (conv_i_src_c012_0_13 0 conv_bpf_c012_0 0) vcvs gain=5.555702330196e-01
SCONVI_c012_0_13 (conv_i_src_c012_0_13 conv_i_c012_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_13 (conv_q_src_c012_0_13 0 conv_bpf_c012_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_0_13 (conv_q_src_c012_0_13 conv_q_c012_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_14 (conv_i_src_c012_0_14 0 conv_bpf_c012_0 0) vcvs gain=8.314696123025e-01
SCONVI_c012_0_14 (conv_i_src_c012_0_14 conv_i_c012_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_14 (conv_q_src_c012_0_14 0 conv_bpf_c012_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_0_14 (conv_q_src_c012_0_14 conv_q_c012_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_0_15 (conv_i_src_c012_0_15 0 conv_bpf_c012_0 0) vcvs gain=9.807852804032e-01
SCONVI_c012_0_15 (conv_i_src_c012_0_15 conv_i_c012_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_0_15 (conv_q_src_c012_0_15 0 conv_bpf_c012_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_0_15 (conv_q_src_c012_0_15 conv_q_c012_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c012_0 (conv_i_c012_0 0) resistor r=1G
RCONVQ_c012_0 (conv_q_c012_0 0) resistor r=1G
RCONVINTI_c012_0 (conv_i_c012_0 ConvIcar_c012_0) resistor r=1k
CCONVINTI_c012_0 (ConvIcar_c012_0 0) capacitor c=80p
RCONVINTQ_c012_0 (conv_q_c012_0 ConvQcar_c012_0) resistor r=1k
CCONVINTQ_c012_0 (ConvQcar_c012_0 0) capacitor c=80p
save conv_bpf_c012_0 ConvIcar_c012_0 ConvQcar_c012_0

// conventional mixed baseline bl012, carrier_1: 500000000 Hz
CCONVBPF_c012_1 (bl012 n_conv_cbpf_c012_1) capacitor c=1.013211836423e-13
LCONVBPF_c012_1 (n_conv_cbpf_c012_1 conv_bpf_c012_1) inductor l=1.000000000000e-06
RCONVBPF_c012_1 (conv_bpf_c012_1 0) resistor r=1.570796326795e+02
ECONVI_c012_1_00 (conv_i_src_c012_1_00 0 conv_bpf_c012_1 0) vcvs gain=9.807852804032e-01
SCONVI_c012_1_00 (conv_i_src_c012_1_00 conv_i_c012_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_00 (conv_q_src_c012_1_00 0 conv_bpf_c012_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_1_00 (conv_q_src_c012_1_00 conv_q_c012_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_01 (conv_i_src_c012_1_01 0 conv_bpf_c012_1 0) vcvs gain=8.314696123025e-01
SCONVI_c012_1_01 (conv_i_src_c012_1_01 conv_i_c012_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_01 (conv_q_src_c012_1_01 0 conv_bpf_c012_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_1_01 (conv_q_src_c012_1_01 conv_q_c012_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_02 (conv_i_src_c012_1_02 0 conv_bpf_c012_1 0) vcvs gain=5.555702330196e-01
SCONVI_c012_1_02 (conv_i_src_c012_1_02 conv_i_c012_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_02 (conv_q_src_c012_1_02 0 conv_bpf_c012_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c012_1_02 (conv_q_src_c012_1_02 conv_q_c012_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_03 (conv_i_src_c012_1_03 0 conv_bpf_c012_1 0) vcvs gain=1.950903220161e-01
SCONVI_c012_1_03 (conv_i_src_c012_1_03 conv_i_c012_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_03 (conv_q_src_c012_1_03 0 conv_bpf_c012_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_1_03 (conv_q_src_c012_1_03 conv_q_c012_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_04 (conv_i_src_c012_1_04 0 conv_bpf_c012_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_1_04 (conv_i_src_c012_1_04 conv_i_c012_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_04 (conv_q_src_c012_1_04 0 conv_bpf_c012_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_1_04 (conv_q_src_c012_1_04 conv_q_c012_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_05 (conv_i_src_c012_1_05 0 conv_bpf_c012_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_1_05 (conv_i_src_c012_1_05 conv_i_c012_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_05 (conv_q_src_c012_1_05 0 conv_bpf_c012_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c012_1_05 (conv_q_src_c012_1_05 conv_q_c012_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_06 (conv_i_src_c012_1_06 0 conv_bpf_c012_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_1_06 (conv_i_src_c012_1_06 conv_i_c012_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_06 (conv_q_src_c012_1_06 0 conv_bpf_c012_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_1_06 (conv_q_src_c012_1_06 conv_q_c012_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_07 (conv_i_src_c012_1_07 0 conv_bpf_c012_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_1_07 (conv_i_src_c012_1_07 conv_i_c012_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_07 (conv_q_src_c012_1_07 0 conv_bpf_c012_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_1_07 (conv_q_src_c012_1_07 conv_q_c012_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_08 (conv_i_src_c012_1_08 0 conv_bpf_c012_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_1_08 (conv_i_src_c012_1_08 conv_i_c012_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_08 (conv_q_src_c012_1_08 0 conv_bpf_c012_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_1_08 (conv_q_src_c012_1_08 conv_q_c012_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_09 (conv_i_src_c012_1_09 0 conv_bpf_c012_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_1_09 (conv_i_src_c012_1_09 conv_i_c012_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_09 (conv_q_src_c012_1_09 0 conv_bpf_c012_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_1_09 (conv_q_src_c012_1_09 conv_q_c012_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_10 (conv_i_src_c012_1_10 0 conv_bpf_c012_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_1_10 (conv_i_src_c012_1_10 conv_i_c012_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_10 (conv_q_src_c012_1_10 0 conv_bpf_c012_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_1_10 (conv_q_src_c012_1_10 conv_q_c012_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_11 (conv_i_src_c012_1_11 0 conv_bpf_c012_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_1_11 (conv_i_src_c012_1_11 conv_i_c012_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_11 (conv_q_src_c012_1_11 0 conv_bpf_c012_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_1_11 (conv_q_src_c012_1_11 conv_q_c012_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_12 (conv_i_src_c012_1_12 0 conv_bpf_c012_1 0) vcvs gain=1.950903220161e-01
SCONVI_c012_1_12 (conv_i_src_c012_1_12 conv_i_c012_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_12 (conv_q_src_c012_1_12 0 conv_bpf_c012_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_1_12 (conv_q_src_c012_1_12 conv_q_c012_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_13 (conv_i_src_c012_1_13 0 conv_bpf_c012_1 0) vcvs gain=5.555702330196e-01
SCONVI_c012_1_13 (conv_i_src_c012_1_13 conv_i_c012_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_13 (conv_q_src_c012_1_13 0 conv_bpf_c012_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_1_13 (conv_q_src_c012_1_13 conv_q_c012_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_14 (conv_i_src_c012_1_14 0 conv_bpf_c012_1 0) vcvs gain=8.314696123025e-01
SCONVI_c012_1_14 (conv_i_src_c012_1_14 conv_i_c012_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_14 (conv_q_src_c012_1_14 0 conv_bpf_c012_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_1_14 (conv_q_src_c012_1_14 conv_q_c012_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_1_15 (conv_i_src_c012_1_15 0 conv_bpf_c012_1 0) vcvs gain=9.807852804032e-01
SCONVI_c012_1_15 (conv_i_src_c012_1_15 conv_i_c012_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_1_15 (conv_q_src_c012_1_15 0 conv_bpf_c012_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_1_15 (conv_q_src_c012_1_15 conv_q_c012_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c012_1 (conv_i_c012_1 0) resistor r=1G
RCONVQ_c012_1 (conv_q_c012_1 0) resistor r=1G
RCONVINTI_c012_1 (conv_i_c012_1 ConvIcar_c012_1) resistor r=1k
CCONVINTI_c012_1 (ConvIcar_c012_1 0) capacitor c=80p
RCONVINTQ_c012_1 (conv_q_c012_1 ConvQcar_c012_1) resistor r=1k
CCONVINTQ_c012_1 (ConvQcar_c012_1 0) capacitor c=80p
save conv_bpf_c012_1 ConvIcar_c012_1 ConvQcar_c012_1

// conventional mixed baseline bl012, carrier_2: 750000000 Hz
CCONVBPF_c012_2 (bl012 n_conv_cbpf_c012_2) capacitor c=4.503163717437e-14
LCONVBPF_c012_2 (n_conv_cbpf_c012_2 conv_bpf_c012_2) inductor l=1.000000000000e-06
RCONVBPF_c012_2 (conv_bpf_c012_2 0) resistor r=2.356194490192e+02
ECONVI_c012_2_00 (conv_i_src_c012_2_00 0 conv_bpf_c012_2 0) vcvs gain=9.807852804032e-01
SCONVI_c012_2_00 (conv_i_src_c012_2_00 conv_i_c012_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_00 (conv_q_src_c012_2_00 0 conv_bpf_c012_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_2_00 (conv_q_src_c012_2_00 conv_q_c012_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_01 (conv_i_src_c012_2_01 0 conv_bpf_c012_2 0) vcvs gain=8.314696123025e-01
SCONVI_c012_2_01 (conv_i_src_c012_2_01 conv_i_c012_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_01 (conv_q_src_c012_2_01 0 conv_bpf_c012_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_2_01 (conv_q_src_c012_2_01 conv_q_c012_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_02 (conv_i_src_c012_2_02 0 conv_bpf_c012_2 0) vcvs gain=5.555702330196e-01
SCONVI_c012_2_02 (conv_i_src_c012_2_02 conv_i_c012_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_02 (conv_q_src_c012_2_02 0 conv_bpf_c012_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c012_2_02 (conv_q_src_c012_2_02 conv_q_c012_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_03 (conv_i_src_c012_2_03 0 conv_bpf_c012_2 0) vcvs gain=1.950903220161e-01
SCONVI_c012_2_03 (conv_i_src_c012_2_03 conv_i_c012_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_03 (conv_q_src_c012_2_03 0 conv_bpf_c012_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_2_03 (conv_q_src_c012_2_03 conv_q_c012_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_04 (conv_i_src_c012_2_04 0 conv_bpf_c012_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_2_04 (conv_i_src_c012_2_04 conv_i_c012_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_04 (conv_q_src_c012_2_04 0 conv_bpf_c012_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_2_04 (conv_q_src_c012_2_04 conv_q_c012_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_05 (conv_i_src_c012_2_05 0 conv_bpf_c012_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_2_05 (conv_i_src_c012_2_05 conv_i_c012_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_05 (conv_q_src_c012_2_05 0 conv_bpf_c012_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c012_2_05 (conv_q_src_c012_2_05 conv_q_c012_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_06 (conv_i_src_c012_2_06 0 conv_bpf_c012_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_2_06 (conv_i_src_c012_2_06 conv_i_c012_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_06 (conv_q_src_c012_2_06 0 conv_bpf_c012_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_2_06 (conv_q_src_c012_2_06 conv_q_c012_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_07 (conv_i_src_c012_2_07 0 conv_bpf_c012_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_2_07 (conv_i_src_c012_2_07 conv_i_c012_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_07 (conv_q_src_c012_2_07 0 conv_bpf_c012_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_2_07 (conv_q_src_c012_2_07 conv_q_c012_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_08 (conv_i_src_c012_2_08 0 conv_bpf_c012_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_2_08 (conv_i_src_c012_2_08 conv_i_c012_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_08 (conv_q_src_c012_2_08 0 conv_bpf_c012_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_2_08 (conv_q_src_c012_2_08 conv_q_c012_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_09 (conv_i_src_c012_2_09 0 conv_bpf_c012_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_2_09 (conv_i_src_c012_2_09 conv_i_c012_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_09 (conv_q_src_c012_2_09 0 conv_bpf_c012_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_2_09 (conv_q_src_c012_2_09 conv_q_c012_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_10 (conv_i_src_c012_2_10 0 conv_bpf_c012_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_2_10 (conv_i_src_c012_2_10 conv_i_c012_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_10 (conv_q_src_c012_2_10 0 conv_bpf_c012_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_2_10 (conv_q_src_c012_2_10 conv_q_c012_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_11 (conv_i_src_c012_2_11 0 conv_bpf_c012_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_2_11 (conv_i_src_c012_2_11 conv_i_c012_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_11 (conv_q_src_c012_2_11 0 conv_bpf_c012_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_2_11 (conv_q_src_c012_2_11 conv_q_c012_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_12 (conv_i_src_c012_2_12 0 conv_bpf_c012_2 0) vcvs gain=1.950903220161e-01
SCONVI_c012_2_12 (conv_i_src_c012_2_12 conv_i_c012_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_12 (conv_q_src_c012_2_12 0 conv_bpf_c012_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_2_12 (conv_q_src_c012_2_12 conv_q_c012_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_13 (conv_i_src_c012_2_13 0 conv_bpf_c012_2 0) vcvs gain=5.555702330196e-01
SCONVI_c012_2_13 (conv_i_src_c012_2_13 conv_i_c012_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_13 (conv_q_src_c012_2_13 0 conv_bpf_c012_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_2_13 (conv_q_src_c012_2_13 conv_q_c012_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_14 (conv_i_src_c012_2_14 0 conv_bpf_c012_2 0) vcvs gain=8.314696123025e-01
SCONVI_c012_2_14 (conv_i_src_c012_2_14 conv_i_c012_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_14 (conv_q_src_c012_2_14 0 conv_bpf_c012_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_2_14 (conv_q_src_c012_2_14 conv_q_c012_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_2_15 (conv_i_src_c012_2_15 0 conv_bpf_c012_2 0) vcvs gain=9.807852804032e-01
SCONVI_c012_2_15 (conv_i_src_c012_2_15 conv_i_c012_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_2_15 (conv_q_src_c012_2_15 0 conv_bpf_c012_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_2_15 (conv_q_src_c012_2_15 conv_q_c012_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c012_2 (conv_i_c012_2 0) resistor r=1G
RCONVQ_c012_2 (conv_q_c012_2 0) resistor r=1G
RCONVINTI_c012_2 (conv_i_c012_2 ConvIcar_c012_2) resistor r=1k
CCONVINTI_c012_2 (ConvIcar_c012_2 0) capacitor c=80p
RCONVINTQ_c012_2 (conv_q_c012_2 ConvQcar_c012_2) resistor r=1k
CCONVINTQ_c012_2 (ConvQcar_c012_2 0) capacitor c=80p
save conv_bpf_c012_2 ConvIcar_c012_2 ConvQcar_c012_2

// conventional mixed baseline bl012, carrier_3: 1000000000 Hz
CCONVBPF_c012_3 (bl012 n_conv_cbpf_c012_3) capacitor c=2.533029591058e-14
LCONVBPF_c012_3 (n_conv_cbpf_c012_3 conv_bpf_c012_3) inductor l=1.000000000000e-06
RCONVBPF_c012_3 (conv_bpf_c012_3 0) resistor r=3.141592653590e+02
ECONVI_c012_3_00 (conv_i_src_c012_3_00 0 conv_bpf_c012_3 0) vcvs gain=9.807852804032e-01
SCONVI_c012_3_00 (conv_i_src_c012_3_00 conv_i_c012_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_00 (conv_q_src_c012_3_00 0 conv_bpf_c012_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_3_00 (conv_q_src_c012_3_00 conv_q_c012_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_01 (conv_i_src_c012_3_01 0 conv_bpf_c012_3 0) vcvs gain=8.314696123025e-01
SCONVI_c012_3_01 (conv_i_src_c012_3_01 conv_i_c012_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_01 (conv_q_src_c012_3_01 0 conv_bpf_c012_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_3_01 (conv_q_src_c012_3_01 conv_q_c012_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_02 (conv_i_src_c012_3_02 0 conv_bpf_c012_3 0) vcvs gain=5.555702330196e-01
SCONVI_c012_3_02 (conv_i_src_c012_3_02 conv_i_c012_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_02 (conv_q_src_c012_3_02 0 conv_bpf_c012_3 0) vcvs gain=8.314696123025e-01
