save conv_bpf_c104_3 ConvIcar_c104_3 ConvQcar_c104_3

// conventional mixed baseline bl105, carrier_0: 250000000 Hz
CCONVBPF_c105_0 (bl105 n_conv_cbpf_c105_0) capacitor c=4.052847345694e-13
LCONVBPF_c105_0 (n_conv_cbpf_c105_0 conv_bpf_c105_0) inductor l=1.000000000000e-06
RCONVBPF_c105_0 (conv_bpf_c105_0 0) resistor r=7.853981633974e+01
ECONVI_c105_0_00 (conv_i_src_c105_0_00 0 conv_bpf_c105_0 0) vcvs gain=9.807852804032e-01
SCONVI_c105_0_00 (conv_i_src_c105_0_00 conv_i_c105_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_00 (conv_q_src_c105_0_00 0 conv_bpf_c105_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_0_00 (conv_q_src_c105_0_00 conv_q_c105_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_01 (conv_i_src_c105_0_01 0 conv_bpf_c105_0 0) vcvs gain=8.314696123025e-01
SCONVI_c105_0_01 (conv_i_src_c105_0_01 conv_i_c105_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_01 (conv_q_src_c105_0_01 0 conv_bpf_c105_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_0_01 (conv_q_src_c105_0_01 conv_q_c105_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_02 (conv_i_src_c105_0_02 0 conv_bpf_c105_0 0) vcvs gain=5.555702330196e-01
SCONVI_c105_0_02 (conv_i_src_c105_0_02 conv_i_c105_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_02 (conv_q_src_c105_0_02 0 conv_bpf_c105_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_0_02 (conv_q_src_c105_0_02 conv_q_c105_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_03 (conv_i_src_c105_0_03 0 conv_bpf_c105_0 0) vcvs gain=1.950903220161e-01
SCONVI_c105_0_03 (conv_i_src_c105_0_03 conv_i_c105_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_03 (conv_q_src_c105_0_03 0 conv_bpf_c105_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_0_03 (conv_q_src_c105_0_03 conv_q_c105_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_04 (conv_i_src_c105_0_04 0 conv_bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_0_04 (conv_i_src_c105_0_04 conv_i_c105_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_04 (conv_q_src_c105_0_04 0 conv_bpf_c105_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_0_04 (conv_q_src_c105_0_04 conv_q_c105_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_05 (conv_i_src_c105_0_05 0 conv_bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_0_05 (conv_i_src_c105_0_05 conv_i_c105_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_05 (conv_q_src_c105_0_05 0 conv_bpf_c105_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_0_05 (conv_q_src_c105_0_05 conv_q_c105_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_06 (conv_i_src_c105_0_06 0 conv_bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_0_06 (conv_i_src_c105_0_06 conv_i_c105_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_06 (conv_q_src_c105_0_06 0 conv_bpf_c105_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_0_06 (conv_q_src_c105_0_06 conv_q_c105_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_07 (conv_i_src_c105_0_07 0 conv_bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_0_07 (conv_i_src_c105_0_07 conv_i_c105_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_07 (conv_q_src_c105_0_07 0 conv_bpf_c105_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_0_07 (conv_q_src_c105_0_07 conv_q_c105_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_08 (conv_i_src_c105_0_08 0 conv_bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_0_08 (conv_i_src_c105_0_08 conv_i_c105_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_08 (conv_q_src_c105_0_08 0 conv_bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_0_08 (conv_q_src_c105_0_08 conv_q_c105_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_09 (conv_i_src_c105_0_09 0 conv_bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_0_09 (conv_i_src_c105_0_09 conv_i_c105_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_09 (conv_q_src_c105_0_09 0 conv_bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_0_09 (conv_q_src_c105_0_09 conv_q_c105_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_10 (conv_i_src_c105_0_10 0 conv_bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_0_10 (conv_i_src_c105_0_10 conv_i_c105_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_10 (conv_q_src_c105_0_10 0 conv_bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_0_10 (conv_q_src_c105_0_10 conv_q_c105_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_11 (conv_i_src_c105_0_11 0 conv_bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_0_11 (conv_i_src_c105_0_11 conv_i_c105_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_11 (conv_q_src_c105_0_11 0 conv_bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_0_11 (conv_q_src_c105_0_11 conv_q_c105_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_12 (conv_i_src_c105_0_12 0 conv_bpf_c105_0 0) vcvs gain=1.950903220161e-01
SCONVI_c105_0_12 (conv_i_src_c105_0_12 conv_i_c105_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_12 (conv_q_src_c105_0_12 0 conv_bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_0_12 (conv_q_src_c105_0_12 conv_q_c105_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_13 (conv_i_src_c105_0_13 0 conv_bpf_c105_0 0) vcvs gain=5.555702330196e-01
SCONVI_c105_0_13 (conv_i_src_c105_0_13 conv_i_c105_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_13 (conv_q_src_c105_0_13 0 conv_bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_0_13 (conv_q_src_c105_0_13 conv_q_c105_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_14 (conv_i_src_c105_0_14 0 conv_bpf_c105_0 0) vcvs gain=8.314696123025e-01
SCONVI_c105_0_14 (conv_i_src_c105_0_14 conv_i_c105_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_14 (conv_q_src_c105_0_14 0 conv_bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_0_14 (conv_q_src_c105_0_14 conv_q_c105_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_0_15 (conv_i_src_c105_0_15 0 conv_bpf_c105_0 0) vcvs gain=9.807852804032e-01
SCONVI_c105_0_15 (conv_i_src_c105_0_15 conv_i_c105_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_0_15 (conv_q_src_c105_0_15 0 conv_bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_0_15 (conv_q_src_c105_0_15 conv_q_c105_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c105_0 (conv_i_c105_0 0) resistor r=1G
RCONVQ_c105_0 (conv_q_c105_0 0) resistor r=1G
RCONVINTI_c105_0 (conv_i_c105_0 ConvIcar_c105_0) resistor r=1k
CCONVINTI_c105_0 (ConvIcar_c105_0 0) capacitor c=80p
RCONVINTQ_c105_0 (conv_q_c105_0 ConvQcar_c105_0) resistor r=1k
CCONVINTQ_c105_0 (ConvQcar_c105_0 0) capacitor c=80p
save conv_bpf_c105_0 ConvIcar_c105_0 ConvQcar_c105_0

// conventional mixed baseline bl105, carrier_1: 500000000 Hz
CCONVBPF_c105_1 (bl105 n_conv_cbpf_c105_1) capacitor c=1.013211836423e-13
LCONVBPF_c105_1 (n_conv_cbpf_c105_1 conv_bpf_c105_1) inductor l=1.000000000000e-06
RCONVBPF_c105_1 (conv_bpf_c105_1 0) resistor r=1.570796326795e+02
ECONVI_c105_1_00 (conv_i_src_c105_1_00 0 conv_bpf_c105_1 0) vcvs gain=9.807852804032e-01
SCONVI_c105_1_00 (conv_i_src_c105_1_00 conv_i_c105_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_00 (conv_q_src_c105_1_00 0 conv_bpf_c105_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_1_00 (conv_q_src_c105_1_00 conv_q_c105_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_01 (conv_i_src_c105_1_01 0 conv_bpf_c105_1 0) vcvs gain=8.314696123025e-01
SCONVI_c105_1_01 (conv_i_src_c105_1_01 conv_i_c105_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_01 (conv_q_src_c105_1_01 0 conv_bpf_c105_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_1_01 (conv_q_src_c105_1_01 conv_q_c105_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_02 (conv_i_src_c105_1_02 0 conv_bpf_c105_1 0) vcvs gain=5.555702330196e-01
SCONVI_c105_1_02 (conv_i_src_c105_1_02 conv_i_c105_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_02 (conv_q_src_c105_1_02 0 conv_bpf_c105_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_1_02 (conv_q_src_c105_1_02 conv_q_c105_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_03 (conv_i_src_c105_1_03 0 conv_bpf_c105_1 0) vcvs gain=1.950903220161e-01
SCONVI_c105_1_03 (conv_i_src_c105_1_03 conv_i_c105_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_03 (conv_q_src_c105_1_03 0 conv_bpf_c105_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_1_03 (conv_q_src_c105_1_03 conv_q_c105_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_04 (conv_i_src_c105_1_04 0 conv_bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_1_04 (conv_i_src_c105_1_04 conv_i_c105_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_04 (conv_q_src_c105_1_04 0 conv_bpf_c105_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_1_04 (conv_q_src_c105_1_04 conv_q_c105_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_05 (conv_i_src_c105_1_05 0 conv_bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_1_05 (conv_i_src_c105_1_05 conv_i_c105_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_05 (conv_q_src_c105_1_05 0 conv_bpf_c105_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_1_05 (conv_q_src_c105_1_05 conv_q_c105_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_06 (conv_i_src_c105_1_06 0 conv_bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_1_06 (conv_i_src_c105_1_06 conv_i_c105_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_06 (conv_q_src_c105_1_06 0 conv_bpf_c105_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_1_06 (conv_q_src_c105_1_06 conv_q_c105_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_07 (conv_i_src_c105_1_07 0 conv_bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_1_07 (conv_i_src_c105_1_07 conv_i_c105_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_07 (conv_q_src_c105_1_07 0 conv_bpf_c105_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_1_07 (conv_q_src_c105_1_07 conv_q_c105_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_08 (conv_i_src_c105_1_08 0 conv_bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_1_08 (conv_i_src_c105_1_08 conv_i_c105_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_08 (conv_q_src_c105_1_08 0 conv_bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_1_08 (conv_q_src_c105_1_08 conv_q_c105_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_09 (conv_i_src_c105_1_09 0 conv_bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_1_09 (conv_i_src_c105_1_09 conv_i_c105_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_09 (conv_q_src_c105_1_09 0 conv_bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_1_09 (conv_q_src_c105_1_09 conv_q_c105_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_10 (conv_i_src_c105_1_10 0 conv_bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_1_10 (conv_i_src_c105_1_10 conv_i_c105_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_10 (conv_q_src_c105_1_10 0 conv_bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_1_10 (conv_q_src_c105_1_10 conv_q_c105_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_11 (conv_i_src_c105_1_11 0 conv_bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_1_11 (conv_i_src_c105_1_11 conv_i_c105_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_11 (conv_q_src_c105_1_11 0 conv_bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_1_11 (conv_q_src_c105_1_11 conv_q_c105_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_12 (conv_i_src_c105_1_12 0 conv_bpf_c105_1 0) vcvs gain=1.950903220161e-01
SCONVI_c105_1_12 (conv_i_src_c105_1_12 conv_i_c105_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_12 (conv_q_src_c105_1_12 0 conv_bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_1_12 (conv_q_src_c105_1_12 conv_q_c105_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_13 (conv_i_src_c105_1_13 0 conv_bpf_c105_1 0) vcvs gain=5.555702330196e-01
SCONVI_c105_1_13 (conv_i_src_c105_1_13 conv_i_c105_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_13 (conv_q_src_c105_1_13 0 conv_bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_1_13 (conv_q_src_c105_1_13 conv_q_c105_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_14 (conv_i_src_c105_1_14 0 conv_bpf_c105_1 0) vcvs gain=8.314696123025e-01
SCONVI_c105_1_14 (conv_i_src_c105_1_14 conv_i_c105_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_14 (conv_q_src_c105_1_14 0 conv_bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_1_14 (conv_q_src_c105_1_14 conv_q_c105_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_1_15 (conv_i_src_c105_1_15 0 conv_bpf_c105_1 0) vcvs gain=9.807852804032e-01
SCONVI_c105_1_15 (conv_i_src_c105_1_15 conv_i_c105_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_1_15 (conv_q_src_c105_1_15 0 conv_bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_1_15 (conv_q_src_c105_1_15 conv_q_c105_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c105_1 (conv_i_c105_1 0) resistor r=1G
RCONVQ_c105_1 (conv_q_c105_1 0) resistor r=1G
RCONVINTI_c105_1 (conv_i_c105_1 ConvIcar_c105_1) resistor r=1k
CCONVINTI_c105_1 (ConvIcar_c105_1 0) capacitor c=80p
RCONVINTQ_c105_1 (conv_q_c105_1 ConvQcar_c105_1) resistor r=1k
CCONVINTQ_c105_1 (ConvQcar_c105_1 0) capacitor c=80p
save conv_bpf_c105_1 ConvIcar_c105_1 ConvQcar_c105_1

// conventional mixed baseline bl105, carrier_2: 750000000 Hz
CCONVBPF_c105_2 (bl105 n_conv_cbpf_c105_2) capacitor c=4.503163717437e-14
LCONVBPF_c105_2 (n_conv_cbpf_c105_2 conv_bpf_c105_2) inductor l=1.000000000000e-06
RCONVBPF_c105_2 (conv_bpf_c105_2 0) resistor r=2.356194490192e+02
ECONVI_c105_2_00 (conv_i_src_c105_2_00 0 conv_bpf_c105_2 0) vcvs gain=9.807852804032e-01
SCONVI_c105_2_00 (conv_i_src_c105_2_00 conv_i_c105_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_00 (conv_q_src_c105_2_00 0 conv_bpf_c105_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_2_00 (conv_q_src_c105_2_00 conv_q_c105_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_01 (conv_i_src_c105_2_01 0 conv_bpf_c105_2 0) vcvs gain=8.314696123025e-01
SCONVI_c105_2_01 (conv_i_src_c105_2_01 conv_i_c105_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_01 (conv_q_src_c105_2_01 0 conv_bpf_c105_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_2_01 (conv_q_src_c105_2_01 conv_q_c105_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_02 (conv_i_src_c105_2_02 0 conv_bpf_c105_2 0) vcvs gain=5.555702330196e-01
SCONVI_c105_2_02 (conv_i_src_c105_2_02 conv_i_c105_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_02 (conv_q_src_c105_2_02 0 conv_bpf_c105_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_2_02 (conv_q_src_c105_2_02 conv_q_c105_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_03 (conv_i_src_c105_2_03 0 conv_bpf_c105_2 0) vcvs gain=1.950903220161e-01
SCONVI_c105_2_03 (conv_i_src_c105_2_03 conv_i_c105_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_03 (conv_q_src_c105_2_03 0 conv_bpf_c105_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_2_03 (conv_q_src_c105_2_03 conv_q_c105_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_04 (conv_i_src_c105_2_04 0 conv_bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_2_04 (conv_i_src_c105_2_04 conv_i_c105_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_04 (conv_q_src_c105_2_04 0 conv_bpf_c105_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_2_04 (conv_q_src_c105_2_04 conv_q_c105_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_05 (conv_i_src_c105_2_05 0 conv_bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_2_05 (conv_i_src_c105_2_05 conv_i_c105_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_05 (conv_q_src_c105_2_05 0 conv_bpf_c105_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_2_05 (conv_q_src_c105_2_05 conv_q_c105_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_06 (conv_i_src_c105_2_06 0 conv_bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_2_06 (conv_i_src_c105_2_06 conv_i_c105_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_06 (conv_q_src_c105_2_06 0 conv_bpf_c105_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_2_06 (conv_q_src_c105_2_06 conv_q_c105_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_07 (conv_i_src_c105_2_07 0 conv_bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_2_07 (conv_i_src_c105_2_07 conv_i_c105_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_07 (conv_q_src_c105_2_07 0 conv_bpf_c105_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_2_07 (conv_q_src_c105_2_07 conv_q_c105_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_08 (conv_i_src_c105_2_08 0 conv_bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_2_08 (conv_i_src_c105_2_08 conv_i_c105_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_08 (conv_q_src_c105_2_08 0 conv_bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_2_08 (conv_q_src_c105_2_08 conv_q_c105_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_09 (conv_i_src_c105_2_09 0 conv_bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_2_09 (conv_i_src_c105_2_09 conv_i_c105_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_09 (conv_q_src_c105_2_09 0 conv_bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_2_09 (conv_q_src_c105_2_09 conv_q_c105_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_10 (conv_i_src_c105_2_10 0 conv_bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_2_10 (conv_i_src_c105_2_10 conv_i_c105_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_10 (conv_q_src_c105_2_10 0 conv_bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_2_10 (conv_q_src_c105_2_10 conv_q_c105_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_11 (conv_i_src_c105_2_11 0 conv_bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_2_11 (conv_i_src_c105_2_11 conv_i_c105_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_11 (conv_q_src_c105_2_11 0 conv_bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_2_11 (conv_q_src_c105_2_11 conv_q_c105_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_12 (conv_i_src_c105_2_12 0 conv_bpf_c105_2 0) vcvs gain=1.950903220161e-01
SCONVI_c105_2_12 (conv_i_src_c105_2_12 conv_i_c105_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_12 (conv_q_src_c105_2_12 0 conv_bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_2_12 (conv_q_src_c105_2_12 conv_q_c105_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_13 (conv_i_src_c105_2_13 0 conv_bpf_c105_2 0) vcvs gain=5.555702330196e-01
SCONVI_c105_2_13 (conv_i_src_c105_2_13 conv_i_c105_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_13 (conv_q_src_c105_2_13 0 conv_bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_2_13 (conv_q_src_c105_2_13 conv_q_c105_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_14 (conv_i_src_c105_2_14 0 conv_bpf_c105_2 0) vcvs gain=8.314696123025e-01
SCONVI_c105_2_14 (conv_i_src_c105_2_14 conv_i_c105_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_14 (conv_q_src_c105_2_14 0 conv_bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_2_14 (conv_q_src_c105_2_14 conv_q_c105_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_2_15 (conv_i_src_c105_2_15 0 conv_bpf_c105_2 0) vcvs gain=9.807852804032e-01
SCONVI_c105_2_15 (conv_i_src_c105_2_15 conv_i_c105_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_2_15 (conv_q_src_c105_2_15 0 conv_bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_2_15 (conv_q_src_c105_2_15 conv_q_c105_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c105_2 (conv_i_c105_2 0) resistor r=1G
RCONVQ_c105_2 (conv_q_c105_2 0) resistor r=1G
RCONVINTI_c105_2 (conv_i_c105_2 ConvIcar_c105_2) resistor r=1k
CCONVINTI_c105_2 (ConvIcar_c105_2 0) capacitor c=80p
RCONVINTQ_c105_2 (conv_q_c105_2 ConvQcar_c105_2) resistor r=1k
CCONVINTQ_c105_2 (ConvQcar_c105_2 0) capacitor c=80p
save conv_bpf_c105_2 ConvIcar_c105_2 ConvQcar_c105_2

// conventional mixed baseline bl105, carrier_3: 1000000000 Hz
CCONVBPF_c105_3 (bl105 n_conv_cbpf_c105_3) capacitor c=2.533029591058e-14
LCONVBPF_c105_3 (n_conv_cbpf_c105_3 conv_bpf_c105_3) inductor l=1.000000000000e-06
RCONVBPF_c105_3 (conv_bpf_c105_3 0) resistor r=3.141592653590e+02
ECONVI_c105_3_00 (conv_i_src_c105_3_00 0 conv_bpf_c105_3 0) vcvs gain=9.807852804032e-01
SCONVI_c105_3_00 (conv_i_src_c105_3_00 conv_i_c105_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_00 (conv_q_src_c105_3_00 0 conv_bpf_c105_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_3_00 (conv_q_src_c105_3_00 conv_q_c105_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_01 (conv_i_src_c105_3_01 0 conv_bpf_c105_3 0) vcvs gain=8.314696123025e-01
SCONVI_c105_3_01 (conv_i_src_c105_3_01 conv_i_c105_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_01 (conv_q_src_c105_3_01 0 conv_bpf_c105_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_3_01 (conv_q_src_c105_3_01 conv_q_c105_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_02 (conv_i_src_c105_3_02 0 conv_bpf_c105_3 0) vcvs gain=5.555702330196e-01
SCONVI_c105_3_02 (conv_i_src_c105_3_02 conv_i_c105_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_02 (conv_q_src_c105_3_02 0 conv_bpf_c105_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_3_02 (conv_q_src_c105_3_02 conv_q_c105_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_03 (conv_i_src_c105_3_03 0 conv_bpf_c105_3 0) vcvs gain=1.950903220161e-01
SCONVI_c105_3_03 (conv_i_src_c105_3_03 conv_i_c105_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_03 (conv_q_src_c105_3_03 0 conv_bpf_c105_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_3_03 (conv_q_src_c105_3_03 conv_q_c105_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_04 (conv_i_src_c105_3_04 0 conv_bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_3_04 (conv_i_src_c105_3_04 conv_i_c105_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_04 (conv_q_src_c105_3_04 0 conv_bpf_c105_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c105_3_04 (conv_q_src_c105_3_04 conv_q_c105_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_05 (conv_i_src_c105_3_05 0 conv_bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_3_05 (conv_i_src_c105_3_05 conv_i_c105_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_05 (conv_q_src_c105_3_05 0 conv_bpf_c105_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c105_3_05 (conv_q_src_c105_3_05 conv_q_c105_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_06 (conv_i_src_c105_3_06 0 conv_bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_3_06 (conv_i_src_c105_3_06 conv_i_c105_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_06 (conv_q_src_c105_3_06 0 conv_bpf_c105_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c105_3_06 (conv_q_src_c105_3_06 conv_q_c105_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_07 (conv_i_src_c105_3_07 0 conv_bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_3_07 (conv_i_src_c105_3_07 conv_i_c105_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_07 (conv_q_src_c105_3_07 0 conv_bpf_c105_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c105_3_07 (conv_q_src_c105_3_07 conv_q_c105_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_08 (conv_i_src_c105_3_08 0 conv_bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c105_3_08 (conv_i_src_c105_3_08 conv_i_c105_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_08 (conv_q_src_c105_3_08 0 conv_bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_3_08 (conv_q_src_c105_3_08 conv_q_c105_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_09 (conv_i_src_c105_3_09 0 conv_bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c105_3_09 (conv_i_src_c105_3_09 conv_i_c105_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_09 (conv_q_src_c105_3_09 0 conv_bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_3_09 (conv_q_src_c105_3_09 conv_q_c105_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_10 (conv_i_src_c105_3_10 0 conv_bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c105_3_10 (conv_i_src_c105_3_10 conv_i_c105_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_10 (conv_q_src_c105_3_10 0 conv_bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_3_10 (conv_q_src_c105_3_10 conv_q_c105_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_11 (conv_i_src_c105_3_11 0 conv_bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c105_3_11 (conv_i_src_c105_3_11 conv_i_c105_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_11 (conv_q_src_c105_3_11 0 conv_bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_3_11 (conv_q_src_c105_3_11 conv_q_c105_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_12 (conv_i_src_c105_3_12 0 conv_bpf_c105_3 0) vcvs gain=1.950903220161e-01
SCONVI_c105_3_12 (conv_i_src_c105_3_12 conv_i_c105_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_12 (conv_q_src_c105_3_12 0 conv_bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c105_3_12 (conv_q_src_c105_3_12 conv_q_c105_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_13 (conv_i_src_c105_3_13 0 conv_bpf_c105_3 0) vcvs gain=5.555702330196e-01
SCONVI_c105_3_13 (conv_i_src_c105_3_13 conv_i_c105_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_13 (conv_q_src_c105_3_13 0 conv_bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c105_3_13 (conv_q_src_c105_3_13 conv_q_c105_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_14 (conv_i_src_c105_3_14 0 conv_bpf_c105_3 0) vcvs gain=8.314696123025e-01
SCONVI_c105_3_14 (conv_i_src_c105_3_14 conv_i_c105_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_14 (conv_q_src_c105_3_14 0 conv_bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c105_3_14 (conv_q_src_c105_3_14 conv_q_c105_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c105_3_15 (conv_i_src_c105_3_15 0 conv_bpf_c105_3 0) vcvs gain=9.807852804032e-01
SCONVI_c105_3_15 (conv_i_src_c105_3_15 conv_i_c105_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c105_3_15 (conv_q_src_c105_3_15 0 conv_bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c105_3_15 (conv_q_src_c105_3_15 conv_q_c105_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c105_3 (conv_i_c105_3 0) resistor r=1G
RCONVQ_c105_3 (conv_q_c105_3 0) resistor r=1G
RCONVINTI_c105_3 (conv_i_c105_3 ConvIcar_c105_3) resistor r=1k
CCONVINTI_c105_3 (ConvIcar_c105_3 0) capacitor c=80p
RCONVINTQ_c105_3 (conv_q_c105_3 ConvQcar_c105_3) resistor r=1k
CCONVINTQ_c105_3 (ConvQcar_c105_3 0) capacitor c=80p
save conv_bpf_c105_3 ConvIcar_c105_3 ConvQcar_c105_3

// conventional mixed baseline bl106, carrier_0: 250000000 Hz
CCONVBPF_c106_0 (bl106 n_conv_cbpf_c106_0) capacitor c=4.052847345694e-13
LCONVBPF_c106_0 (n_conv_cbpf_c106_0 conv_bpf_c106_0) inductor l=1.000000000000e-06
RCONVBPF_c106_0 (conv_bpf_c106_0 0) resistor r=7.853981633974e+01
ECONVI_c106_0_00 (conv_i_src_c106_0_00 0 conv_bpf_c106_0 0) vcvs gain=9.807852804032e-01
SCONVI_c106_0_00 (conv_i_src_c106_0_00 conv_i_c106_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_00 (conv_q_src_c106_0_00 0 conv_bpf_c106_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_0_00 (conv_q_src_c106_0_00 conv_q_c106_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_01 (conv_i_src_c106_0_01 0 conv_bpf_c106_0 0) vcvs gain=8.314696123025e-01
SCONVI_c106_0_01 (conv_i_src_c106_0_01 conv_i_c106_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_01 (conv_q_src_c106_0_01 0 conv_bpf_c106_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_0_01 (conv_q_src_c106_0_01 conv_q_c106_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_02 (conv_i_src_c106_0_02 0 conv_bpf_c106_0 0) vcvs gain=5.555702330196e-01
SCONVI_c106_0_02 (conv_i_src_c106_0_02 conv_i_c106_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_02 (conv_q_src_c106_0_02 0 conv_bpf_c106_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_0_02 (conv_q_src_c106_0_02 conv_q_c106_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_03 (conv_i_src_c106_0_03 0 conv_bpf_c106_0 0) vcvs gain=1.950903220161e-01
SCONVI_c106_0_03 (conv_i_src_c106_0_03 conv_i_c106_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_03 (conv_q_src_c106_0_03 0 conv_bpf_c106_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_0_03 (conv_q_src_c106_0_03 conv_q_c106_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_04 (conv_i_src_c106_0_04 0 conv_bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_0_04 (conv_i_src_c106_0_04 conv_i_c106_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_04 (conv_q_src_c106_0_04 0 conv_bpf_c106_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_0_04 (conv_q_src_c106_0_04 conv_q_c106_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_05 (conv_i_src_c106_0_05 0 conv_bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_0_05 (conv_i_src_c106_0_05 conv_i_c106_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_05 (conv_q_src_c106_0_05 0 conv_bpf_c106_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_0_05 (conv_q_src_c106_0_05 conv_q_c106_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_06 (conv_i_src_c106_0_06 0 conv_bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_0_06 (conv_i_src_c106_0_06 conv_i_c106_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_06 (conv_q_src_c106_0_06 0 conv_bpf_c106_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_0_06 (conv_q_src_c106_0_06 conv_q_c106_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_07 (conv_i_src_c106_0_07 0 conv_bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_0_07 (conv_i_src_c106_0_07 conv_i_c106_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_07 (conv_q_src_c106_0_07 0 conv_bpf_c106_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_0_07 (conv_q_src_c106_0_07 conv_q_c106_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_08 (conv_i_src_c106_0_08 0 conv_bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_0_08 (conv_i_src_c106_0_08 conv_i_c106_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_08 (conv_q_src_c106_0_08 0 conv_bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_0_08 (conv_q_src_c106_0_08 conv_q_c106_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_09 (conv_i_src_c106_0_09 0 conv_bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_0_09 (conv_i_src_c106_0_09 conv_i_c106_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_09 (conv_q_src_c106_0_09 0 conv_bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_0_09 (conv_q_src_c106_0_09 conv_q_c106_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_10 (conv_i_src_c106_0_10 0 conv_bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_0_10 (conv_i_src_c106_0_10 conv_i_c106_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_10 (conv_q_src_c106_0_10 0 conv_bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_0_10 (conv_q_src_c106_0_10 conv_q_c106_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_11 (conv_i_src_c106_0_11 0 conv_bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_0_11 (conv_i_src_c106_0_11 conv_i_c106_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_11 (conv_q_src_c106_0_11 0 conv_bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_0_11 (conv_q_src_c106_0_11 conv_q_c106_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_12 (conv_i_src_c106_0_12 0 conv_bpf_c106_0 0) vcvs gain=1.950903220161e-01
SCONVI_c106_0_12 (conv_i_src_c106_0_12 conv_i_c106_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_12 (conv_q_src_c106_0_12 0 conv_bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_0_12 (conv_q_src_c106_0_12 conv_q_c106_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_13 (conv_i_src_c106_0_13 0 conv_bpf_c106_0 0) vcvs gain=5.555702330196e-01
SCONVI_c106_0_13 (conv_i_src_c106_0_13 conv_i_c106_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_13 (conv_q_src_c106_0_13 0 conv_bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_0_13 (conv_q_src_c106_0_13 conv_q_c106_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_14 (conv_i_src_c106_0_14 0 conv_bpf_c106_0 0) vcvs gain=8.314696123025e-01
SCONVI_c106_0_14 (conv_i_src_c106_0_14 conv_i_c106_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_14 (conv_q_src_c106_0_14 0 conv_bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_0_14 (conv_q_src_c106_0_14 conv_q_c106_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_0_15 (conv_i_src_c106_0_15 0 conv_bpf_c106_0 0) vcvs gain=9.807852804032e-01
SCONVI_c106_0_15 (conv_i_src_c106_0_15 conv_i_c106_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_0_15 (conv_q_src_c106_0_15 0 conv_bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_0_15 (conv_q_src_c106_0_15 conv_q_c106_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c106_0 (conv_i_c106_0 0) resistor r=1G
RCONVQ_c106_0 (conv_q_c106_0 0) resistor r=1G
RCONVINTI_c106_0 (conv_i_c106_0 ConvIcar_c106_0) resistor r=1k
CCONVINTI_c106_0 (ConvIcar_c106_0 0) capacitor c=80p
RCONVINTQ_c106_0 (conv_q_c106_0 ConvQcar_c106_0) resistor r=1k
CCONVINTQ_c106_0 (ConvQcar_c106_0 0) capacitor c=80p
save conv_bpf_c106_0 ConvIcar_c106_0 ConvQcar_c106_0

// conventional mixed baseline bl106, carrier_1: 500000000 Hz
CCONVBPF_c106_1 (bl106 n_conv_cbpf_c106_1) capacitor c=1.013211836423e-13
LCONVBPF_c106_1 (n_conv_cbpf_c106_1 conv_bpf_c106_1) inductor l=1.000000000000e-06
RCONVBPF_c106_1 (conv_bpf_c106_1 0) resistor r=1.570796326795e+02
ECONVI_c106_1_00 (conv_i_src_c106_1_00 0 conv_bpf_c106_1 0) vcvs gain=9.807852804032e-01
SCONVI_c106_1_00 (conv_i_src_c106_1_00 conv_i_c106_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_00 (conv_q_src_c106_1_00 0 conv_bpf_c106_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_1_00 (conv_q_src_c106_1_00 conv_q_c106_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_01 (conv_i_src_c106_1_01 0 conv_bpf_c106_1 0) vcvs gain=8.314696123025e-01
SCONVI_c106_1_01 (conv_i_src_c106_1_01 conv_i_c106_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_01 (conv_q_src_c106_1_01 0 conv_bpf_c106_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_1_01 (conv_q_src_c106_1_01 conv_q_c106_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_02 (conv_i_src_c106_1_02 0 conv_bpf_c106_1 0) vcvs gain=5.555702330196e-01
SCONVI_c106_1_02 (conv_i_src_c106_1_02 conv_i_c106_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_02 (conv_q_src_c106_1_02 0 conv_bpf_c106_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_1_02 (conv_q_src_c106_1_02 conv_q_c106_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_03 (conv_i_src_c106_1_03 0 conv_bpf_c106_1 0) vcvs gain=1.950903220161e-01
SCONVI_c106_1_03 (conv_i_src_c106_1_03 conv_i_c106_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_03 (conv_q_src_c106_1_03 0 conv_bpf_c106_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_1_03 (conv_q_src_c106_1_03 conv_q_c106_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_04 (conv_i_src_c106_1_04 0 conv_bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_1_04 (conv_i_src_c106_1_04 conv_i_c106_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_04 (conv_q_src_c106_1_04 0 conv_bpf_c106_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_1_04 (conv_q_src_c106_1_04 conv_q_c106_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_05 (conv_i_src_c106_1_05 0 conv_bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_1_05 (conv_i_src_c106_1_05 conv_i_c106_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_05 (conv_q_src_c106_1_05 0 conv_bpf_c106_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_1_05 (conv_q_src_c106_1_05 conv_q_c106_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_06 (conv_i_src_c106_1_06 0 conv_bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_1_06 (conv_i_src_c106_1_06 conv_i_c106_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_06 (conv_q_src_c106_1_06 0 conv_bpf_c106_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_1_06 (conv_q_src_c106_1_06 conv_q_c106_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_07 (conv_i_src_c106_1_07 0 conv_bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_1_07 (conv_i_src_c106_1_07 conv_i_c106_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_07 (conv_q_src_c106_1_07 0 conv_bpf_c106_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_1_07 (conv_q_src_c106_1_07 conv_q_c106_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_08 (conv_i_src_c106_1_08 0 conv_bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_1_08 (conv_i_src_c106_1_08 conv_i_c106_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_08 (conv_q_src_c106_1_08 0 conv_bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_1_08 (conv_q_src_c106_1_08 conv_q_c106_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_09 (conv_i_src_c106_1_09 0 conv_bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_1_09 (conv_i_src_c106_1_09 conv_i_c106_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_09 (conv_q_src_c106_1_09 0 conv_bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_1_09 (conv_q_src_c106_1_09 conv_q_c106_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_10 (conv_i_src_c106_1_10 0 conv_bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_1_10 (conv_i_src_c106_1_10 conv_i_c106_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_10 (conv_q_src_c106_1_10 0 conv_bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_1_10 (conv_q_src_c106_1_10 conv_q_c106_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_11 (conv_i_src_c106_1_11 0 conv_bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_1_11 (conv_i_src_c106_1_11 conv_i_c106_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_11 (conv_q_src_c106_1_11 0 conv_bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_1_11 (conv_q_src_c106_1_11 conv_q_c106_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_12 (conv_i_src_c106_1_12 0 conv_bpf_c106_1 0) vcvs gain=1.950903220161e-01
SCONVI_c106_1_12 (conv_i_src_c106_1_12 conv_i_c106_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_12 (conv_q_src_c106_1_12 0 conv_bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_1_12 (conv_q_src_c106_1_12 conv_q_c106_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_13 (conv_i_src_c106_1_13 0 conv_bpf_c106_1 0) vcvs gain=5.555702330196e-01
SCONVI_c106_1_13 (conv_i_src_c106_1_13 conv_i_c106_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_13 (conv_q_src_c106_1_13 0 conv_bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_1_13 (conv_q_src_c106_1_13 conv_q_c106_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_14 (conv_i_src_c106_1_14 0 conv_bpf_c106_1 0) vcvs gain=8.314696123025e-01
SCONVI_c106_1_14 (conv_i_src_c106_1_14 conv_i_c106_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_14 (conv_q_src_c106_1_14 0 conv_bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_1_14 (conv_q_src_c106_1_14 conv_q_c106_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_1_15 (conv_i_src_c106_1_15 0 conv_bpf_c106_1 0) vcvs gain=9.807852804032e-01
SCONVI_c106_1_15 (conv_i_src_c106_1_15 conv_i_c106_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_1_15 (conv_q_src_c106_1_15 0 conv_bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_1_15 (conv_q_src_c106_1_15 conv_q_c106_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c106_1 (conv_i_c106_1 0) resistor r=1G
RCONVQ_c106_1 (conv_q_c106_1 0) resistor r=1G
RCONVINTI_c106_1 (conv_i_c106_1 ConvIcar_c106_1) resistor r=1k
CCONVINTI_c106_1 (ConvIcar_c106_1 0) capacitor c=80p
RCONVINTQ_c106_1 (conv_q_c106_1 ConvQcar_c106_1) resistor r=1k
CCONVINTQ_c106_1 (ConvQcar_c106_1 0) capacitor c=80p
save conv_bpf_c106_1 ConvIcar_c106_1 ConvQcar_c106_1

// conventional mixed baseline bl106, carrier_2: 750000000 Hz
CCONVBPF_c106_2 (bl106 n_conv_cbpf_c106_2) capacitor c=4.503163717437e-14
LCONVBPF_c106_2 (n_conv_cbpf_c106_2 conv_bpf_c106_2) inductor l=1.000000000000e-06
RCONVBPF_c106_2 (conv_bpf_c106_2 0) resistor r=2.356194490192e+02
ECONVI_c106_2_00 (conv_i_src_c106_2_00 0 conv_bpf_c106_2 0) vcvs gain=9.807852804032e-01
SCONVI_c106_2_00 (conv_i_src_c106_2_00 conv_i_c106_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_00 (conv_q_src_c106_2_00 0 conv_bpf_c106_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_2_00 (conv_q_src_c106_2_00 conv_q_c106_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_01 (conv_i_src_c106_2_01 0 conv_bpf_c106_2 0) vcvs gain=8.314696123025e-01
SCONVI_c106_2_01 (conv_i_src_c106_2_01 conv_i_c106_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_01 (conv_q_src_c106_2_01 0 conv_bpf_c106_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_2_01 (conv_q_src_c106_2_01 conv_q_c106_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_02 (conv_i_src_c106_2_02 0 conv_bpf_c106_2 0) vcvs gain=5.555702330196e-01
SCONVI_c106_2_02 (conv_i_src_c106_2_02 conv_i_c106_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_02 (conv_q_src_c106_2_02 0 conv_bpf_c106_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_2_02 (conv_q_src_c106_2_02 conv_q_c106_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_03 (conv_i_src_c106_2_03 0 conv_bpf_c106_2 0) vcvs gain=1.950903220161e-01
SCONVI_c106_2_03 (conv_i_src_c106_2_03 conv_i_c106_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_03 (conv_q_src_c106_2_03 0 conv_bpf_c106_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_2_03 (conv_q_src_c106_2_03 conv_q_c106_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_04 (conv_i_src_c106_2_04 0 conv_bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_2_04 (conv_i_src_c106_2_04 conv_i_c106_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_04 (conv_q_src_c106_2_04 0 conv_bpf_c106_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_2_04 (conv_q_src_c106_2_04 conv_q_c106_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_05 (conv_i_src_c106_2_05 0 conv_bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_2_05 (conv_i_src_c106_2_05 conv_i_c106_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_05 (conv_q_src_c106_2_05 0 conv_bpf_c106_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_2_05 (conv_q_src_c106_2_05 conv_q_c106_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_06 (conv_i_src_c106_2_06 0 conv_bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_2_06 (conv_i_src_c106_2_06 conv_i_c106_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_06 (conv_q_src_c106_2_06 0 conv_bpf_c106_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_2_06 (conv_q_src_c106_2_06 conv_q_c106_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_07 (conv_i_src_c106_2_07 0 conv_bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_2_07 (conv_i_src_c106_2_07 conv_i_c106_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_07 (conv_q_src_c106_2_07 0 conv_bpf_c106_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_2_07 (conv_q_src_c106_2_07 conv_q_c106_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_08 (conv_i_src_c106_2_08 0 conv_bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_2_08 (conv_i_src_c106_2_08 conv_i_c106_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_08 (conv_q_src_c106_2_08 0 conv_bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_2_08 (conv_q_src_c106_2_08 conv_q_c106_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_09 (conv_i_src_c106_2_09 0 conv_bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_2_09 (conv_i_src_c106_2_09 conv_i_c106_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_09 (conv_q_src_c106_2_09 0 conv_bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_2_09 (conv_q_src_c106_2_09 conv_q_c106_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_10 (conv_i_src_c106_2_10 0 conv_bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_2_10 (conv_i_src_c106_2_10 conv_i_c106_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_10 (conv_q_src_c106_2_10 0 conv_bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_2_10 (conv_q_src_c106_2_10 conv_q_c106_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_11 (conv_i_src_c106_2_11 0 conv_bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_2_11 (conv_i_src_c106_2_11 conv_i_c106_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_11 (conv_q_src_c106_2_11 0 conv_bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_2_11 (conv_q_src_c106_2_11 conv_q_c106_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_12 (conv_i_src_c106_2_12 0 conv_bpf_c106_2 0) vcvs gain=1.950903220161e-01
SCONVI_c106_2_12 (conv_i_src_c106_2_12 conv_i_c106_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_12 (conv_q_src_c106_2_12 0 conv_bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_2_12 (conv_q_src_c106_2_12 conv_q_c106_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_13 (conv_i_src_c106_2_13 0 conv_bpf_c106_2 0) vcvs gain=5.555702330196e-01
SCONVI_c106_2_13 (conv_i_src_c106_2_13 conv_i_c106_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_13 (conv_q_src_c106_2_13 0 conv_bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_2_13 (conv_q_src_c106_2_13 conv_q_c106_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_14 (conv_i_src_c106_2_14 0 conv_bpf_c106_2 0) vcvs gain=8.314696123025e-01
SCONVI_c106_2_14 (conv_i_src_c106_2_14 conv_i_c106_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_14 (conv_q_src_c106_2_14 0 conv_bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_2_14 (conv_q_src_c106_2_14 conv_q_c106_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_2_15 (conv_i_src_c106_2_15 0 conv_bpf_c106_2 0) vcvs gain=9.807852804032e-01
SCONVI_c106_2_15 (conv_i_src_c106_2_15 conv_i_c106_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_2_15 (conv_q_src_c106_2_15 0 conv_bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_2_15 (conv_q_src_c106_2_15 conv_q_c106_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c106_2 (conv_i_c106_2 0) resistor r=1G
RCONVQ_c106_2 (conv_q_c106_2 0) resistor r=1G
RCONVINTI_c106_2 (conv_i_c106_2 ConvIcar_c106_2) resistor r=1k
CCONVINTI_c106_2 (ConvIcar_c106_2 0) capacitor c=80p
RCONVINTQ_c106_2 (conv_q_c106_2 ConvQcar_c106_2) resistor r=1k
CCONVINTQ_c106_2 (ConvQcar_c106_2 0) capacitor c=80p
save conv_bpf_c106_2 ConvIcar_c106_2 ConvQcar_c106_2

// conventional mixed baseline bl106, carrier_3: 1000000000 Hz
CCONVBPF_c106_3 (bl106 n_conv_cbpf_c106_3) capacitor c=2.533029591058e-14
LCONVBPF_c106_3 (n_conv_cbpf_c106_3 conv_bpf_c106_3) inductor l=1.000000000000e-06
RCONVBPF_c106_3 (conv_bpf_c106_3 0) resistor r=3.141592653590e+02
ECONVI_c106_3_00 (conv_i_src_c106_3_00 0 conv_bpf_c106_3 0) vcvs gain=9.807852804032e-01
SCONVI_c106_3_00 (conv_i_src_c106_3_00 conv_i_c106_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_00 (conv_q_src_c106_3_00 0 conv_bpf_c106_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_3_00 (conv_q_src_c106_3_00 conv_q_c106_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_01 (conv_i_src_c106_3_01 0 conv_bpf_c106_3 0) vcvs gain=8.314696123025e-01
SCONVI_c106_3_01 (conv_i_src_c106_3_01 conv_i_c106_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_01 (conv_q_src_c106_3_01 0 conv_bpf_c106_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_3_01 (conv_q_src_c106_3_01 conv_q_c106_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_02 (conv_i_src_c106_3_02 0 conv_bpf_c106_3 0) vcvs gain=5.555702330196e-01
SCONVI_c106_3_02 (conv_i_src_c106_3_02 conv_i_c106_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_02 (conv_q_src_c106_3_02 0 conv_bpf_c106_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_3_02 (conv_q_src_c106_3_02 conv_q_c106_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_03 (conv_i_src_c106_3_03 0 conv_bpf_c106_3 0) vcvs gain=1.950903220161e-01
SCONVI_c106_3_03 (conv_i_src_c106_3_03 conv_i_c106_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_03 (conv_q_src_c106_3_03 0 conv_bpf_c106_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_3_03 (conv_q_src_c106_3_03 conv_q_c106_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_04 (conv_i_src_c106_3_04 0 conv_bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_3_04 (conv_i_src_c106_3_04 conv_i_c106_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_04 (conv_q_src_c106_3_04 0 conv_bpf_c106_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c106_3_04 (conv_q_src_c106_3_04 conv_q_c106_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_05 (conv_i_src_c106_3_05 0 conv_bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_3_05 (conv_i_src_c106_3_05 conv_i_c106_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_05 (conv_q_src_c106_3_05 0 conv_bpf_c106_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c106_3_05 (conv_q_src_c106_3_05 conv_q_c106_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_06 (conv_i_src_c106_3_06 0 conv_bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_3_06 (conv_i_src_c106_3_06 conv_i_c106_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_06 (conv_q_src_c106_3_06 0 conv_bpf_c106_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c106_3_06 (conv_q_src_c106_3_06 conv_q_c106_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_07 (conv_i_src_c106_3_07 0 conv_bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_3_07 (conv_i_src_c106_3_07 conv_i_c106_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_07 (conv_q_src_c106_3_07 0 conv_bpf_c106_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c106_3_07 (conv_q_src_c106_3_07 conv_q_c106_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_08 (conv_i_src_c106_3_08 0 conv_bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c106_3_08 (conv_i_src_c106_3_08 conv_i_c106_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_08 (conv_q_src_c106_3_08 0 conv_bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_3_08 (conv_q_src_c106_3_08 conv_q_c106_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_09 (conv_i_src_c106_3_09 0 conv_bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c106_3_09 (conv_i_src_c106_3_09 conv_i_c106_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_09 (conv_q_src_c106_3_09 0 conv_bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_3_09 (conv_q_src_c106_3_09 conv_q_c106_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_10 (conv_i_src_c106_3_10 0 conv_bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c106_3_10 (conv_i_src_c106_3_10 conv_i_c106_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_10 (conv_q_src_c106_3_10 0 conv_bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_3_10 (conv_q_src_c106_3_10 conv_q_c106_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_11 (conv_i_src_c106_3_11 0 conv_bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c106_3_11 (conv_i_src_c106_3_11 conv_i_c106_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_11 (conv_q_src_c106_3_11 0 conv_bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_3_11 (conv_q_src_c106_3_11 conv_q_c106_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_12 (conv_i_src_c106_3_12 0 conv_bpf_c106_3 0) vcvs gain=1.950903220161e-01
SCONVI_c106_3_12 (conv_i_src_c106_3_12 conv_i_c106_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_12 (conv_q_src_c106_3_12 0 conv_bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c106_3_12 (conv_q_src_c106_3_12 conv_q_c106_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_13 (conv_i_src_c106_3_13 0 conv_bpf_c106_3 0) vcvs gain=5.555702330196e-01
SCONVI_c106_3_13 (conv_i_src_c106_3_13 conv_i_c106_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_13 (conv_q_src_c106_3_13 0 conv_bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c106_3_13 (conv_q_src_c106_3_13 conv_q_c106_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_14 (conv_i_src_c106_3_14 0 conv_bpf_c106_3 0) vcvs gain=8.314696123025e-01
SCONVI_c106_3_14 (conv_i_src_c106_3_14 conv_i_c106_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_14 (conv_q_src_c106_3_14 0 conv_bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c106_3_14 (conv_q_src_c106_3_14 conv_q_c106_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c106_3_15 (conv_i_src_c106_3_15 0 conv_bpf_c106_3 0) vcvs gain=9.807852804032e-01
SCONVI_c106_3_15 (conv_i_src_c106_3_15 conv_i_c106_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c106_3_15 (conv_q_src_c106_3_15 0 conv_bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c106_3_15 (conv_q_src_c106_3_15 conv_q_c106_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c106_3 (conv_i_c106_3 0) resistor r=1G
RCONVQ_c106_3 (conv_q_c106_3 0) resistor r=1G
RCONVINTI_c106_3 (conv_i_c106_3 ConvIcar_c106_3) resistor r=1k
CCONVINTI_c106_3 (ConvIcar_c106_3 0) capacitor c=80p
RCONVINTQ_c106_3 (conv_q_c106_3 ConvQcar_c106_3) resistor r=1k
CCONVINTQ_c106_3 (ConvQcar_c106_3 0) capacitor c=80p
save conv_bpf_c106_3 ConvIcar_c106_3 ConvQcar_c106_3

// conventional mixed baseline bl107, carrier_0: 250000000 Hz
CCONVBPF_c107_0 (bl107 n_conv_cbpf_c107_0) capacitor c=4.052847345694e-13
LCONVBPF_c107_0 (n_conv_cbpf_c107_0 conv_bpf_c107_0) inductor l=1.000000000000e-06
RCONVBPF_c107_0 (conv_bpf_c107_0 0) resistor r=7.853981633974e+01
ECONVI_c107_0_00 (conv_i_src_c107_0_00 0 conv_bpf_c107_0 0) vcvs gain=9.807852804032e-01
SCONVI_c107_0_00 (conv_i_src_c107_0_00 conv_i_c107_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_00 (conv_q_src_c107_0_00 0 conv_bpf_c107_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_0_00 (conv_q_src_c107_0_00 conv_q_c107_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_01 (conv_i_src_c107_0_01 0 conv_bpf_c107_0 0) vcvs gain=8.314696123025e-01
SCONVI_c107_0_01 (conv_i_src_c107_0_01 conv_i_c107_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_01 (conv_q_src_c107_0_01 0 conv_bpf_c107_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_0_01 (conv_q_src_c107_0_01 conv_q_c107_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_02 (conv_i_src_c107_0_02 0 conv_bpf_c107_0 0) vcvs gain=5.555702330196e-01
SCONVI_c107_0_02 (conv_i_src_c107_0_02 conv_i_c107_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_02 (conv_q_src_c107_0_02 0 conv_bpf_c107_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_0_02 (conv_q_src_c107_0_02 conv_q_c107_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_03 (conv_i_src_c107_0_03 0 conv_bpf_c107_0 0) vcvs gain=1.950903220161e-01
SCONVI_c107_0_03 (conv_i_src_c107_0_03 conv_i_c107_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_03 (conv_q_src_c107_0_03 0 conv_bpf_c107_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_0_03 (conv_q_src_c107_0_03 conv_q_c107_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_04 (conv_i_src_c107_0_04 0 conv_bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_0_04 (conv_i_src_c107_0_04 conv_i_c107_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_04 (conv_q_src_c107_0_04 0 conv_bpf_c107_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_0_04 (conv_q_src_c107_0_04 conv_q_c107_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_05 (conv_i_src_c107_0_05 0 conv_bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_0_05 (conv_i_src_c107_0_05 conv_i_c107_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_05 (conv_q_src_c107_0_05 0 conv_bpf_c107_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_0_05 (conv_q_src_c107_0_05 conv_q_c107_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_06 (conv_i_src_c107_0_06 0 conv_bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_0_06 (conv_i_src_c107_0_06 conv_i_c107_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_06 (conv_q_src_c107_0_06 0 conv_bpf_c107_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_0_06 (conv_q_src_c107_0_06 conv_q_c107_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_07 (conv_i_src_c107_0_07 0 conv_bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_0_07 (conv_i_src_c107_0_07 conv_i_c107_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_07 (conv_q_src_c107_0_07 0 conv_bpf_c107_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_0_07 (conv_q_src_c107_0_07 conv_q_c107_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_08 (conv_i_src_c107_0_08 0 conv_bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_0_08 (conv_i_src_c107_0_08 conv_i_c107_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_08 (conv_q_src_c107_0_08 0 conv_bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_0_08 (conv_q_src_c107_0_08 conv_q_c107_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_09 (conv_i_src_c107_0_09 0 conv_bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_0_09 (conv_i_src_c107_0_09 conv_i_c107_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_09 (conv_q_src_c107_0_09 0 conv_bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_0_09 (conv_q_src_c107_0_09 conv_q_c107_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_10 (conv_i_src_c107_0_10 0 conv_bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_0_10 (conv_i_src_c107_0_10 conv_i_c107_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_10 (conv_q_src_c107_0_10 0 conv_bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_0_10 (conv_q_src_c107_0_10 conv_q_c107_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_11 (conv_i_src_c107_0_11 0 conv_bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_0_11 (conv_i_src_c107_0_11 conv_i_c107_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_11 (conv_q_src_c107_0_11 0 conv_bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_0_11 (conv_q_src_c107_0_11 conv_q_c107_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_12 (conv_i_src_c107_0_12 0 conv_bpf_c107_0 0) vcvs gain=1.950903220161e-01
SCONVI_c107_0_12 (conv_i_src_c107_0_12 conv_i_c107_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_12 (conv_q_src_c107_0_12 0 conv_bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_0_12 (conv_q_src_c107_0_12 conv_q_c107_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_13 (conv_i_src_c107_0_13 0 conv_bpf_c107_0 0) vcvs gain=5.555702330196e-01
SCONVI_c107_0_13 (conv_i_src_c107_0_13 conv_i_c107_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_13 (conv_q_src_c107_0_13 0 conv_bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_0_13 (conv_q_src_c107_0_13 conv_q_c107_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_14 (conv_i_src_c107_0_14 0 conv_bpf_c107_0 0) vcvs gain=8.314696123025e-01
SCONVI_c107_0_14 (conv_i_src_c107_0_14 conv_i_c107_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_14 (conv_q_src_c107_0_14 0 conv_bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_0_14 (conv_q_src_c107_0_14 conv_q_c107_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_0_15 (conv_i_src_c107_0_15 0 conv_bpf_c107_0 0) vcvs gain=9.807852804032e-01
SCONVI_c107_0_15 (conv_i_src_c107_0_15 conv_i_c107_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_0_15 (conv_q_src_c107_0_15 0 conv_bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_0_15 (conv_q_src_c107_0_15 conv_q_c107_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c107_0 (conv_i_c107_0 0) resistor r=1G
RCONVQ_c107_0 (conv_q_c107_0 0) resistor r=1G
RCONVINTI_c107_0 (conv_i_c107_0 ConvIcar_c107_0) resistor r=1k
CCONVINTI_c107_0 (ConvIcar_c107_0 0) capacitor c=80p
RCONVINTQ_c107_0 (conv_q_c107_0 ConvQcar_c107_0) resistor r=1k
CCONVINTQ_c107_0 (ConvQcar_c107_0 0) capacitor c=80p
save conv_bpf_c107_0 ConvIcar_c107_0 ConvQcar_c107_0

// conventional mixed baseline bl107, carrier_1: 500000000 Hz
CCONVBPF_c107_1 (bl107 n_conv_cbpf_c107_1) capacitor c=1.013211836423e-13
LCONVBPF_c107_1 (n_conv_cbpf_c107_1 conv_bpf_c107_1) inductor l=1.000000000000e-06
RCONVBPF_c107_1 (conv_bpf_c107_1 0) resistor r=1.570796326795e+02
ECONVI_c107_1_00 (conv_i_src_c107_1_00 0 conv_bpf_c107_1 0) vcvs gain=9.807852804032e-01
SCONVI_c107_1_00 (conv_i_src_c107_1_00 conv_i_c107_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_00 (conv_q_src_c107_1_00 0 conv_bpf_c107_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_1_00 (conv_q_src_c107_1_00 conv_q_c107_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_01 (conv_i_src_c107_1_01 0 conv_bpf_c107_1 0) vcvs gain=8.314696123025e-01
SCONVI_c107_1_01 (conv_i_src_c107_1_01 conv_i_c107_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_01 (conv_q_src_c107_1_01 0 conv_bpf_c107_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_1_01 (conv_q_src_c107_1_01 conv_q_c107_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_02 (conv_i_src_c107_1_02 0 conv_bpf_c107_1 0) vcvs gain=5.555702330196e-01
SCONVI_c107_1_02 (conv_i_src_c107_1_02 conv_i_c107_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_02 (conv_q_src_c107_1_02 0 conv_bpf_c107_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_1_02 (conv_q_src_c107_1_02 conv_q_c107_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_03 (conv_i_src_c107_1_03 0 conv_bpf_c107_1 0) vcvs gain=1.950903220161e-01
SCONVI_c107_1_03 (conv_i_src_c107_1_03 conv_i_c107_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_03 (conv_q_src_c107_1_03 0 conv_bpf_c107_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_1_03 (conv_q_src_c107_1_03 conv_q_c107_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_04 (conv_i_src_c107_1_04 0 conv_bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_1_04 (conv_i_src_c107_1_04 conv_i_c107_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_04 (conv_q_src_c107_1_04 0 conv_bpf_c107_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_1_04 (conv_q_src_c107_1_04 conv_q_c107_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_05 (conv_i_src_c107_1_05 0 conv_bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_1_05 (conv_i_src_c107_1_05 conv_i_c107_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_05 (conv_q_src_c107_1_05 0 conv_bpf_c107_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_1_05 (conv_q_src_c107_1_05 conv_q_c107_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_06 (conv_i_src_c107_1_06 0 conv_bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_1_06 (conv_i_src_c107_1_06 conv_i_c107_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_06 (conv_q_src_c107_1_06 0 conv_bpf_c107_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_1_06 (conv_q_src_c107_1_06 conv_q_c107_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_07 (conv_i_src_c107_1_07 0 conv_bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_1_07 (conv_i_src_c107_1_07 conv_i_c107_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_07 (conv_q_src_c107_1_07 0 conv_bpf_c107_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_1_07 (conv_q_src_c107_1_07 conv_q_c107_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_08 (conv_i_src_c107_1_08 0 conv_bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_1_08 (conv_i_src_c107_1_08 conv_i_c107_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_08 (conv_q_src_c107_1_08 0 conv_bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_1_08 (conv_q_src_c107_1_08 conv_q_c107_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_09 (conv_i_src_c107_1_09 0 conv_bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_1_09 (conv_i_src_c107_1_09 conv_i_c107_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_09 (conv_q_src_c107_1_09 0 conv_bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_1_09 (conv_q_src_c107_1_09 conv_q_c107_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_10 (conv_i_src_c107_1_10 0 conv_bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_1_10 (conv_i_src_c107_1_10 conv_i_c107_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_10 (conv_q_src_c107_1_10 0 conv_bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_1_10 (conv_q_src_c107_1_10 conv_q_c107_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_11 (conv_i_src_c107_1_11 0 conv_bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_1_11 (conv_i_src_c107_1_11 conv_i_c107_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_11 (conv_q_src_c107_1_11 0 conv_bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_1_11 (conv_q_src_c107_1_11 conv_q_c107_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_12 (conv_i_src_c107_1_12 0 conv_bpf_c107_1 0) vcvs gain=1.950903220161e-01
SCONVI_c107_1_12 (conv_i_src_c107_1_12 conv_i_c107_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_12 (conv_q_src_c107_1_12 0 conv_bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_1_12 (conv_q_src_c107_1_12 conv_q_c107_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_13 (conv_i_src_c107_1_13 0 conv_bpf_c107_1 0) vcvs gain=5.555702330196e-01
SCONVI_c107_1_13 (conv_i_src_c107_1_13 conv_i_c107_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_13 (conv_q_src_c107_1_13 0 conv_bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_1_13 (conv_q_src_c107_1_13 conv_q_c107_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_14 (conv_i_src_c107_1_14 0 conv_bpf_c107_1 0) vcvs gain=8.314696123025e-01
SCONVI_c107_1_14 (conv_i_src_c107_1_14 conv_i_c107_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_14 (conv_q_src_c107_1_14 0 conv_bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_1_14 (conv_q_src_c107_1_14 conv_q_c107_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_1_15 (conv_i_src_c107_1_15 0 conv_bpf_c107_1 0) vcvs gain=9.807852804032e-01
SCONVI_c107_1_15 (conv_i_src_c107_1_15 conv_i_c107_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_1_15 (conv_q_src_c107_1_15 0 conv_bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_1_15 (conv_q_src_c107_1_15 conv_q_c107_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c107_1 (conv_i_c107_1 0) resistor r=1G
RCONVQ_c107_1 (conv_q_c107_1 0) resistor r=1G
RCONVINTI_c107_1 (conv_i_c107_1 ConvIcar_c107_1) resistor r=1k
CCONVINTI_c107_1 (ConvIcar_c107_1 0) capacitor c=80p
RCONVINTQ_c107_1 (conv_q_c107_1 ConvQcar_c107_1) resistor r=1k
CCONVINTQ_c107_1 (ConvQcar_c107_1 0) capacitor c=80p
save conv_bpf_c107_1 ConvIcar_c107_1 ConvQcar_c107_1

// conventional mixed baseline bl107, carrier_2: 750000000 Hz
CCONVBPF_c107_2 (bl107 n_conv_cbpf_c107_2) capacitor c=4.503163717437e-14
LCONVBPF_c107_2 (n_conv_cbpf_c107_2 conv_bpf_c107_2) inductor l=1.000000000000e-06
RCONVBPF_c107_2 (conv_bpf_c107_2 0) resistor r=2.356194490192e+02
ECONVI_c107_2_00 (conv_i_src_c107_2_00 0 conv_bpf_c107_2 0) vcvs gain=9.807852804032e-01
SCONVI_c107_2_00 (conv_i_src_c107_2_00 conv_i_c107_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_00 (conv_q_src_c107_2_00 0 conv_bpf_c107_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_2_00 (conv_q_src_c107_2_00 conv_q_c107_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_01 (conv_i_src_c107_2_01 0 conv_bpf_c107_2 0) vcvs gain=8.314696123025e-01
SCONVI_c107_2_01 (conv_i_src_c107_2_01 conv_i_c107_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_01 (conv_q_src_c107_2_01 0 conv_bpf_c107_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_2_01 (conv_q_src_c107_2_01 conv_q_c107_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_02 (conv_i_src_c107_2_02 0 conv_bpf_c107_2 0) vcvs gain=5.555702330196e-01
SCONVI_c107_2_02 (conv_i_src_c107_2_02 conv_i_c107_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_02 (conv_q_src_c107_2_02 0 conv_bpf_c107_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_2_02 (conv_q_src_c107_2_02 conv_q_c107_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_03 (conv_i_src_c107_2_03 0 conv_bpf_c107_2 0) vcvs gain=1.950903220161e-01
SCONVI_c107_2_03 (conv_i_src_c107_2_03 conv_i_c107_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_03 (conv_q_src_c107_2_03 0 conv_bpf_c107_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_2_03 (conv_q_src_c107_2_03 conv_q_c107_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_04 (conv_i_src_c107_2_04 0 conv_bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_2_04 (conv_i_src_c107_2_04 conv_i_c107_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_04 (conv_q_src_c107_2_04 0 conv_bpf_c107_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_2_04 (conv_q_src_c107_2_04 conv_q_c107_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_05 (conv_i_src_c107_2_05 0 conv_bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_2_05 (conv_i_src_c107_2_05 conv_i_c107_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_05 (conv_q_src_c107_2_05 0 conv_bpf_c107_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_2_05 (conv_q_src_c107_2_05 conv_q_c107_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_06 (conv_i_src_c107_2_06 0 conv_bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_2_06 (conv_i_src_c107_2_06 conv_i_c107_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_06 (conv_q_src_c107_2_06 0 conv_bpf_c107_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_2_06 (conv_q_src_c107_2_06 conv_q_c107_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_07 (conv_i_src_c107_2_07 0 conv_bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_2_07 (conv_i_src_c107_2_07 conv_i_c107_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_07 (conv_q_src_c107_2_07 0 conv_bpf_c107_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_2_07 (conv_q_src_c107_2_07 conv_q_c107_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_08 (conv_i_src_c107_2_08 0 conv_bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_2_08 (conv_i_src_c107_2_08 conv_i_c107_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_08 (conv_q_src_c107_2_08 0 conv_bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_2_08 (conv_q_src_c107_2_08 conv_q_c107_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_09 (conv_i_src_c107_2_09 0 conv_bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_2_09 (conv_i_src_c107_2_09 conv_i_c107_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_09 (conv_q_src_c107_2_09 0 conv_bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_2_09 (conv_q_src_c107_2_09 conv_q_c107_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_10 (conv_i_src_c107_2_10 0 conv_bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_2_10 (conv_i_src_c107_2_10 conv_i_c107_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_10 (conv_q_src_c107_2_10 0 conv_bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_2_10 (conv_q_src_c107_2_10 conv_q_c107_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_11 (conv_i_src_c107_2_11 0 conv_bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_2_11 (conv_i_src_c107_2_11 conv_i_c107_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_11 (conv_q_src_c107_2_11 0 conv_bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_2_11 (conv_q_src_c107_2_11 conv_q_c107_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_12 (conv_i_src_c107_2_12 0 conv_bpf_c107_2 0) vcvs gain=1.950903220161e-01
SCONVI_c107_2_12 (conv_i_src_c107_2_12 conv_i_c107_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_12 (conv_q_src_c107_2_12 0 conv_bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_2_12 (conv_q_src_c107_2_12 conv_q_c107_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_13 (conv_i_src_c107_2_13 0 conv_bpf_c107_2 0) vcvs gain=5.555702330196e-01
SCONVI_c107_2_13 (conv_i_src_c107_2_13 conv_i_c107_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_13 (conv_q_src_c107_2_13 0 conv_bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_2_13 (conv_q_src_c107_2_13 conv_q_c107_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_14 (conv_i_src_c107_2_14 0 conv_bpf_c107_2 0) vcvs gain=8.314696123025e-01
SCONVI_c107_2_14 (conv_i_src_c107_2_14 conv_i_c107_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_14 (conv_q_src_c107_2_14 0 conv_bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_2_14 (conv_q_src_c107_2_14 conv_q_c107_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_2_15 (conv_i_src_c107_2_15 0 conv_bpf_c107_2 0) vcvs gain=9.807852804032e-01
SCONVI_c107_2_15 (conv_i_src_c107_2_15 conv_i_c107_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_2_15 (conv_q_src_c107_2_15 0 conv_bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_2_15 (conv_q_src_c107_2_15 conv_q_c107_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c107_2 (conv_i_c107_2 0) resistor r=1G
RCONVQ_c107_2 (conv_q_c107_2 0) resistor r=1G
RCONVINTI_c107_2 (conv_i_c107_2 ConvIcar_c107_2) resistor r=1k
CCONVINTI_c107_2 (ConvIcar_c107_2 0) capacitor c=80p
RCONVINTQ_c107_2 (conv_q_c107_2 ConvQcar_c107_2) resistor r=1k
CCONVINTQ_c107_2 (ConvQcar_c107_2 0) capacitor c=80p
save conv_bpf_c107_2 ConvIcar_c107_2 ConvQcar_c107_2

// conventional mixed baseline bl107, carrier_3: 1000000000 Hz
CCONVBPF_c107_3 (bl107 n_conv_cbpf_c107_3) capacitor c=2.533029591058e-14
LCONVBPF_c107_3 (n_conv_cbpf_c107_3 conv_bpf_c107_3) inductor l=1.000000000000e-06
RCONVBPF_c107_3 (conv_bpf_c107_3 0) resistor r=3.141592653590e+02
ECONVI_c107_3_00 (conv_i_src_c107_3_00 0 conv_bpf_c107_3 0) vcvs gain=9.807852804032e-01
SCONVI_c107_3_00 (conv_i_src_c107_3_00 conv_i_c107_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_00 (conv_q_src_c107_3_00 0 conv_bpf_c107_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_3_00 (conv_q_src_c107_3_00 conv_q_c107_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_01 (conv_i_src_c107_3_01 0 conv_bpf_c107_3 0) vcvs gain=8.314696123025e-01
SCONVI_c107_3_01 (conv_i_src_c107_3_01 conv_i_c107_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_01 (conv_q_src_c107_3_01 0 conv_bpf_c107_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_3_01 (conv_q_src_c107_3_01 conv_q_c107_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_02 (conv_i_src_c107_3_02 0 conv_bpf_c107_3 0) vcvs gain=5.555702330196e-01
SCONVI_c107_3_02 (conv_i_src_c107_3_02 conv_i_c107_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_02 (conv_q_src_c107_3_02 0 conv_bpf_c107_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_3_02 (conv_q_src_c107_3_02 conv_q_c107_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_03 (conv_i_src_c107_3_03 0 conv_bpf_c107_3 0) vcvs gain=1.950903220161e-01
SCONVI_c107_3_03 (conv_i_src_c107_3_03 conv_i_c107_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_03 (conv_q_src_c107_3_03 0 conv_bpf_c107_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_3_03 (conv_q_src_c107_3_03 conv_q_c107_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_04 (conv_i_src_c107_3_04 0 conv_bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_3_04 (conv_i_src_c107_3_04 conv_i_c107_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_04 (conv_q_src_c107_3_04 0 conv_bpf_c107_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c107_3_04 (conv_q_src_c107_3_04 conv_q_c107_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_05 (conv_i_src_c107_3_05 0 conv_bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_3_05 (conv_i_src_c107_3_05 conv_i_c107_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_05 (conv_q_src_c107_3_05 0 conv_bpf_c107_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c107_3_05 (conv_q_src_c107_3_05 conv_q_c107_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_06 (conv_i_src_c107_3_06 0 conv_bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_3_06 (conv_i_src_c107_3_06 conv_i_c107_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_06 (conv_q_src_c107_3_06 0 conv_bpf_c107_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c107_3_06 (conv_q_src_c107_3_06 conv_q_c107_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_07 (conv_i_src_c107_3_07 0 conv_bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_3_07 (conv_i_src_c107_3_07 conv_i_c107_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_07 (conv_q_src_c107_3_07 0 conv_bpf_c107_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c107_3_07 (conv_q_src_c107_3_07 conv_q_c107_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_08 (conv_i_src_c107_3_08 0 conv_bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c107_3_08 (conv_i_src_c107_3_08 conv_i_c107_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_08 (conv_q_src_c107_3_08 0 conv_bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_3_08 (conv_q_src_c107_3_08 conv_q_c107_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_09 (conv_i_src_c107_3_09 0 conv_bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c107_3_09 (conv_i_src_c107_3_09 conv_i_c107_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_09 (conv_q_src_c107_3_09 0 conv_bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_3_09 (conv_q_src_c107_3_09 conv_q_c107_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_10 (conv_i_src_c107_3_10 0 conv_bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c107_3_10 (conv_i_src_c107_3_10 conv_i_c107_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_10 (conv_q_src_c107_3_10 0 conv_bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_3_10 (conv_q_src_c107_3_10 conv_q_c107_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_11 (conv_i_src_c107_3_11 0 conv_bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c107_3_11 (conv_i_src_c107_3_11 conv_i_c107_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_11 (conv_q_src_c107_3_11 0 conv_bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_3_11 (conv_q_src_c107_3_11 conv_q_c107_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_12 (conv_i_src_c107_3_12 0 conv_bpf_c107_3 0) vcvs gain=1.950903220161e-01
SCONVI_c107_3_12 (conv_i_src_c107_3_12 conv_i_c107_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_12 (conv_q_src_c107_3_12 0 conv_bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c107_3_12 (conv_q_src_c107_3_12 conv_q_c107_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_13 (conv_i_src_c107_3_13 0 conv_bpf_c107_3 0) vcvs gain=5.555702330196e-01
SCONVI_c107_3_13 (conv_i_src_c107_3_13 conv_i_c107_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_13 (conv_q_src_c107_3_13 0 conv_bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c107_3_13 (conv_q_src_c107_3_13 conv_q_c107_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_14 (conv_i_src_c107_3_14 0 conv_bpf_c107_3 0) vcvs gain=8.314696123025e-01
SCONVI_c107_3_14 (conv_i_src_c107_3_14 conv_i_c107_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_14 (conv_q_src_c107_3_14 0 conv_bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c107_3_14 (conv_q_src_c107_3_14 conv_q_c107_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c107_3_15 (conv_i_src_c107_3_15 0 conv_bpf_c107_3 0) vcvs gain=9.807852804032e-01
SCONVI_c107_3_15 (conv_i_src_c107_3_15 conv_i_c107_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c107_3_15 (conv_q_src_c107_3_15 0 conv_bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c107_3_15 (conv_q_src_c107_3_15 conv_q_c107_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c107_3 (conv_i_c107_3 0) resistor r=1G
RCONVQ_c107_3 (conv_q_c107_3 0) resistor r=1G
RCONVINTI_c107_3 (conv_i_c107_3 ConvIcar_c107_3) resistor r=1k
CCONVINTI_c107_3 (ConvIcar_c107_3 0) capacitor c=80p
RCONVINTQ_c107_3 (conv_q_c107_3 ConvQcar_c107_3) resistor r=1k
CCONVINTQ_c107_3 (ConvQcar_c107_3 0) capacitor c=80p
save conv_bpf_c107_3 ConvIcar_c107_3 ConvQcar_c107_3

// conventional mixed baseline bl108, carrier_0: 250000000 Hz
CCONVBPF_c108_0 (bl108 n_conv_cbpf_c108_0) capacitor c=4.052847345694e-13
LCONVBPF_c108_0 (n_conv_cbpf_c108_0 conv_bpf_c108_0) inductor l=1.000000000000e-06
RCONVBPF_c108_0 (conv_bpf_c108_0 0) resistor r=7.853981633974e+01
ECONVI_c108_0_00 (conv_i_src_c108_0_00 0 conv_bpf_c108_0 0) vcvs gain=9.807852804032e-01
SCONVI_c108_0_00 (conv_i_src_c108_0_00 conv_i_c108_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_00 (conv_q_src_c108_0_00 0 conv_bpf_c108_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_0_00 (conv_q_src_c108_0_00 conv_q_c108_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_01 (conv_i_src_c108_0_01 0 conv_bpf_c108_0 0) vcvs gain=8.314696123025e-01
SCONVI_c108_0_01 (conv_i_src_c108_0_01 conv_i_c108_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_01 (conv_q_src_c108_0_01 0 conv_bpf_c108_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_0_01 (conv_q_src_c108_0_01 conv_q_c108_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_02 (conv_i_src_c108_0_02 0 conv_bpf_c108_0 0) vcvs gain=5.555702330196e-01
SCONVI_c108_0_02 (conv_i_src_c108_0_02 conv_i_c108_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_02 (conv_q_src_c108_0_02 0 conv_bpf_c108_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_0_02 (conv_q_src_c108_0_02 conv_q_c108_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_03 (conv_i_src_c108_0_03 0 conv_bpf_c108_0 0) vcvs gain=1.950903220161e-01
SCONVI_c108_0_03 (conv_i_src_c108_0_03 conv_i_c108_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_03 (conv_q_src_c108_0_03 0 conv_bpf_c108_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_0_03 (conv_q_src_c108_0_03 conv_q_c108_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_04 (conv_i_src_c108_0_04 0 conv_bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_0_04 (conv_i_src_c108_0_04 conv_i_c108_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_04 (conv_q_src_c108_0_04 0 conv_bpf_c108_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_0_04 (conv_q_src_c108_0_04 conv_q_c108_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_05 (conv_i_src_c108_0_05 0 conv_bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_0_05 (conv_i_src_c108_0_05 conv_i_c108_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_05 (conv_q_src_c108_0_05 0 conv_bpf_c108_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_0_05 (conv_q_src_c108_0_05 conv_q_c108_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_06 (conv_i_src_c108_0_06 0 conv_bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_0_06 (conv_i_src_c108_0_06 conv_i_c108_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_06 (conv_q_src_c108_0_06 0 conv_bpf_c108_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_0_06 (conv_q_src_c108_0_06 conv_q_c108_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_07 (conv_i_src_c108_0_07 0 conv_bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_0_07 (conv_i_src_c108_0_07 conv_i_c108_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_07 (conv_q_src_c108_0_07 0 conv_bpf_c108_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_0_07 (conv_q_src_c108_0_07 conv_q_c108_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_08 (conv_i_src_c108_0_08 0 conv_bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_0_08 (conv_i_src_c108_0_08 conv_i_c108_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_08 (conv_q_src_c108_0_08 0 conv_bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_0_08 (conv_q_src_c108_0_08 conv_q_c108_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_09 (conv_i_src_c108_0_09 0 conv_bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_0_09 (conv_i_src_c108_0_09 conv_i_c108_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_09 (conv_q_src_c108_0_09 0 conv_bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_0_09 (conv_q_src_c108_0_09 conv_q_c108_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_10 (conv_i_src_c108_0_10 0 conv_bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_0_10 (conv_i_src_c108_0_10 conv_i_c108_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_10 (conv_q_src_c108_0_10 0 conv_bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_0_10 (conv_q_src_c108_0_10 conv_q_c108_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_11 (conv_i_src_c108_0_11 0 conv_bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_0_11 (conv_i_src_c108_0_11 conv_i_c108_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_11 (conv_q_src_c108_0_11 0 conv_bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_0_11 (conv_q_src_c108_0_11 conv_q_c108_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_12 (conv_i_src_c108_0_12 0 conv_bpf_c108_0 0) vcvs gain=1.950903220161e-01
SCONVI_c108_0_12 (conv_i_src_c108_0_12 conv_i_c108_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_12 (conv_q_src_c108_0_12 0 conv_bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_0_12 (conv_q_src_c108_0_12 conv_q_c108_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_13 (conv_i_src_c108_0_13 0 conv_bpf_c108_0 0) vcvs gain=5.555702330196e-01
SCONVI_c108_0_13 (conv_i_src_c108_0_13 conv_i_c108_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_13 (conv_q_src_c108_0_13 0 conv_bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_0_13 (conv_q_src_c108_0_13 conv_q_c108_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_14 (conv_i_src_c108_0_14 0 conv_bpf_c108_0 0) vcvs gain=8.314696123025e-01
SCONVI_c108_0_14 (conv_i_src_c108_0_14 conv_i_c108_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_14 (conv_q_src_c108_0_14 0 conv_bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_0_14 (conv_q_src_c108_0_14 conv_q_c108_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_0_15 (conv_i_src_c108_0_15 0 conv_bpf_c108_0 0) vcvs gain=9.807852804032e-01
SCONVI_c108_0_15 (conv_i_src_c108_0_15 conv_i_c108_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_0_15 (conv_q_src_c108_0_15 0 conv_bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_0_15 (conv_q_src_c108_0_15 conv_q_c108_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c108_0 (conv_i_c108_0 0) resistor r=1G
RCONVQ_c108_0 (conv_q_c108_0 0) resistor r=1G
RCONVINTI_c108_0 (conv_i_c108_0 ConvIcar_c108_0) resistor r=1k
CCONVINTI_c108_0 (ConvIcar_c108_0 0) capacitor c=80p
RCONVINTQ_c108_0 (conv_q_c108_0 ConvQcar_c108_0) resistor r=1k
CCONVINTQ_c108_0 (ConvQcar_c108_0 0) capacitor c=80p
save conv_bpf_c108_0 ConvIcar_c108_0 ConvQcar_c108_0

// conventional mixed baseline bl108, carrier_1: 500000000 Hz
CCONVBPF_c108_1 (bl108 n_conv_cbpf_c108_1) capacitor c=1.013211836423e-13
LCONVBPF_c108_1 (n_conv_cbpf_c108_1 conv_bpf_c108_1) inductor l=1.000000000000e-06
RCONVBPF_c108_1 (conv_bpf_c108_1 0) resistor r=1.570796326795e+02
ECONVI_c108_1_00 (conv_i_src_c108_1_00 0 conv_bpf_c108_1 0) vcvs gain=9.807852804032e-01
SCONVI_c108_1_00 (conv_i_src_c108_1_00 conv_i_c108_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_00 (conv_q_src_c108_1_00 0 conv_bpf_c108_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_1_00 (conv_q_src_c108_1_00 conv_q_c108_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_01 (conv_i_src_c108_1_01 0 conv_bpf_c108_1 0) vcvs gain=8.314696123025e-01
SCONVI_c108_1_01 (conv_i_src_c108_1_01 conv_i_c108_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_01 (conv_q_src_c108_1_01 0 conv_bpf_c108_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_1_01 (conv_q_src_c108_1_01 conv_q_c108_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_02 (conv_i_src_c108_1_02 0 conv_bpf_c108_1 0) vcvs gain=5.555702330196e-01
SCONVI_c108_1_02 (conv_i_src_c108_1_02 conv_i_c108_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_02 (conv_q_src_c108_1_02 0 conv_bpf_c108_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_1_02 (conv_q_src_c108_1_02 conv_q_c108_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_03 (conv_i_src_c108_1_03 0 conv_bpf_c108_1 0) vcvs gain=1.950903220161e-01
SCONVI_c108_1_03 (conv_i_src_c108_1_03 conv_i_c108_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_03 (conv_q_src_c108_1_03 0 conv_bpf_c108_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_1_03 (conv_q_src_c108_1_03 conv_q_c108_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_04 (conv_i_src_c108_1_04 0 conv_bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_1_04 (conv_i_src_c108_1_04 conv_i_c108_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_04 (conv_q_src_c108_1_04 0 conv_bpf_c108_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_1_04 (conv_q_src_c108_1_04 conv_q_c108_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_05 (conv_i_src_c108_1_05 0 conv_bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_1_05 (conv_i_src_c108_1_05 conv_i_c108_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_05 (conv_q_src_c108_1_05 0 conv_bpf_c108_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_1_05 (conv_q_src_c108_1_05 conv_q_c108_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_06 (conv_i_src_c108_1_06 0 conv_bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_1_06 (conv_i_src_c108_1_06 conv_i_c108_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_06 (conv_q_src_c108_1_06 0 conv_bpf_c108_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_1_06 (conv_q_src_c108_1_06 conv_q_c108_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_07 (conv_i_src_c108_1_07 0 conv_bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_1_07 (conv_i_src_c108_1_07 conv_i_c108_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_07 (conv_q_src_c108_1_07 0 conv_bpf_c108_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_1_07 (conv_q_src_c108_1_07 conv_q_c108_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_08 (conv_i_src_c108_1_08 0 conv_bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_1_08 (conv_i_src_c108_1_08 conv_i_c108_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_08 (conv_q_src_c108_1_08 0 conv_bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_1_08 (conv_q_src_c108_1_08 conv_q_c108_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_09 (conv_i_src_c108_1_09 0 conv_bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_1_09 (conv_i_src_c108_1_09 conv_i_c108_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_09 (conv_q_src_c108_1_09 0 conv_bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_1_09 (conv_q_src_c108_1_09 conv_q_c108_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_10 (conv_i_src_c108_1_10 0 conv_bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_1_10 (conv_i_src_c108_1_10 conv_i_c108_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_10 (conv_q_src_c108_1_10 0 conv_bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_1_10 (conv_q_src_c108_1_10 conv_q_c108_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_11 (conv_i_src_c108_1_11 0 conv_bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_1_11 (conv_i_src_c108_1_11 conv_i_c108_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_11 (conv_q_src_c108_1_11 0 conv_bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_1_11 (conv_q_src_c108_1_11 conv_q_c108_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_12 (conv_i_src_c108_1_12 0 conv_bpf_c108_1 0) vcvs gain=1.950903220161e-01
SCONVI_c108_1_12 (conv_i_src_c108_1_12 conv_i_c108_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_12 (conv_q_src_c108_1_12 0 conv_bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_1_12 (conv_q_src_c108_1_12 conv_q_c108_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_13 (conv_i_src_c108_1_13 0 conv_bpf_c108_1 0) vcvs gain=5.555702330196e-01
SCONVI_c108_1_13 (conv_i_src_c108_1_13 conv_i_c108_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_13 (conv_q_src_c108_1_13 0 conv_bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_1_13 (conv_q_src_c108_1_13 conv_q_c108_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_14 (conv_i_src_c108_1_14 0 conv_bpf_c108_1 0) vcvs gain=8.314696123025e-01
SCONVI_c108_1_14 (conv_i_src_c108_1_14 conv_i_c108_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_14 (conv_q_src_c108_1_14 0 conv_bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_1_14 (conv_q_src_c108_1_14 conv_q_c108_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_1_15 (conv_i_src_c108_1_15 0 conv_bpf_c108_1 0) vcvs gain=9.807852804032e-01
SCONVI_c108_1_15 (conv_i_src_c108_1_15 conv_i_c108_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_1_15 (conv_q_src_c108_1_15 0 conv_bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_1_15 (conv_q_src_c108_1_15 conv_q_c108_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c108_1 (conv_i_c108_1 0) resistor r=1G
RCONVQ_c108_1 (conv_q_c108_1 0) resistor r=1G
RCONVINTI_c108_1 (conv_i_c108_1 ConvIcar_c108_1) resistor r=1k
CCONVINTI_c108_1 (ConvIcar_c108_1 0) capacitor c=80p
RCONVINTQ_c108_1 (conv_q_c108_1 ConvQcar_c108_1) resistor r=1k
CCONVINTQ_c108_1 (ConvQcar_c108_1 0) capacitor c=80p
save conv_bpf_c108_1 ConvIcar_c108_1 ConvQcar_c108_1

// conventional mixed baseline bl108, carrier_2: 750000000 Hz
CCONVBPF_c108_2 (bl108 n_conv_cbpf_c108_2) capacitor c=4.503163717437e-14
LCONVBPF_c108_2 (n_conv_cbpf_c108_2 conv_bpf_c108_2) inductor l=1.000000000000e-06
RCONVBPF_c108_2 (conv_bpf_c108_2 0) resistor r=2.356194490192e+02
ECONVI_c108_2_00 (conv_i_src_c108_2_00 0 conv_bpf_c108_2 0) vcvs gain=9.807852804032e-01
SCONVI_c108_2_00 (conv_i_src_c108_2_00 conv_i_c108_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_00 (conv_q_src_c108_2_00 0 conv_bpf_c108_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_2_00 (conv_q_src_c108_2_00 conv_q_c108_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_01 (conv_i_src_c108_2_01 0 conv_bpf_c108_2 0) vcvs gain=8.314696123025e-01
SCONVI_c108_2_01 (conv_i_src_c108_2_01 conv_i_c108_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_01 (conv_q_src_c108_2_01 0 conv_bpf_c108_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_2_01 (conv_q_src_c108_2_01 conv_q_c108_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_02 (conv_i_src_c108_2_02 0 conv_bpf_c108_2 0) vcvs gain=5.555702330196e-01
SCONVI_c108_2_02 (conv_i_src_c108_2_02 conv_i_c108_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_02 (conv_q_src_c108_2_02 0 conv_bpf_c108_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_2_02 (conv_q_src_c108_2_02 conv_q_c108_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_03 (conv_i_src_c108_2_03 0 conv_bpf_c108_2 0) vcvs gain=1.950903220161e-01
SCONVI_c108_2_03 (conv_i_src_c108_2_03 conv_i_c108_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_03 (conv_q_src_c108_2_03 0 conv_bpf_c108_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_2_03 (conv_q_src_c108_2_03 conv_q_c108_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_04 (conv_i_src_c108_2_04 0 conv_bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_2_04 (conv_i_src_c108_2_04 conv_i_c108_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_04 (conv_q_src_c108_2_04 0 conv_bpf_c108_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_2_04 (conv_q_src_c108_2_04 conv_q_c108_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_05 (conv_i_src_c108_2_05 0 conv_bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_2_05 (conv_i_src_c108_2_05 conv_i_c108_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_05 (conv_q_src_c108_2_05 0 conv_bpf_c108_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_2_05 (conv_q_src_c108_2_05 conv_q_c108_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_06 (conv_i_src_c108_2_06 0 conv_bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_2_06 (conv_i_src_c108_2_06 conv_i_c108_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_06 (conv_q_src_c108_2_06 0 conv_bpf_c108_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_2_06 (conv_q_src_c108_2_06 conv_q_c108_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_07 (conv_i_src_c108_2_07 0 conv_bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_2_07 (conv_i_src_c108_2_07 conv_i_c108_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_07 (conv_q_src_c108_2_07 0 conv_bpf_c108_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_2_07 (conv_q_src_c108_2_07 conv_q_c108_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_08 (conv_i_src_c108_2_08 0 conv_bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_2_08 (conv_i_src_c108_2_08 conv_i_c108_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_08 (conv_q_src_c108_2_08 0 conv_bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_2_08 (conv_q_src_c108_2_08 conv_q_c108_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_09 (conv_i_src_c108_2_09 0 conv_bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_2_09 (conv_i_src_c108_2_09 conv_i_c108_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_09 (conv_q_src_c108_2_09 0 conv_bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_2_09 (conv_q_src_c108_2_09 conv_q_c108_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_10 (conv_i_src_c108_2_10 0 conv_bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_2_10 (conv_i_src_c108_2_10 conv_i_c108_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_10 (conv_q_src_c108_2_10 0 conv_bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_2_10 (conv_q_src_c108_2_10 conv_q_c108_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_11 (conv_i_src_c108_2_11 0 conv_bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_2_11 (conv_i_src_c108_2_11 conv_i_c108_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_11 (conv_q_src_c108_2_11 0 conv_bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_2_11 (conv_q_src_c108_2_11 conv_q_c108_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_12 (conv_i_src_c108_2_12 0 conv_bpf_c108_2 0) vcvs gain=1.950903220161e-01
SCONVI_c108_2_12 (conv_i_src_c108_2_12 conv_i_c108_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_12 (conv_q_src_c108_2_12 0 conv_bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_2_12 (conv_q_src_c108_2_12 conv_q_c108_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_13 (conv_i_src_c108_2_13 0 conv_bpf_c108_2 0) vcvs gain=5.555702330196e-01
SCONVI_c108_2_13 (conv_i_src_c108_2_13 conv_i_c108_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_13 (conv_q_src_c108_2_13 0 conv_bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_2_13 (conv_q_src_c108_2_13 conv_q_c108_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_14 (conv_i_src_c108_2_14 0 conv_bpf_c108_2 0) vcvs gain=8.314696123025e-01
SCONVI_c108_2_14 (conv_i_src_c108_2_14 conv_i_c108_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_14 (conv_q_src_c108_2_14 0 conv_bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_2_14 (conv_q_src_c108_2_14 conv_q_c108_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_2_15 (conv_i_src_c108_2_15 0 conv_bpf_c108_2 0) vcvs gain=9.807852804032e-01
SCONVI_c108_2_15 (conv_i_src_c108_2_15 conv_i_c108_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_2_15 (conv_q_src_c108_2_15 0 conv_bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_2_15 (conv_q_src_c108_2_15 conv_q_c108_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c108_2 (conv_i_c108_2 0) resistor r=1G
RCONVQ_c108_2 (conv_q_c108_2 0) resistor r=1G
RCONVINTI_c108_2 (conv_i_c108_2 ConvIcar_c108_2) resistor r=1k
CCONVINTI_c108_2 (ConvIcar_c108_2 0) capacitor c=80p
RCONVINTQ_c108_2 (conv_q_c108_2 ConvQcar_c108_2) resistor r=1k
CCONVINTQ_c108_2 (ConvQcar_c108_2 0) capacitor c=80p
save conv_bpf_c108_2 ConvIcar_c108_2 ConvQcar_c108_2

// conventional mixed baseline bl108, carrier_3: 1000000000 Hz
CCONVBPF_c108_3 (bl108 n_conv_cbpf_c108_3) capacitor c=2.533029591058e-14
LCONVBPF_c108_3 (n_conv_cbpf_c108_3 conv_bpf_c108_3) inductor l=1.000000000000e-06
RCONVBPF_c108_3 (conv_bpf_c108_3 0) resistor r=3.141592653590e+02
ECONVI_c108_3_00 (conv_i_src_c108_3_00 0 conv_bpf_c108_3 0) vcvs gain=9.807852804032e-01
SCONVI_c108_3_00 (conv_i_src_c108_3_00 conv_i_c108_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_00 (conv_q_src_c108_3_00 0 conv_bpf_c108_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_3_00 (conv_q_src_c108_3_00 conv_q_c108_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_01 (conv_i_src_c108_3_01 0 conv_bpf_c108_3 0) vcvs gain=8.314696123025e-01
SCONVI_c108_3_01 (conv_i_src_c108_3_01 conv_i_c108_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_01 (conv_q_src_c108_3_01 0 conv_bpf_c108_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_3_01 (conv_q_src_c108_3_01 conv_q_c108_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_02 (conv_i_src_c108_3_02 0 conv_bpf_c108_3 0) vcvs gain=5.555702330196e-01
SCONVI_c108_3_02 (conv_i_src_c108_3_02 conv_i_c108_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_02 (conv_q_src_c108_3_02 0 conv_bpf_c108_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_3_02 (conv_q_src_c108_3_02 conv_q_c108_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_03 (conv_i_src_c108_3_03 0 conv_bpf_c108_3 0) vcvs gain=1.950903220161e-01
SCONVI_c108_3_03 (conv_i_src_c108_3_03 conv_i_c108_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_03 (conv_q_src_c108_3_03 0 conv_bpf_c108_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_3_03 (conv_q_src_c108_3_03 conv_q_c108_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_04 (conv_i_src_c108_3_04 0 conv_bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_3_04 (conv_i_src_c108_3_04 conv_i_c108_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_04 (conv_q_src_c108_3_04 0 conv_bpf_c108_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c108_3_04 (conv_q_src_c108_3_04 conv_q_c108_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_05 (conv_i_src_c108_3_05 0 conv_bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_3_05 (conv_i_src_c108_3_05 conv_i_c108_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_05 (conv_q_src_c108_3_05 0 conv_bpf_c108_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c108_3_05 (conv_q_src_c108_3_05 conv_q_c108_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_06 (conv_i_src_c108_3_06 0 conv_bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_3_06 (conv_i_src_c108_3_06 conv_i_c108_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_06 (conv_q_src_c108_3_06 0 conv_bpf_c108_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c108_3_06 (conv_q_src_c108_3_06 conv_q_c108_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_07 (conv_i_src_c108_3_07 0 conv_bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_3_07 (conv_i_src_c108_3_07 conv_i_c108_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_07 (conv_q_src_c108_3_07 0 conv_bpf_c108_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c108_3_07 (conv_q_src_c108_3_07 conv_q_c108_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_08 (conv_i_src_c108_3_08 0 conv_bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c108_3_08 (conv_i_src_c108_3_08 conv_i_c108_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_08 (conv_q_src_c108_3_08 0 conv_bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_3_08 (conv_q_src_c108_3_08 conv_q_c108_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_09 (conv_i_src_c108_3_09 0 conv_bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c108_3_09 (conv_i_src_c108_3_09 conv_i_c108_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_09 (conv_q_src_c108_3_09 0 conv_bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_3_09 (conv_q_src_c108_3_09 conv_q_c108_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_10 (conv_i_src_c108_3_10 0 conv_bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c108_3_10 (conv_i_src_c108_3_10 conv_i_c108_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_10 (conv_q_src_c108_3_10 0 conv_bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_3_10 (conv_q_src_c108_3_10 conv_q_c108_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_11 (conv_i_src_c108_3_11 0 conv_bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c108_3_11 (conv_i_src_c108_3_11 conv_i_c108_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_11 (conv_q_src_c108_3_11 0 conv_bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_3_11 (conv_q_src_c108_3_11 conv_q_c108_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_12 (conv_i_src_c108_3_12 0 conv_bpf_c108_3 0) vcvs gain=1.950903220161e-01
SCONVI_c108_3_12 (conv_i_src_c108_3_12 conv_i_c108_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_12 (conv_q_src_c108_3_12 0 conv_bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c108_3_12 (conv_q_src_c108_3_12 conv_q_c108_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_13 (conv_i_src_c108_3_13 0 conv_bpf_c108_3 0) vcvs gain=5.555702330196e-01
SCONVI_c108_3_13 (conv_i_src_c108_3_13 conv_i_c108_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_13 (conv_q_src_c108_3_13 0 conv_bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c108_3_13 (conv_q_src_c108_3_13 conv_q_c108_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_14 (conv_i_src_c108_3_14 0 conv_bpf_c108_3 0) vcvs gain=8.314696123025e-01
SCONVI_c108_3_14 (conv_i_src_c108_3_14 conv_i_c108_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_14 (conv_q_src_c108_3_14 0 conv_bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c108_3_14 (conv_q_src_c108_3_14 conv_q_c108_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c108_3_15 (conv_i_src_c108_3_15 0 conv_bpf_c108_3 0) vcvs gain=9.807852804032e-01
SCONVI_c108_3_15 (conv_i_src_c108_3_15 conv_i_c108_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c108_3_15 (conv_q_src_c108_3_15 0 conv_bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c108_3_15 (conv_q_src_c108_3_15 conv_q_c108_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c108_3 (conv_i_c108_3 0) resistor r=1G
RCONVQ_c108_3 (conv_q_c108_3 0) resistor r=1G
RCONVINTI_c108_3 (conv_i_c108_3 ConvIcar_c108_3) resistor r=1k
CCONVINTI_c108_3 (ConvIcar_c108_3 0) capacitor c=80p
RCONVINTQ_c108_3 (conv_q_c108_3 ConvQcar_c108_3) resistor r=1k
CCONVINTQ_c108_3 (ConvQcar_c108_3 0) capacitor c=80p
save conv_bpf_c108_3 ConvIcar_c108_3 ConvQcar_c108_3

// conventional mixed baseline bl109, carrier_0: 250000000 Hz
CCONVBPF_c109_0 (bl109 n_conv_cbpf_c109_0) capacitor c=4.052847345694e-13
LCONVBPF_c109_0 (n_conv_cbpf_c109_0 conv_bpf_c109_0) inductor l=1.000000000000e-06
RCONVBPF_c109_0 (conv_bpf_c109_0 0) resistor r=7.853981633974e+01
ECONVI_c109_0_00 (conv_i_src_c109_0_00 0 conv_bpf_c109_0 0) vcvs gain=9.807852804032e-01
SCONVI_c109_0_00 (conv_i_src_c109_0_00 conv_i_c109_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_00 (conv_q_src_c109_0_00 0 conv_bpf_c109_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_0_00 (conv_q_src_c109_0_00 conv_q_c109_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_01 (conv_i_src_c109_0_01 0 conv_bpf_c109_0 0) vcvs gain=8.314696123025e-01
SCONVI_c109_0_01 (conv_i_src_c109_0_01 conv_i_c109_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_01 (conv_q_src_c109_0_01 0 conv_bpf_c109_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_0_01 (conv_q_src_c109_0_01 conv_q_c109_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_02 (conv_i_src_c109_0_02 0 conv_bpf_c109_0 0) vcvs gain=5.555702330196e-01
SCONVI_c109_0_02 (conv_i_src_c109_0_02 conv_i_c109_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_02 (conv_q_src_c109_0_02 0 conv_bpf_c109_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_0_02 (conv_q_src_c109_0_02 conv_q_c109_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_03 (conv_i_src_c109_0_03 0 conv_bpf_c109_0 0) vcvs gain=1.950903220161e-01
SCONVI_c109_0_03 (conv_i_src_c109_0_03 conv_i_c109_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_03 (conv_q_src_c109_0_03 0 conv_bpf_c109_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_0_03 (conv_q_src_c109_0_03 conv_q_c109_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_04 (conv_i_src_c109_0_04 0 conv_bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_0_04 (conv_i_src_c109_0_04 conv_i_c109_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_04 (conv_q_src_c109_0_04 0 conv_bpf_c109_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_0_04 (conv_q_src_c109_0_04 conv_q_c109_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_05 (conv_i_src_c109_0_05 0 conv_bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_0_05 (conv_i_src_c109_0_05 conv_i_c109_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_05 (conv_q_src_c109_0_05 0 conv_bpf_c109_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_0_05 (conv_q_src_c109_0_05 conv_q_c109_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_06 (conv_i_src_c109_0_06 0 conv_bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_0_06 (conv_i_src_c109_0_06 conv_i_c109_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_06 (conv_q_src_c109_0_06 0 conv_bpf_c109_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_0_06 (conv_q_src_c109_0_06 conv_q_c109_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_07 (conv_i_src_c109_0_07 0 conv_bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_0_07 (conv_i_src_c109_0_07 conv_i_c109_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_07 (conv_q_src_c109_0_07 0 conv_bpf_c109_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_0_07 (conv_q_src_c109_0_07 conv_q_c109_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_08 (conv_i_src_c109_0_08 0 conv_bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_0_08 (conv_i_src_c109_0_08 conv_i_c109_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_08 (conv_q_src_c109_0_08 0 conv_bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_0_08 (conv_q_src_c109_0_08 conv_q_c109_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_09 (conv_i_src_c109_0_09 0 conv_bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_0_09 (conv_i_src_c109_0_09 conv_i_c109_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_09 (conv_q_src_c109_0_09 0 conv_bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_0_09 (conv_q_src_c109_0_09 conv_q_c109_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_10 (conv_i_src_c109_0_10 0 conv_bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_0_10 (conv_i_src_c109_0_10 conv_i_c109_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_10 (conv_q_src_c109_0_10 0 conv_bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_0_10 (conv_q_src_c109_0_10 conv_q_c109_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_11 (conv_i_src_c109_0_11 0 conv_bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_0_11 (conv_i_src_c109_0_11 conv_i_c109_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_11 (conv_q_src_c109_0_11 0 conv_bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_0_11 (conv_q_src_c109_0_11 conv_q_c109_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_12 (conv_i_src_c109_0_12 0 conv_bpf_c109_0 0) vcvs gain=1.950903220161e-01
SCONVI_c109_0_12 (conv_i_src_c109_0_12 conv_i_c109_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_12 (conv_q_src_c109_0_12 0 conv_bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_0_12 (conv_q_src_c109_0_12 conv_q_c109_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_13 (conv_i_src_c109_0_13 0 conv_bpf_c109_0 0) vcvs gain=5.555702330196e-01
SCONVI_c109_0_13 (conv_i_src_c109_0_13 conv_i_c109_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_13 (conv_q_src_c109_0_13 0 conv_bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_0_13 (conv_q_src_c109_0_13 conv_q_c109_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_14 (conv_i_src_c109_0_14 0 conv_bpf_c109_0 0) vcvs gain=8.314696123025e-01
SCONVI_c109_0_14 (conv_i_src_c109_0_14 conv_i_c109_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_14 (conv_q_src_c109_0_14 0 conv_bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_0_14 (conv_q_src_c109_0_14 conv_q_c109_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_0_15 (conv_i_src_c109_0_15 0 conv_bpf_c109_0 0) vcvs gain=9.807852804032e-01
SCONVI_c109_0_15 (conv_i_src_c109_0_15 conv_i_c109_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_0_15 (conv_q_src_c109_0_15 0 conv_bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_0_15 (conv_q_src_c109_0_15 conv_q_c109_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c109_0 (conv_i_c109_0 0) resistor r=1G
RCONVQ_c109_0 (conv_q_c109_0 0) resistor r=1G
RCONVINTI_c109_0 (conv_i_c109_0 ConvIcar_c109_0) resistor r=1k
CCONVINTI_c109_0 (ConvIcar_c109_0 0) capacitor c=80p
RCONVINTQ_c109_0 (conv_q_c109_0 ConvQcar_c109_0) resistor r=1k
CCONVINTQ_c109_0 (ConvQcar_c109_0 0) capacitor c=80p
save conv_bpf_c109_0 ConvIcar_c109_0 ConvQcar_c109_0

// conventional mixed baseline bl109, carrier_1: 500000000 Hz
CCONVBPF_c109_1 (bl109 n_conv_cbpf_c109_1) capacitor c=1.013211836423e-13
LCONVBPF_c109_1 (n_conv_cbpf_c109_1 conv_bpf_c109_1) inductor l=1.000000000000e-06
RCONVBPF_c109_1 (conv_bpf_c109_1 0) resistor r=1.570796326795e+02
ECONVI_c109_1_00 (conv_i_src_c109_1_00 0 conv_bpf_c109_1 0) vcvs gain=9.807852804032e-01
SCONVI_c109_1_00 (conv_i_src_c109_1_00 conv_i_c109_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_00 (conv_q_src_c109_1_00 0 conv_bpf_c109_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_1_00 (conv_q_src_c109_1_00 conv_q_c109_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_01 (conv_i_src_c109_1_01 0 conv_bpf_c109_1 0) vcvs gain=8.314696123025e-01
SCONVI_c109_1_01 (conv_i_src_c109_1_01 conv_i_c109_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_01 (conv_q_src_c109_1_01 0 conv_bpf_c109_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_1_01 (conv_q_src_c109_1_01 conv_q_c109_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_02 (conv_i_src_c109_1_02 0 conv_bpf_c109_1 0) vcvs gain=5.555702330196e-01
SCONVI_c109_1_02 (conv_i_src_c109_1_02 conv_i_c109_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_02 (conv_q_src_c109_1_02 0 conv_bpf_c109_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_1_02 (conv_q_src_c109_1_02 conv_q_c109_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_03 (conv_i_src_c109_1_03 0 conv_bpf_c109_1 0) vcvs gain=1.950903220161e-01
SCONVI_c109_1_03 (conv_i_src_c109_1_03 conv_i_c109_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_03 (conv_q_src_c109_1_03 0 conv_bpf_c109_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_1_03 (conv_q_src_c109_1_03 conv_q_c109_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_04 (conv_i_src_c109_1_04 0 conv_bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_1_04 (conv_i_src_c109_1_04 conv_i_c109_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_04 (conv_q_src_c109_1_04 0 conv_bpf_c109_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_1_04 (conv_q_src_c109_1_04 conv_q_c109_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_05 (conv_i_src_c109_1_05 0 conv_bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_1_05 (conv_i_src_c109_1_05 conv_i_c109_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_05 (conv_q_src_c109_1_05 0 conv_bpf_c109_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_1_05 (conv_q_src_c109_1_05 conv_q_c109_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_06 (conv_i_src_c109_1_06 0 conv_bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_1_06 (conv_i_src_c109_1_06 conv_i_c109_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_06 (conv_q_src_c109_1_06 0 conv_bpf_c109_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_1_06 (conv_q_src_c109_1_06 conv_q_c109_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_07 (conv_i_src_c109_1_07 0 conv_bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_1_07 (conv_i_src_c109_1_07 conv_i_c109_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_07 (conv_q_src_c109_1_07 0 conv_bpf_c109_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_1_07 (conv_q_src_c109_1_07 conv_q_c109_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_08 (conv_i_src_c109_1_08 0 conv_bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_1_08 (conv_i_src_c109_1_08 conv_i_c109_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_08 (conv_q_src_c109_1_08 0 conv_bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_1_08 (conv_q_src_c109_1_08 conv_q_c109_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_09 (conv_i_src_c109_1_09 0 conv_bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_1_09 (conv_i_src_c109_1_09 conv_i_c109_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_09 (conv_q_src_c109_1_09 0 conv_bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_1_09 (conv_q_src_c109_1_09 conv_q_c109_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_10 (conv_i_src_c109_1_10 0 conv_bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_1_10 (conv_i_src_c109_1_10 conv_i_c109_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_10 (conv_q_src_c109_1_10 0 conv_bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_1_10 (conv_q_src_c109_1_10 conv_q_c109_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_11 (conv_i_src_c109_1_11 0 conv_bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_1_11 (conv_i_src_c109_1_11 conv_i_c109_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_11 (conv_q_src_c109_1_11 0 conv_bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_1_11 (conv_q_src_c109_1_11 conv_q_c109_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_12 (conv_i_src_c109_1_12 0 conv_bpf_c109_1 0) vcvs gain=1.950903220161e-01
SCONVI_c109_1_12 (conv_i_src_c109_1_12 conv_i_c109_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_12 (conv_q_src_c109_1_12 0 conv_bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_1_12 (conv_q_src_c109_1_12 conv_q_c109_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_13 (conv_i_src_c109_1_13 0 conv_bpf_c109_1 0) vcvs gain=5.555702330196e-01
SCONVI_c109_1_13 (conv_i_src_c109_1_13 conv_i_c109_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_13 (conv_q_src_c109_1_13 0 conv_bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_1_13 (conv_q_src_c109_1_13 conv_q_c109_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_14 (conv_i_src_c109_1_14 0 conv_bpf_c109_1 0) vcvs gain=8.314696123025e-01
SCONVI_c109_1_14 (conv_i_src_c109_1_14 conv_i_c109_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_14 (conv_q_src_c109_1_14 0 conv_bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_1_14 (conv_q_src_c109_1_14 conv_q_c109_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_1_15 (conv_i_src_c109_1_15 0 conv_bpf_c109_1 0) vcvs gain=9.807852804032e-01
SCONVI_c109_1_15 (conv_i_src_c109_1_15 conv_i_c109_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_1_15 (conv_q_src_c109_1_15 0 conv_bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_1_15 (conv_q_src_c109_1_15 conv_q_c109_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c109_1 (conv_i_c109_1 0) resistor r=1G
RCONVQ_c109_1 (conv_q_c109_1 0) resistor r=1G
RCONVINTI_c109_1 (conv_i_c109_1 ConvIcar_c109_1) resistor r=1k
CCONVINTI_c109_1 (ConvIcar_c109_1 0) capacitor c=80p
RCONVINTQ_c109_1 (conv_q_c109_1 ConvQcar_c109_1) resistor r=1k
CCONVINTQ_c109_1 (ConvQcar_c109_1 0) capacitor c=80p
save conv_bpf_c109_1 ConvIcar_c109_1 ConvQcar_c109_1

// conventional mixed baseline bl109, carrier_2: 750000000 Hz
CCONVBPF_c109_2 (bl109 n_conv_cbpf_c109_2) capacitor c=4.503163717437e-14
LCONVBPF_c109_2 (n_conv_cbpf_c109_2 conv_bpf_c109_2) inductor l=1.000000000000e-06
RCONVBPF_c109_2 (conv_bpf_c109_2 0) resistor r=2.356194490192e+02
ECONVI_c109_2_00 (conv_i_src_c109_2_00 0 conv_bpf_c109_2 0) vcvs gain=9.807852804032e-01
SCONVI_c109_2_00 (conv_i_src_c109_2_00 conv_i_c109_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_00 (conv_q_src_c109_2_00 0 conv_bpf_c109_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_2_00 (conv_q_src_c109_2_00 conv_q_c109_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_01 (conv_i_src_c109_2_01 0 conv_bpf_c109_2 0) vcvs gain=8.314696123025e-01
SCONVI_c109_2_01 (conv_i_src_c109_2_01 conv_i_c109_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_01 (conv_q_src_c109_2_01 0 conv_bpf_c109_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_2_01 (conv_q_src_c109_2_01 conv_q_c109_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_02 (conv_i_src_c109_2_02 0 conv_bpf_c109_2 0) vcvs gain=5.555702330196e-01
SCONVI_c109_2_02 (conv_i_src_c109_2_02 conv_i_c109_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_02 (conv_q_src_c109_2_02 0 conv_bpf_c109_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_2_02 (conv_q_src_c109_2_02 conv_q_c109_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_03 (conv_i_src_c109_2_03 0 conv_bpf_c109_2 0) vcvs gain=1.950903220161e-01
SCONVI_c109_2_03 (conv_i_src_c109_2_03 conv_i_c109_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_03 (conv_q_src_c109_2_03 0 conv_bpf_c109_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_2_03 (conv_q_src_c109_2_03 conv_q_c109_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_04 (conv_i_src_c109_2_04 0 conv_bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_2_04 (conv_i_src_c109_2_04 conv_i_c109_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_04 (conv_q_src_c109_2_04 0 conv_bpf_c109_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_2_04 (conv_q_src_c109_2_04 conv_q_c109_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_05 (conv_i_src_c109_2_05 0 conv_bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_2_05 (conv_i_src_c109_2_05 conv_i_c109_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_05 (conv_q_src_c109_2_05 0 conv_bpf_c109_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_2_05 (conv_q_src_c109_2_05 conv_q_c109_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_06 (conv_i_src_c109_2_06 0 conv_bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_2_06 (conv_i_src_c109_2_06 conv_i_c109_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_06 (conv_q_src_c109_2_06 0 conv_bpf_c109_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_2_06 (conv_q_src_c109_2_06 conv_q_c109_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_07 (conv_i_src_c109_2_07 0 conv_bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_2_07 (conv_i_src_c109_2_07 conv_i_c109_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_07 (conv_q_src_c109_2_07 0 conv_bpf_c109_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_2_07 (conv_q_src_c109_2_07 conv_q_c109_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_08 (conv_i_src_c109_2_08 0 conv_bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_2_08 (conv_i_src_c109_2_08 conv_i_c109_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_08 (conv_q_src_c109_2_08 0 conv_bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_2_08 (conv_q_src_c109_2_08 conv_q_c109_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_09 (conv_i_src_c109_2_09 0 conv_bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_2_09 (conv_i_src_c109_2_09 conv_i_c109_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_09 (conv_q_src_c109_2_09 0 conv_bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_2_09 (conv_q_src_c109_2_09 conv_q_c109_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_10 (conv_i_src_c109_2_10 0 conv_bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_2_10 (conv_i_src_c109_2_10 conv_i_c109_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_10 (conv_q_src_c109_2_10 0 conv_bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_2_10 (conv_q_src_c109_2_10 conv_q_c109_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_11 (conv_i_src_c109_2_11 0 conv_bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_2_11 (conv_i_src_c109_2_11 conv_i_c109_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_11 (conv_q_src_c109_2_11 0 conv_bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_2_11 (conv_q_src_c109_2_11 conv_q_c109_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_12 (conv_i_src_c109_2_12 0 conv_bpf_c109_2 0) vcvs gain=1.950903220161e-01
SCONVI_c109_2_12 (conv_i_src_c109_2_12 conv_i_c109_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_12 (conv_q_src_c109_2_12 0 conv_bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_2_12 (conv_q_src_c109_2_12 conv_q_c109_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_13 (conv_i_src_c109_2_13 0 conv_bpf_c109_2 0) vcvs gain=5.555702330196e-01
SCONVI_c109_2_13 (conv_i_src_c109_2_13 conv_i_c109_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_13 (conv_q_src_c109_2_13 0 conv_bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_2_13 (conv_q_src_c109_2_13 conv_q_c109_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_14 (conv_i_src_c109_2_14 0 conv_bpf_c109_2 0) vcvs gain=8.314696123025e-01
SCONVI_c109_2_14 (conv_i_src_c109_2_14 conv_i_c109_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_14 (conv_q_src_c109_2_14 0 conv_bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_2_14 (conv_q_src_c109_2_14 conv_q_c109_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_2_15 (conv_i_src_c109_2_15 0 conv_bpf_c109_2 0) vcvs gain=9.807852804032e-01
SCONVI_c109_2_15 (conv_i_src_c109_2_15 conv_i_c109_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_2_15 (conv_q_src_c109_2_15 0 conv_bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_2_15 (conv_q_src_c109_2_15 conv_q_c109_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c109_2 (conv_i_c109_2 0) resistor r=1G
RCONVQ_c109_2 (conv_q_c109_2 0) resistor r=1G
RCONVINTI_c109_2 (conv_i_c109_2 ConvIcar_c109_2) resistor r=1k
CCONVINTI_c109_2 (ConvIcar_c109_2 0) capacitor c=80p
RCONVINTQ_c109_2 (conv_q_c109_2 ConvQcar_c109_2) resistor r=1k
CCONVINTQ_c109_2 (ConvQcar_c109_2 0) capacitor c=80p
save conv_bpf_c109_2 ConvIcar_c109_2 ConvQcar_c109_2

// conventional mixed baseline bl109, carrier_3: 1000000000 Hz
CCONVBPF_c109_3 (bl109 n_conv_cbpf_c109_3) capacitor c=2.533029591058e-14
LCONVBPF_c109_3 (n_conv_cbpf_c109_3 conv_bpf_c109_3) inductor l=1.000000000000e-06
RCONVBPF_c109_3 (conv_bpf_c109_3 0) resistor r=3.141592653590e+02
ECONVI_c109_3_00 (conv_i_src_c109_3_00 0 conv_bpf_c109_3 0) vcvs gain=9.807852804032e-01
SCONVI_c109_3_00 (conv_i_src_c109_3_00 conv_i_c109_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_00 (conv_q_src_c109_3_00 0 conv_bpf_c109_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_3_00 (conv_q_src_c109_3_00 conv_q_c109_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_01 (conv_i_src_c109_3_01 0 conv_bpf_c109_3 0) vcvs gain=8.314696123025e-01
SCONVI_c109_3_01 (conv_i_src_c109_3_01 conv_i_c109_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_01 (conv_q_src_c109_3_01 0 conv_bpf_c109_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_3_01 (conv_q_src_c109_3_01 conv_q_c109_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_02 (conv_i_src_c109_3_02 0 conv_bpf_c109_3 0) vcvs gain=5.555702330196e-01
SCONVI_c109_3_02 (conv_i_src_c109_3_02 conv_i_c109_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_02 (conv_q_src_c109_3_02 0 conv_bpf_c109_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_3_02 (conv_q_src_c109_3_02 conv_q_c109_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_03 (conv_i_src_c109_3_03 0 conv_bpf_c109_3 0) vcvs gain=1.950903220161e-01
SCONVI_c109_3_03 (conv_i_src_c109_3_03 conv_i_c109_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_03 (conv_q_src_c109_3_03 0 conv_bpf_c109_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_3_03 (conv_q_src_c109_3_03 conv_q_c109_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_04 (conv_i_src_c109_3_04 0 conv_bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_3_04 (conv_i_src_c109_3_04 conv_i_c109_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_04 (conv_q_src_c109_3_04 0 conv_bpf_c109_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c109_3_04 (conv_q_src_c109_3_04 conv_q_c109_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_05 (conv_i_src_c109_3_05 0 conv_bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_3_05 (conv_i_src_c109_3_05 conv_i_c109_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_05 (conv_q_src_c109_3_05 0 conv_bpf_c109_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c109_3_05 (conv_q_src_c109_3_05 conv_q_c109_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_06 (conv_i_src_c109_3_06 0 conv_bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_3_06 (conv_i_src_c109_3_06 conv_i_c109_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_06 (conv_q_src_c109_3_06 0 conv_bpf_c109_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c109_3_06 (conv_q_src_c109_3_06 conv_q_c109_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_07 (conv_i_src_c109_3_07 0 conv_bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_3_07 (conv_i_src_c109_3_07 conv_i_c109_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_07 (conv_q_src_c109_3_07 0 conv_bpf_c109_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c109_3_07 (conv_q_src_c109_3_07 conv_q_c109_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_08 (conv_i_src_c109_3_08 0 conv_bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c109_3_08 (conv_i_src_c109_3_08 conv_i_c109_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_08 (conv_q_src_c109_3_08 0 conv_bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_3_08 (conv_q_src_c109_3_08 conv_q_c109_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_09 (conv_i_src_c109_3_09 0 conv_bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c109_3_09 (conv_i_src_c109_3_09 conv_i_c109_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_09 (conv_q_src_c109_3_09 0 conv_bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_3_09 (conv_q_src_c109_3_09 conv_q_c109_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_10 (conv_i_src_c109_3_10 0 conv_bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c109_3_10 (conv_i_src_c109_3_10 conv_i_c109_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_10 (conv_q_src_c109_3_10 0 conv_bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_3_10 (conv_q_src_c109_3_10 conv_q_c109_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_11 (conv_i_src_c109_3_11 0 conv_bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c109_3_11 (conv_i_src_c109_3_11 conv_i_c109_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_11 (conv_q_src_c109_3_11 0 conv_bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_3_11 (conv_q_src_c109_3_11 conv_q_c109_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_12 (conv_i_src_c109_3_12 0 conv_bpf_c109_3 0) vcvs gain=1.950903220161e-01
SCONVI_c109_3_12 (conv_i_src_c109_3_12 conv_i_c109_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_12 (conv_q_src_c109_3_12 0 conv_bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c109_3_12 (conv_q_src_c109_3_12 conv_q_c109_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_13 (conv_i_src_c109_3_13 0 conv_bpf_c109_3 0) vcvs gain=5.555702330196e-01
SCONVI_c109_3_13 (conv_i_src_c109_3_13 conv_i_c109_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_13 (conv_q_src_c109_3_13 0 conv_bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c109_3_13 (conv_q_src_c109_3_13 conv_q_c109_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_14 (conv_i_src_c109_3_14 0 conv_bpf_c109_3 0) vcvs gain=8.314696123025e-01
SCONVI_c109_3_14 (conv_i_src_c109_3_14 conv_i_c109_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_14 (conv_q_src_c109_3_14 0 conv_bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c109_3_14 (conv_q_src_c109_3_14 conv_q_c109_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c109_3_15 (conv_i_src_c109_3_15 0 conv_bpf_c109_3 0) vcvs gain=9.807852804032e-01
SCONVI_c109_3_15 (conv_i_src_c109_3_15 conv_i_c109_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c109_3_15 (conv_q_src_c109_3_15 0 conv_bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c109_3_15 (conv_q_src_c109_3_15 conv_q_c109_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c109_3 (conv_i_c109_3 0) resistor r=1G
RCONVQ_c109_3 (conv_q_c109_3 0) resistor r=1G
RCONVINTI_c109_3 (conv_i_c109_3 ConvIcar_c109_3) resistor r=1k
CCONVINTI_c109_3 (ConvIcar_c109_3 0) capacitor c=80p
RCONVINTQ_c109_3 (conv_q_c109_3 ConvQcar_c109_3) resistor r=1k
CCONVINTQ_c109_3 (ConvQcar_c109_3 0) capacitor c=80p
save conv_bpf_c109_3 ConvIcar_c109_3 ConvQcar_c109_3

// conventional mixed baseline bl110, carrier_0: 250000000 Hz
CCONVBPF_c110_0 (bl110 n_conv_cbpf_c110_0) capacitor c=4.052847345694e-13
LCONVBPF_c110_0 (n_conv_cbpf_c110_0 conv_bpf_c110_0) inductor l=1.000000000000e-06
RCONVBPF_c110_0 (conv_bpf_c110_0 0) resistor r=7.853981633974e+01
ECONVI_c110_0_00 (conv_i_src_c110_0_00 0 conv_bpf_c110_0 0) vcvs gain=9.807852804032e-01
SCONVI_c110_0_00 (conv_i_src_c110_0_00 conv_i_c110_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_00 (conv_q_src_c110_0_00 0 conv_bpf_c110_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_0_00 (conv_q_src_c110_0_00 conv_q_c110_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_01 (conv_i_src_c110_0_01 0 conv_bpf_c110_0 0) vcvs gain=8.314696123025e-01
SCONVI_c110_0_01 (conv_i_src_c110_0_01 conv_i_c110_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_01 (conv_q_src_c110_0_01 0 conv_bpf_c110_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_0_01 (conv_q_src_c110_0_01 conv_q_c110_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_02 (conv_i_src_c110_0_02 0 conv_bpf_c110_0 0) vcvs gain=5.555702330196e-01
SCONVI_c110_0_02 (conv_i_src_c110_0_02 conv_i_c110_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_02 (conv_q_src_c110_0_02 0 conv_bpf_c110_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_0_02 (conv_q_src_c110_0_02 conv_q_c110_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_03 (conv_i_src_c110_0_03 0 conv_bpf_c110_0 0) vcvs gain=1.950903220161e-01
SCONVI_c110_0_03 (conv_i_src_c110_0_03 conv_i_c110_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_03 (conv_q_src_c110_0_03 0 conv_bpf_c110_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_0_03 (conv_q_src_c110_0_03 conv_q_c110_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_04 (conv_i_src_c110_0_04 0 conv_bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_0_04 (conv_i_src_c110_0_04 conv_i_c110_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_04 (conv_q_src_c110_0_04 0 conv_bpf_c110_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_0_04 (conv_q_src_c110_0_04 conv_q_c110_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_05 (conv_i_src_c110_0_05 0 conv_bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_0_05 (conv_i_src_c110_0_05 conv_i_c110_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_05 (conv_q_src_c110_0_05 0 conv_bpf_c110_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_0_05 (conv_q_src_c110_0_05 conv_q_c110_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_06 (conv_i_src_c110_0_06 0 conv_bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_0_06 (conv_i_src_c110_0_06 conv_i_c110_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_06 (conv_q_src_c110_0_06 0 conv_bpf_c110_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_0_06 (conv_q_src_c110_0_06 conv_q_c110_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_07 (conv_i_src_c110_0_07 0 conv_bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_0_07 (conv_i_src_c110_0_07 conv_i_c110_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_07 (conv_q_src_c110_0_07 0 conv_bpf_c110_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_0_07 (conv_q_src_c110_0_07 conv_q_c110_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_08 (conv_i_src_c110_0_08 0 conv_bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_0_08 (conv_i_src_c110_0_08 conv_i_c110_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_08 (conv_q_src_c110_0_08 0 conv_bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_0_08 (conv_q_src_c110_0_08 conv_q_c110_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_09 (conv_i_src_c110_0_09 0 conv_bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_0_09 (conv_i_src_c110_0_09 conv_i_c110_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_09 (conv_q_src_c110_0_09 0 conv_bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_0_09 (conv_q_src_c110_0_09 conv_q_c110_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_10 (conv_i_src_c110_0_10 0 conv_bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_0_10 (conv_i_src_c110_0_10 conv_i_c110_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_10 (conv_q_src_c110_0_10 0 conv_bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_0_10 (conv_q_src_c110_0_10 conv_q_c110_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_11 (conv_i_src_c110_0_11 0 conv_bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_0_11 (conv_i_src_c110_0_11 conv_i_c110_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_11 (conv_q_src_c110_0_11 0 conv_bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_0_11 (conv_q_src_c110_0_11 conv_q_c110_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_12 (conv_i_src_c110_0_12 0 conv_bpf_c110_0 0) vcvs gain=1.950903220161e-01
SCONVI_c110_0_12 (conv_i_src_c110_0_12 conv_i_c110_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_12 (conv_q_src_c110_0_12 0 conv_bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_0_12 (conv_q_src_c110_0_12 conv_q_c110_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_13 (conv_i_src_c110_0_13 0 conv_bpf_c110_0 0) vcvs gain=5.555702330196e-01
SCONVI_c110_0_13 (conv_i_src_c110_0_13 conv_i_c110_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_13 (conv_q_src_c110_0_13 0 conv_bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_0_13 (conv_q_src_c110_0_13 conv_q_c110_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_14 (conv_i_src_c110_0_14 0 conv_bpf_c110_0 0) vcvs gain=8.314696123025e-01
SCONVI_c110_0_14 (conv_i_src_c110_0_14 conv_i_c110_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_14 (conv_q_src_c110_0_14 0 conv_bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_0_14 (conv_q_src_c110_0_14 conv_q_c110_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_0_15 (conv_i_src_c110_0_15 0 conv_bpf_c110_0 0) vcvs gain=9.807852804032e-01
SCONVI_c110_0_15 (conv_i_src_c110_0_15 conv_i_c110_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_0_15 (conv_q_src_c110_0_15 0 conv_bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_0_15 (conv_q_src_c110_0_15 conv_q_c110_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c110_0 (conv_i_c110_0 0) resistor r=1G
RCONVQ_c110_0 (conv_q_c110_0 0) resistor r=1G
RCONVINTI_c110_0 (conv_i_c110_0 ConvIcar_c110_0) resistor r=1k
CCONVINTI_c110_0 (ConvIcar_c110_0 0) capacitor c=80p
RCONVINTQ_c110_0 (conv_q_c110_0 ConvQcar_c110_0) resistor r=1k
CCONVINTQ_c110_0 (ConvQcar_c110_0 0) capacitor c=80p
save conv_bpf_c110_0 ConvIcar_c110_0 ConvQcar_c110_0

// conventional mixed baseline bl110, carrier_1: 500000000 Hz
CCONVBPF_c110_1 (bl110 n_conv_cbpf_c110_1) capacitor c=1.013211836423e-13
LCONVBPF_c110_1 (n_conv_cbpf_c110_1 conv_bpf_c110_1) inductor l=1.000000000000e-06
RCONVBPF_c110_1 (conv_bpf_c110_1 0) resistor r=1.570796326795e+02
ECONVI_c110_1_00 (conv_i_src_c110_1_00 0 conv_bpf_c110_1 0) vcvs gain=9.807852804032e-01
SCONVI_c110_1_00 (conv_i_src_c110_1_00 conv_i_c110_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_00 (conv_q_src_c110_1_00 0 conv_bpf_c110_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_1_00 (conv_q_src_c110_1_00 conv_q_c110_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_01 (conv_i_src_c110_1_01 0 conv_bpf_c110_1 0) vcvs gain=8.314696123025e-01
SCONVI_c110_1_01 (conv_i_src_c110_1_01 conv_i_c110_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_01 (conv_q_src_c110_1_01 0 conv_bpf_c110_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_1_01 (conv_q_src_c110_1_01 conv_q_c110_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_02 (conv_i_src_c110_1_02 0 conv_bpf_c110_1 0) vcvs gain=5.555702330196e-01
SCONVI_c110_1_02 (conv_i_src_c110_1_02 conv_i_c110_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_02 (conv_q_src_c110_1_02 0 conv_bpf_c110_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_1_02 (conv_q_src_c110_1_02 conv_q_c110_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_03 (conv_i_src_c110_1_03 0 conv_bpf_c110_1 0) vcvs gain=1.950903220161e-01
SCONVI_c110_1_03 (conv_i_src_c110_1_03 conv_i_c110_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_03 (conv_q_src_c110_1_03 0 conv_bpf_c110_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_1_03 (conv_q_src_c110_1_03 conv_q_c110_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_04 (conv_i_src_c110_1_04 0 conv_bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_1_04 (conv_i_src_c110_1_04 conv_i_c110_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_04 (conv_q_src_c110_1_04 0 conv_bpf_c110_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_1_04 (conv_q_src_c110_1_04 conv_q_c110_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_05 (conv_i_src_c110_1_05 0 conv_bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_1_05 (conv_i_src_c110_1_05 conv_i_c110_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_05 (conv_q_src_c110_1_05 0 conv_bpf_c110_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_1_05 (conv_q_src_c110_1_05 conv_q_c110_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_06 (conv_i_src_c110_1_06 0 conv_bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_1_06 (conv_i_src_c110_1_06 conv_i_c110_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_06 (conv_q_src_c110_1_06 0 conv_bpf_c110_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_1_06 (conv_q_src_c110_1_06 conv_q_c110_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_07 (conv_i_src_c110_1_07 0 conv_bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_1_07 (conv_i_src_c110_1_07 conv_i_c110_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_07 (conv_q_src_c110_1_07 0 conv_bpf_c110_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_1_07 (conv_q_src_c110_1_07 conv_q_c110_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_08 (conv_i_src_c110_1_08 0 conv_bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_1_08 (conv_i_src_c110_1_08 conv_i_c110_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_08 (conv_q_src_c110_1_08 0 conv_bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_1_08 (conv_q_src_c110_1_08 conv_q_c110_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_09 (conv_i_src_c110_1_09 0 conv_bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_1_09 (conv_i_src_c110_1_09 conv_i_c110_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_09 (conv_q_src_c110_1_09 0 conv_bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_1_09 (conv_q_src_c110_1_09 conv_q_c110_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_10 (conv_i_src_c110_1_10 0 conv_bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_1_10 (conv_i_src_c110_1_10 conv_i_c110_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_10 (conv_q_src_c110_1_10 0 conv_bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_1_10 (conv_q_src_c110_1_10 conv_q_c110_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_11 (conv_i_src_c110_1_11 0 conv_bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_1_11 (conv_i_src_c110_1_11 conv_i_c110_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_11 (conv_q_src_c110_1_11 0 conv_bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_1_11 (conv_q_src_c110_1_11 conv_q_c110_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_12 (conv_i_src_c110_1_12 0 conv_bpf_c110_1 0) vcvs gain=1.950903220161e-01
SCONVI_c110_1_12 (conv_i_src_c110_1_12 conv_i_c110_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_12 (conv_q_src_c110_1_12 0 conv_bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_1_12 (conv_q_src_c110_1_12 conv_q_c110_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_13 (conv_i_src_c110_1_13 0 conv_bpf_c110_1 0) vcvs gain=5.555702330196e-01
SCONVI_c110_1_13 (conv_i_src_c110_1_13 conv_i_c110_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_13 (conv_q_src_c110_1_13 0 conv_bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_1_13 (conv_q_src_c110_1_13 conv_q_c110_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_14 (conv_i_src_c110_1_14 0 conv_bpf_c110_1 0) vcvs gain=8.314696123025e-01
SCONVI_c110_1_14 (conv_i_src_c110_1_14 conv_i_c110_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_14 (conv_q_src_c110_1_14 0 conv_bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_1_14 (conv_q_src_c110_1_14 conv_q_c110_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_1_15 (conv_i_src_c110_1_15 0 conv_bpf_c110_1 0) vcvs gain=9.807852804032e-01
SCONVI_c110_1_15 (conv_i_src_c110_1_15 conv_i_c110_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_1_15 (conv_q_src_c110_1_15 0 conv_bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_1_15 (conv_q_src_c110_1_15 conv_q_c110_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c110_1 (conv_i_c110_1 0) resistor r=1G
RCONVQ_c110_1 (conv_q_c110_1 0) resistor r=1G
RCONVINTI_c110_1 (conv_i_c110_1 ConvIcar_c110_1) resistor r=1k
CCONVINTI_c110_1 (ConvIcar_c110_1 0) capacitor c=80p
RCONVINTQ_c110_1 (conv_q_c110_1 ConvQcar_c110_1) resistor r=1k
CCONVINTQ_c110_1 (ConvQcar_c110_1 0) capacitor c=80p
save conv_bpf_c110_1 ConvIcar_c110_1 ConvQcar_c110_1

// conventional mixed baseline bl110, carrier_2: 750000000 Hz
CCONVBPF_c110_2 (bl110 n_conv_cbpf_c110_2) capacitor c=4.503163717437e-14
LCONVBPF_c110_2 (n_conv_cbpf_c110_2 conv_bpf_c110_2) inductor l=1.000000000000e-06
RCONVBPF_c110_2 (conv_bpf_c110_2 0) resistor r=2.356194490192e+02
ECONVI_c110_2_00 (conv_i_src_c110_2_00 0 conv_bpf_c110_2 0) vcvs gain=9.807852804032e-01
SCONVI_c110_2_00 (conv_i_src_c110_2_00 conv_i_c110_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_00 (conv_q_src_c110_2_00 0 conv_bpf_c110_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_2_00 (conv_q_src_c110_2_00 conv_q_c110_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_01 (conv_i_src_c110_2_01 0 conv_bpf_c110_2 0) vcvs gain=8.314696123025e-01
SCONVI_c110_2_01 (conv_i_src_c110_2_01 conv_i_c110_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_01 (conv_q_src_c110_2_01 0 conv_bpf_c110_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_2_01 (conv_q_src_c110_2_01 conv_q_c110_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_02 (conv_i_src_c110_2_02 0 conv_bpf_c110_2 0) vcvs gain=5.555702330196e-01
SCONVI_c110_2_02 (conv_i_src_c110_2_02 conv_i_c110_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_02 (conv_q_src_c110_2_02 0 conv_bpf_c110_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_2_02 (conv_q_src_c110_2_02 conv_q_c110_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_03 (conv_i_src_c110_2_03 0 conv_bpf_c110_2 0) vcvs gain=1.950903220161e-01
SCONVI_c110_2_03 (conv_i_src_c110_2_03 conv_i_c110_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_03 (conv_q_src_c110_2_03 0 conv_bpf_c110_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_2_03 (conv_q_src_c110_2_03 conv_q_c110_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_04 (conv_i_src_c110_2_04 0 conv_bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_2_04 (conv_i_src_c110_2_04 conv_i_c110_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_04 (conv_q_src_c110_2_04 0 conv_bpf_c110_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_2_04 (conv_q_src_c110_2_04 conv_q_c110_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_05 (conv_i_src_c110_2_05 0 conv_bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_2_05 (conv_i_src_c110_2_05 conv_i_c110_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_05 (conv_q_src_c110_2_05 0 conv_bpf_c110_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_2_05 (conv_q_src_c110_2_05 conv_q_c110_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_06 (conv_i_src_c110_2_06 0 conv_bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_2_06 (conv_i_src_c110_2_06 conv_i_c110_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_06 (conv_q_src_c110_2_06 0 conv_bpf_c110_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_2_06 (conv_q_src_c110_2_06 conv_q_c110_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_07 (conv_i_src_c110_2_07 0 conv_bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_2_07 (conv_i_src_c110_2_07 conv_i_c110_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_07 (conv_q_src_c110_2_07 0 conv_bpf_c110_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_2_07 (conv_q_src_c110_2_07 conv_q_c110_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_08 (conv_i_src_c110_2_08 0 conv_bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_2_08 (conv_i_src_c110_2_08 conv_i_c110_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_08 (conv_q_src_c110_2_08 0 conv_bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_2_08 (conv_q_src_c110_2_08 conv_q_c110_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_09 (conv_i_src_c110_2_09 0 conv_bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_2_09 (conv_i_src_c110_2_09 conv_i_c110_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_09 (conv_q_src_c110_2_09 0 conv_bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_2_09 (conv_q_src_c110_2_09 conv_q_c110_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_10 (conv_i_src_c110_2_10 0 conv_bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_2_10 (conv_i_src_c110_2_10 conv_i_c110_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_10 (conv_q_src_c110_2_10 0 conv_bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_2_10 (conv_q_src_c110_2_10 conv_q_c110_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_11 (conv_i_src_c110_2_11 0 conv_bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_2_11 (conv_i_src_c110_2_11 conv_i_c110_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_11 (conv_q_src_c110_2_11 0 conv_bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_2_11 (conv_q_src_c110_2_11 conv_q_c110_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_12 (conv_i_src_c110_2_12 0 conv_bpf_c110_2 0) vcvs gain=1.950903220161e-01
SCONVI_c110_2_12 (conv_i_src_c110_2_12 conv_i_c110_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_12 (conv_q_src_c110_2_12 0 conv_bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_2_12 (conv_q_src_c110_2_12 conv_q_c110_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_13 (conv_i_src_c110_2_13 0 conv_bpf_c110_2 0) vcvs gain=5.555702330196e-01
SCONVI_c110_2_13 (conv_i_src_c110_2_13 conv_i_c110_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_13 (conv_q_src_c110_2_13 0 conv_bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_2_13 (conv_q_src_c110_2_13 conv_q_c110_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_14 (conv_i_src_c110_2_14 0 conv_bpf_c110_2 0) vcvs gain=8.314696123025e-01
SCONVI_c110_2_14 (conv_i_src_c110_2_14 conv_i_c110_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_14 (conv_q_src_c110_2_14 0 conv_bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_2_14 (conv_q_src_c110_2_14 conv_q_c110_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_2_15 (conv_i_src_c110_2_15 0 conv_bpf_c110_2 0) vcvs gain=9.807852804032e-01
SCONVI_c110_2_15 (conv_i_src_c110_2_15 conv_i_c110_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_2_15 (conv_q_src_c110_2_15 0 conv_bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_2_15 (conv_q_src_c110_2_15 conv_q_c110_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c110_2 (conv_i_c110_2 0) resistor r=1G
RCONVQ_c110_2 (conv_q_c110_2 0) resistor r=1G
RCONVINTI_c110_2 (conv_i_c110_2 ConvIcar_c110_2) resistor r=1k
CCONVINTI_c110_2 (ConvIcar_c110_2 0) capacitor c=80p
RCONVINTQ_c110_2 (conv_q_c110_2 ConvQcar_c110_2) resistor r=1k
CCONVINTQ_c110_2 (ConvQcar_c110_2 0) capacitor c=80p
save conv_bpf_c110_2 ConvIcar_c110_2 ConvQcar_c110_2

// conventional mixed baseline bl110, carrier_3: 1000000000 Hz
CCONVBPF_c110_3 (bl110 n_conv_cbpf_c110_3) capacitor c=2.533029591058e-14
LCONVBPF_c110_3 (n_conv_cbpf_c110_3 conv_bpf_c110_3) inductor l=1.000000000000e-06
RCONVBPF_c110_3 (conv_bpf_c110_3 0) resistor r=3.141592653590e+02
ECONVI_c110_3_00 (conv_i_src_c110_3_00 0 conv_bpf_c110_3 0) vcvs gain=9.807852804032e-01
SCONVI_c110_3_00 (conv_i_src_c110_3_00 conv_i_c110_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_00 (conv_q_src_c110_3_00 0 conv_bpf_c110_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_3_00 (conv_q_src_c110_3_00 conv_q_c110_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_01 (conv_i_src_c110_3_01 0 conv_bpf_c110_3 0) vcvs gain=8.314696123025e-01
SCONVI_c110_3_01 (conv_i_src_c110_3_01 conv_i_c110_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_01 (conv_q_src_c110_3_01 0 conv_bpf_c110_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_3_01 (conv_q_src_c110_3_01 conv_q_c110_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_02 (conv_i_src_c110_3_02 0 conv_bpf_c110_3 0) vcvs gain=5.555702330196e-01
SCONVI_c110_3_02 (conv_i_src_c110_3_02 conv_i_c110_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_02 (conv_q_src_c110_3_02 0 conv_bpf_c110_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_3_02 (conv_q_src_c110_3_02 conv_q_c110_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_03 (conv_i_src_c110_3_03 0 conv_bpf_c110_3 0) vcvs gain=1.950903220161e-01
SCONVI_c110_3_03 (conv_i_src_c110_3_03 conv_i_c110_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_03 (conv_q_src_c110_3_03 0 conv_bpf_c110_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_3_03 (conv_q_src_c110_3_03 conv_q_c110_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_04 (conv_i_src_c110_3_04 0 conv_bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_3_04 (conv_i_src_c110_3_04 conv_i_c110_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_04 (conv_q_src_c110_3_04 0 conv_bpf_c110_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c110_3_04 (conv_q_src_c110_3_04 conv_q_c110_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_05 (conv_i_src_c110_3_05 0 conv_bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_3_05 (conv_i_src_c110_3_05 conv_i_c110_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_05 (conv_q_src_c110_3_05 0 conv_bpf_c110_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c110_3_05 (conv_q_src_c110_3_05 conv_q_c110_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_06 (conv_i_src_c110_3_06 0 conv_bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_3_06 (conv_i_src_c110_3_06 conv_i_c110_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_06 (conv_q_src_c110_3_06 0 conv_bpf_c110_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c110_3_06 (conv_q_src_c110_3_06 conv_q_c110_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_07 (conv_i_src_c110_3_07 0 conv_bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_3_07 (conv_i_src_c110_3_07 conv_i_c110_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_07 (conv_q_src_c110_3_07 0 conv_bpf_c110_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c110_3_07 (conv_q_src_c110_3_07 conv_q_c110_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_08 (conv_i_src_c110_3_08 0 conv_bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c110_3_08 (conv_i_src_c110_3_08 conv_i_c110_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_08 (conv_q_src_c110_3_08 0 conv_bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_3_08 (conv_q_src_c110_3_08 conv_q_c110_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_09 (conv_i_src_c110_3_09 0 conv_bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c110_3_09 (conv_i_src_c110_3_09 conv_i_c110_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_09 (conv_q_src_c110_3_09 0 conv_bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_3_09 (conv_q_src_c110_3_09 conv_q_c110_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_10 (conv_i_src_c110_3_10 0 conv_bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c110_3_10 (conv_i_src_c110_3_10 conv_i_c110_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_10 (conv_q_src_c110_3_10 0 conv_bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_3_10 (conv_q_src_c110_3_10 conv_q_c110_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_11 (conv_i_src_c110_3_11 0 conv_bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c110_3_11 (conv_i_src_c110_3_11 conv_i_c110_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_11 (conv_q_src_c110_3_11 0 conv_bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_3_11 (conv_q_src_c110_3_11 conv_q_c110_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_12 (conv_i_src_c110_3_12 0 conv_bpf_c110_3 0) vcvs gain=1.950903220161e-01
SCONVI_c110_3_12 (conv_i_src_c110_3_12 conv_i_c110_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_12 (conv_q_src_c110_3_12 0 conv_bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c110_3_12 (conv_q_src_c110_3_12 conv_q_c110_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_13 (conv_i_src_c110_3_13 0 conv_bpf_c110_3 0) vcvs gain=5.555702330196e-01
SCONVI_c110_3_13 (conv_i_src_c110_3_13 conv_i_c110_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_13 (conv_q_src_c110_3_13 0 conv_bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c110_3_13 (conv_q_src_c110_3_13 conv_q_c110_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_14 (conv_i_src_c110_3_14 0 conv_bpf_c110_3 0) vcvs gain=8.314696123025e-01
SCONVI_c110_3_14 (conv_i_src_c110_3_14 conv_i_c110_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_14 (conv_q_src_c110_3_14 0 conv_bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c110_3_14 (conv_q_src_c110_3_14 conv_q_c110_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c110_3_15 (conv_i_src_c110_3_15 0 conv_bpf_c110_3 0) vcvs gain=9.807852804032e-01
SCONVI_c110_3_15 (conv_i_src_c110_3_15 conv_i_c110_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c110_3_15 (conv_q_src_c110_3_15 0 conv_bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c110_3_15 (conv_q_src_c110_3_15 conv_q_c110_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c110_3 (conv_i_c110_3 0) resistor r=1G
RCONVQ_c110_3 (conv_q_c110_3 0) resistor r=1G
RCONVINTI_c110_3 (conv_i_c110_3 ConvIcar_c110_3) resistor r=1k
CCONVINTI_c110_3 (ConvIcar_c110_3 0) capacitor c=80p
RCONVINTQ_c110_3 (conv_q_c110_3 ConvQcar_c110_3) resistor r=1k
CCONVINTQ_c110_3 (ConvQcar_c110_3 0) capacitor c=80p
save conv_bpf_c110_3 ConvIcar_c110_3 ConvQcar_c110_3

// conventional mixed baseline bl111, carrier_0: 250000000 Hz
CCONVBPF_c111_0 (bl111 n_conv_cbpf_c111_0) capacitor c=4.052847345694e-13
LCONVBPF_c111_0 (n_conv_cbpf_c111_0 conv_bpf_c111_0) inductor l=1.000000000000e-06
RCONVBPF_c111_0 (conv_bpf_c111_0 0) resistor r=7.853981633974e+01
ECONVI_c111_0_00 (conv_i_src_c111_0_00 0 conv_bpf_c111_0 0) vcvs gain=9.807852804032e-01
SCONVI_c111_0_00 (conv_i_src_c111_0_00 conv_i_c111_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_00 (conv_q_src_c111_0_00 0 conv_bpf_c111_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_0_00 (conv_q_src_c111_0_00 conv_q_c111_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_01 (conv_i_src_c111_0_01 0 conv_bpf_c111_0 0) vcvs gain=8.314696123025e-01
SCONVI_c111_0_01 (conv_i_src_c111_0_01 conv_i_c111_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_01 (conv_q_src_c111_0_01 0 conv_bpf_c111_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_0_01 (conv_q_src_c111_0_01 conv_q_c111_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_02 (conv_i_src_c111_0_02 0 conv_bpf_c111_0 0) vcvs gain=5.555702330196e-01
SCONVI_c111_0_02 (conv_i_src_c111_0_02 conv_i_c111_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_02 (conv_q_src_c111_0_02 0 conv_bpf_c111_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_0_02 (conv_q_src_c111_0_02 conv_q_c111_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_03 (conv_i_src_c111_0_03 0 conv_bpf_c111_0 0) vcvs gain=1.950903220161e-01
SCONVI_c111_0_03 (conv_i_src_c111_0_03 conv_i_c111_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_03 (conv_q_src_c111_0_03 0 conv_bpf_c111_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_0_03 (conv_q_src_c111_0_03 conv_q_c111_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_04 (conv_i_src_c111_0_04 0 conv_bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_0_04 (conv_i_src_c111_0_04 conv_i_c111_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_04 (conv_q_src_c111_0_04 0 conv_bpf_c111_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_0_04 (conv_q_src_c111_0_04 conv_q_c111_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_05 (conv_i_src_c111_0_05 0 conv_bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_0_05 (conv_i_src_c111_0_05 conv_i_c111_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_05 (conv_q_src_c111_0_05 0 conv_bpf_c111_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_0_05 (conv_q_src_c111_0_05 conv_q_c111_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_06 (conv_i_src_c111_0_06 0 conv_bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_0_06 (conv_i_src_c111_0_06 conv_i_c111_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_06 (conv_q_src_c111_0_06 0 conv_bpf_c111_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_0_06 (conv_q_src_c111_0_06 conv_q_c111_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_07 (conv_i_src_c111_0_07 0 conv_bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_0_07 (conv_i_src_c111_0_07 conv_i_c111_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_07 (conv_q_src_c111_0_07 0 conv_bpf_c111_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_0_07 (conv_q_src_c111_0_07 conv_q_c111_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_08 (conv_i_src_c111_0_08 0 conv_bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_0_08 (conv_i_src_c111_0_08 conv_i_c111_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_08 (conv_q_src_c111_0_08 0 conv_bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_0_08 (conv_q_src_c111_0_08 conv_q_c111_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_09 (conv_i_src_c111_0_09 0 conv_bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_0_09 (conv_i_src_c111_0_09 conv_i_c111_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_09 (conv_q_src_c111_0_09 0 conv_bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_0_09 (conv_q_src_c111_0_09 conv_q_c111_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_10 (conv_i_src_c111_0_10 0 conv_bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_0_10 (conv_i_src_c111_0_10 conv_i_c111_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_10 (conv_q_src_c111_0_10 0 conv_bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_0_10 (conv_q_src_c111_0_10 conv_q_c111_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_11 (conv_i_src_c111_0_11 0 conv_bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_0_11 (conv_i_src_c111_0_11 conv_i_c111_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_11 (conv_q_src_c111_0_11 0 conv_bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_0_11 (conv_q_src_c111_0_11 conv_q_c111_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_12 (conv_i_src_c111_0_12 0 conv_bpf_c111_0 0) vcvs gain=1.950903220161e-01
SCONVI_c111_0_12 (conv_i_src_c111_0_12 conv_i_c111_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_12 (conv_q_src_c111_0_12 0 conv_bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_0_12 (conv_q_src_c111_0_12 conv_q_c111_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_13 (conv_i_src_c111_0_13 0 conv_bpf_c111_0 0) vcvs gain=5.555702330196e-01
SCONVI_c111_0_13 (conv_i_src_c111_0_13 conv_i_c111_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_13 (conv_q_src_c111_0_13 0 conv_bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_0_13 (conv_q_src_c111_0_13 conv_q_c111_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_14 (conv_i_src_c111_0_14 0 conv_bpf_c111_0 0) vcvs gain=8.314696123025e-01
SCONVI_c111_0_14 (conv_i_src_c111_0_14 conv_i_c111_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_14 (conv_q_src_c111_0_14 0 conv_bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_0_14 (conv_q_src_c111_0_14 conv_q_c111_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_0_15 (conv_i_src_c111_0_15 0 conv_bpf_c111_0 0) vcvs gain=9.807852804032e-01
SCONVI_c111_0_15 (conv_i_src_c111_0_15 conv_i_c111_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_0_15 (conv_q_src_c111_0_15 0 conv_bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_0_15 (conv_q_src_c111_0_15 conv_q_c111_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c111_0 (conv_i_c111_0 0) resistor r=1G
RCONVQ_c111_0 (conv_q_c111_0 0) resistor r=1G
RCONVINTI_c111_0 (conv_i_c111_0 ConvIcar_c111_0) resistor r=1k
CCONVINTI_c111_0 (ConvIcar_c111_0 0) capacitor c=80p
RCONVINTQ_c111_0 (conv_q_c111_0 ConvQcar_c111_0) resistor r=1k
CCONVINTQ_c111_0 (ConvQcar_c111_0 0) capacitor c=80p
save conv_bpf_c111_0 ConvIcar_c111_0 ConvQcar_c111_0

// conventional mixed baseline bl111, carrier_1: 500000000 Hz
CCONVBPF_c111_1 (bl111 n_conv_cbpf_c111_1) capacitor c=1.013211836423e-13
LCONVBPF_c111_1 (n_conv_cbpf_c111_1 conv_bpf_c111_1) inductor l=1.000000000000e-06
RCONVBPF_c111_1 (conv_bpf_c111_1 0) resistor r=1.570796326795e+02
ECONVI_c111_1_00 (conv_i_src_c111_1_00 0 conv_bpf_c111_1 0) vcvs gain=9.807852804032e-01
SCONVI_c111_1_00 (conv_i_src_c111_1_00 conv_i_c111_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_00 (conv_q_src_c111_1_00 0 conv_bpf_c111_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_1_00 (conv_q_src_c111_1_00 conv_q_c111_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_01 (conv_i_src_c111_1_01 0 conv_bpf_c111_1 0) vcvs gain=8.314696123025e-01
SCONVI_c111_1_01 (conv_i_src_c111_1_01 conv_i_c111_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_01 (conv_q_src_c111_1_01 0 conv_bpf_c111_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_1_01 (conv_q_src_c111_1_01 conv_q_c111_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_02 (conv_i_src_c111_1_02 0 conv_bpf_c111_1 0) vcvs gain=5.555702330196e-01
SCONVI_c111_1_02 (conv_i_src_c111_1_02 conv_i_c111_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_02 (conv_q_src_c111_1_02 0 conv_bpf_c111_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_1_02 (conv_q_src_c111_1_02 conv_q_c111_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_03 (conv_i_src_c111_1_03 0 conv_bpf_c111_1 0) vcvs gain=1.950903220161e-01
SCONVI_c111_1_03 (conv_i_src_c111_1_03 conv_i_c111_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_03 (conv_q_src_c111_1_03 0 conv_bpf_c111_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_1_03 (conv_q_src_c111_1_03 conv_q_c111_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_04 (conv_i_src_c111_1_04 0 conv_bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_1_04 (conv_i_src_c111_1_04 conv_i_c111_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_04 (conv_q_src_c111_1_04 0 conv_bpf_c111_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_1_04 (conv_q_src_c111_1_04 conv_q_c111_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_05 (conv_i_src_c111_1_05 0 conv_bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_1_05 (conv_i_src_c111_1_05 conv_i_c111_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_05 (conv_q_src_c111_1_05 0 conv_bpf_c111_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_1_05 (conv_q_src_c111_1_05 conv_q_c111_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_06 (conv_i_src_c111_1_06 0 conv_bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_1_06 (conv_i_src_c111_1_06 conv_i_c111_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_06 (conv_q_src_c111_1_06 0 conv_bpf_c111_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_1_06 (conv_q_src_c111_1_06 conv_q_c111_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_07 (conv_i_src_c111_1_07 0 conv_bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_1_07 (conv_i_src_c111_1_07 conv_i_c111_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_07 (conv_q_src_c111_1_07 0 conv_bpf_c111_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_1_07 (conv_q_src_c111_1_07 conv_q_c111_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_08 (conv_i_src_c111_1_08 0 conv_bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_1_08 (conv_i_src_c111_1_08 conv_i_c111_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_08 (conv_q_src_c111_1_08 0 conv_bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_1_08 (conv_q_src_c111_1_08 conv_q_c111_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_09 (conv_i_src_c111_1_09 0 conv_bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_1_09 (conv_i_src_c111_1_09 conv_i_c111_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_09 (conv_q_src_c111_1_09 0 conv_bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_1_09 (conv_q_src_c111_1_09 conv_q_c111_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_10 (conv_i_src_c111_1_10 0 conv_bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_1_10 (conv_i_src_c111_1_10 conv_i_c111_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_10 (conv_q_src_c111_1_10 0 conv_bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_1_10 (conv_q_src_c111_1_10 conv_q_c111_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_11 (conv_i_src_c111_1_11 0 conv_bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_1_11 (conv_i_src_c111_1_11 conv_i_c111_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_11 (conv_q_src_c111_1_11 0 conv_bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_1_11 (conv_q_src_c111_1_11 conv_q_c111_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_12 (conv_i_src_c111_1_12 0 conv_bpf_c111_1 0) vcvs gain=1.950903220161e-01
SCONVI_c111_1_12 (conv_i_src_c111_1_12 conv_i_c111_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_12 (conv_q_src_c111_1_12 0 conv_bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_1_12 (conv_q_src_c111_1_12 conv_q_c111_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_13 (conv_i_src_c111_1_13 0 conv_bpf_c111_1 0) vcvs gain=5.555702330196e-01
SCONVI_c111_1_13 (conv_i_src_c111_1_13 conv_i_c111_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_13 (conv_q_src_c111_1_13 0 conv_bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_1_13 (conv_q_src_c111_1_13 conv_q_c111_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_14 (conv_i_src_c111_1_14 0 conv_bpf_c111_1 0) vcvs gain=8.314696123025e-01
SCONVI_c111_1_14 (conv_i_src_c111_1_14 conv_i_c111_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_14 (conv_q_src_c111_1_14 0 conv_bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_1_14 (conv_q_src_c111_1_14 conv_q_c111_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_1_15 (conv_i_src_c111_1_15 0 conv_bpf_c111_1 0) vcvs gain=9.807852804032e-01
SCONVI_c111_1_15 (conv_i_src_c111_1_15 conv_i_c111_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_1_15 (conv_q_src_c111_1_15 0 conv_bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_1_15 (conv_q_src_c111_1_15 conv_q_c111_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c111_1 (conv_i_c111_1 0) resistor r=1G
RCONVQ_c111_1 (conv_q_c111_1 0) resistor r=1G
RCONVINTI_c111_1 (conv_i_c111_1 ConvIcar_c111_1) resistor r=1k
CCONVINTI_c111_1 (ConvIcar_c111_1 0) capacitor c=80p
RCONVINTQ_c111_1 (conv_q_c111_1 ConvQcar_c111_1) resistor r=1k
CCONVINTQ_c111_1 (ConvQcar_c111_1 0) capacitor c=80p
save conv_bpf_c111_1 ConvIcar_c111_1 ConvQcar_c111_1

// conventional mixed baseline bl111, carrier_2: 750000000 Hz
CCONVBPF_c111_2 (bl111 n_conv_cbpf_c111_2) capacitor c=4.503163717437e-14
LCONVBPF_c111_2 (n_conv_cbpf_c111_2 conv_bpf_c111_2) inductor l=1.000000000000e-06
RCONVBPF_c111_2 (conv_bpf_c111_2 0) resistor r=2.356194490192e+02
ECONVI_c111_2_00 (conv_i_src_c111_2_00 0 conv_bpf_c111_2 0) vcvs gain=9.807852804032e-01
SCONVI_c111_2_00 (conv_i_src_c111_2_00 conv_i_c111_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_00 (conv_q_src_c111_2_00 0 conv_bpf_c111_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_2_00 (conv_q_src_c111_2_00 conv_q_c111_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_01 (conv_i_src_c111_2_01 0 conv_bpf_c111_2 0) vcvs gain=8.314696123025e-01
SCONVI_c111_2_01 (conv_i_src_c111_2_01 conv_i_c111_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_01 (conv_q_src_c111_2_01 0 conv_bpf_c111_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_2_01 (conv_q_src_c111_2_01 conv_q_c111_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_02 (conv_i_src_c111_2_02 0 conv_bpf_c111_2 0) vcvs gain=5.555702330196e-01
SCONVI_c111_2_02 (conv_i_src_c111_2_02 conv_i_c111_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_02 (conv_q_src_c111_2_02 0 conv_bpf_c111_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_2_02 (conv_q_src_c111_2_02 conv_q_c111_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_03 (conv_i_src_c111_2_03 0 conv_bpf_c111_2 0) vcvs gain=1.950903220161e-01
SCONVI_c111_2_03 (conv_i_src_c111_2_03 conv_i_c111_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_03 (conv_q_src_c111_2_03 0 conv_bpf_c111_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_2_03 (conv_q_src_c111_2_03 conv_q_c111_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_04 (conv_i_src_c111_2_04 0 conv_bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_2_04 (conv_i_src_c111_2_04 conv_i_c111_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_04 (conv_q_src_c111_2_04 0 conv_bpf_c111_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_2_04 (conv_q_src_c111_2_04 conv_q_c111_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_05 (conv_i_src_c111_2_05 0 conv_bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_2_05 (conv_i_src_c111_2_05 conv_i_c111_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_05 (conv_q_src_c111_2_05 0 conv_bpf_c111_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_2_05 (conv_q_src_c111_2_05 conv_q_c111_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_06 (conv_i_src_c111_2_06 0 conv_bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_2_06 (conv_i_src_c111_2_06 conv_i_c111_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_06 (conv_q_src_c111_2_06 0 conv_bpf_c111_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_2_06 (conv_q_src_c111_2_06 conv_q_c111_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_07 (conv_i_src_c111_2_07 0 conv_bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_2_07 (conv_i_src_c111_2_07 conv_i_c111_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_07 (conv_q_src_c111_2_07 0 conv_bpf_c111_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_2_07 (conv_q_src_c111_2_07 conv_q_c111_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_08 (conv_i_src_c111_2_08 0 conv_bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_2_08 (conv_i_src_c111_2_08 conv_i_c111_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_08 (conv_q_src_c111_2_08 0 conv_bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_2_08 (conv_q_src_c111_2_08 conv_q_c111_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_09 (conv_i_src_c111_2_09 0 conv_bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_2_09 (conv_i_src_c111_2_09 conv_i_c111_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_09 (conv_q_src_c111_2_09 0 conv_bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_2_09 (conv_q_src_c111_2_09 conv_q_c111_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_10 (conv_i_src_c111_2_10 0 conv_bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_2_10 (conv_i_src_c111_2_10 conv_i_c111_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_10 (conv_q_src_c111_2_10 0 conv_bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_2_10 (conv_q_src_c111_2_10 conv_q_c111_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_11 (conv_i_src_c111_2_11 0 conv_bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_2_11 (conv_i_src_c111_2_11 conv_i_c111_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_11 (conv_q_src_c111_2_11 0 conv_bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_2_11 (conv_q_src_c111_2_11 conv_q_c111_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_12 (conv_i_src_c111_2_12 0 conv_bpf_c111_2 0) vcvs gain=1.950903220161e-01
SCONVI_c111_2_12 (conv_i_src_c111_2_12 conv_i_c111_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_12 (conv_q_src_c111_2_12 0 conv_bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_2_12 (conv_q_src_c111_2_12 conv_q_c111_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_13 (conv_i_src_c111_2_13 0 conv_bpf_c111_2 0) vcvs gain=5.555702330196e-01
SCONVI_c111_2_13 (conv_i_src_c111_2_13 conv_i_c111_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_13 (conv_q_src_c111_2_13 0 conv_bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_2_13 (conv_q_src_c111_2_13 conv_q_c111_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_14 (conv_i_src_c111_2_14 0 conv_bpf_c111_2 0) vcvs gain=8.314696123025e-01
SCONVI_c111_2_14 (conv_i_src_c111_2_14 conv_i_c111_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_14 (conv_q_src_c111_2_14 0 conv_bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_2_14 (conv_q_src_c111_2_14 conv_q_c111_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_2_15 (conv_i_src_c111_2_15 0 conv_bpf_c111_2 0) vcvs gain=9.807852804032e-01
SCONVI_c111_2_15 (conv_i_src_c111_2_15 conv_i_c111_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_2_15 (conv_q_src_c111_2_15 0 conv_bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_2_15 (conv_q_src_c111_2_15 conv_q_c111_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c111_2 (conv_i_c111_2 0) resistor r=1G
RCONVQ_c111_2 (conv_q_c111_2 0) resistor r=1G
RCONVINTI_c111_2 (conv_i_c111_2 ConvIcar_c111_2) resistor r=1k
CCONVINTI_c111_2 (ConvIcar_c111_2 0) capacitor c=80p
RCONVINTQ_c111_2 (conv_q_c111_2 ConvQcar_c111_2) resistor r=1k
CCONVINTQ_c111_2 (ConvQcar_c111_2 0) capacitor c=80p
save conv_bpf_c111_2 ConvIcar_c111_2 ConvQcar_c111_2

// conventional mixed baseline bl111, carrier_3: 1000000000 Hz
CCONVBPF_c111_3 (bl111 n_conv_cbpf_c111_3) capacitor c=2.533029591058e-14
LCONVBPF_c111_3 (n_conv_cbpf_c111_3 conv_bpf_c111_3) inductor l=1.000000000000e-06
RCONVBPF_c111_3 (conv_bpf_c111_3 0) resistor r=3.141592653590e+02
ECONVI_c111_3_00 (conv_i_src_c111_3_00 0 conv_bpf_c111_3 0) vcvs gain=9.807852804032e-01
SCONVI_c111_3_00 (conv_i_src_c111_3_00 conv_i_c111_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_00 (conv_q_src_c111_3_00 0 conv_bpf_c111_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_3_00 (conv_q_src_c111_3_00 conv_q_c111_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_01 (conv_i_src_c111_3_01 0 conv_bpf_c111_3 0) vcvs gain=8.314696123025e-01
SCONVI_c111_3_01 (conv_i_src_c111_3_01 conv_i_c111_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_01 (conv_q_src_c111_3_01 0 conv_bpf_c111_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_3_01 (conv_q_src_c111_3_01 conv_q_c111_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_02 (conv_i_src_c111_3_02 0 conv_bpf_c111_3 0) vcvs gain=5.555702330196e-01
SCONVI_c111_3_02 (conv_i_src_c111_3_02 conv_i_c111_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_02 (conv_q_src_c111_3_02 0 conv_bpf_c111_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_3_02 (conv_q_src_c111_3_02 conv_q_c111_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_03 (conv_i_src_c111_3_03 0 conv_bpf_c111_3 0) vcvs gain=1.950903220161e-01
SCONVI_c111_3_03 (conv_i_src_c111_3_03 conv_i_c111_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_03 (conv_q_src_c111_3_03 0 conv_bpf_c111_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_3_03 (conv_q_src_c111_3_03 conv_q_c111_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_04 (conv_i_src_c111_3_04 0 conv_bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_3_04 (conv_i_src_c111_3_04 conv_i_c111_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_04 (conv_q_src_c111_3_04 0 conv_bpf_c111_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c111_3_04 (conv_q_src_c111_3_04 conv_q_c111_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_05 (conv_i_src_c111_3_05 0 conv_bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_3_05 (conv_i_src_c111_3_05 conv_i_c111_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_05 (conv_q_src_c111_3_05 0 conv_bpf_c111_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c111_3_05 (conv_q_src_c111_3_05 conv_q_c111_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_06 (conv_i_src_c111_3_06 0 conv_bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_3_06 (conv_i_src_c111_3_06 conv_i_c111_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_06 (conv_q_src_c111_3_06 0 conv_bpf_c111_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c111_3_06 (conv_q_src_c111_3_06 conv_q_c111_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_07 (conv_i_src_c111_3_07 0 conv_bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_3_07 (conv_i_src_c111_3_07 conv_i_c111_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_07 (conv_q_src_c111_3_07 0 conv_bpf_c111_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c111_3_07 (conv_q_src_c111_3_07 conv_q_c111_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_08 (conv_i_src_c111_3_08 0 conv_bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c111_3_08 (conv_i_src_c111_3_08 conv_i_c111_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_08 (conv_q_src_c111_3_08 0 conv_bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_3_08 (conv_q_src_c111_3_08 conv_q_c111_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_09 (conv_i_src_c111_3_09 0 conv_bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c111_3_09 (conv_i_src_c111_3_09 conv_i_c111_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_09 (conv_q_src_c111_3_09 0 conv_bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_3_09 (conv_q_src_c111_3_09 conv_q_c111_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_10 (conv_i_src_c111_3_10 0 conv_bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c111_3_10 (conv_i_src_c111_3_10 conv_i_c111_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_10 (conv_q_src_c111_3_10 0 conv_bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_3_10 (conv_q_src_c111_3_10 conv_q_c111_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_11 (conv_i_src_c111_3_11 0 conv_bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c111_3_11 (conv_i_src_c111_3_11 conv_i_c111_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_11 (conv_q_src_c111_3_11 0 conv_bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_3_11 (conv_q_src_c111_3_11 conv_q_c111_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_12 (conv_i_src_c111_3_12 0 conv_bpf_c111_3 0) vcvs gain=1.950903220161e-01
SCONVI_c111_3_12 (conv_i_src_c111_3_12 conv_i_c111_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_12 (conv_q_src_c111_3_12 0 conv_bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c111_3_12 (conv_q_src_c111_3_12 conv_q_c111_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_13 (conv_i_src_c111_3_13 0 conv_bpf_c111_3 0) vcvs gain=5.555702330196e-01
SCONVI_c111_3_13 (conv_i_src_c111_3_13 conv_i_c111_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_13 (conv_q_src_c111_3_13 0 conv_bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c111_3_13 (conv_q_src_c111_3_13 conv_q_c111_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_14 (conv_i_src_c111_3_14 0 conv_bpf_c111_3 0) vcvs gain=8.314696123025e-01
SCONVI_c111_3_14 (conv_i_src_c111_3_14 conv_i_c111_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_14 (conv_q_src_c111_3_14 0 conv_bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c111_3_14 (conv_q_src_c111_3_14 conv_q_c111_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c111_3_15 (conv_i_src_c111_3_15 0 conv_bpf_c111_3 0) vcvs gain=9.807852804032e-01
SCONVI_c111_3_15 (conv_i_src_c111_3_15 conv_i_c111_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c111_3_15 (conv_q_src_c111_3_15 0 conv_bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c111_3_15 (conv_q_src_c111_3_15 conv_q_c111_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c111_3 (conv_i_c111_3 0) resistor r=1G
RCONVQ_c111_3 (conv_q_c111_3 0) resistor r=1G
RCONVINTI_c111_3 (conv_i_c111_3 ConvIcar_c111_3) resistor r=1k
CCONVINTI_c111_3 (ConvIcar_c111_3 0) capacitor c=80p
RCONVINTQ_c111_3 (conv_q_c111_3 ConvQcar_c111_3) resistor r=1k
CCONVINTQ_c111_3 (ConvQcar_c111_3 0) capacitor c=80p
save conv_bpf_c111_3 ConvIcar_c111_3 ConvQcar_c111_3

// conventional mixed baseline bl112, carrier_0: 250000000 Hz
CCONVBPF_c112_0 (bl112 n_conv_cbpf_c112_0) capacitor c=4.052847345694e-13
LCONVBPF_c112_0 (n_conv_cbpf_c112_0 conv_bpf_c112_0) inductor l=1.000000000000e-06
RCONVBPF_c112_0 (conv_bpf_c112_0 0) resistor r=7.853981633974e+01
ECONVI_c112_0_00 (conv_i_src_c112_0_00 0 conv_bpf_c112_0 0) vcvs gain=9.807852804032e-01
SCONVI_c112_0_00 (conv_i_src_c112_0_00 conv_i_c112_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_00 (conv_q_src_c112_0_00 0 conv_bpf_c112_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_0_00 (conv_q_src_c112_0_00 conv_q_c112_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_01 (conv_i_src_c112_0_01 0 conv_bpf_c112_0 0) vcvs gain=8.314696123025e-01
SCONVI_c112_0_01 (conv_i_src_c112_0_01 conv_i_c112_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_01 (conv_q_src_c112_0_01 0 conv_bpf_c112_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_0_01 (conv_q_src_c112_0_01 conv_q_c112_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_02 (conv_i_src_c112_0_02 0 conv_bpf_c112_0 0) vcvs gain=5.555702330196e-01
SCONVI_c112_0_02 (conv_i_src_c112_0_02 conv_i_c112_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_02 (conv_q_src_c112_0_02 0 conv_bpf_c112_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_0_02 (conv_q_src_c112_0_02 conv_q_c112_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_03 (conv_i_src_c112_0_03 0 conv_bpf_c112_0 0) vcvs gain=1.950903220161e-01
SCONVI_c112_0_03 (conv_i_src_c112_0_03 conv_i_c112_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_03 (conv_q_src_c112_0_03 0 conv_bpf_c112_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_0_03 (conv_q_src_c112_0_03 conv_q_c112_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_04 (conv_i_src_c112_0_04 0 conv_bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_0_04 (conv_i_src_c112_0_04 conv_i_c112_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_04 (conv_q_src_c112_0_04 0 conv_bpf_c112_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_0_04 (conv_q_src_c112_0_04 conv_q_c112_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_05 (conv_i_src_c112_0_05 0 conv_bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_0_05 (conv_i_src_c112_0_05 conv_i_c112_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_05 (conv_q_src_c112_0_05 0 conv_bpf_c112_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_0_05 (conv_q_src_c112_0_05 conv_q_c112_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_06 (conv_i_src_c112_0_06 0 conv_bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_0_06 (conv_i_src_c112_0_06 conv_i_c112_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_06 (conv_q_src_c112_0_06 0 conv_bpf_c112_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_0_06 (conv_q_src_c112_0_06 conv_q_c112_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_07 (conv_i_src_c112_0_07 0 conv_bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_0_07 (conv_i_src_c112_0_07 conv_i_c112_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_07 (conv_q_src_c112_0_07 0 conv_bpf_c112_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_0_07 (conv_q_src_c112_0_07 conv_q_c112_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_08 (conv_i_src_c112_0_08 0 conv_bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_0_08 (conv_i_src_c112_0_08 conv_i_c112_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_08 (conv_q_src_c112_0_08 0 conv_bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_0_08 (conv_q_src_c112_0_08 conv_q_c112_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_09 (conv_i_src_c112_0_09 0 conv_bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_0_09 (conv_i_src_c112_0_09 conv_i_c112_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_09 (conv_q_src_c112_0_09 0 conv_bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_0_09 (conv_q_src_c112_0_09 conv_q_c112_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_10 (conv_i_src_c112_0_10 0 conv_bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_0_10 (conv_i_src_c112_0_10 conv_i_c112_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_10 (conv_q_src_c112_0_10 0 conv_bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_0_10 (conv_q_src_c112_0_10 conv_q_c112_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_11 (conv_i_src_c112_0_11 0 conv_bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_0_11 (conv_i_src_c112_0_11 conv_i_c112_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_11 (conv_q_src_c112_0_11 0 conv_bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_0_11 (conv_q_src_c112_0_11 conv_q_c112_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_12 (conv_i_src_c112_0_12 0 conv_bpf_c112_0 0) vcvs gain=1.950903220161e-01
SCONVI_c112_0_12 (conv_i_src_c112_0_12 conv_i_c112_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_12 (conv_q_src_c112_0_12 0 conv_bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_0_12 (conv_q_src_c112_0_12 conv_q_c112_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_13 (conv_i_src_c112_0_13 0 conv_bpf_c112_0 0) vcvs gain=5.555702330196e-01
SCONVI_c112_0_13 (conv_i_src_c112_0_13 conv_i_c112_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_13 (conv_q_src_c112_0_13 0 conv_bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_0_13 (conv_q_src_c112_0_13 conv_q_c112_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_14 (conv_i_src_c112_0_14 0 conv_bpf_c112_0 0) vcvs gain=8.314696123025e-01
SCONVI_c112_0_14 (conv_i_src_c112_0_14 conv_i_c112_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_14 (conv_q_src_c112_0_14 0 conv_bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_0_14 (conv_q_src_c112_0_14 conv_q_c112_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_0_15 (conv_i_src_c112_0_15 0 conv_bpf_c112_0 0) vcvs gain=9.807852804032e-01
SCONVI_c112_0_15 (conv_i_src_c112_0_15 conv_i_c112_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_0_15 (conv_q_src_c112_0_15 0 conv_bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_0_15 (conv_q_src_c112_0_15 conv_q_c112_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c112_0 (conv_i_c112_0 0) resistor r=1G
RCONVQ_c112_0 (conv_q_c112_0 0) resistor r=1G
RCONVINTI_c112_0 (conv_i_c112_0 ConvIcar_c112_0) resistor r=1k
CCONVINTI_c112_0 (ConvIcar_c112_0 0) capacitor c=80p
RCONVINTQ_c112_0 (conv_q_c112_0 ConvQcar_c112_0) resistor r=1k
CCONVINTQ_c112_0 (ConvQcar_c112_0 0) capacitor c=80p
save conv_bpf_c112_0 ConvIcar_c112_0 ConvQcar_c112_0

// conventional mixed baseline bl112, carrier_1: 500000000 Hz
CCONVBPF_c112_1 (bl112 n_conv_cbpf_c112_1) capacitor c=1.013211836423e-13
LCONVBPF_c112_1 (n_conv_cbpf_c112_1 conv_bpf_c112_1) inductor l=1.000000000000e-06
RCONVBPF_c112_1 (conv_bpf_c112_1 0) resistor r=1.570796326795e+02
ECONVI_c112_1_00 (conv_i_src_c112_1_00 0 conv_bpf_c112_1 0) vcvs gain=9.807852804032e-01
SCONVI_c112_1_00 (conv_i_src_c112_1_00 conv_i_c112_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_00 (conv_q_src_c112_1_00 0 conv_bpf_c112_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_1_00 (conv_q_src_c112_1_00 conv_q_c112_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_01 (conv_i_src_c112_1_01 0 conv_bpf_c112_1 0) vcvs gain=8.314696123025e-01
SCONVI_c112_1_01 (conv_i_src_c112_1_01 conv_i_c112_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_01 (conv_q_src_c112_1_01 0 conv_bpf_c112_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_1_01 (conv_q_src_c112_1_01 conv_q_c112_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_02 (conv_i_src_c112_1_02 0 conv_bpf_c112_1 0) vcvs gain=5.555702330196e-01
SCONVI_c112_1_02 (conv_i_src_c112_1_02 conv_i_c112_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_02 (conv_q_src_c112_1_02 0 conv_bpf_c112_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_1_02 (conv_q_src_c112_1_02 conv_q_c112_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_03 (conv_i_src_c112_1_03 0 conv_bpf_c112_1 0) vcvs gain=1.950903220161e-01
SCONVI_c112_1_03 (conv_i_src_c112_1_03 conv_i_c112_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_03 (conv_q_src_c112_1_03 0 conv_bpf_c112_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_1_03 (conv_q_src_c112_1_03 conv_q_c112_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_04 (conv_i_src_c112_1_04 0 conv_bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_1_04 (conv_i_src_c112_1_04 conv_i_c112_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_04 (conv_q_src_c112_1_04 0 conv_bpf_c112_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_1_04 (conv_q_src_c112_1_04 conv_q_c112_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_05 (conv_i_src_c112_1_05 0 conv_bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_1_05 (conv_i_src_c112_1_05 conv_i_c112_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_05 (conv_q_src_c112_1_05 0 conv_bpf_c112_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_1_05 (conv_q_src_c112_1_05 conv_q_c112_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_06 (conv_i_src_c112_1_06 0 conv_bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_1_06 (conv_i_src_c112_1_06 conv_i_c112_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_06 (conv_q_src_c112_1_06 0 conv_bpf_c112_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_1_06 (conv_q_src_c112_1_06 conv_q_c112_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_07 (conv_i_src_c112_1_07 0 conv_bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_1_07 (conv_i_src_c112_1_07 conv_i_c112_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_07 (conv_q_src_c112_1_07 0 conv_bpf_c112_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_1_07 (conv_q_src_c112_1_07 conv_q_c112_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_08 (conv_i_src_c112_1_08 0 conv_bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_1_08 (conv_i_src_c112_1_08 conv_i_c112_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_08 (conv_q_src_c112_1_08 0 conv_bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_1_08 (conv_q_src_c112_1_08 conv_q_c112_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_09 (conv_i_src_c112_1_09 0 conv_bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_1_09 (conv_i_src_c112_1_09 conv_i_c112_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_09 (conv_q_src_c112_1_09 0 conv_bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_1_09 (conv_q_src_c112_1_09 conv_q_c112_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_10 (conv_i_src_c112_1_10 0 conv_bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_1_10 (conv_i_src_c112_1_10 conv_i_c112_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_10 (conv_q_src_c112_1_10 0 conv_bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_1_10 (conv_q_src_c112_1_10 conv_q_c112_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_11 (conv_i_src_c112_1_11 0 conv_bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_1_11 (conv_i_src_c112_1_11 conv_i_c112_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_11 (conv_q_src_c112_1_11 0 conv_bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_1_11 (conv_q_src_c112_1_11 conv_q_c112_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_12 (conv_i_src_c112_1_12 0 conv_bpf_c112_1 0) vcvs gain=1.950903220161e-01
SCONVI_c112_1_12 (conv_i_src_c112_1_12 conv_i_c112_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_12 (conv_q_src_c112_1_12 0 conv_bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_1_12 (conv_q_src_c112_1_12 conv_q_c112_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_13 (conv_i_src_c112_1_13 0 conv_bpf_c112_1 0) vcvs gain=5.555702330196e-01
SCONVI_c112_1_13 (conv_i_src_c112_1_13 conv_i_c112_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_13 (conv_q_src_c112_1_13 0 conv_bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_1_13 (conv_q_src_c112_1_13 conv_q_c112_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_14 (conv_i_src_c112_1_14 0 conv_bpf_c112_1 0) vcvs gain=8.314696123025e-01
SCONVI_c112_1_14 (conv_i_src_c112_1_14 conv_i_c112_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_14 (conv_q_src_c112_1_14 0 conv_bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_1_14 (conv_q_src_c112_1_14 conv_q_c112_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_1_15 (conv_i_src_c112_1_15 0 conv_bpf_c112_1 0) vcvs gain=9.807852804032e-01
SCONVI_c112_1_15 (conv_i_src_c112_1_15 conv_i_c112_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_1_15 (conv_q_src_c112_1_15 0 conv_bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_1_15 (conv_q_src_c112_1_15 conv_q_c112_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c112_1 (conv_i_c112_1 0) resistor r=1G
RCONVQ_c112_1 (conv_q_c112_1 0) resistor r=1G
RCONVINTI_c112_1 (conv_i_c112_1 ConvIcar_c112_1) resistor r=1k
CCONVINTI_c112_1 (ConvIcar_c112_1 0) capacitor c=80p
RCONVINTQ_c112_1 (conv_q_c112_1 ConvQcar_c112_1) resistor r=1k
CCONVINTQ_c112_1 (ConvQcar_c112_1 0) capacitor c=80p
save conv_bpf_c112_1 ConvIcar_c112_1 ConvQcar_c112_1

// conventional mixed baseline bl112, carrier_2: 750000000 Hz
CCONVBPF_c112_2 (bl112 n_conv_cbpf_c112_2) capacitor c=4.503163717437e-14
LCONVBPF_c112_2 (n_conv_cbpf_c112_2 conv_bpf_c112_2) inductor l=1.000000000000e-06
RCONVBPF_c112_2 (conv_bpf_c112_2 0) resistor r=2.356194490192e+02
ECONVI_c112_2_00 (conv_i_src_c112_2_00 0 conv_bpf_c112_2 0) vcvs gain=9.807852804032e-01
SCONVI_c112_2_00 (conv_i_src_c112_2_00 conv_i_c112_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_00 (conv_q_src_c112_2_00 0 conv_bpf_c112_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_2_00 (conv_q_src_c112_2_00 conv_q_c112_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_01 (conv_i_src_c112_2_01 0 conv_bpf_c112_2 0) vcvs gain=8.314696123025e-01
SCONVI_c112_2_01 (conv_i_src_c112_2_01 conv_i_c112_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_01 (conv_q_src_c112_2_01 0 conv_bpf_c112_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_2_01 (conv_q_src_c112_2_01 conv_q_c112_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_02 (conv_i_src_c112_2_02 0 conv_bpf_c112_2 0) vcvs gain=5.555702330196e-01
SCONVI_c112_2_02 (conv_i_src_c112_2_02 conv_i_c112_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_02 (conv_q_src_c112_2_02 0 conv_bpf_c112_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_2_02 (conv_q_src_c112_2_02 conv_q_c112_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_03 (conv_i_src_c112_2_03 0 conv_bpf_c112_2 0) vcvs gain=1.950903220161e-01
SCONVI_c112_2_03 (conv_i_src_c112_2_03 conv_i_c112_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_03 (conv_q_src_c112_2_03 0 conv_bpf_c112_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_2_03 (conv_q_src_c112_2_03 conv_q_c112_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_04 (conv_i_src_c112_2_04 0 conv_bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_2_04 (conv_i_src_c112_2_04 conv_i_c112_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_04 (conv_q_src_c112_2_04 0 conv_bpf_c112_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_2_04 (conv_q_src_c112_2_04 conv_q_c112_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_05 (conv_i_src_c112_2_05 0 conv_bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_2_05 (conv_i_src_c112_2_05 conv_i_c112_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_05 (conv_q_src_c112_2_05 0 conv_bpf_c112_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_2_05 (conv_q_src_c112_2_05 conv_q_c112_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_06 (conv_i_src_c112_2_06 0 conv_bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_2_06 (conv_i_src_c112_2_06 conv_i_c112_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_06 (conv_q_src_c112_2_06 0 conv_bpf_c112_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_2_06 (conv_q_src_c112_2_06 conv_q_c112_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_07 (conv_i_src_c112_2_07 0 conv_bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_2_07 (conv_i_src_c112_2_07 conv_i_c112_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_07 (conv_q_src_c112_2_07 0 conv_bpf_c112_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_2_07 (conv_q_src_c112_2_07 conv_q_c112_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_08 (conv_i_src_c112_2_08 0 conv_bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_2_08 (conv_i_src_c112_2_08 conv_i_c112_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_08 (conv_q_src_c112_2_08 0 conv_bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_2_08 (conv_q_src_c112_2_08 conv_q_c112_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_09 (conv_i_src_c112_2_09 0 conv_bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_2_09 (conv_i_src_c112_2_09 conv_i_c112_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_09 (conv_q_src_c112_2_09 0 conv_bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_2_09 (conv_q_src_c112_2_09 conv_q_c112_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_10 (conv_i_src_c112_2_10 0 conv_bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_2_10 (conv_i_src_c112_2_10 conv_i_c112_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_10 (conv_q_src_c112_2_10 0 conv_bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_2_10 (conv_q_src_c112_2_10 conv_q_c112_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_11 (conv_i_src_c112_2_11 0 conv_bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_2_11 (conv_i_src_c112_2_11 conv_i_c112_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_11 (conv_q_src_c112_2_11 0 conv_bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_2_11 (conv_q_src_c112_2_11 conv_q_c112_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_12 (conv_i_src_c112_2_12 0 conv_bpf_c112_2 0) vcvs gain=1.950903220161e-01
SCONVI_c112_2_12 (conv_i_src_c112_2_12 conv_i_c112_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_12 (conv_q_src_c112_2_12 0 conv_bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_2_12 (conv_q_src_c112_2_12 conv_q_c112_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_13 (conv_i_src_c112_2_13 0 conv_bpf_c112_2 0) vcvs gain=5.555702330196e-01
SCONVI_c112_2_13 (conv_i_src_c112_2_13 conv_i_c112_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_13 (conv_q_src_c112_2_13 0 conv_bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_2_13 (conv_q_src_c112_2_13 conv_q_c112_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_14 (conv_i_src_c112_2_14 0 conv_bpf_c112_2 0) vcvs gain=8.314696123025e-01
SCONVI_c112_2_14 (conv_i_src_c112_2_14 conv_i_c112_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_14 (conv_q_src_c112_2_14 0 conv_bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_2_14 (conv_q_src_c112_2_14 conv_q_c112_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_2_15 (conv_i_src_c112_2_15 0 conv_bpf_c112_2 0) vcvs gain=9.807852804032e-01
SCONVI_c112_2_15 (conv_i_src_c112_2_15 conv_i_c112_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_2_15 (conv_q_src_c112_2_15 0 conv_bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_2_15 (conv_q_src_c112_2_15 conv_q_c112_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c112_2 (conv_i_c112_2 0) resistor r=1G
RCONVQ_c112_2 (conv_q_c112_2 0) resistor r=1G
RCONVINTI_c112_2 (conv_i_c112_2 ConvIcar_c112_2) resistor r=1k
CCONVINTI_c112_2 (ConvIcar_c112_2 0) capacitor c=80p
RCONVINTQ_c112_2 (conv_q_c112_2 ConvQcar_c112_2) resistor r=1k
CCONVINTQ_c112_2 (ConvQcar_c112_2 0) capacitor c=80p
save conv_bpf_c112_2 ConvIcar_c112_2 ConvQcar_c112_2

// conventional mixed baseline bl112, carrier_3: 1000000000 Hz
CCONVBPF_c112_3 (bl112 n_conv_cbpf_c112_3) capacitor c=2.533029591058e-14
LCONVBPF_c112_3 (n_conv_cbpf_c112_3 conv_bpf_c112_3) inductor l=1.000000000000e-06
RCONVBPF_c112_3 (conv_bpf_c112_3 0) resistor r=3.141592653590e+02
ECONVI_c112_3_00 (conv_i_src_c112_3_00 0 conv_bpf_c112_3 0) vcvs gain=9.807852804032e-01
SCONVI_c112_3_00 (conv_i_src_c112_3_00 conv_i_c112_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_00 (conv_q_src_c112_3_00 0 conv_bpf_c112_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_3_00 (conv_q_src_c112_3_00 conv_q_c112_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_01 (conv_i_src_c112_3_01 0 conv_bpf_c112_3 0) vcvs gain=8.314696123025e-01
SCONVI_c112_3_01 (conv_i_src_c112_3_01 conv_i_c112_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_01 (conv_q_src_c112_3_01 0 conv_bpf_c112_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_3_01 (conv_q_src_c112_3_01 conv_q_c112_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_02 (conv_i_src_c112_3_02 0 conv_bpf_c112_3 0) vcvs gain=5.555702330196e-01
SCONVI_c112_3_02 (conv_i_src_c112_3_02 conv_i_c112_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_02 (conv_q_src_c112_3_02 0 conv_bpf_c112_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_3_02 (conv_q_src_c112_3_02 conv_q_c112_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_03 (conv_i_src_c112_3_03 0 conv_bpf_c112_3 0) vcvs gain=1.950903220161e-01
SCONVI_c112_3_03 (conv_i_src_c112_3_03 conv_i_c112_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_03 (conv_q_src_c112_3_03 0 conv_bpf_c112_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_3_03 (conv_q_src_c112_3_03 conv_q_c112_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_04 (conv_i_src_c112_3_04 0 conv_bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_3_04 (conv_i_src_c112_3_04 conv_i_c112_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_04 (conv_q_src_c112_3_04 0 conv_bpf_c112_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c112_3_04 (conv_q_src_c112_3_04 conv_q_c112_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_05 (conv_i_src_c112_3_05 0 conv_bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_3_05 (conv_i_src_c112_3_05 conv_i_c112_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_05 (conv_q_src_c112_3_05 0 conv_bpf_c112_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c112_3_05 (conv_q_src_c112_3_05 conv_q_c112_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_06 (conv_i_src_c112_3_06 0 conv_bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_3_06 (conv_i_src_c112_3_06 conv_i_c112_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_06 (conv_q_src_c112_3_06 0 conv_bpf_c112_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c112_3_06 (conv_q_src_c112_3_06 conv_q_c112_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_07 (conv_i_src_c112_3_07 0 conv_bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_3_07 (conv_i_src_c112_3_07 conv_i_c112_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_07 (conv_q_src_c112_3_07 0 conv_bpf_c112_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c112_3_07 (conv_q_src_c112_3_07 conv_q_c112_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_08 (conv_i_src_c112_3_08 0 conv_bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c112_3_08 (conv_i_src_c112_3_08 conv_i_c112_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_08 (conv_q_src_c112_3_08 0 conv_bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_3_08 (conv_q_src_c112_3_08 conv_q_c112_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_09 (conv_i_src_c112_3_09 0 conv_bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c112_3_09 (conv_i_src_c112_3_09 conv_i_c112_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_09 (conv_q_src_c112_3_09 0 conv_bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_3_09 (conv_q_src_c112_3_09 conv_q_c112_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_10 (conv_i_src_c112_3_10 0 conv_bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c112_3_10 (conv_i_src_c112_3_10 conv_i_c112_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_10 (conv_q_src_c112_3_10 0 conv_bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_3_10 (conv_q_src_c112_3_10 conv_q_c112_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_11 (conv_i_src_c112_3_11 0 conv_bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c112_3_11 (conv_i_src_c112_3_11 conv_i_c112_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_11 (conv_q_src_c112_3_11 0 conv_bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_3_11 (conv_q_src_c112_3_11 conv_q_c112_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_12 (conv_i_src_c112_3_12 0 conv_bpf_c112_3 0) vcvs gain=1.950903220161e-01
SCONVI_c112_3_12 (conv_i_src_c112_3_12 conv_i_c112_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_12 (conv_q_src_c112_3_12 0 conv_bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c112_3_12 (conv_q_src_c112_3_12 conv_q_c112_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_13 (conv_i_src_c112_3_13 0 conv_bpf_c112_3 0) vcvs gain=5.555702330196e-01
SCONVI_c112_3_13 (conv_i_src_c112_3_13 conv_i_c112_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_13 (conv_q_src_c112_3_13 0 conv_bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c112_3_13 (conv_q_src_c112_3_13 conv_q_c112_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_14 (conv_i_src_c112_3_14 0 conv_bpf_c112_3 0) vcvs gain=8.314696123025e-01
SCONVI_c112_3_14 (conv_i_src_c112_3_14 conv_i_c112_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_14 (conv_q_src_c112_3_14 0 conv_bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c112_3_14 (conv_q_src_c112_3_14 conv_q_c112_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c112_3_15 (conv_i_src_c112_3_15 0 conv_bpf_c112_3 0) vcvs gain=9.807852804032e-01
SCONVI_c112_3_15 (conv_i_src_c112_3_15 conv_i_c112_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c112_3_15 (conv_q_src_c112_3_15 0 conv_bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c112_3_15 (conv_q_src_c112_3_15 conv_q_c112_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c112_3 (conv_i_c112_3 0) resistor r=1G
RCONVQ_c112_3 (conv_q_c112_3 0) resistor r=1G
RCONVINTI_c112_3 (conv_i_c112_3 ConvIcar_c112_3) resistor r=1k
CCONVINTI_c112_3 (ConvIcar_c112_3 0) capacitor c=80p
RCONVINTQ_c112_3 (conv_q_c112_3 ConvQcar_c112_3) resistor r=1k
CCONVINTQ_c112_3 (ConvQcar_c112_3 0) capacitor c=80p
save conv_bpf_c112_3 ConvIcar_c112_3 ConvQcar_c112_3

// conventional mixed baseline bl113, carrier_0: 250000000 Hz
CCONVBPF_c113_0 (bl113 n_conv_cbpf_c113_0) capacitor c=4.052847345694e-13
LCONVBPF_c113_0 (n_conv_cbpf_c113_0 conv_bpf_c113_0) inductor l=1.000000000000e-06
RCONVBPF_c113_0 (conv_bpf_c113_0 0) resistor r=7.853981633974e+01
ECONVI_c113_0_00 (conv_i_src_c113_0_00 0 conv_bpf_c113_0 0) vcvs gain=9.807852804032e-01
SCONVI_c113_0_00 (conv_i_src_c113_0_00 conv_i_c113_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_00 (conv_q_src_c113_0_00 0 conv_bpf_c113_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_0_00 (conv_q_src_c113_0_00 conv_q_c113_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_01 (conv_i_src_c113_0_01 0 conv_bpf_c113_0 0) vcvs gain=8.314696123025e-01
SCONVI_c113_0_01 (conv_i_src_c113_0_01 conv_i_c113_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_01 (conv_q_src_c113_0_01 0 conv_bpf_c113_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_0_01 (conv_q_src_c113_0_01 conv_q_c113_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_02 (conv_i_src_c113_0_02 0 conv_bpf_c113_0 0) vcvs gain=5.555702330196e-01
SCONVI_c113_0_02 (conv_i_src_c113_0_02 conv_i_c113_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_02 (conv_q_src_c113_0_02 0 conv_bpf_c113_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_0_02 (conv_q_src_c113_0_02 conv_q_c113_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_03 (conv_i_src_c113_0_03 0 conv_bpf_c113_0 0) vcvs gain=1.950903220161e-01
SCONVI_c113_0_03 (conv_i_src_c113_0_03 conv_i_c113_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_03 (conv_q_src_c113_0_03 0 conv_bpf_c113_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_0_03 (conv_q_src_c113_0_03 conv_q_c113_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_04 (conv_i_src_c113_0_04 0 conv_bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_0_04 (conv_i_src_c113_0_04 conv_i_c113_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_04 (conv_q_src_c113_0_04 0 conv_bpf_c113_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_0_04 (conv_q_src_c113_0_04 conv_q_c113_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_05 (conv_i_src_c113_0_05 0 conv_bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_0_05 (conv_i_src_c113_0_05 conv_i_c113_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_05 (conv_q_src_c113_0_05 0 conv_bpf_c113_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_0_05 (conv_q_src_c113_0_05 conv_q_c113_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_06 (conv_i_src_c113_0_06 0 conv_bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_0_06 (conv_i_src_c113_0_06 conv_i_c113_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_06 (conv_q_src_c113_0_06 0 conv_bpf_c113_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_0_06 (conv_q_src_c113_0_06 conv_q_c113_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_07 (conv_i_src_c113_0_07 0 conv_bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_0_07 (conv_i_src_c113_0_07 conv_i_c113_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_07 (conv_q_src_c113_0_07 0 conv_bpf_c113_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_0_07 (conv_q_src_c113_0_07 conv_q_c113_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_08 (conv_i_src_c113_0_08 0 conv_bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_0_08 (conv_i_src_c113_0_08 conv_i_c113_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_08 (conv_q_src_c113_0_08 0 conv_bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_0_08 (conv_q_src_c113_0_08 conv_q_c113_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_09 (conv_i_src_c113_0_09 0 conv_bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_0_09 (conv_i_src_c113_0_09 conv_i_c113_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_09 (conv_q_src_c113_0_09 0 conv_bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_0_09 (conv_q_src_c113_0_09 conv_q_c113_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_10 (conv_i_src_c113_0_10 0 conv_bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_0_10 (conv_i_src_c113_0_10 conv_i_c113_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_10 (conv_q_src_c113_0_10 0 conv_bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_0_10 (conv_q_src_c113_0_10 conv_q_c113_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_11 (conv_i_src_c113_0_11 0 conv_bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_0_11 (conv_i_src_c113_0_11 conv_i_c113_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_11 (conv_q_src_c113_0_11 0 conv_bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_0_11 (conv_q_src_c113_0_11 conv_q_c113_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_12 (conv_i_src_c113_0_12 0 conv_bpf_c113_0 0) vcvs gain=1.950903220161e-01
SCONVI_c113_0_12 (conv_i_src_c113_0_12 conv_i_c113_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_12 (conv_q_src_c113_0_12 0 conv_bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_0_12 (conv_q_src_c113_0_12 conv_q_c113_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_13 (conv_i_src_c113_0_13 0 conv_bpf_c113_0 0) vcvs gain=5.555702330196e-01
SCONVI_c113_0_13 (conv_i_src_c113_0_13 conv_i_c113_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_13 (conv_q_src_c113_0_13 0 conv_bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_0_13 (conv_q_src_c113_0_13 conv_q_c113_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_14 (conv_i_src_c113_0_14 0 conv_bpf_c113_0 0) vcvs gain=8.314696123025e-01
SCONVI_c113_0_14 (conv_i_src_c113_0_14 conv_i_c113_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_14 (conv_q_src_c113_0_14 0 conv_bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_0_14 (conv_q_src_c113_0_14 conv_q_c113_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_0_15 (conv_i_src_c113_0_15 0 conv_bpf_c113_0 0) vcvs gain=9.807852804032e-01
SCONVI_c113_0_15 (conv_i_src_c113_0_15 conv_i_c113_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_0_15 (conv_q_src_c113_0_15 0 conv_bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_0_15 (conv_q_src_c113_0_15 conv_q_c113_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c113_0 (conv_i_c113_0 0) resistor r=1G
RCONVQ_c113_0 (conv_q_c113_0 0) resistor r=1G
RCONVINTI_c113_0 (conv_i_c113_0 ConvIcar_c113_0) resistor r=1k
CCONVINTI_c113_0 (ConvIcar_c113_0 0) capacitor c=80p
RCONVINTQ_c113_0 (conv_q_c113_0 ConvQcar_c113_0) resistor r=1k
CCONVINTQ_c113_0 (ConvQcar_c113_0 0) capacitor c=80p
save conv_bpf_c113_0 ConvIcar_c113_0 ConvQcar_c113_0

// conventional mixed baseline bl113, carrier_1: 500000000 Hz
CCONVBPF_c113_1 (bl113 n_conv_cbpf_c113_1) capacitor c=1.013211836423e-13
LCONVBPF_c113_1 (n_conv_cbpf_c113_1 conv_bpf_c113_1) inductor l=1.000000000000e-06
RCONVBPF_c113_1 (conv_bpf_c113_1 0) resistor r=1.570796326795e+02
ECONVI_c113_1_00 (conv_i_src_c113_1_00 0 conv_bpf_c113_1 0) vcvs gain=9.807852804032e-01
SCONVI_c113_1_00 (conv_i_src_c113_1_00 conv_i_c113_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_00 (conv_q_src_c113_1_00 0 conv_bpf_c113_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_1_00 (conv_q_src_c113_1_00 conv_q_c113_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_01 (conv_i_src_c113_1_01 0 conv_bpf_c113_1 0) vcvs gain=8.314696123025e-01
SCONVI_c113_1_01 (conv_i_src_c113_1_01 conv_i_c113_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_01 (conv_q_src_c113_1_01 0 conv_bpf_c113_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_1_01 (conv_q_src_c113_1_01 conv_q_c113_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_02 (conv_i_src_c113_1_02 0 conv_bpf_c113_1 0) vcvs gain=5.555702330196e-01
SCONVI_c113_1_02 (conv_i_src_c113_1_02 conv_i_c113_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_02 (conv_q_src_c113_1_02 0 conv_bpf_c113_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_1_02 (conv_q_src_c113_1_02 conv_q_c113_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_03 (conv_i_src_c113_1_03 0 conv_bpf_c113_1 0) vcvs gain=1.950903220161e-01
SCONVI_c113_1_03 (conv_i_src_c113_1_03 conv_i_c113_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_03 (conv_q_src_c113_1_03 0 conv_bpf_c113_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_1_03 (conv_q_src_c113_1_03 conv_q_c113_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_04 (conv_i_src_c113_1_04 0 conv_bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_1_04 (conv_i_src_c113_1_04 conv_i_c113_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_04 (conv_q_src_c113_1_04 0 conv_bpf_c113_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_1_04 (conv_q_src_c113_1_04 conv_q_c113_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_05 (conv_i_src_c113_1_05 0 conv_bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_1_05 (conv_i_src_c113_1_05 conv_i_c113_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_05 (conv_q_src_c113_1_05 0 conv_bpf_c113_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_1_05 (conv_q_src_c113_1_05 conv_q_c113_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_06 (conv_i_src_c113_1_06 0 conv_bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_1_06 (conv_i_src_c113_1_06 conv_i_c113_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_06 (conv_q_src_c113_1_06 0 conv_bpf_c113_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_1_06 (conv_q_src_c113_1_06 conv_q_c113_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_07 (conv_i_src_c113_1_07 0 conv_bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_1_07 (conv_i_src_c113_1_07 conv_i_c113_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_07 (conv_q_src_c113_1_07 0 conv_bpf_c113_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_1_07 (conv_q_src_c113_1_07 conv_q_c113_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_08 (conv_i_src_c113_1_08 0 conv_bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_1_08 (conv_i_src_c113_1_08 conv_i_c113_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_08 (conv_q_src_c113_1_08 0 conv_bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_1_08 (conv_q_src_c113_1_08 conv_q_c113_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_09 (conv_i_src_c113_1_09 0 conv_bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_1_09 (conv_i_src_c113_1_09 conv_i_c113_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_09 (conv_q_src_c113_1_09 0 conv_bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_1_09 (conv_q_src_c113_1_09 conv_q_c113_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_10 (conv_i_src_c113_1_10 0 conv_bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_1_10 (conv_i_src_c113_1_10 conv_i_c113_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_10 (conv_q_src_c113_1_10 0 conv_bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_1_10 (conv_q_src_c113_1_10 conv_q_c113_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_11 (conv_i_src_c113_1_11 0 conv_bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_1_11 (conv_i_src_c113_1_11 conv_i_c113_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_11 (conv_q_src_c113_1_11 0 conv_bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_1_11 (conv_q_src_c113_1_11 conv_q_c113_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_12 (conv_i_src_c113_1_12 0 conv_bpf_c113_1 0) vcvs gain=1.950903220161e-01
SCONVI_c113_1_12 (conv_i_src_c113_1_12 conv_i_c113_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_12 (conv_q_src_c113_1_12 0 conv_bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_1_12 (conv_q_src_c113_1_12 conv_q_c113_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_13 (conv_i_src_c113_1_13 0 conv_bpf_c113_1 0) vcvs gain=5.555702330196e-01
SCONVI_c113_1_13 (conv_i_src_c113_1_13 conv_i_c113_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_13 (conv_q_src_c113_1_13 0 conv_bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_1_13 (conv_q_src_c113_1_13 conv_q_c113_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_14 (conv_i_src_c113_1_14 0 conv_bpf_c113_1 0) vcvs gain=8.314696123025e-01
SCONVI_c113_1_14 (conv_i_src_c113_1_14 conv_i_c113_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_14 (conv_q_src_c113_1_14 0 conv_bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_1_14 (conv_q_src_c113_1_14 conv_q_c113_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_1_15 (conv_i_src_c113_1_15 0 conv_bpf_c113_1 0) vcvs gain=9.807852804032e-01
SCONVI_c113_1_15 (conv_i_src_c113_1_15 conv_i_c113_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_1_15 (conv_q_src_c113_1_15 0 conv_bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_1_15 (conv_q_src_c113_1_15 conv_q_c113_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c113_1 (conv_i_c113_1 0) resistor r=1G
RCONVQ_c113_1 (conv_q_c113_1 0) resistor r=1G
RCONVINTI_c113_1 (conv_i_c113_1 ConvIcar_c113_1) resistor r=1k
CCONVINTI_c113_1 (ConvIcar_c113_1 0) capacitor c=80p
RCONVINTQ_c113_1 (conv_q_c113_1 ConvQcar_c113_1) resistor r=1k
CCONVINTQ_c113_1 (ConvQcar_c113_1 0) capacitor c=80p
save conv_bpf_c113_1 ConvIcar_c113_1 ConvQcar_c113_1

// conventional mixed baseline bl113, carrier_2: 750000000 Hz
CCONVBPF_c113_2 (bl113 n_conv_cbpf_c113_2) capacitor c=4.503163717437e-14
LCONVBPF_c113_2 (n_conv_cbpf_c113_2 conv_bpf_c113_2) inductor l=1.000000000000e-06
RCONVBPF_c113_2 (conv_bpf_c113_2 0) resistor r=2.356194490192e+02
ECONVI_c113_2_00 (conv_i_src_c113_2_00 0 conv_bpf_c113_2 0) vcvs gain=9.807852804032e-01
SCONVI_c113_2_00 (conv_i_src_c113_2_00 conv_i_c113_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_00 (conv_q_src_c113_2_00 0 conv_bpf_c113_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_2_00 (conv_q_src_c113_2_00 conv_q_c113_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_01 (conv_i_src_c113_2_01 0 conv_bpf_c113_2 0) vcvs gain=8.314696123025e-01
SCONVI_c113_2_01 (conv_i_src_c113_2_01 conv_i_c113_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_01 (conv_q_src_c113_2_01 0 conv_bpf_c113_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_2_01 (conv_q_src_c113_2_01 conv_q_c113_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_02 (conv_i_src_c113_2_02 0 conv_bpf_c113_2 0) vcvs gain=5.555702330196e-01
SCONVI_c113_2_02 (conv_i_src_c113_2_02 conv_i_c113_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_02 (conv_q_src_c113_2_02 0 conv_bpf_c113_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_2_02 (conv_q_src_c113_2_02 conv_q_c113_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_03 (conv_i_src_c113_2_03 0 conv_bpf_c113_2 0) vcvs gain=1.950903220161e-01
SCONVI_c113_2_03 (conv_i_src_c113_2_03 conv_i_c113_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_03 (conv_q_src_c113_2_03 0 conv_bpf_c113_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_2_03 (conv_q_src_c113_2_03 conv_q_c113_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_04 (conv_i_src_c113_2_04 0 conv_bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_2_04 (conv_i_src_c113_2_04 conv_i_c113_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_04 (conv_q_src_c113_2_04 0 conv_bpf_c113_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_2_04 (conv_q_src_c113_2_04 conv_q_c113_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_05 (conv_i_src_c113_2_05 0 conv_bpf_c113_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_2_05 (conv_i_src_c113_2_05 conv_i_c113_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_05 (conv_q_src_c113_2_05 0 conv_bpf_c113_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_2_05 (conv_q_src_c113_2_05 conv_q_c113_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_06 (conv_i_src_c113_2_06 0 conv_bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_2_06 (conv_i_src_c113_2_06 conv_i_c113_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_06 (conv_q_src_c113_2_06 0 conv_bpf_c113_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_2_06 (conv_q_src_c113_2_06 conv_q_c113_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_07 (conv_i_src_c113_2_07 0 conv_bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_2_07 (conv_i_src_c113_2_07 conv_i_c113_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_07 (conv_q_src_c113_2_07 0 conv_bpf_c113_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_2_07 (conv_q_src_c113_2_07 conv_q_c113_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_08 (conv_i_src_c113_2_08 0 conv_bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_2_08 (conv_i_src_c113_2_08 conv_i_c113_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_08 (conv_q_src_c113_2_08 0 conv_bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_2_08 (conv_q_src_c113_2_08 conv_q_c113_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_09 (conv_i_src_c113_2_09 0 conv_bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_2_09 (conv_i_src_c113_2_09 conv_i_c113_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_09 (conv_q_src_c113_2_09 0 conv_bpf_c113_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_2_09 (conv_q_src_c113_2_09 conv_q_c113_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_10 (conv_i_src_c113_2_10 0 conv_bpf_c113_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_2_10 (conv_i_src_c113_2_10 conv_i_c113_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_10 (conv_q_src_c113_2_10 0 conv_bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_2_10 (conv_q_src_c113_2_10 conv_q_c113_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_11 (conv_i_src_c113_2_11 0 conv_bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_2_11 (conv_i_src_c113_2_11 conv_i_c113_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_11 (conv_q_src_c113_2_11 0 conv_bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_2_11 (conv_q_src_c113_2_11 conv_q_c113_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_12 (conv_i_src_c113_2_12 0 conv_bpf_c113_2 0) vcvs gain=1.950903220161e-01
SCONVI_c113_2_12 (conv_i_src_c113_2_12 conv_i_c113_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_12 (conv_q_src_c113_2_12 0 conv_bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_2_12 (conv_q_src_c113_2_12 conv_q_c113_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_13 (conv_i_src_c113_2_13 0 conv_bpf_c113_2 0) vcvs gain=5.555702330196e-01
SCONVI_c113_2_13 (conv_i_src_c113_2_13 conv_i_c113_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_13 (conv_q_src_c113_2_13 0 conv_bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_2_13 (conv_q_src_c113_2_13 conv_q_c113_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_14 (conv_i_src_c113_2_14 0 conv_bpf_c113_2 0) vcvs gain=8.314696123025e-01
SCONVI_c113_2_14 (conv_i_src_c113_2_14 conv_i_c113_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_14 (conv_q_src_c113_2_14 0 conv_bpf_c113_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_2_14 (conv_q_src_c113_2_14 conv_q_c113_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_2_15 (conv_i_src_c113_2_15 0 conv_bpf_c113_2 0) vcvs gain=9.807852804032e-01
SCONVI_c113_2_15 (conv_i_src_c113_2_15 conv_i_c113_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_2_15 (conv_q_src_c113_2_15 0 conv_bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_2_15 (conv_q_src_c113_2_15 conv_q_c113_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c113_2 (conv_i_c113_2 0) resistor r=1G
RCONVQ_c113_2 (conv_q_c113_2 0) resistor r=1G
RCONVINTI_c113_2 (conv_i_c113_2 ConvIcar_c113_2) resistor r=1k
CCONVINTI_c113_2 (ConvIcar_c113_2 0) capacitor c=80p
RCONVINTQ_c113_2 (conv_q_c113_2 ConvQcar_c113_2) resistor r=1k
CCONVINTQ_c113_2 (ConvQcar_c113_2 0) capacitor c=80p
save conv_bpf_c113_2 ConvIcar_c113_2 ConvQcar_c113_2

// conventional mixed baseline bl113, carrier_3: 1000000000 Hz
CCONVBPF_c113_3 (bl113 n_conv_cbpf_c113_3) capacitor c=2.533029591058e-14
LCONVBPF_c113_3 (n_conv_cbpf_c113_3 conv_bpf_c113_3) inductor l=1.000000000000e-06
RCONVBPF_c113_3 (conv_bpf_c113_3 0) resistor r=3.141592653590e+02
ECONVI_c113_3_00 (conv_i_src_c113_3_00 0 conv_bpf_c113_3 0) vcvs gain=9.807852804032e-01
SCONVI_c113_3_00 (conv_i_src_c113_3_00 conv_i_c113_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_00 (conv_q_src_c113_3_00 0 conv_bpf_c113_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_3_00 (conv_q_src_c113_3_00 conv_q_c113_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_01 (conv_i_src_c113_3_01 0 conv_bpf_c113_3 0) vcvs gain=8.314696123025e-01
SCONVI_c113_3_01 (conv_i_src_c113_3_01 conv_i_c113_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_01 (conv_q_src_c113_3_01 0 conv_bpf_c113_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_3_01 (conv_q_src_c113_3_01 conv_q_c113_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_02 (conv_i_src_c113_3_02 0 conv_bpf_c113_3 0) vcvs gain=5.555702330196e-01
SCONVI_c113_3_02 (conv_i_src_c113_3_02 conv_i_c113_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_02 (conv_q_src_c113_3_02 0 conv_bpf_c113_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_3_02 (conv_q_src_c113_3_02 conv_q_c113_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_03 (conv_i_src_c113_3_03 0 conv_bpf_c113_3 0) vcvs gain=1.950903220161e-01
SCONVI_c113_3_03 (conv_i_src_c113_3_03 conv_i_c113_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_03 (conv_q_src_c113_3_03 0 conv_bpf_c113_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_3_03 (conv_q_src_c113_3_03 conv_q_c113_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_04 (conv_i_src_c113_3_04 0 conv_bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_3_04 (conv_i_src_c113_3_04 conv_i_c113_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_04 (conv_q_src_c113_3_04 0 conv_bpf_c113_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c113_3_04 (conv_q_src_c113_3_04 conv_q_c113_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_05 (conv_i_src_c113_3_05 0 conv_bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_3_05 (conv_i_src_c113_3_05 conv_i_c113_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_05 (conv_q_src_c113_3_05 0 conv_bpf_c113_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c113_3_05 (conv_q_src_c113_3_05 conv_q_c113_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_06 (conv_i_src_c113_3_06 0 conv_bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_3_06 (conv_i_src_c113_3_06 conv_i_c113_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_06 (conv_q_src_c113_3_06 0 conv_bpf_c113_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c113_3_06 (conv_q_src_c113_3_06 conv_q_c113_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_07 (conv_i_src_c113_3_07 0 conv_bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_3_07 (conv_i_src_c113_3_07 conv_i_c113_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_07 (conv_q_src_c113_3_07 0 conv_bpf_c113_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c113_3_07 (conv_q_src_c113_3_07 conv_q_c113_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_08 (conv_i_src_c113_3_08 0 conv_bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c113_3_08 (conv_i_src_c113_3_08 conv_i_c113_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_08 (conv_q_src_c113_3_08 0 conv_bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_3_08 (conv_q_src_c113_3_08 conv_q_c113_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_09 (conv_i_src_c113_3_09 0 conv_bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c113_3_09 (conv_i_src_c113_3_09 conv_i_c113_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_09 (conv_q_src_c113_3_09 0 conv_bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_3_09 (conv_q_src_c113_3_09 conv_q_c113_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_10 (conv_i_src_c113_3_10 0 conv_bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c113_3_10 (conv_i_src_c113_3_10 conv_i_c113_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_10 (conv_q_src_c113_3_10 0 conv_bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_3_10 (conv_q_src_c113_3_10 conv_q_c113_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_11 (conv_i_src_c113_3_11 0 conv_bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c113_3_11 (conv_i_src_c113_3_11 conv_i_c113_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_11 (conv_q_src_c113_3_11 0 conv_bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_3_11 (conv_q_src_c113_3_11 conv_q_c113_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_12 (conv_i_src_c113_3_12 0 conv_bpf_c113_3 0) vcvs gain=1.950903220161e-01
SCONVI_c113_3_12 (conv_i_src_c113_3_12 conv_i_c113_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_12 (conv_q_src_c113_3_12 0 conv_bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c113_3_12 (conv_q_src_c113_3_12 conv_q_c113_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_13 (conv_i_src_c113_3_13 0 conv_bpf_c113_3 0) vcvs gain=5.555702330196e-01
SCONVI_c113_3_13 (conv_i_src_c113_3_13 conv_i_c113_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_13 (conv_q_src_c113_3_13 0 conv_bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c113_3_13 (conv_q_src_c113_3_13 conv_q_c113_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_14 (conv_i_src_c113_3_14 0 conv_bpf_c113_3 0) vcvs gain=8.314696123025e-01
SCONVI_c113_3_14 (conv_i_src_c113_3_14 conv_i_c113_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_14 (conv_q_src_c113_3_14 0 conv_bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c113_3_14 (conv_q_src_c113_3_14 conv_q_c113_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c113_3_15 (conv_i_src_c113_3_15 0 conv_bpf_c113_3 0) vcvs gain=9.807852804032e-01
SCONVI_c113_3_15 (conv_i_src_c113_3_15 conv_i_c113_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c113_3_15 (conv_q_src_c113_3_15 0 conv_bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c113_3_15 (conv_q_src_c113_3_15 conv_q_c113_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c113_3 (conv_i_c113_3 0) resistor r=1G
RCONVQ_c113_3 (conv_q_c113_3 0) resistor r=1G
RCONVINTI_c113_3 (conv_i_c113_3 ConvIcar_c113_3) resistor r=1k
CCONVINTI_c113_3 (ConvIcar_c113_3 0) capacitor c=80p
RCONVINTQ_c113_3 (conv_q_c113_3 ConvQcar_c113_3) resistor r=1k
CCONVINTQ_c113_3 (ConvQcar_c113_3 0) capacitor c=80p
save conv_bpf_c113_3 ConvIcar_c113_3 ConvQcar_c113_3

// conventional mixed baseline bl114, carrier_0: 250000000 Hz
CCONVBPF_c114_0 (bl114 n_conv_cbpf_c114_0) capacitor c=4.052847345694e-13
LCONVBPF_c114_0 (n_conv_cbpf_c114_0 conv_bpf_c114_0) inductor l=1.000000000000e-06
RCONVBPF_c114_0 (conv_bpf_c114_0 0) resistor r=7.853981633974e+01
ECONVI_c114_0_00 (conv_i_src_c114_0_00 0 conv_bpf_c114_0 0) vcvs gain=9.807852804032e-01
SCONVI_c114_0_00 (conv_i_src_c114_0_00 conv_i_c114_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_00 (conv_q_src_c114_0_00 0 conv_bpf_c114_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_0_00 (conv_q_src_c114_0_00 conv_q_c114_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_01 (conv_i_src_c114_0_01 0 conv_bpf_c114_0 0) vcvs gain=8.314696123025e-01
SCONVI_c114_0_01 (conv_i_src_c114_0_01 conv_i_c114_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_01 (conv_q_src_c114_0_01 0 conv_bpf_c114_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_0_01 (conv_q_src_c114_0_01 conv_q_c114_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_02 (conv_i_src_c114_0_02 0 conv_bpf_c114_0 0) vcvs gain=5.555702330196e-01
SCONVI_c114_0_02 (conv_i_src_c114_0_02 conv_i_c114_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_02 (conv_q_src_c114_0_02 0 conv_bpf_c114_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_0_02 (conv_q_src_c114_0_02 conv_q_c114_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_03 (conv_i_src_c114_0_03 0 conv_bpf_c114_0 0) vcvs gain=1.950903220161e-01
SCONVI_c114_0_03 (conv_i_src_c114_0_03 conv_i_c114_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_03 (conv_q_src_c114_0_03 0 conv_bpf_c114_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_0_03 (conv_q_src_c114_0_03 conv_q_c114_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_04 (conv_i_src_c114_0_04 0 conv_bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_0_04 (conv_i_src_c114_0_04 conv_i_c114_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_04 (conv_q_src_c114_0_04 0 conv_bpf_c114_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_0_04 (conv_q_src_c114_0_04 conv_q_c114_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_05 (conv_i_src_c114_0_05 0 conv_bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_0_05 (conv_i_src_c114_0_05 conv_i_c114_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_05 (conv_q_src_c114_0_05 0 conv_bpf_c114_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_0_05 (conv_q_src_c114_0_05 conv_q_c114_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_06 (conv_i_src_c114_0_06 0 conv_bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_0_06 (conv_i_src_c114_0_06 conv_i_c114_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_06 (conv_q_src_c114_0_06 0 conv_bpf_c114_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_0_06 (conv_q_src_c114_0_06 conv_q_c114_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_07 (conv_i_src_c114_0_07 0 conv_bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_0_07 (conv_i_src_c114_0_07 conv_i_c114_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_07 (conv_q_src_c114_0_07 0 conv_bpf_c114_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_0_07 (conv_q_src_c114_0_07 conv_q_c114_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_08 (conv_i_src_c114_0_08 0 conv_bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_0_08 (conv_i_src_c114_0_08 conv_i_c114_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_08 (conv_q_src_c114_0_08 0 conv_bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_0_08 (conv_q_src_c114_0_08 conv_q_c114_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_09 (conv_i_src_c114_0_09 0 conv_bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_0_09 (conv_i_src_c114_0_09 conv_i_c114_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_09 (conv_q_src_c114_0_09 0 conv_bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_0_09 (conv_q_src_c114_0_09 conv_q_c114_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_10 (conv_i_src_c114_0_10 0 conv_bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_0_10 (conv_i_src_c114_0_10 conv_i_c114_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_10 (conv_q_src_c114_0_10 0 conv_bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_0_10 (conv_q_src_c114_0_10 conv_q_c114_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_11 (conv_i_src_c114_0_11 0 conv_bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_0_11 (conv_i_src_c114_0_11 conv_i_c114_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_11 (conv_q_src_c114_0_11 0 conv_bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_0_11 (conv_q_src_c114_0_11 conv_q_c114_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_12 (conv_i_src_c114_0_12 0 conv_bpf_c114_0 0) vcvs gain=1.950903220161e-01
SCONVI_c114_0_12 (conv_i_src_c114_0_12 conv_i_c114_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_12 (conv_q_src_c114_0_12 0 conv_bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_0_12 (conv_q_src_c114_0_12 conv_q_c114_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_13 (conv_i_src_c114_0_13 0 conv_bpf_c114_0 0) vcvs gain=5.555702330196e-01
SCONVI_c114_0_13 (conv_i_src_c114_0_13 conv_i_c114_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_13 (conv_q_src_c114_0_13 0 conv_bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_0_13 (conv_q_src_c114_0_13 conv_q_c114_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_14 (conv_i_src_c114_0_14 0 conv_bpf_c114_0 0) vcvs gain=8.314696123025e-01
SCONVI_c114_0_14 (conv_i_src_c114_0_14 conv_i_c114_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_14 (conv_q_src_c114_0_14 0 conv_bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_0_14 (conv_q_src_c114_0_14 conv_q_c114_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_0_15 (conv_i_src_c114_0_15 0 conv_bpf_c114_0 0) vcvs gain=9.807852804032e-01
SCONVI_c114_0_15 (conv_i_src_c114_0_15 conv_i_c114_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_0_15 (conv_q_src_c114_0_15 0 conv_bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_0_15 (conv_q_src_c114_0_15 conv_q_c114_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c114_0 (conv_i_c114_0 0) resistor r=1G
RCONVQ_c114_0 (conv_q_c114_0 0) resistor r=1G
RCONVINTI_c114_0 (conv_i_c114_0 ConvIcar_c114_0) resistor r=1k
CCONVINTI_c114_0 (ConvIcar_c114_0 0) capacitor c=80p
RCONVINTQ_c114_0 (conv_q_c114_0 ConvQcar_c114_0) resistor r=1k
CCONVINTQ_c114_0 (ConvQcar_c114_0 0) capacitor c=80p
save conv_bpf_c114_0 ConvIcar_c114_0 ConvQcar_c114_0

// conventional mixed baseline bl114, carrier_1: 500000000 Hz
CCONVBPF_c114_1 (bl114 n_conv_cbpf_c114_1) capacitor c=1.013211836423e-13
LCONVBPF_c114_1 (n_conv_cbpf_c114_1 conv_bpf_c114_1) inductor l=1.000000000000e-06
RCONVBPF_c114_1 (conv_bpf_c114_1 0) resistor r=1.570796326795e+02
ECONVI_c114_1_00 (conv_i_src_c114_1_00 0 conv_bpf_c114_1 0) vcvs gain=9.807852804032e-01
SCONVI_c114_1_00 (conv_i_src_c114_1_00 conv_i_c114_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_00 (conv_q_src_c114_1_00 0 conv_bpf_c114_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_1_00 (conv_q_src_c114_1_00 conv_q_c114_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_01 (conv_i_src_c114_1_01 0 conv_bpf_c114_1 0) vcvs gain=8.314696123025e-01
SCONVI_c114_1_01 (conv_i_src_c114_1_01 conv_i_c114_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_01 (conv_q_src_c114_1_01 0 conv_bpf_c114_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_1_01 (conv_q_src_c114_1_01 conv_q_c114_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_02 (conv_i_src_c114_1_02 0 conv_bpf_c114_1 0) vcvs gain=5.555702330196e-01
SCONVI_c114_1_02 (conv_i_src_c114_1_02 conv_i_c114_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_02 (conv_q_src_c114_1_02 0 conv_bpf_c114_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_1_02 (conv_q_src_c114_1_02 conv_q_c114_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_03 (conv_i_src_c114_1_03 0 conv_bpf_c114_1 0) vcvs gain=1.950903220161e-01
SCONVI_c114_1_03 (conv_i_src_c114_1_03 conv_i_c114_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_03 (conv_q_src_c114_1_03 0 conv_bpf_c114_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_1_03 (conv_q_src_c114_1_03 conv_q_c114_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_04 (conv_i_src_c114_1_04 0 conv_bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_1_04 (conv_i_src_c114_1_04 conv_i_c114_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_04 (conv_q_src_c114_1_04 0 conv_bpf_c114_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_1_04 (conv_q_src_c114_1_04 conv_q_c114_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_05 (conv_i_src_c114_1_05 0 conv_bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_1_05 (conv_i_src_c114_1_05 conv_i_c114_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_05 (conv_q_src_c114_1_05 0 conv_bpf_c114_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_1_05 (conv_q_src_c114_1_05 conv_q_c114_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_06 (conv_i_src_c114_1_06 0 conv_bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_1_06 (conv_i_src_c114_1_06 conv_i_c114_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_06 (conv_q_src_c114_1_06 0 conv_bpf_c114_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_1_06 (conv_q_src_c114_1_06 conv_q_c114_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_07 (conv_i_src_c114_1_07 0 conv_bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_1_07 (conv_i_src_c114_1_07 conv_i_c114_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_07 (conv_q_src_c114_1_07 0 conv_bpf_c114_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_1_07 (conv_q_src_c114_1_07 conv_q_c114_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_08 (conv_i_src_c114_1_08 0 conv_bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_1_08 (conv_i_src_c114_1_08 conv_i_c114_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_08 (conv_q_src_c114_1_08 0 conv_bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_1_08 (conv_q_src_c114_1_08 conv_q_c114_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_09 (conv_i_src_c114_1_09 0 conv_bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_1_09 (conv_i_src_c114_1_09 conv_i_c114_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_09 (conv_q_src_c114_1_09 0 conv_bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_1_09 (conv_q_src_c114_1_09 conv_q_c114_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_10 (conv_i_src_c114_1_10 0 conv_bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_1_10 (conv_i_src_c114_1_10 conv_i_c114_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_10 (conv_q_src_c114_1_10 0 conv_bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_1_10 (conv_q_src_c114_1_10 conv_q_c114_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_11 (conv_i_src_c114_1_11 0 conv_bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_1_11 (conv_i_src_c114_1_11 conv_i_c114_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_11 (conv_q_src_c114_1_11 0 conv_bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_1_11 (conv_q_src_c114_1_11 conv_q_c114_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_12 (conv_i_src_c114_1_12 0 conv_bpf_c114_1 0) vcvs gain=1.950903220161e-01
SCONVI_c114_1_12 (conv_i_src_c114_1_12 conv_i_c114_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_12 (conv_q_src_c114_1_12 0 conv_bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_1_12 (conv_q_src_c114_1_12 conv_q_c114_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_13 (conv_i_src_c114_1_13 0 conv_bpf_c114_1 0) vcvs gain=5.555702330196e-01
SCONVI_c114_1_13 (conv_i_src_c114_1_13 conv_i_c114_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_13 (conv_q_src_c114_1_13 0 conv_bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_1_13 (conv_q_src_c114_1_13 conv_q_c114_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_14 (conv_i_src_c114_1_14 0 conv_bpf_c114_1 0) vcvs gain=8.314696123025e-01
SCONVI_c114_1_14 (conv_i_src_c114_1_14 conv_i_c114_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_14 (conv_q_src_c114_1_14 0 conv_bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_1_14 (conv_q_src_c114_1_14 conv_q_c114_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_1_15 (conv_i_src_c114_1_15 0 conv_bpf_c114_1 0) vcvs gain=9.807852804032e-01
SCONVI_c114_1_15 (conv_i_src_c114_1_15 conv_i_c114_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_1_15 (conv_q_src_c114_1_15 0 conv_bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_1_15 (conv_q_src_c114_1_15 conv_q_c114_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c114_1 (conv_i_c114_1 0) resistor r=1G
RCONVQ_c114_1 (conv_q_c114_1 0) resistor r=1G
RCONVINTI_c114_1 (conv_i_c114_1 ConvIcar_c114_1) resistor r=1k
CCONVINTI_c114_1 (ConvIcar_c114_1 0) capacitor c=80p
RCONVINTQ_c114_1 (conv_q_c114_1 ConvQcar_c114_1) resistor r=1k
CCONVINTQ_c114_1 (ConvQcar_c114_1 0) capacitor c=80p
save conv_bpf_c114_1 ConvIcar_c114_1 ConvQcar_c114_1

// conventional mixed baseline bl114, carrier_2: 750000000 Hz
CCONVBPF_c114_2 (bl114 n_conv_cbpf_c114_2) capacitor c=4.503163717437e-14
LCONVBPF_c114_2 (n_conv_cbpf_c114_2 conv_bpf_c114_2) inductor l=1.000000000000e-06
RCONVBPF_c114_2 (conv_bpf_c114_2 0) resistor r=2.356194490192e+02
ECONVI_c114_2_00 (conv_i_src_c114_2_00 0 conv_bpf_c114_2 0) vcvs gain=9.807852804032e-01
SCONVI_c114_2_00 (conv_i_src_c114_2_00 conv_i_c114_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_00 (conv_q_src_c114_2_00 0 conv_bpf_c114_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_2_00 (conv_q_src_c114_2_00 conv_q_c114_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_01 (conv_i_src_c114_2_01 0 conv_bpf_c114_2 0) vcvs gain=8.314696123025e-01
SCONVI_c114_2_01 (conv_i_src_c114_2_01 conv_i_c114_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_01 (conv_q_src_c114_2_01 0 conv_bpf_c114_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_2_01 (conv_q_src_c114_2_01 conv_q_c114_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_02 (conv_i_src_c114_2_02 0 conv_bpf_c114_2 0) vcvs gain=5.555702330196e-01
SCONVI_c114_2_02 (conv_i_src_c114_2_02 conv_i_c114_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_02 (conv_q_src_c114_2_02 0 conv_bpf_c114_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_2_02 (conv_q_src_c114_2_02 conv_q_c114_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_03 (conv_i_src_c114_2_03 0 conv_bpf_c114_2 0) vcvs gain=1.950903220161e-01
SCONVI_c114_2_03 (conv_i_src_c114_2_03 conv_i_c114_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_03 (conv_q_src_c114_2_03 0 conv_bpf_c114_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_2_03 (conv_q_src_c114_2_03 conv_q_c114_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_04 (conv_i_src_c114_2_04 0 conv_bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_2_04 (conv_i_src_c114_2_04 conv_i_c114_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_04 (conv_q_src_c114_2_04 0 conv_bpf_c114_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_2_04 (conv_q_src_c114_2_04 conv_q_c114_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_05 (conv_i_src_c114_2_05 0 conv_bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_2_05 (conv_i_src_c114_2_05 conv_i_c114_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_05 (conv_q_src_c114_2_05 0 conv_bpf_c114_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_2_05 (conv_q_src_c114_2_05 conv_q_c114_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_06 (conv_i_src_c114_2_06 0 conv_bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_2_06 (conv_i_src_c114_2_06 conv_i_c114_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_06 (conv_q_src_c114_2_06 0 conv_bpf_c114_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_2_06 (conv_q_src_c114_2_06 conv_q_c114_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_07 (conv_i_src_c114_2_07 0 conv_bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_2_07 (conv_i_src_c114_2_07 conv_i_c114_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_07 (conv_q_src_c114_2_07 0 conv_bpf_c114_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_2_07 (conv_q_src_c114_2_07 conv_q_c114_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_08 (conv_i_src_c114_2_08 0 conv_bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_2_08 (conv_i_src_c114_2_08 conv_i_c114_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_08 (conv_q_src_c114_2_08 0 conv_bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_2_08 (conv_q_src_c114_2_08 conv_q_c114_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_09 (conv_i_src_c114_2_09 0 conv_bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_2_09 (conv_i_src_c114_2_09 conv_i_c114_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_09 (conv_q_src_c114_2_09 0 conv_bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_2_09 (conv_q_src_c114_2_09 conv_q_c114_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_10 (conv_i_src_c114_2_10 0 conv_bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_2_10 (conv_i_src_c114_2_10 conv_i_c114_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_10 (conv_q_src_c114_2_10 0 conv_bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_2_10 (conv_q_src_c114_2_10 conv_q_c114_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_11 (conv_i_src_c114_2_11 0 conv_bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_2_11 (conv_i_src_c114_2_11 conv_i_c114_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_11 (conv_q_src_c114_2_11 0 conv_bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_2_11 (conv_q_src_c114_2_11 conv_q_c114_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_12 (conv_i_src_c114_2_12 0 conv_bpf_c114_2 0) vcvs gain=1.950903220161e-01
SCONVI_c114_2_12 (conv_i_src_c114_2_12 conv_i_c114_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_12 (conv_q_src_c114_2_12 0 conv_bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_2_12 (conv_q_src_c114_2_12 conv_q_c114_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_13 (conv_i_src_c114_2_13 0 conv_bpf_c114_2 0) vcvs gain=5.555702330196e-01
SCONVI_c114_2_13 (conv_i_src_c114_2_13 conv_i_c114_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_13 (conv_q_src_c114_2_13 0 conv_bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_2_13 (conv_q_src_c114_2_13 conv_q_c114_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_14 (conv_i_src_c114_2_14 0 conv_bpf_c114_2 0) vcvs gain=8.314696123025e-01
SCONVI_c114_2_14 (conv_i_src_c114_2_14 conv_i_c114_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_14 (conv_q_src_c114_2_14 0 conv_bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_2_14 (conv_q_src_c114_2_14 conv_q_c114_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_2_15 (conv_i_src_c114_2_15 0 conv_bpf_c114_2 0) vcvs gain=9.807852804032e-01
SCONVI_c114_2_15 (conv_i_src_c114_2_15 conv_i_c114_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_2_15 (conv_q_src_c114_2_15 0 conv_bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_2_15 (conv_q_src_c114_2_15 conv_q_c114_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c114_2 (conv_i_c114_2 0) resistor r=1G
RCONVQ_c114_2 (conv_q_c114_2 0) resistor r=1G
RCONVINTI_c114_2 (conv_i_c114_2 ConvIcar_c114_2) resistor r=1k
CCONVINTI_c114_2 (ConvIcar_c114_2 0) capacitor c=80p
RCONVINTQ_c114_2 (conv_q_c114_2 ConvQcar_c114_2) resistor r=1k
CCONVINTQ_c114_2 (ConvQcar_c114_2 0) capacitor c=80p
save conv_bpf_c114_2 ConvIcar_c114_2 ConvQcar_c114_2

// conventional mixed baseline bl114, carrier_3: 1000000000 Hz
CCONVBPF_c114_3 (bl114 n_conv_cbpf_c114_3) capacitor c=2.533029591058e-14
LCONVBPF_c114_3 (n_conv_cbpf_c114_3 conv_bpf_c114_3) inductor l=1.000000000000e-06
RCONVBPF_c114_3 (conv_bpf_c114_3 0) resistor r=3.141592653590e+02
ECONVI_c114_3_00 (conv_i_src_c114_3_00 0 conv_bpf_c114_3 0) vcvs gain=9.807852804032e-01
SCONVI_c114_3_00 (conv_i_src_c114_3_00 conv_i_c114_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_00 (conv_q_src_c114_3_00 0 conv_bpf_c114_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_3_00 (conv_q_src_c114_3_00 conv_q_c114_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_01 (conv_i_src_c114_3_01 0 conv_bpf_c114_3 0) vcvs gain=8.314696123025e-01
SCONVI_c114_3_01 (conv_i_src_c114_3_01 conv_i_c114_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_01 (conv_q_src_c114_3_01 0 conv_bpf_c114_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_3_01 (conv_q_src_c114_3_01 conv_q_c114_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_02 (conv_i_src_c114_3_02 0 conv_bpf_c114_3 0) vcvs gain=5.555702330196e-01
SCONVI_c114_3_02 (conv_i_src_c114_3_02 conv_i_c114_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_02 (conv_q_src_c114_3_02 0 conv_bpf_c114_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_3_02 (conv_q_src_c114_3_02 conv_q_c114_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_03 (conv_i_src_c114_3_03 0 conv_bpf_c114_3 0) vcvs gain=1.950903220161e-01
SCONVI_c114_3_03 (conv_i_src_c114_3_03 conv_i_c114_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_03 (conv_q_src_c114_3_03 0 conv_bpf_c114_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_3_03 (conv_q_src_c114_3_03 conv_q_c114_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_04 (conv_i_src_c114_3_04 0 conv_bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_3_04 (conv_i_src_c114_3_04 conv_i_c114_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_04 (conv_q_src_c114_3_04 0 conv_bpf_c114_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c114_3_04 (conv_q_src_c114_3_04 conv_q_c114_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_05 (conv_i_src_c114_3_05 0 conv_bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_3_05 (conv_i_src_c114_3_05 conv_i_c114_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_05 (conv_q_src_c114_3_05 0 conv_bpf_c114_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c114_3_05 (conv_q_src_c114_3_05 conv_q_c114_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_06 (conv_i_src_c114_3_06 0 conv_bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_3_06 (conv_i_src_c114_3_06 conv_i_c114_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_06 (conv_q_src_c114_3_06 0 conv_bpf_c114_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c114_3_06 (conv_q_src_c114_3_06 conv_q_c114_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_07 (conv_i_src_c114_3_07 0 conv_bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_3_07 (conv_i_src_c114_3_07 conv_i_c114_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_07 (conv_q_src_c114_3_07 0 conv_bpf_c114_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c114_3_07 (conv_q_src_c114_3_07 conv_q_c114_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_08 (conv_i_src_c114_3_08 0 conv_bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c114_3_08 (conv_i_src_c114_3_08 conv_i_c114_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_08 (conv_q_src_c114_3_08 0 conv_bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_3_08 (conv_q_src_c114_3_08 conv_q_c114_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_09 (conv_i_src_c114_3_09 0 conv_bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c114_3_09 (conv_i_src_c114_3_09 conv_i_c114_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_09 (conv_q_src_c114_3_09 0 conv_bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_3_09 (conv_q_src_c114_3_09 conv_q_c114_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_10 (conv_i_src_c114_3_10 0 conv_bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c114_3_10 (conv_i_src_c114_3_10 conv_i_c114_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_10 (conv_q_src_c114_3_10 0 conv_bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_3_10 (conv_q_src_c114_3_10 conv_q_c114_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_11 (conv_i_src_c114_3_11 0 conv_bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c114_3_11 (conv_i_src_c114_3_11 conv_i_c114_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_11 (conv_q_src_c114_3_11 0 conv_bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_3_11 (conv_q_src_c114_3_11 conv_q_c114_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_12 (conv_i_src_c114_3_12 0 conv_bpf_c114_3 0) vcvs gain=1.950903220161e-01
SCONVI_c114_3_12 (conv_i_src_c114_3_12 conv_i_c114_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_12 (conv_q_src_c114_3_12 0 conv_bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c114_3_12 (conv_q_src_c114_3_12 conv_q_c114_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_13 (conv_i_src_c114_3_13 0 conv_bpf_c114_3 0) vcvs gain=5.555702330196e-01
SCONVI_c114_3_13 (conv_i_src_c114_3_13 conv_i_c114_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_13 (conv_q_src_c114_3_13 0 conv_bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c114_3_13 (conv_q_src_c114_3_13 conv_q_c114_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_14 (conv_i_src_c114_3_14 0 conv_bpf_c114_3 0) vcvs gain=8.314696123025e-01
SCONVI_c114_3_14 (conv_i_src_c114_3_14 conv_i_c114_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_14 (conv_q_src_c114_3_14 0 conv_bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c114_3_14 (conv_q_src_c114_3_14 conv_q_c114_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c114_3_15 (conv_i_src_c114_3_15 0 conv_bpf_c114_3 0) vcvs gain=9.807852804032e-01
SCONVI_c114_3_15 (conv_i_src_c114_3_15 conv_i_c114_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c114_3_15 (conv_q_src_c114_3_15 0 conv_bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c114_3_15 (conv_q_src_c114_3_15 conv_q_c114_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c114_3 (conv_i_c114_3 0) resistor r=1G
RCONVQ_c114_3 (conv_q_c114_3 0) resistor r=1G
RCONVINTI_c114_3 (conv_i_c114_3 ConvIcar_c114_3) resistor r=1k
CCONVINTI_c114_3 (ConvIcar_c114_3 0) capacitor c=80p
RCONVINTQ_c114_3 (conv_q_c114_3 ConvQcar_c114_3) resistor r=1k
CCONVINTQ_c114_3 (ConvQcar_c114_3 0) capacitor c=80p
save conv_bpf_c114_3 ConvIcar_c114_3 ConvQcar_c114_3

// conventional mixed baseline bl115, carrier_0: 250000000 Hz
CCONVBPF_c115_0 (bl115 n_conv_cbpf_c115_0) capacitor c=4.052847345694e-13
LCONVBPF_c115_0 (n_conv_cbpf_c115_0 conv_bpf_c115_0) inductor l=1.000000000000e-06
RCONVBPF_c115_0 (conv_bpf_c115_0 0) resistor r=7.853981633974e+01
ECONVI_c115_0_00 (conv_i_src_c115_0_00 0 conv_bpf_c115_0 0) vcvs gain=9.807852804032e-01
SCONVI_c115_0_00 (conv_i_src_c115_0_00 conv_i_c115_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_00 (conv_q_src_c115_0_00 0 conv_bpf_c115_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_0_00 (conv_q_src_c115_0_00 conv_q_c115_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_01 (conv_i_src_c115_0_01 0 conv_bpf_c115_0 0) vcvs gain=8.314696123025e-01
SCONVI_c115_0_01 (conv_i_src_c115_0_01 conv_i_c115_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_01 (conv_q_src_c115_0_01 0 conv_bpf_c115_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_0_01 (conv_q_src_c115_0_01 conv_q_c115_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_02 (conv_i_src_c115_0_02 0 conv_bpf_c115_0 0) vcvs gain=5.555702330196e-01
SCONVI_c115_0_02 (conv_i_src_c115_0_02 conv_i_c115_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_02 (conv_q_src_c115_0_02 0 conv_bpf_c115_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_0_02 (conv_q_src_c115_0_02 conv_q_c115_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_03 (conv_i_src_c115_0_03 0 conv_bpf_c115_0 0) vcvs gain=1.950903220161e-01
SCONVI_c115_0_03 (conv_i_src_c115_0_03 conv_i_c115_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_03 (conv_q_src_c115_0_03 0 conv_bpf_c115_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_0_03 (conv_q_src_c115_0_03 conv_q_c115_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_04 (conv_i_src_c115_0_04 0 conv_bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_0_04 (conv_i_src_c115_0_04 conv_i_c115_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_04 (conv_q_src_c115_0_04 0 conv_bpf_c115_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_0_04 (conv_q_src_c115_0_04 conv_q_c115_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_05 (conv_i_src_c115_0_05 0 conv_bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_0_05 (conv_i_src_c115_0_05 conv_i_c115_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_05 (conv_q_src_c115_0_05 0 conv_bpf_c115_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_0_05 (conv_q_src_c115_0_05 conv_q_c115_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_06 (conv_i_src_c115_0_06 0 conv_bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_0_06 (conv_i_src_c115_0_06 conv_i_c115_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_06 (conv_q_src_c115_0_06 0 conv_bpf_c115_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_0_06 (conv_q_src_c115_0_06 conv_q_c115_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_07 (conv_i_src_c115_0_07 0 conv_bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_0_07 (conv_i_src_c115_0_07 conv_i_c115_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_07 (conv_q_src_c115_0_07 0 conv_bpf_c115_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_0_07 (conv_q_src_c115_0_07 conv_q_c115_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_08 (conv_i_src_c115_0_08 0 conv_bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_0_08 (conv_i_src_c115_0_08 conv_i_c115_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_08 (conv_q_src_c115_0_08 0 conv_bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_0_08 (conv_q_src_c115_0_08 conv_q_c115_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_09 (conv_i_src_c115_0_09 0 conv_bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_0_09 (conv_i_src_c115_0_09 conv_i_c115_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_09 (conv_q_src_c115_0_09 0 conv_bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_0_09 (conv_q_src_c115_0_09 conv_q_c115_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_10 (conv_i_src_c115_0_10 0 conv_bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_0_10 (conv_i_src_c115_0_10 conv_i_c115_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_10 (conv_q_src_c115_0_10 0 conv_bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_0_10 (conv_q_src_c115_0_10 conv_q_c115_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_11 (conv_i_src_c115_0_11 0 conv_bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_0_11 (conv_i_src_c115_0_11 conv_i_c115_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_11 (conv_q_src_c115_0_11 0 conv_bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_0_11 (conv_q_src_c115_0_11 conv_q_c115_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_12 (conv_i_src_c115_0_12 0 conv_bpf_c115_0 0) vcvs gain=1.950903220161e-01
SCONVI_c115_0_12 (conv_i_src_c115_0_12 conv_i_c115_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_12 (conv_q_src_c115_0_12 0 conv_bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_0_12 (conv_q_src_c115_0_12 conv_q_c115_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_13 (conv_i_src_c115_0_13 0 conv_bpf_c115_0 0) vcvs gain=5.555702330196e-01
SCONVI_c115_0_13 (conv_i_src_c115_0_13 conv_i_c115_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_13 (conv_q_src_c115_0_13 0 conv_bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_0_13 (conv_q_src_c115_0_13 conv_q_c115_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_14 (conv_i_src_c115_0_14 0 conv_bpf_c115_0 0) vcvs gain=8.314696123025e-01
SCONVI_c115_0_14 (conv_i_src_c115_0_14 conv_i_c115_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_14 (conv_q_src_c115_0_14 0 conv_bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_0_14 (conv_q_src_c115_0_14 conv_q_c115_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_0_15 (conv_i_src_c115_0_15 0 conv_bpf_c115_0 0) vcvs gain=9.807852804032e-01
SCONVI_c115_0_15 (conv_i_src_c115_0_15 conv_i_c115_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_0_15 (conv_q_src_c115_0_15 0 conv_bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_0_15 (conv_q_src_c115_0_15 conv_q_c115_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c115_0 (conv_i_c115_0 0) resistor r=1G
RCONVQ_c115_0 (conv_q_c115_0 0) resistor r=1G
RCONVINTI_c115_0 (conv_i_c115_0 ConvIcar_c115_0) resistor r=1k
CCONVINTI_c115_0 (ConvIcar_c115_0 0) capacitor c=80p
RCONVINTQ_c115_0 (conv_q_c115_0 ConvQcar_c115_0) resistor r=1k
CCONVINTQ_c115_0 (ConvQcar_c115_0 0) capacitor c=80p
save conv_bpf_c115_0 ConvIcar_c115_0 ConvQcar_c115_0

// conventional mixed baseline bl115, carrier_1: 500000000 Hz
CCONVBPF_c115_1 (bl115 n_conv_cbpf_c115_1) capacitor c=1.013211836423e-13
LCONVBPF_c115_1 (n_conv_cbpf_c115_1 conv_bpf_c115_1) inductor l=1.000000000000e-06
RCONVBPF_c115_1 (conv_bpf_c115_1 0) resistor r=1.570796326795e+02
ECONVI_c115_1_00 (conv_i_src_c115_1_00 0 conv_bpf_c115_1 0) vcvs gain=9.807852804032e-01
SCONVI_c115_1_00 (conv_i_src_c115_1_00 conv_i_c115_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_00 (conv_q_src_c115_1_00 0 conv_bpf_c115_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_1_00 (conv_q_src_c115_1_00 conv_q_c115_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_01 (conv_i_src_c115_1_01 0 conv_bpf_c115_1 0) vcvs gain=8.314696123025e-01
SCONVI_c115_1_01 (conv_i_src_c115_1_01 conv_i_c115_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_01 (conv_q_src_c115_1_01 0 conv_bpf_c115_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_1_01 (conv_q_src_c115_1_01 conv_q_c115_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_02 (conv_i_src_c115_1_02 0 conv_bpf_c115_1 0) vcvs gain=5.555702330196e-01
SCONVI_c115_1_02 (conv_i_src_c115_1_02 conv_i_c115_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_02 (conv_q_src_c115_1_02 0 conv_bpf_c115_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_1_02 (conv_q_src_c115_1_02 conv_q_c115_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_03 (conv_i_src_c115_1_03 0 conv_bpf_c115_1 0) vcvs gain=1.950903220161e-01
SCONVI_c115_1_03 (conv_i_src_c115_1_03 conv_i_c115_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_03 (conv_q_src_c115_1_03 0 conv_bpf_c115_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_1_03 (conv_q_src_c115_1_03 conv_q_c115_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_04 (conv_i_src_c115_1_04 0 conv_bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_1_04 (conv_i_src_c115_1_04 conv_i_c115_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_04 (conv_q_src_c115_1_04 0 conv_bpf_c115_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_1_04 (conv_q_src_c115_1_04 conv_q_c115_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_05 (conv_i_src_c115_1_05 0 conv_bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_1_05 (conv_i_src_c115_1_05 conv_i_c115_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_05 (conv_q_src_c115_1_05 0 conv_bpf_c115_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_1_05 (conv_q_src_c115_1_05 conv_q_c115_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_06 (conv_i_src_c115_1_06 0 conv_bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_1_06 (conv_i_src_c115_1_06 conv_i_c115_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_06 (conv_q_src_c115_1_06 0 conv_bpf_c115_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_1_06 (conv_q_src_c115_1_06 conv_q_c115_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_07 (conv_i_src_c115_1_07 0 conv_bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_1_07 (conv_i_src_c115_1_07 conv_i_c115_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_07 (conv_q_src_c115_1_07 0 conv_bpf_c115_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_1_07 (conv_q_src_c115_1_07 conv_q_c115_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_08 (conv_i_src_c115_1_08 0 conv_bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_1_08 (conv_i_src_c115_1_08 conv_i_c115_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_08 (conv_q_src_c115_1_08 0 conv_bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_1_08 (conv_q_src_c115_1_08 conv_q_c115_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_09 (conv_i_src_c115_1_09 0 conv_bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_1_09 (conv_i_src_c115_1_09 conv_i_c115_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_09 (conv_q_src_c115_1_09 0 conv_bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_1_09 (conv_q_src_c115_1_09 conv_q_c115_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_10 (conv_i_src_c115_1_10 0 conv_bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_1_10 (conv_i_src_c115_1_10 conv_i_c115_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_10 (conv_q_src_c115_1_10 0 conv_bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_1_10 (conv_q_src_c115_1_10 conv_q_c115_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_11 (conv_i_src_c115_1_11 0 conv_bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_1_11 (conv_i_src_c115_1_11 conv_i_c115_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_11 (conv_q_src_c115_1_11 0 conv_bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_1_11 (conv_q_src_c115_1_11 conv_q_c115_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_12 (conv_i_src_c115_1_12 0 conv_bpf_c115_1 0) vcvs gain=1.950903220161e-01
SCONVI_c115_1_12 (conv_i_src_c115_1_12 conv_i_c115_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_12 (conv_q_src_c115_1_12 0 conv_bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_1_12 (conv_q_src_c115_1_12 conv_q_c115_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_13 (conv_i_src_c115_1_13 0 conv_bpf_c115_1 0) vcvs gain=5.555702330196e-01
SCONVI_c115_1_13 (conv_i_src_c115_1_13 conv_i_c115_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_13 (conv_q_src_c115_1_13 0 conv_bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_1_13 (conv_q_src_c115_1_13 conv_q_c115_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_14 (conv_i_src_c115_1_14 0 conv_bpf_c115_1 0) vcvs gain=8.314696123025e-01
SCONVI_c115_1_14 (conv_i_src_c115_1_14 conv_i_c115_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_14 (conv_q_src_c115_1_14 0 conv_bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_1_14 (conv_q_src_c115_1_14 conv_q_c115_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_1_15 (conv_i_src_c115_1_15 0 conv_bpf_c115_1 0) vcvs gain=9.807852804032e-01
SCONVI_c115_1_15 (conv_i_src_c115_1_15 conv_i_c115_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_1_15 (conv_q_src_c115_1_15 0 conv_bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_1_15 (conv_q_src_c115_1_15 conv_q_c115_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c115_1 (conv_i_c115_1 0) resistor r=1G
RCONVQ_c115_1 (conv_q_c115_1 0) resistor r=1G
RCONVINTI_c115_1 (conv_i_c115_1 ConvIcar_c115_1) resistor r=1k
CCONVINTI_c115_1 (ConvIcar_c115_1 0) capacitor c=80p
RCONVINTQ_c115_1 (conv_q_c115_1 ConvQcar_c115_1) resistor r=1k
CCONVINTQ_c115_1 (ConvQcar_c115_1 0) capacitor c=80p
save conv_bpf_c115_1 ConvIcar_c115_1 ConvQcar_c115_1

// conventional mixed baseline bl115, carrier_2: 750000000 Hz
CCONVBPF_c115_2 (bl115 n_conv_cbpf_c115_2) capacitor c=4.503163717437e-14
LCONVBPF_c115_2 (n_conv_cbpf_c115_2 conv_bpf_c115_2) inductor l=1.000000000000e-06
RCONVBPF_c115_2 (conv_bpf_c115_2 0) resistor r=2.356194490192e+02
ECONVI_c115_2_00 (conv_i_src_c115_2_00 0 conv_bpf_c115_2 0) vcvs gain=9.807852804032e-01
SCONVI_c115_2_00 (conv_i_src_c115_2_00 conv_i_c115_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_00 (conv_q_src_c115_2_00 0 conv_bpf_c115_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_2_00 (conv_q_src_c115_2_00 conv_q_c115_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_01 (conv_i_src_c115_2_01 0 conv_bpf_c115_2 0) vcvs gain=8.314696123025e-01
SCONVI_c115_2_01 (conv_i_src_c115_2_01 conv_i_c115_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_01 (conv_q_src_c115_2_01 0 conv_bpf_c115_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_2_01 (conv_q_src_c115_2_01 conv_q_c115_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_02 (conv_i_src_c115_2_02 0 conv_bpf_c115_2 0) vcvs gain=5.555702330196e-01
SCONVI_c115_2_02 (conv_i_src_c115_2_02 conv_i_c115_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_02 (conv_q_src_c115_2_02 0 conv_bpf_c115_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_2_02 (conv_q_src_c115_2_02 conv_q_c115_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_03 (conv_i_src_c115_2_03 0 conv_bpf_c115_2 0) vcvs gain=1.950903220161e-01
SCONVI_c115_2_03 (conv_i_src_c115_2_03 conv_i_c115_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_03 (conv_q_src_c115_2_03 0 conv_bpf_c115_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_2_03 (conv_q_src_c115_2_03 conv_q_c115_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_04 (conv_i_src_c115_2_04 0 conv_bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_2_04 (conv_i_src_c115_2_04 conv_i_c115_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_04 (conv_q_src_c115_2_04 0 conv_bpf_c115_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_2_04 (conv_q_src_c115_2_04 conv_q_c115_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_05 (conv_i_src_c115_2_05 0 conv_bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_2_05 (conv_i_src_c115_2_05 conv_i_c115_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_05 (conv_q_src_c115_2_05 0 conv_bpf_c115_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_2_05 (conv_q_src_c115_2_05 conv_q_c115_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_06 (conv_i_src_c115_2_06 0 conv_bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_2_06 (conv_i_src_c115_2_06 conv_i_c115_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_06 (conv_q_src_c115_2_06 0 conv_bpf_c115_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_2_06 (conv_q_src_c115_2_06 conv_q_c115_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_07 (conv_i_src_c115_2_07 0 conv_bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_2_07 (conv_i_src_c115_2_07 conv_i_c115_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_07 (conv_q_src_c115_2_07 0 conv_bpf_c115_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_2_07 (conv_q_src_c115_2_07 conv_q_c115_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_08 (conv_i_src_c115_2_08 0 conv_bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_2_08 (conv_i_src_c115_2_08 conv_i_c115_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_08 (conv_q_src_c115_2_08 0 conv_bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_2_08 (conv_q_src_c115_2_08 conv_q_c115_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_09 (conv_i_src_c115_2_09 0 conv_bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_2_09 (conv_i_src_c115_2_09 conv_i_c115_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_09 (conv_q_src_c115_2_09 0 conv_bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_2_09 (conv_q_src_c115_2_09 conv_q_c115_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_10 (conv_i_src_c115_2_10 0 conv_bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_2_10 (conv_i_src_c115_2_10 conv_i_c115_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_10 (conv_q_src_c115_2_10 0 conv_bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_2_10 (conv_q_src_c115_2_10 conv_q_c115_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_11 (conv_i_src_c115_2_11 0 conv_bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_2_11 (conv_i_src_c115_2_11 conv_i_c115_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_11 (conv_q_src_c115_2_11 0 conv_bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_2_11 (conv_q_src_c115_2_11 conv_q_c115_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_12 (conv_i_src_c115_2_12 0 conv_bpf_c115_2 0) vcvs gain=1.950903220161e-01
SCONVI_c115_2_12 (conv_i_src_c115_2_12 conv_i_c115_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_12 (conv_q_src_c115_2_12 0 conv_bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_2_12 (conv_q_src_c115_2_12 conv_q_c115_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_13 (conv_i_src_c115_2_13 0 conv_bpf_c115_2 0) vcvs gain=5.555702330196e-01
SCONVI_c115_2_13 (conv_i_src_c115_2_13 conv_i_c115_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_13 (conv_q_src_c115_2_13 0 conv_bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_2_13 (conv_q_src_c115_2_13 conv_q_c115_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_14 (conv_i_src_c115_2_14 0 conv_bpf_c115_2 0) vcvs gain=8.314696123025e-01
SCONVI_c115_2_14 (conv_i_src_c115_2_14 conv_i_c115_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_14 (conv_q_src_c115_2_14 0 conv_bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_2_14 (conv_q_src_c115_2_14 conv_q_c115_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_2_15 (conv_i_src_c115_2_15 0 conv_bpf_c115_2 0) vcvs gain=9.807852804032e-01
SCONVI_c115_2_15 (conv_i_src_c115_2_15 conv_i_c115_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_2_15 (conv_q_src_c115_2_15 0 conv_bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_2_15 (conv_q_src_c115_2_15 conv_q_c115_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c115_2 (conv_i_c115_2 0) resistor r=1G
RCONVQ_c115_2 (conv_q_c115_2 0) resistor r=1G
RCONVINTI_c115_2 (conv_i_c115_2 ConvIcar_c115_2) resistor r=1k
CCONVINTI_c115_2 (ConvIcar_c115_2 0) capacitor c=80p
RCONVINTQ_c115_2 (conv_q_c115_2 ConvQcar_c115_2) resistor r=1k
CCONVINTQ_c115_2 (ConvQcar_c115_2 0) capacitor c=80p
save conv_bpf_c115_2 ConvIcar_c115_2 ConvQcar_c115_2

// conventional mixed baseline bl115, carrier_3: 1000000000 Hz
CCONVBPF_c115_3 (bl115 n_conv_cbpf_c115_3) capacitor c=2.533029591058e-14
LCONVBPF_c115_3 (n_conv_cbpf_c115_3 conv_bpf_c115_3) inductor l=1.000000000000e-06
RCONVBPF_c115_3 (conv_bpf_c115_3 0) resistor r=3.141592653590e+02
ECONVI_c115_3_00 (conv_i_src_c115_3_00 0 conv_bpf_c115_3 0) vcvs gain=9.807852804032e-01
SCONVI_c115_3_00 (conv_i_src_c115_3_00 conv_i_c115_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_00 (conv_q_src_c115_3_00 0 conv_bpf_c115_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_3_00 (conv_q_src_c115_3_00 conv_q_c115_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_01 (conv_i_src_c115_3_01 0 conv_bpf_c115_3 0) vcvs gain=8.314696123025e-01
SCONVI_c115_3_01 (conv_i_src_c115_3_01 conv_i_c115_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_01 (conv_q_src_c115_3_01 0 conv_bpf_c115_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_3_01 (conv_q_src_c115_3_01 conv_q_c115_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_02 (conv_i_src_c115_3_02 0 conv_bpf_c115_3 0) vcvs gain=5.555702330196e-01
SCONVI_c115_3_02 (conv_i_src_c115_3_02 conv_i_c115_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_02 (conv_q_src_c115_3_02 0 conv_bpf_c115_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_3_02 (conv_q_src_c115_3_02 conv_q_c115_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_03 (conv_i_src_c115_3_03 0 conv_bpf_c115_3 0) vcvs gain=1.950903220161e-01
SCONVI_c115_3_03 (conv_i_src_c115_3_03 conv_i_c115_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_03 (conv_q_src_c115_3_03 0 conv_bpf_c115_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_3_03 (conv_q_src_c115_3_03 conv_q_c115_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_04 (conv_i_src_c115_3_04 0 conv_bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_3_04 (conv_i_src_c115_3_04 conv_i_c115_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_04 (conv_q_src_c115_3_04 0 conv_bpf_c115_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c115_3_04 (conv_q_src_c115_3_04 conv_q_c115_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_05 (conv_i_src_c115_3_05 0 conv_bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_3_05 (conv_i_src_c115_3_05 conv_i_c115_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_05 (conv_q_src_c115_3_05 0 conv_bpf_c115_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c115_3_05 (conv_q_src_c115_3_05 conv_q_c115_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_06 (conv_i_src_c115_3_06 0 conv_bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_3_06 (conv_i_src_c115_3_06 conv_i_c115_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_06 (conv_q_src_c115_3_06 0 conv_bpf_c115_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c115_3_06 (conv_q_src_c115_3_06 conv_q_c115_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_07 (conv_i_src_c115_3_07 0 conv_bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_3_07 (conv_i_src_c115_3_07 conv_i_c115_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_07 (conv_q_src_c115_3_07 0 conv_bpf_c115_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c115_3_07 (conv_q_src_c115_3_07 conv_q_c115_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_08 (conv_i_src_c115_3_08 0 conv_bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c115_3_08 (conv_i_src_c115_3_08 conv_i_c115_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_08 (conv_q_src_c115_3_08 0 conv_bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_3_08 (conv_q_src_c115_3_08 conv_q_c115_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_09 (conv_i_src_c115_3_09 0 conv_bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c115_3_09 (conv_i_src_c115_3_09 conv_i_c115_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_09 (conv_q_src_c115_3_09 0 conv_bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_3_09 (conv_q_src_c115_3_09 conv_q_c115_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_10 (conv_i_src_c115_3_10 0 conv_bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c115_3_10 (conv_i_src_c115_3_10 conv_i_c115_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_10 (conv_q_src_c115_3_10 0 conv_bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_3_10 (conv_q_src_c115_3_10 conv_q_c115_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_11 (conv_i_src_c115_3_11 0 conv_bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c115_3_11 (conv_i_src_c115_3_11 conv_i_c115_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_11 (conv_q_src_c115_3_11 0 conv_bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_3_11 (conv_q_src_c115_3_11 conv_q_c115_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_12 (conv_i_src_c115_3_12 0 conv_bpf_c115_3 0) vcvs gain=1.950903220161e-01
SCONVI_c115_3_12 (conv_i_src_c115_3_12 conv_i_c115_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_12 (conv_q_src_c115_3_12 0 conv_bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c115_3_12 (conv_q_src_c115_3_12 conv_q_c115_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_13 (conv_i_src_c115_3_13 0 conv_bpf_c115_3 0) vcvs gain=5.555702330196e-01
SCONVI_c115_3_13 (conv_i_src_c115_3_13 conv_i_c115_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_13 (conv_q_src_c115_3_13 0 conv_bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c115_3_13 (conv_q_src_c115_3_13 conv_q_c115_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_14 (conv_i_src_c115_3_14 0 conv_bpf_c115_3 0) vcvs gain=8.314696123025e-01
SCONVI_c115_3_14 (conv_i_src_c115_3_14 conv_i_c115_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_14 (conv_q_src_c115_3_14 0 conv_bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c115_3_14 (conv_q_src_c115_3_14 conv_q_c115_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c115_3_15 (conv_i_src_c115_3_15 0 conv_bpf_c115_3 0) vcvs gain=9.807852804032e-01
SCONVI_c115_3_15 (conv_i_src_c115_3_15 conv_i_c115_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c115_3_15 (conv_q_src_c115_3_15 0 conv_bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c115_3_15 (conv_q_src_c115_3_15 conv_q_c115_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c115_3 (conv_i_c115_3 0) resistor r=1G
RCONVQ_c115_3 (conv_q_c115_3 0) resistor r=1G
RCONVINTI_c115_3 (conv_i_c115_3 ConvIcar_c115_3) resistor r=1k
CCONVINTI_c115_3 (ConvIcar_c115_3 0) capacitor c=80p
RCONVINTQ_c115_3 (conv_q_c115_3 ConvQcar_c115_3) resistor r=1k
CCONVINTQ_c115_3 (ConvQcar_c115_3 0) capacitor c=80p
save conv_bpf_c115_3 ConvIcar_c115_3 ConvQcar_c115_3

// conventional mixed baseline bl116, carrier_0: 250000000 Hz
CCONVBPF_c116_0 (bl116 n_conv_cbpf_c116_0) capacitor c=4.052847345694e-13
LCONVBPF_c116_0 (n_conv_cbpf_c116_0 conv_bpf_c116_0) inductor l=1.000000000000e-06
RCONVBPF_c116_0 (conv_bpf_c116_0 0) resistor r=7.853981633974e+01
ECONVI_c116_0_00 (conv_i_src_c116_0_00 0 conv_bpf_c116_0 0) vcvs gain=9.807852804032e-01
SCONVI_c116_0_00 (conv_i_src_c116_0_00 conv_i_c116_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_00 (conv_q_src_c116_0_00 0 conv_bpf_c116_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_0_00 (conv_q_src_c116_0_00 conv_q_c116_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_01 (conv_i_src_c116_0_01 0 conv_bpf_c116_0 0) vcvs gain=8.314696123025e-01
SCONVI_c116_0_01 (conv_i_src_c116_0_01 conv_i_c116_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_01 (conv_q_src_c116_0_01 0 conv_bpf_c116_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_0_01 (conv_q_src_c116_0_01 conv_q_c116_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_02 (conv_i_src_c116_0_02 0 conv_bpf_c116_0 0) vcvs gain=5.555702330196e-01
SCONVI_c116_0_02 (conv_i_src_c116_0_02 conv_i_c116_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_02 (conv_q_src_c116_0_02 0 conv_bpf_c116_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_0_02 (conv_q_src_c116_0_02 conv_q_c116_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_03 (conv_i_src_c116_0_03 0 conv_bpf_c116_0 0) vcvs gain=1.950903220161e-01
SCONVI_c116_0_03 (conv_i_src_c116_0_03 conv_i_c116_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_03 (conv_q_src_c116_0_03 0 conv_bpf_c116_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_0_03 (conv_q_src_c116_0_03 conv_q_c116_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_04 (conv_i_src_c116_0_04 0 conv_bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_0_04 (conv_i_src_c116_0_04 conv_i_c116_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_04 (conv_q_src_c116_0_04 0 conv_bpf_c116_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_0_04 (conv_q_src_c116_0_04 conv_q_c116_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_05 (conv_i_src_c116_0_05 0 conv_bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_0_05 (conv_i_src_c116_0_05 conv_i_c116_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_05 (conv_q_src_c116_0_05 0 conv_bpf_c116_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_0_05 (conv_q_src_c116_0_05 conv_q_c116_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_06 (conv_i_src_c116_0_06 0 conv_bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_0_06 (conv_i_src_c116_0_06 conv_i_c116_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_06 (conv_q_src_c116_0_06 0 conv_bpf_c116_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_0_06 (conv_q_src_c116_0_06 conv_q_c116_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_07 (conv_i_src_c116_0_07 0 conv_bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_0_07 (conv_i_src_c116_0_07 conv_i_c116_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_07 (conv_q_src_c116_0_07 0 conv_bpf_c116_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_0_07 (conv_q_src_c116_0_07 conv_q_c116_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_08 (conv_i_src_c116_0_08 0 conv_bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_0_08 (conv_i_src_c116_0_08 conv_i_c116_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_08 (conv_q_src_c116_0_08 0 conv_bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_0_08 (conv_q_src_c116_0_08 conv_q_c116_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_09 (conv_i_src_c116_0_09 0 conv_bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_0_09 (conv_i_src_c116_0_09 conv_i_c116_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_09 (conv_q_src_c116_0_09 0 conv_bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_0_09 (conv_q_src_c116_0_09 conv_q_c116_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_10 (conv_i_src_c116_0_10 0 conv_bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_0_10 (conv_i_src_c116_0_10 conv_i_c116_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_10 (conv_q_src_c116_0_10 0 conv_bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_0_10 (conv_q_src_c116_0_10 conv_q_c116_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_11 (conv_i_src_c116_0_11 0 conv_bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_0_11 (conv_i_src_c116_0_11 conv_i_c116_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_11 (conv_q_src_c116_0_11 0 conv_bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_0_11 (conv_q_src_c116_0_11 conv_q_c116_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_12 (conv_i_src_c116_0_12 0 conv_bpf_c116_0 0) vcvs gain=1.950903220161e-01
SCONVI_c116_0_12 (conv_i_src_c116_0_12 conv_i_c116_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_12 (conv_q_src_c116_0_12 0 conv_bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_0_12 (conv_q_src_c116_0_12 conv_q_c116_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_13 (conv_i_src_c116_0_13 0 conv_bpf_c116_0 0) vcvs gain=5.555702330196e-01
SCONVI_c116_0_13 (conv_i_src_c116_0_13 conv_i_c116_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_13 (conv_q_src_c116_0_13 0 conv_bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_0_13 (conv_q_src_c116_0_13 conv_q_c116_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_14 (conv_i_src_c116_0_14 0 conv_bpf_c116_0 0) vcvs gain=8.314696123025e-01
SCONVI_c116_0_14 (conv_i_src_c116_0_14 conv_i_c116_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_14 (conv_q_src_c116_0_14 0 conv_bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_0_14 (conv_q_src_c116_0_14 conv_q_c116_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_0_15 (conv_i_src_c116_0_15 0 conv_bpf_c116_0 0) vcvs gain=9.807852804032e-01
SCONVI_c116_0_15 (conv_i_src_c116_0_15 conv_i_c116_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_0_15 (conv_q_src_c116_0_15 0 conv_bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_0_15 (conv_q_src_c116_0_15 conv_q_c116_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c116_0 (conv_i_c116_0 0) resistor r=1G
RCONVQ_c116_0 (conv_q_c116_0 0) resistor r=1G
RCONVINTI_c116_0 (conv_i_c116_0 ConvIcar_c116_0) resistor r=1k
CCONVINTI_c116_0 (ConvIcar_c116_0 0) capacitor c=80p
RCONVINTQ_c116_0 (conv_q_c116_0 ConvQcar_c116_0) resistor r=1k
CCONVINTQ_c116_0 (ConvQcar_c116_0 0) capacitor c=80p
save conv_bpf_c116_0 ConvIcar_c116_0 ConvQcar_c116_0

// conventional mixed baseline bl116, carrier_1: 500000000 Hz
CCONVBPF_c116_1 (bl116 n_conv_cbpf_c116_1) capacitor c=1.013211836423e-13
LCONVBPF_c116_1 (n_conv_cbpf_c116_1 conv_bpf_c116_1) inductor l=1.000000000000e-06
RCONVBPF_c116_1 (conv_bpf_c116_1 0) resistor r=1.570796326795e+02
ECONVI_c116_1_00 (conv_i_src_c116_1_00 0 conv_bpf_c116_1 0) vcvs gain=9.807852804032e-01
SCONVI_c116_1_00 (conv_i_src_c116_1_00 conv_i_c116_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_00 (conv_q_src_c116_1_00 0 conv_bpf_c116_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_1_00 (conv_q_src_c116_1_00 conv_q_c116_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_01 (conv_i_src_c116_1_01 0 conv_bpf_c116_1 0) vcvs gain=8.314696123025e-01
SCONVI_c116_1_01 (conv_i_src_c116_1_01 conv_i_c116_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_01 (conv_q_src_c116_1_01 0 conv_bpf_c116_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_1_01 (conv_q_src_c116_1_01 conv_q_c116_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_02 (conv_i_src_c116_1_02 0 conv_bpf_c116_1 0) vcvs gain=5.555702330196e-01
SCONVI_c116_1_02 (conv_i_src_c116_1_02 conv_i_c116_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_02 (conv_q_src_c116_1_02 0 conv_bpf_c116_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_1_02 (conv_q_src_c116_1_02 conv_q_c116_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_03 (conv_i_src_c116_1_03 0 conv_bpf_c116_1 0) vcvs gain=1.950903220161e-01
SCONVI_c116_1_03 (conv_i_src_c116_1_03 conv_i_c116_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_03 (conv_q_src_c116_1_03 0 conv_bpf_c116_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_1_03 (conv_q_src_c116_1_03 conv_q_c116_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_04 (conv_i_src_c116_1_04 0 conv_bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_1_04 (conv_i_src_c116_1_04 conv_i_c116_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_04 (conv_q_src_c116_1_04 0 conv_bpf_c116_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_1_04 (conv_q_src_c116_1_04 conv_q_c116_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_05 (conv_i_src_c116_1_05 0 conv_bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_1_05 (conv_i_src_c116_1_05 conv_i_c116_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_05 (conv_q_src_c116_1_05 0 conv_bpf_c116_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_1_05 (conv_q_src_c116_1_05 conv_q_c116_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_06 (conv_i_src_c116_1_06 0 conv_bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_1_06 (conv_i_src_c116_1_06 conv_i_c116_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_06 (conv_q_src_c116_1_06 0 conv_bpf_c116_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_1_06 (conv_q_src_c116_1_06 conv_q_c116_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_07 (conv_i_src_c116_1_07 0 conv_bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_1_07 (conv_i_src_c116_1_07 conv_i_c116_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_07 (conv_q_src_c116_1_07 0 conv_bpf_c116_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_1_07 (conv_q_src_c116_1_07 conv_q_c116_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_08 (conv_i_src_c116_1_08 0 conv_bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_1_08 (conv_i_src_c116_1_08 conv_i_c116_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_08 (conv_q_src_c116_1_08 0 conv_bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_1_08 (conv_q_src_c116_1_08 conv_q_c116_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_09 (conv_i_src_c116_1_09 0 conv_bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_1_09 (conv_i_src_c116_1_09 conv_i_c116_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_09 (conv_q_src_c116_1_09 0 conv_bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_1_09 (conv_q_src_c116_1_09 conv_q_c116_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_10 (conv_i_src_c116_1_10 0 conv_bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_1_10 (conv_i_src_c116_1_10 conv_i_c116_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_10 (conv_q_src_c116_1_10 0 conv_bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_1_10 (conv_q_src_c116_1_10 conv_q_c116_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_11 (conv_i_src_c116_1_11 0 conv_bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_1_11 (conv_i_src_c116_1_11 conv_i_c116_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_11 (conv_q_src_c116_1_11 0 conv_bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_1_11 (conv_q_src_c116_1_11 conv_q_c116_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_12 (conv_i_src_c116_1_12 0 conv_bpf_c116_1 0) vcvs gain=1.950903220161e-01
SCONVI_c116_1_12 (conv_i_src_c116_1_12 conv_i_c116_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_12 (conv_q_src_c116_1_12 0 conv_bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_1_12 (conv_q_src_c116_1_12 conv_q_c116_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_13 (conv_i_src_c116_1_13 0 conv_bpf_c116_1 0) vcvs gain=5.555702330196e-01
SCONVI_c116_1_13 (conv_i_src_c116_1_13 conv_i_c116_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_13 (conv_q_src_c116_1_13 0 conv_bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_1_13 (conv_q_src_c116_1_13 conv_q_c116_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_14 (conv_i_src_c116_1_14 0 conv_bpf_c116_1 0) vcvs gain=8.314696123025e-01
SCONVI_c116_1_14 (conv_i_src_c116_1_14 conv_i_c116_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_14 (conv_q_src_c116_1_14 0 conv_bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_1_14 (conv_q_src_c116_1_14 conv_q_c116_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_1_15 (conv_i_src_c116_1_15 0 conv_bpf_c116_1 0) vcvs gain=9.807852804032e-01
SCONVI_c116_1_15 (conv_i_src_c116_1_15 conv_i_c116_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_1_15 (conv_q_src_c116_1_15 0 conv_bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_1_15 (conv_q_src_c116_1_15 conv_q_c116_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c116_1 (conv_i_c116_1 0) resistor r=1G
RCONVQ_c116_1 (conv_q_c116_1 0) resistor r=1G
RCONVINTI_c116_1 (conv_i_c116_1 ConvIcar_c116_1) resistor r=1k
CCONVINTI_c116_1 (ConvIcar_c116_1 0) capacitor c=80p
RCONVINTQ_c116_1 (conv_q_c116_1 ConvQcar_c116_1) resistor r=1k
CCONVINTQ_c116_1 (ConvQcar_c116_1 0) capacitor c=80p
save conv_bpf_c116_1 ConvIcar_c116_1 ConvQcar_c116_1

// conventional mixed baseline bl116, carrier_2: 750000000 Hz
CCONVBPF_c116_2 (bl116 n_conv_cbpf_c116_2) capacitor c=4.503163717437e-14
LCONVBPF_c116_2 (n_conv_cbpf_c116_2 conv_bpf_c116_2) inductor l=1.000000000000e-06
RCONVBPF_c116_2 (conv_bpf_c116_2 0) resistor r=2.356194490192e+02
ECONVI_c116_2_00 (conv_i_src_c116_2_00 0 conv_bpf_c116_2 0) vcvs gain=9.807852804032e-01
SCONVI_c116_2_00 (conv_i_src_c116_2_00 conv_i_c116_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_00 (conv_q_src_c116_2_00 0 conv_bpf_c116_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_2_00 (conv_q_src_c116_2_00 conv_q_c116_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_01 (conv_i_src_c116_2_01 0 conv_bpf_c116_2 0) vcvs gain=8.314696123025e-01
SCONVI_c116_2_01 (conv_i_src_c116_2_01 conv_i_c116_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_01 (conv_q_src_c116_2_01 0 conv_bpf_c116_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_2_01 (conv_q_src_c116_2_01 conv_q_c116_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_02 (conv_i_src_c116_2_02 0 conv_bpf_c116_2 0) vcvs gain=5.555702330196e-01
SCONVI_c116_2_02 (conv_i_src_c116_2_02 conv_i_c116_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_02 (conv_q_src_c116_2_02 0 conv_bpf_c116_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_2_02 (conv_q_src_c116_2_02 conv_q_c116_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_03 (conv_i_src_c116_2_03 0 conv_bpf_c116_2 0) vcvs gain=1.950903220161e-01
SCONVI_c116_2_03 (conv_i_src_c116_2_03 conv_i_c116_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_03 (conv_q_src_c116_2_03 0 conv_bpf_c116_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_2_03 (conv_q_src_c116_2_03 conv_q_c116_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_04 (conv_i_src_c116_2_04 0 conv_bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_2_04 (conv_i_src_c116_2_04 conv_i_c116_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_04 (conv_q_src_c116_2_04 0 conv_bpf_c116_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_2_04 (conv_q_src_c116_2_04 conv_q_c116_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_05 (conv_i_src_c116_2_05 0 conv_bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_2_05 (conv_i_src_c116_2_05 conv_i_c116_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_05 (conv_q_src_c116_2_05 0 conv_bpf_c116_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_2_05 (conv_q_src_c116_2_05 conv_q_c116_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_06 (conv_i_src_c116_2_06 0 conv_bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_2_06 (conv_i_src_c116_2_06 conv_i_c116_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_06 (conv_q_src_c116_2_06 0 conv_bpf_c116_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_2_06 (conv_q_src_c116_2_06 conv_q_c116_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_07 (conv_i_src_c116_2_07 0 conv_bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_2_07 (conv_i_src_c116_2_07 conv_i_c116_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_07 (conv_q_src_c116_2_07 0 conv_bpf_c116_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_2_07 (conv_q_src_c116_2_07 conv_q_c116_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_08 (conv_i_src_c116_2_08 0 conv_bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_2_08 (conv_i_src_c116_2_08 conv_i_c116_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_08 (conv_q_src_c116_2_08 0 conv_bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_2_08 (conv_q_src_c116_2_08 conv_q_c116_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_09 (conv_i_src_c116_2_09 0 conv_bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_2_09 (conv_i_src_c116_2_09 conv_i_c116_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_09 (conv_q_src_c116_2_09 0 conv_bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_2_09 (conv_q_src_c116_2_09 conv_q_c116_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_10 (conv_i_src_c116_2_10 0 conv_bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_2_10 (conv_i_src_c116_2_10 conv_i_c116_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_10 (conv_q_src_c116_2_10 0 conv_bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_2_10 (conv_q_src_c116_2_10 conv_q_c116_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_11 (conv_i_src_c116_2_11 0 conv_bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_2_11 (conv_i_src_c116_2_11 conv_i_c116_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_11 (conv_q_src_c116_2_11 0 conv_bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_2_11 (conv_q_src_c116_2_11 conv_q_c116_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_12 (conv_i_src_c116_2_12 0 conv_bpf_c116_2 0) vcvs gain=1.950903220161e-01
SCONVI_c116_2_12 (conv_i_src_c116_2_12 conv_i_c116_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_12 (conv_q_src_c116_2_12 0 conv_bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_2_12 (conv_q_src_c116_2_12 conv_q_c116_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_13 (conv_i_src_c116_2_13 0 conv_bpf_c116_2 0) vcvs gain=5.555702330196e-01
SCONVI_c116_2_13 (conv_i_src_c116_2_13 conv_i_c116_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_13 (conv_q_src_c116_2_13 0 conv_bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_2_13 (conv_q_src_c116_2_13 conv_q_c116_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_14 (conv_i_src_c116_2_14 0 conv_bpf_c116_2 0) vcvs gain=8.314696123025e-01
SCONVI_c116_2_14 (conv_i_src_c116_2_14 conv_i_c116_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_14 (conv_q_src_c116_2_14 0 conv_bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_2_14 (conv_q_src_c116_2_14 conv_q_c116_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_2_15 (conv_i_src_c116_2_15 0 conv_bpf_c116_2 0) vcvs gain=9.807852804032e-01
SCONVI_c116_2_15 (conv_i_src_c116_2_15 conv_i_c116_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_2_15 (conv_q_src_c116_2_15 0 conv_bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_2_15 (conv_q_src_c116_2_15 conv_q_c116_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c116_2 (conv_i_c116_2 0) resistor r=1G
RCONVQ_c116_2 (conv_q_c116_2 0) resistor r=1G
RCONVINTI_c116_2 (conv_i_c116_2 ConvIcar_c116_2) resistor r=1k
CCONVINTI_c116_2 (ConvIcar_c116_2 0) capacitor c=80p
RCONVINTQ_c116_2 (conv_q_c116_2 ConvQcar_c116_2) resistor r=1k
CCONVINTQ_c116_2 (ConvQcar_c116_2 0) capacitor c=80p
save conv_bpf_c116_2 ConvIcar_c116_2 ConvQcar_c116_2

// conventional mixed baseline bl116, carrier_3: 1000000000 Hz
CCONVBPF_c116_3 (bl116 n_conv_cbpf_c116_3) capacitor c=2.533029591058e-14
LCONVBPF_c116_3 (n_conv_cbpf_c116_3 conv_bpf_c116_3) inductor l=1.000000000000e-06
RCONVBPF_c116_3 (conv_bpf_c116_3 0) resistor r=3.141592653590e+02
ECONVI_c116_3_00 (conv_i_src_c116_3_00 0 conv_bpf_c116_3 0) vcvs gain=9.807852804032e-01
SCONVI_c116_3_00 (conv_i_src_c116_3_00 conv_i_c116_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_00 (conv_q_src_c116_3_00 0 conv_bpf_c116_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_3_00 (conv_q_src_c116_3_00 conv_q_c116_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_01 (conv_i_src_c116_3_01 0 conv_bpf_c116_3 0) vcvs gain=8.314696123025e-01
SCONVI_c116_3_01 (conv_i_src_c116_3_01 conv_i_c116_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_01 (conv_q_src_c116_3_01 0 conv_bpf_c116_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_3_01 (conv_q_src_c116_3_01 conv_q_c116_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_02 (conv_i_src_c116_3_02 0 conv_bpf_c116_3 0) vcvs gain=5.555702330196e-01
SCONVI_c116_3_02 (conv_i_src_c116_3_02 conv_i_c116_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_02 (conv_q_src_c116_3_02 0 conv_bpf_c116_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_3_02 (conv_q_src_c116_3_02 conv_q_c116_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_03 (conv_i_src_c116_3_03 0 conv_bpf_c116_3 0) vcvs gain=1.950903220161e-01
SCONVI_c116_3_03 (conv_i_src_c116_3_03 conv_i_c116_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_03 (conv_q_src_c116_3_03 0 conv_bpf_c116_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_3_03 (conv_q_src_c116_3_03 conv_q_c116_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_04 (conv_i_src_c116_3_04 0 conv_bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_3_04 (conv_i_src_c116_3_04 conv_i_c116_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_04 (conv_q_src_c116_3_04 0 conv_bpf_c116_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c116_3_04 (conv_q_src_c116_3_04 conv_q_c116_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_05 (conv_i_src_c116_3_05 0 conv_bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_3_05 (conv_i_src_c116_3_05 conv_i_c116_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_05 (conv_q_src_c116_3_05 0 conv_bpf_c116_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c116_3_05 (conv_q_src_c116_3_05 conv_q_c116_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_06 (conv_i_src_c116_3_06 0 conv_bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_3_06 (conv_i_src_c116_3_06 conv_i_c116_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_06 (conv_q_src_c116_3_06 0 conv_bpf_c116_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c116_3_06 (conv_q_src_c116_3_06 conv_q_c116_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_07 (conv_i_src_c116_3_07 0 conv_bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_3_07 (conv_i_src_c116_3_07 conv_i_c116_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_07 (conv_q_src_c116_3_07 0 conv_bpf_c116_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c116_3_07 (conv_q_src_c116_3_07 conv_q_c116_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_08 (conv_i_src_c116_3_08 0 conv_bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c116_3_08 (conv_i_src_c116_3_08 conv_i_c116_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_08 (conv_q_src_c116_3_08 0 conv_bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_3_08 (conv_q_src_c116_3_08 conv_q_c116_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_09 (conv_i_src_c116_3_09 0 conv_bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c116_3_09 (conv_i_src_c116_3_09 conv_i_c116_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_09 (conv_q_src_c116_3_09 0 conv_bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_3_09 (conv_q_src_c116_3_09 conv_q_c116_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_10 (conv_i_src_c116_3_10 0 conv_bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c116_3_10 (conv_i_src_c116_3_10 conv_i_c116_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_10 (conv_q_src_c116_3_10 0 conv_bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_3_10 (conv_q_src_c116_3_10 conv_q_c116_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_11 (conv_i_src_c116_3_11 0 conv_bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c116_3_11 (conv_i_src_c116_3_11 conv_i_c116_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_11 (conv_q_src_c116_3_11 0 conv_bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_3_11 (conv_q_src_c116_3_11 conv_q_c116_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_12 (conv_i_src_c116_3_12 0 conv_bpf_c116_3 0) vcvs gain=1.950903220161e-01
SCONVI_c116_3_12 (conv_i_src_c116_3_12 conv_i_c116_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_12 (conv_q_src_c116_3_12 0 conv_bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c116_3_12 (conv_q_src_c116_3_12 conv_q_c116_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_13 (conv_i_src_c116_3_13 0 conv_bpf_c116_3 0) vcvs gain=5.555702330196e-01
SCONVI_c116_3_13 (conv_i_src_c116_3_13 conv_i_c116_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_13 (conv_q_src_c116_3_13 0 conv_bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c116_3_13 (conv_q_src_c116_3_13 conv_q_c116_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_14 (conv_i_src_c116_3_14 0 conv_bpf_c116_3 0) vcvs gain=8.314696123025e-01
SCONVI_c116_3_14 (conv_i_src_c116_3_14 conv_i_c116_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_14 (conv_q_src_c116_3_14 0 conv_bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c116_3_14 (conv_q_src_c116_3_14 conv_q_c116_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c116_3_15 (conv_i_src_c116_3_15 0 conv_bpf_c116_3 0) vcvs gain=9.807852804032e-01
SCONVI_c116_3_15 (conv_i_src_c116_3_15 conv_i_c116_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c116_3_15 (conv_q_src_c116_3_15 0 conv_bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c116_3_15 (conv_q_src_c116_3_15 conv_q_c116_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c116_3 (conv_i_c116_3 0) resistor r=1G
RCONVQ_c116_3 (conv_q_c116_3 0) resistor r=1G
RCONVINTI_c116_3 (conv_i_c116_3 ConvIcar_c116_3) resistor r=1k
CCONVINTI_c116_3 (ConvIcar_c116_3 0) capacitor c=80p
RCONVINTQ_c116_3 (conv_q_c116_3 ConvQcar_c116_3) resistor r=1k
CCONVINTQ_c116_3 (ConvQcar_c116_3 0) capacitor c=80p
save conv_bpf_c116_3 ConvIcar_c116_3 ConvQcar_c116_3

// conventional mixed baseline bl117, carrier_0: 250000000 Hz
CCONVBPF_c117_0 (bl117 n_conv_cbpf_c117_0) capacitor c=4.052847345694e-13
LCONVBPF_c117_0 (n_conv_cbpf_c117_0 conv_bpf_c117_0) inductor l=1.000000000000e-06
RCONVBPF_c117_0 (conv_bpf_c117_0 0) resistor r=7.853981633974e+01
ECONVI_c117_0_00 (conv_i_src_c117_0_00 0 conv_bpf_c117_0 0) vcvs gain=9.807852804032e-01
SCONVI_c117_0_00 (conv_i_src_c117_0_00 conv_i_c117_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_00 (conv_q_src_c117_0_00 0 conv_bpf_c117_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_0_00 (conv_q_src_c117_0_00 conv_q_c117_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_01 (conv_i_src_c117_0_01 0 conv_bpf_c117_0 0) vcvs gain=8.314696123025e-01
SCONVI_c117_0_01 (conv_i_src_c117_0_01 conv_i_c117_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_01 (conv_q_src_c117_0_01 0 conv_bpf_c117_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_0_01 (conv_q_src_c117_0_01 conv_q_c117_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_02 (conv_i_src_c117_0_02 0 conv_bpf_c117_0 0) vcvs gain=5.555702330196e-01
SCONVI_c117_0_02 (conv_i_src_c117_0_02 conv_i_c117_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_02 (conv_q_src_c117_0_02 0 conv_bpf_c117_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_0_02 (conv_q_src_c117_0_02 conv_q_c117_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_03 (conv_i_src_c117_0_03 0 conv_bpf_c117_0 0) vcvs gain=1.950903220161e-01
SCONVI_c117_0_03 (conv_i_src_c117_0_03 conv_i_c117_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_03 (conv_q_src_c117_0_03 0 conv_bpf_c117_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_0_03 (conv_q_src_c117_0_03 conv_q_c117_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_04 (conv_i_src_c117_0_04 0 conv_bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_0_04 (conv_i_src_c117_0_04 conv_i_c117_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_04 (conv_q_src_c117_0_04 0 conv_bpf_c117_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_0_04 (conv_q_src_c117_0_04 conv_q_c117_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_05 (conv_i_src_c117_0_05 0 conv_bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_0_05 (conv_i_src_c117_0_05 conv_i_c117_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_05 (conv_q_src_c117_0_05 0 conv_bpf_c117_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_0_05 (conv_q_src_c117_0_05 conv_q_c117_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_06 (conv_i_src_c117_0_06 0 conv_bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_0_06 (conv_i_src_c117_0_06 conv_i_c117_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_06 (conv_q_src_c117_0_06 0 conv_bpf_c117_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_0_06 (conv_q_src_c117_0_06 conv_q_c117_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_07 (conv_i_src_c117_0_07 0 conv_bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_0_07 (conv_i_src_c117_0_07 conv_i_c117_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_07 (conv_q_src_c117_0_07 0 conv_bpf_c117_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_0_07 (conv_q_src_c117_0_07 conv_q_c117_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_08 (conv_i_src_c117_0_08 0 conv_bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_0_08 (conv_i_src_c117_0_08 conv_i_c117_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_08 (conv_q_src_c117_0_08 0 conv_bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_0_08 (conv_q_src_c117_0_08 conv_q_c117_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_09 (conv_i_src_c117_0_09 0 conv_bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_0_09 (conv_i_src_c117_0_09 conv_i_c117_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_09 (conv_q_src_c117_0_09 0 conv_bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_0_09 (conv_q_src_c117_0_09 conv_q_c117_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_10 (conv_i_src_c117_0_10 0 conv_bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_0_10 (conv_i_src_c117_0_10 conv_i_c117_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_10 (conv_q_src_c117_0_10 0 conv_bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_0_10 (conv_q_src_c117_0_10 conv_q_c117_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_11 (conv_i_src_c117_0_11 0 conv_bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_0_11 (conv_i_src_c117_0_11 conv_i_c117_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_11 (conv_q_src_c117_0_11 0 conv_bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_0_11 (conv_q_src_c117_0_11 conv_q_c117_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_12 (conv_i_src_c117_0_12 0 conv_bpf_c117_0 0) vcvs gain=1.950903220161e-01
SCONVI_c117_0_12 (conv_i_src_c117_0_12 conv_i_c117_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_12 (conv_q_src_c117_0_12 0 conv_bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_0_12 (conv_q_src_c117_0_12 conv_q_c117_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_13 (conv_i_src_c117_0_13 0 conv_bpf_c117_0 0) vcvs gain=5.555702330196e-01
SCONVI_c117_0_13 (conv_i_src_c117_0_13 conv_i_c117_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_13 (conv_q_src_c117_0_13 0 conv_bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_0_13 (conv_q_src_c117_0_13 conv_q_c117_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_14 (conv_i_src_c117_0_14 0 conv_bpf_c117_0 0) vcvs gain=8.314696123025e-01
SCONVI_c117_0_14 (conv_i_src_c117_0_14 conv_i_c117_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_14 (conv_q_src_c117_0_14 0 conv_bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_0_14 (conv_q_src_c117_0_14 conv_q_c117_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_0_15 (conv_i_src_c117_0_15 0 conv_bpf_c117_0 0) vcvs gain=9.807852804032e-01
SCONVI_c117_0_15 (conv_i_src_c117_0_15 conv_i_c117_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_0_15 (conv_q_src_c117_0_15 0 conv_bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_0_15 (conv_q_src_c117_0_15 conv_q_c117_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c117_0 (conv_i_c117_0 0) resistor r=1G
RCONVQ_c117_0 (conv_q_c117_0 0) resistor r=1G
RCONVINTI_c117_0 (conv_i_c117_0 ConvIcar_c117_0) resistor r=1k
CCONVINTI_c117_0 (ConvIcar_c117_0 0) capacitor c=80p
RCONVINTQ_c117_0 (conv_q_c117_0 ConvQcar_c117_0) resistor r=1k
CCONVINTQ_c117_0 (ConvQcar_c117_0 0) capacitor c=80p
save conv_bpf_c117_0 ConvIcar_c117_0 ConvQcar_c117_0

// conventional mixed baseline bl117, carrier_1: 500000000 Hz
CCONVBPF_c117_1 (bl117 n_conv_cbpf_c117_1) capacitor c=1.013211836423e-13
LCONVBPF_c117_1 (n_conv_cbpf_c117_1 conv_bpf_c117_1) inductor l=1.000000000000e-06
RCONVBPF_c117_1 (conv_bpf_c117_1 0) resistor r=1.570796326795e+02
ECONVI_c117_1_00 (conv_i_src_c117_1_00 0 conv_bpf_c117_1 0) vcvs gain=9.807852804032e-01
SCONVI_c117_1_00 (conv_i_src_c117_1_00 conv_i_c117_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_00 (conv_q_src_c117_1_00 0 conv_bpf_c117_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_1_00 (conv_q_src_c117_1_00 conv_q_c117_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_01 (conv_i_src_c117_1_01 0 conv_bpf_c117_1 0) vcvs gain=8.314696123025e-01
SCONVI_c117_1_01 (conv_i_src_c117_1_01 conv_i_c117_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_01 (conv_q_src_c117_1_01 0 conv_bpf_c117_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_1_01 (conv_q_src_c117_1_01 conv_q_c117_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_02 (conv_i_src_c117_1_02 0 conv_bpf_c117_1 0) vcvs gain=5.555702330196e-01
SCONVI_c117_1_02 (conv_i_src_c117_1_02 conv_i_c117_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_02 (conv_q_src_c117_1_02 0 conv_bpf_c117_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_1_02 (conv_q_src_c117_1_02 conv_q_c117_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_03 (conv_i_src_c117_1_03 0 conv_bpf_c117_1 0) vcvs gain=1.950903220161e-01
SCONVI_c117_1_03 (conv_i_src_c117_1_03 conv_i_c117_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_03 (conv_q_src_c117_1_03 0 conv_bpf_c117_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_1_03 (conv_q_src_c117_1_03 conv_q_c117_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_04 (conv_i_src_c117_1_04 0 conv_bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_1_04 (conv_i_src_c117_1_04 conv_i_c117_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_04 (conv_q_src_c117_1_04 0 conv_bpf_c117_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_1_04 (conv_q_src_c117_1_04 conv_q_c117_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_05 (conv_i_src_c117_1_05 0 conv_bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_1_05 (conv_i_src_c117_1_05 conv_i_c117_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_05 (conv_q_src_c117_1_05 0 conv_bpf_c117_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_1_05 (conv_q_src_c117_1_05 conv_q_c117_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_06 (conv_i_src_c117_1_06 0 conv_bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_1_06 (conv_i_src_c117_1_06 conv_i_c117_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_06 (conv_q_src_c117_1_06 0 conv_bpf_c117_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_1_06 (conv_q_src_c117_1_06 conv_q_c117_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_07 (conv_i_src_c117_1_07 0 conv_bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_1_07 (conv_i_src_c117_1_07 conv_i_c117_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_07 (conv_q_src_c117_1_07 0 conv_bpf_c117_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_1_07 (conv_q_src_c117_1_07 conv_q_c117_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_08 (conv_i_src_c117_1_08 0 conv_bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_1_08 (conv_i_src_c117_1_08 conv_i_c117_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_08 (conv_q_src_c117_1_08 0 conv_bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_1_08 (conv_q_src_c117_1_08 conv_q_c117_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_09 (conv_i_src_c117_1_09 0 conv_bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_1_09 (conv_i_src_c117_1_09 conv_i_c117_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_09 (conv_q_src_c117_1_09 0 conv_bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_1_09 (conv_q_src_c117_1_09 conv_q_c117_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_10 (conv_i_src_c117_1_10 0 conv_bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_1_10 (conv_i_src_c117_1_10 conv_i_c117_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_10 (conv_q_src_c117_1_10 0 conv_bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_1_10 (conv_q_src_c117_1_10 conv_q_c117_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_11 (conv_i_src_c117_1_11 0 conv_bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_1_11 (conv_i_src_c117_1_11 conv_i_c117_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_11 (conv_q_src_c117_1_11 0 conv_bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_1_11 (conv_q_src_c117_1_11 conv_q_c117_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_12 (conv_i_src_c117_1_12 0 conv_bpf_c117_1 0) vcvs gain=1.950903220161e-01
SCONVI_c117_1_12 (conv_i_src_c117_1_12 conv_i_c117_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_12 (conv_q_src_c117_1_12 0 conv_bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_1_12 (conv_q_src_c117_1_12 conv_q_c117_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_13 (conv_i_src_c117_1_13 0 conv_bpf_c117_1 0) vcvs gain=5.555702330196e-01
SCONVI_c117_1_13 (conv_i_src_c117_1_13 conv_i_c117_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_13 (conv_q_src_c117_1_13 0 conv_bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_1_13 (conv_q_src_c117_1_13 conv_q_c117_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_14 (conv_i_src_c117_1_14 0 conv_bpf_c117_1 0) vcvs gain=8.314696123025e-01
SCONVI_c117_1_14 (conv_i_src_c117_1_14 conv_i_c117_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_14 (conv_q_src_c117_1_14 0 conv_bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_1_14 (conv_q_src_c117_1_14 conv_q_c117_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_1_15 (conv_i_src_c117_1_15 0 conv_bpf_c117_1 0) vcvs gain=9.807852804032e-01
SCONVI_c117_1_15 (conv_i_src_c117_1_15 conv_i_c117_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_1_15 (conv_q_src_c117_1_15 0 conv_bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_1_15 (conv_q_src_c117_1_15 conv_q_c117_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c117_1 (conv_i_c117_1 0) resistor r=1G
RCONVQ_c117_1 (conv_q_c117_1 0) resistor r=1G
RCONVINTI_c117_1 (conv_i_c117_1 ConvIcar_c117_1) resistor r=1k
CCONVINTI_c117_1 (ConvIcar_c117_1 0) capacitor c=80p
RCONVINTQ_c117_1 (conv_q_c117_1 ConvQcar_c117_1) resistor r=1k
CCONVINTQ_c117_1 (ConvQcar_c117_1 0) capacitor c=80p
save conv_bpf_c117_1 ConvIcar_c117_1 ConvQcar_c117_1

// conventional mixed baseline bl117, carrier_2: 750000000 Hz
CCONVBPF_c117_2 (bl117 n_conv_cbpf_c117_2) capacitor c=4.503163717437e-14
LCONVBPF_c117_2 (n_conv_cbpf_c117_2 conv_bpf_c117_2) inductor l=1.000000000000e-06
RCONVBPF_c117_2 (conv_bpf_c117_2 0) resistor r=2.356194490192e+02
ECONVI_c117_2_00 (conv_i_src_c117_2_00 0 conv_bpf_c117_2 0) vcvs gain=9.807852804032e-01
SCONVI_c117_2_00 (conv_i_src_c117_2_00 conv_i_c117_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_00 (conv_q_src_c117_2_00 0 conv_bpf_c117_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_2_00 (conv_q_src_c117_2_00 conv_q_c117_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_01 (conv_i_src_c117_2_01 0 conv_bpf_c117_2 0) vcvs gain=8.314696123025e-01
SCONVI_c117_2_01 (conv_i_src_c117_2_01 conv_i_c117_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_01 (conv_q_src_c117_2_01 0 conv_bpf_c117_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_2_01 (conv_q_src_c117_2_01 conv_q_c117_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_02 (conv_i_src_c117_2_02 0 conv_bpf_c117_2 0) vcvs gain=5.555702330196e-01
SCONVI_c117_2_02 (conv_i_src_c117_2_02 conv_i_c117_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_02 (conv_q_src_c117_2_02 0 conv_bpf_c117_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_2_02 (conv_q_src_c117_2_02 conv_q_c117_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_03 (conv_i_src_c117_2_03 0 conv_bpf_c117_2 0) vcvs gain=1.950903220161e-01
SCONVI_c117_2_03 (conv_i_src_c117_2_03 conv_i_c117_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_03 (conv_q_src_c117_2_03 0 conv_bpf_c117_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_2_03 (conv_q_src_c117_2_03 conv_q_c117_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_04 (conv_i_src_c117_2_04 0 conv_bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_2_04 (conv_i_src_c117_2_04 conv_i_c117_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_04 (conv_q_src_c117_2_04 0 conv_bpf_c117_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_2_04 (conv_q_src_c117_2_04 conv_q_c117_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_05 (conv_i_src_c117_2_05 0 conv_bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_2_05 (conv_i_src_c117_2_05 conv_i_c117_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_05 (conv_q_src_c117_2_05 0 conv_bpf_c117_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_2_05 (conv_q_src_c117_2_05 conv_q_c117_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_06 (conv_i_src_c117_2_06 0 conv_bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_2_06 (conv_i_src_c117_2_06 conv_i_c117_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_06 (conv_q_src_c117_2_06 0 conv_bpf_c117_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_2_06 (conv_q_src_c117_2_06 conv_q_c117_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_07 (conv_i_src_c117_2_07 0 conv_bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_2_07 (conv_i_src_c117_2_07 conv_i_c117_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_07 (conv_q_src_c117_2_07 0 conv_bpf_c117_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_2_07 (conv_q_src_c117_2_07 conv_q_c117_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_08 (conv_i_src_c117_2_08 0 conv_bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_2_08 (conv_i_src_c117_2_08 conv_i_c117_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_08 (conv_q_src_c117_2_08 0 conv_bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_2_08 (conv_q_src_c117_2_08 conv_q_c117_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_09 (conv_i_src_c117_2_09 0 conv_bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_2_09 (conv_i_src_c117_2_09 conv_i_c117_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_09 (conv_q_src_c117_2_09 0 conv_bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_2_09 (conv_q_src_c117_2_09 conv_q_c117_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_10 (conv_i_src_c117_2_10 0 conv_bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_2_10 (conv_i_src_c117_2_10 conv_i_c117_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_10 (conv_q_src_c117_2_10 0 conv_bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_2_10 (conv_q_src_c117_2_10 conv_q_c117_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_11 (conv_i_src_c117_2_11 0 conv_bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_2_11 (conv_i_src_c117_2_11 conv_i_c117_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_11 (conv_q_src_c117_2_11 0 conv_bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_2_11 (conv_q_src_c117_2_11 conv_q_c117_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_12 (conv_i_src_c117_2_12 0 conv_bpf_c117_2 0) vcvs gain=1.950903220161e-01
SCONVI_c117_2_12 (conv_i_src_c117_2_12 conv_i_c117_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_12 (conv_q_src_c117_2_12 0 conv_bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_2_12 (conv_q_src_c117_2_12 conv_q_c117_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_13 (conv_i_src_c117_2_13 0 conv_bpf_c117_2 0) vcvs gain=5.555702330196e-01
SCONVI_c117_2_13 (conv_i_src_c117_2_13 conv_i_c117_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_13 (conv_q_src_c117_2_13 0 conv_bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_2_13 (conv_q_src_c117_2_13 conv_q_c117_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_14 (conv_i_src_c117_2_14 0 conv_bpf_c117_2 0) vcvs gain=8.314696123025e-01
SCONVI_c117_2_14 (conv_i_src_c117_2_14 conv_i_c117_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_14 (conv_q_src_c117_2_14 0 conv_bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_2_14 (conv_q_src_c117_2_14 conv_q_c117_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_2_15 (conv_i_src_c117_2_15 0 conv_bpf_c117_2 0) vcvs gain=9.807852804032e-01
SCONVI_c117_2_15 (conv_i_src_c117_2_15 conv_i_c117_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_2_15 (conv_q_src_c117_2_15 0 conv_bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_2_15 (conv_q_src_c117_2_15 conv_q_c117_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c117_2 (conv_i_c117_2 0) resistor r=1G
RCONVQ_c117_2 (conv_q_c117_2 0) resistor r=1G
RCONVINTI_c117_2 (conv_i_c117_2 ConvIcar_c117_2) resistor r=1k
CCONVINTI_c117_2 (ConvIcar_c117_2 0) capacitor c=80p
RCONVINTQ_c117_2 (conv_q_c117_2 ConvQcar_c117_2) resistor r=1k
CCONVINTQ_c117_2 (ConvQcar_c117_2 0) capacitor c=80p
save conv_bpf_c117_2 ConvIcar_c117_2 ConvQcar_c117_2

// conventional mixed baseline bl117, carrier_3: 1000000000 Hz
CCONVBPF_c117_3 (bl117 n_conv_cbpf_c117_3) capacitor c=2.533029591058e-14
LCONVBPF_c117_3 (n_conv_cbpf_c117_3 conv_bpf_c117_3) inductor l=1.000000000000e-06
RCONVBPF_c117_3 (conv_bpf_c117_3 0) resistor r=3.141592653590e+02
ECONVI_c117_3_00 (conv_i_src_c117_3_00 0 conv_bpf_c117_3 0) vcvs gain=9.807852804032e-01
SCONVI_c117_3_00 (conv_i_src_c117_3_00 conv_i_c117_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_00 (conv_q_src_c117_3_00 0 conv_bpf_c117_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_3_00 (conv_q_src_c117_3_00 conv_q_c117_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_01 (conv_i_src_c117_3_01 0 conv_bpf_c117_3 0) vcvs gain=8.314696123025e-01
SCONVI_c117_3_01 (conv_i_src_c117_3_01 conv_i_c117_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_01 (conv_q_src_c117_3_01 0 conv_bpf_c117_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_3_01 (conv_q_src_c117_3_01 conv_q_c117_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_02 (conv_i_src_c117_3_02 0 conv_bpf_c117_3 0) vcvs gain=5.555702330196e-01
SCONVI_c117_3_02 (conv_i_src_c117_3_02 conv_i_c117_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_02 (conv_q_src_c117_3_02 0 conv_bpf_c117_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_3_02 (conv_q_src_c117_3_02 conv_q_c117_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_03 (conv_i_src_c117_3_03 0 conv_bpf_c117_3 0) vcvs gain=1.950903220161e-01
SCONVI_c117_3_03 (conv_i_src_c117_3_03 conv_i_c117_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_03 (conv_q_src_c117_3_03 0 conv_bpf_c117_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_3_03 (conv_q_src_c117_3_03 conv_q_c117_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_04 (conv_i_src_c117_3_04 0 conv_bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_3_04 (conv_i_src_c117_3_04 conv_i_c117_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_04 (conv_q_src_c117_3_04 0 conv_bpf_c117_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c117_3_04 (conv_q_src_c117_3_04 conv_q_c117_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_05 (conv_i_src_c117_3_05 0 conv_bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_3_05 (conv_i_src_c117_3_05 conv_i_c117_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_05 (conv_q_src_c117_3_05 0 conv_bpf_c117_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c117_3_05 (conv_q_src_c117_3_05 conv_q_c117_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_06 (conv_i_src_c117_3_06 0 conv_bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_3_06 (conv_i_src_c117_3_06 conv_i_c117_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_06 (conv_q_src_c117_3_06 0 conv_bpf_c117_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c117_3_06 (conv_q_src_c117_3_06 conv_q_c117_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_07 (conv_i_src_c117_3_07 0 conv_bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_3_07 (conv_i_src_c117_3_07 conv_i_c117_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_07 (conv_q_src_c117_3_07 0 conv_bpf_c117_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c117_3_07 (conv_q_src_c117_3_07 conv_q_c117_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_08 (conv_i_src_c117_3_08 0 conv_bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c117_3_08 (conv_i_src_c117_3_08 conv_i_c117_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_08 (conv_q_src_c117_3_08 0 conv_bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_3_08 (conv_q_src_c117_3_08 conv_q_c117_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_09 (conv_i_src_c117_3_09 0 conv_bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c117_3_09 (conv_i_src_c117_3_09 conv_i_c117_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_09 (conv_q_src_c117_3_09 0 conv_bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_3_09 (conv_q_src_c117_3_09 conv_q_c117_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_10 (conv_i_src_c117_3_10 0 conv_bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c117_3_10 (conv_i_src_c117_3_10 conv_i_c117_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_10 (conv_q_src_c117_3_10 0 conv_bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_3_10 (conv_q_src_c117_3_10 conv_q_c117_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_11 (conv_i_src_c117_3_11 0 conv_bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c117_3_11 (conv_i_src_c117_3_11 conv_i_c117_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_11 (conv_q_src_c117_3_11 0 conv_bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_3_11 (conv_q_src_c117_3_11 conv_q_c117_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_12 (conv_i_src_c117_3_12 0 conv_bpf_c117_3 0) vcvs gain=1.950903220161e-01
SCONVI_c117_3_12 (conv_i_src_c117_3_12 conv_i_c117_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_12 (conv_q_src_c117_3_12 0 conv_bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c117_3_12 (conv_q_src_c117_3_12 conv_q_c117_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_13 (conv_i_src_c117_3_13 0 conv_bpf_c117_3 0) vcvs gain=5.555702330196e-01
SCONVI_c117_3_13 (conv_i_src_c117_3_13 conv_i_c117_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_13 (conv_q_src_c117_3_13 0 conv_bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c117_3_13 (conv_q_src_c117_3_13 conv_q_c117_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_14 (conv_i_src_c117_3_14 0 conv_bpf_c117_3 0) vcvs gain=8.314696123025e-01
SCONVI_c117_3_14 (conv_i_src_c117_3_14 conv_i_c117_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_14 (conv_q_src_c117_3_14 0 conv_bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c117_3_14 (conv_q_src_c117_3_14 conv_q_c117_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c117_3_15 (conv_i_src_c117_3_15 0 conv_bpf_c117_3 0) vcvs gain=9.807852804032e-01
SCONVI_c117_3_15 (conv_i_src_c117_3_15 conv_i_c117_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c117_3_15 (conv_q_src_c117_3_15 0 conv_bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c117_3_15 (conv_q_src_c117_3_15 conv_q_c117_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c117_3 (conv_i_c117_3 0) resistor r=1G
RCONVQ_c117_3 (conv_q_c117_3 0) resistor r=1G
RCONVINTI_c117_3 (conv_i_c117_3 ConvIcar_c117_3) resistor r=1k
CCONVINTI_c117_3 (ConvIcar_c117_3 0) capacitor c=80p
RCONVINTQ_c117_3 (conv_q_c117_3 ConvQcar_c117_3) resistor r=1k
CCONVINTQ_c117_3 (ConvQcar_c117_3 0) capacitor c=80p
save conv_bpf_c117_3 ConvIcar_c117_3 ConvQcar_c117_3

// conventional mixed baseline bl118, carrier_0: 250000000 Hz
CCONVBPF_c118_0 (bl118 n_conv_cbpf_c118_0) capacitor c=4.052847345694e-13
LCONVBPF_c118_0 (n_conv_cbpf_c118_0 conv_bpf_c118_0) inductor l=1.000000000000e-06
RCONVBPF_c118_0 (conv_bpf_c118_0 0) resistor r=7.853981633974e+01
ECONVI_c118_0_00 (conv_i_src_c118_0_00 0 conv_bpf_c118_0 0) vcvs gain=9.807852804032e-01
SCONVI_c118_0_00 (conv_i_src_c118_0_00 conv_i_c118_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_00 (conv_q_src_c118_0_00 0 conv_bpf_c118_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_0_00 (conv_q_src_c118_0_00 conv_q_c118_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_01 (conv_i_src_c118_0_01 0 conv_bpf_c118_0 0) vcvs gain=8.314696123025e-01
SCONVI_c118_0_01 (conv_i_src_c118_0_01 conv_i_c118_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_01 (conv_q_src_c118_0_01 0 conv_bpf_c118_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_0_01 (conv_q_src_c118_0_01 conv_q_c118_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_02 (conv_i_src_c118_0_02 0 conv_bpf_c118_0 0) vcvs gain=5.555702330196e-01
SCONVI_c118_0_02 (conv_i_src_c118_0_02 conv_i_c118_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_02 (conv_q_src_c118_0_02 0 conv_bpf_c118_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_0_02 (conv_q_src_c118_0_02 conv_q_c118_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_03 (conv_i_src_c118_0_03 0 conv_bpf_c118_0 0) vcvs gain=1.950903220161e-01
SCONVI_c118_0_03 (conv_i_src_c118_0_03 conv_i_c118_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_03 (conv_q_src_c118_0_03 0 conv_bpf_c118_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_0_03 (conv_q_src_c118_0_03 conv_q_c118_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_04 (conv_i_src_c118_0_04 0 conv_bpf_c118_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c118_0_04 (conv_i_src_c118_0_04 conv_i_c118_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_04 (conv_q_src_c118_0_04 0 conv_bpf_c118_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_0_04 (conv_q_src_c118_0_04 conv_q_c118_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_05 (conv_i_src_c118_0_05 0 conv_bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_0_05 (conv_i_src_c118_0_05 conv_i_c118_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_05 (conv_q_src_c118_0_05 0 conv_bpf_c118_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_0_05 (conv_q_src_c118_0_05 conv_q_c118_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_06 (conv_i_src_c118_0_06 0 conv_bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_0_06 (conv_i_src_c118_0_06 conv_i_c118_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_06 (conv_q_src_c118_0_06 0 conv_bpf_c118_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_0_06 (conv_q_src_c118_0_06 conv_q_c118_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_07 (conv_i_src_c118_0_07 0 conv_bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_0_07 (conv_i_src_c118_0_07 conv_i_c118_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_07 (conv_q_src_c118_0_07 0 conv_bpf_c118_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_0_07 (conv_q_src_c118_0_07 conv_q_c118_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_08 (conv_i_src_c118_0_08 0 conv_bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_0_08 (conv_i_src_c118_0_08 conv_i_c118_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_08 (conv_q_src_c118_0_08 0 conv_bpf_c118_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_0_08 (conv_q_src_c118_0_08 conv_q_c118_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_09 (conv_i_src_c118_0_09 0 conv_bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_0_09 (conv_i_src_c118_0_09 conv_i_c118_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_09 (conv_q_src_c118_0_09 0 conv_bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_0_09 (conv_q_src_c118_0_09 conv_q_c118_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_10 (conv_i_src_c118_0_10 0 conv_bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_0_10 (conv_i_src_c118_0_10 conv_i_c118_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_10 (conv_q_src_c118_0_10 0 conv_bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_0_10 (conv_q_src_c118_0_10 conv_q_c118_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_11 (conv_i_src_c118_0_11 0 conv_bpf_c118_0 0) vcvs gain=-1.950903220161e-01
