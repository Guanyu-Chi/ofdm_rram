SCONVI_c078_2_10 (conv_i_src_c078_2_10 conv_i_c078_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_10 (conv_q_src_c078_2_10 0 conv_bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_2_10 (conv_q_src_c078_2_10 conv_q_c078_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_11 (conv_i_src_c078_2_11 0 conv_bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_2_11 (conv_i_src_c078_2_11 conv_i_c078_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_11 (conv_q_src_c078_2_11 0 conv_bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_2_11 (conv_q_src_c078_2_11 conv_q_c078_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_12 (conv_i_src_c078_2_12 0 conv_bpf_c078_2 0) vcvs gain=1.950903220161e-01
SCONVI_c078_2_12 (conv_i_src_c078_2_12 conv_i_c078_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_12 (conv_q_src_c078_2_12 0 conv_bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_2_12 (conv_q_src_c078_2_12 conv_q_c078_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_13 (conv_i_src_c078_2_13 0 conv_bpf_c078_2 0) vcvs gain=5.555702330196e-01
SCONVI_c078_2_13 (conv_i_src_c078_2_13 conv_i_c078_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_13 (conv_q_src_c078_2_13 0 conv_bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_2_13 (conv_q_src_c078_2_13 conv_q_c078_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_14 (conv_i_src_c078_2_14 0 conv_bpf_c078_2 0) vcvs gain=8.314696123025e-01
SCONVI_c078_2_14 (conv_i_src_c078_2_14 conv_i_c078_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_14 (conv_q_src_c078_2_14 0 conv_bpf_c078_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_2_14 (conv_q_src_c078_2_14 conv_q_c078_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_15 (conv_i_src_c078_2_15 0 conv_bpf_c078_2 0) vcvs gain=9.807852804032e-01
SCONVI_c078_2_15 (conv_i_src_c078_2_15 conv_i_c078_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_15 (conv_q_src_c078_2_15 0 conv_bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_2_15 (conv_q_src_c078_2_15 conv_q_c078_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c078_2 (conv_i_c078_2 0) resistor r=1G
RCONVQ_c078_2 (conv_q_c078_2 0) resistor r=1G
RCONVINTI_c078_2 (conv_i_c078_2 ConvIcar_c078_2) resistor r=1k
CCONVINTI_c078_2 (ConvIcar_c078_2 0) capacitor c=80p
RCONVINTQ_c078_2 (conv_q_c078_2 ConvQcar_c078_2) resistor r=1k
CCONVINTQ_c078_2 (ConvQcar_c078_2 0) capacitor c=80p
save conv_bpf_c078_2 ConvIcar_c078_2 ConvQcar_c078_2

// conventional mixed baseline bl078, carrier_3: 1000000000 Hz
CCONVBPF_c078_3 (bl078 n_conv_cbpf_c078_3) capacitor c=2.533029591058e-14
LCONVBPF_c078_3 (n_conv_cbpf_c078_3 conv_bpf_c078_3) inductor l=1.000000000000e-06
RCONVBPF_c078_3 (conv_bpf_c078_3 0) resistor r=3.141592653590e+02
ECONVI_c078_3_00 (conv_i_src_c078_3_00 0 conv_bpf_c078_3 0) vcvs gain=9.807852804032e-01
SCONVI_c078_3_00 (conv_i_src_c078_3_00 conv_i_c078_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_00 (conv_q_src_c078_3_00 0 conv_bpf_c078_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_3_00 (conv_q_src_c078_3_00 conv_q_c078_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_01 (conv_i_src_c078_3_01 0 conv_bpf_c078_3 0) vcvs gain=8.314696123025e-01
SCONVI_c078_3_01 (conv_i_src_c078_3_01 conv_i_c078_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_01 (conv_q_src_c078_3_01 0 conv_bpf_c078_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_3_01 (conv_q_src_c078_3_01 conv_q_c078_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_02 (conv_i_src_c078_3_02 0 conv_bpf_c078_3 0) vcvs gain=5.555702330196e-01
SCONVI_c078_3_02 (conv_i_src_c078_3_02 conv_i_c078_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_02 (conv_q_src_c078_3_02 0 conv_bpf_c078_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_3_02 (conv_q_src_c078_3_02 conv_q_c078_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_03 (conv_i_src_c078_3_03 0 conv_bpf_c078_3 0) vcvs gain=1.950903220161e-01
SCONVI_c078_3_03 (conv_i_src_c078_3_03 conv_i_c078_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_03 (conv_q_src_c078_3_03 0 conv_bpf_c078_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_3_03 (conv_q_src_c078_3_03 conv_q_c078_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_04 (conv_i_src_c078_3_04 0 conv_bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_3_04 (conv_i_src_c078_3_04 conv_i_c078_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_04 (conv_q_src_c078_3_04 0 conv_bpf_c078_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_3_04 (conv_q_src_c078_3_04 conv_q_c078_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_05 (conv_i_src_c078_3_05 0 conv_bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c078_3_05 (conv_i_src_c078_3_05 conv_i_c078_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_05 (conv_q_src_c078_3_05 0 conv_bpf_c078_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_3_05 (conv_q_src_c078_3_05 conv_q_c078_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_06 (conv_i_src_c078_3_06 0 conv_bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_3_06 (conv_i_src_c078_3_06 conv_i_c078_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_06 (conv_q_src_c078_3_06 0 conv_bpf_c078_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_3_06 (conv_q_src_c078_3_06 conv_q_c078_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_07 (conv_i_src_c078_3_07 0 conv_bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_3_07 (conv_i_src_c078_3_07 conv_i_c078_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_07 (conv_q_src_c078_3_07 0 conv_bpf_c078_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_3_07 (conv_q_src_c078_3_07 conv_q_c078_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_08 (conv_i_src_c078_3_08 0 conv_bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_3_08 (conv_i_src_c078_3_08 conv_i_c078_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_08 (conv_q_src_c078_3_08 0 conv_bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_3_08 (conv_q_src_c078_3_08 conv_q_c078_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_09 (conv_i_src_c078_3_09 0 conv_bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_3_09 (conv_i_src_c078_3_09 conv_i_c078_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_09 (conv_q_src_c078_3_09 0 conv_bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_3_09 (conv_q_src_c078_3_09 conv_q_c078_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_10 (conv_i_src_c078_3_10 0 conv_bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c078_3_10 (conv_i_src_c078_3_10 conv_i_c078_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_10 (conv_q_src_c078_3_10 0 conv_bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_3_10 (conv_q_src_c078_3_10 conv_q_c078_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_11 (conv_i_src_c078_3_11 0 conv_bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_3_11 (conv_i_src_c078_3_11 conv_i_c078_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_11 (conv_q_src_c078_3_11 0 conv_bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_3_11 (conv_q_src_c078_3_11 conv_q_c078_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_12 (conv_i_src_c078_3_12 0 conv_bpf_c078_3 0) vcvs gain=1.950903220161e-01
SCONVI_c078_3_12 (conv_i_src_c078_3_12 conv_i_c078_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_12 (conv_q_src_c078_3_12 0 conv_bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_3_12 (conv_q_src_c078_3_12 conv_q_c078_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_13 (conv_i_src_c078_3_13 0 conv_bpf_c078_3 0) vcvs gain=5.555702330196e-01
SCONVI_c078_3_13 (conv_i_src_c078_3_13 conv_i_c078_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_13 (conv_q_src_c078_3_13 0 conv_bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_3_13 (conv_q_src_c078_3_13 conv_q_c078_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_14 (conv_i_src_c078_3_14 0 conv_bpf_c078_3 0) vcvs gain=8.314696123025e-01
SCONVI_c078_3_14 (conv_i_src_c078_3_14 conv_i_c078_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_14 (conv_q_src_c078_3_14 0 conv_bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_3_14 (conv_q_src_c078_3_14 conv_q_c078_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_3_15 (conv_i_src_c078_3_15 0 conv_bpf_c078_3 0) vcvs gain=9.807852804032e-01
SCONVI_c078_3_15 (conv_i_src_c078_3_15 conv_i_c078_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_3_15 (conv_q_src_c078_3_15 0 conv_bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_3_15 (conv_q_src_c078_3_15 conv_q_c078_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c078_3 (conv_i_c078_3 0) resistor r=1G
RCONVQ_c078_3 (conv_q_c078_3 0) resistor r=1G
RCONVINTI_c078_3 (conv_i_c078_3 ConvIcar_c078_3) resistor r=1k
CCONVINTI_c078_3 (ConvIcar_c078_3 0) capacitor c=80p
RCONVINTQ_c078_3 (conv_q_c078_3 ConvQcar_c078_3) resistor r=1k
CCONVINTQ_c078_3 (ConvQcar_c078_3 0) capacitor c=80p
save conv_bpf_c078_3 ConvIcar_c078_3 ConvQcar_c078_3

// conventional mixed baseline bl079, carrier_0: 250000000 Hz
CCONVBPF_c079_0 (bl079 n_conv_cbpf_c079_0) capacitor c=4.052847345694e-13
LCONVBPF_c079_0 (n_conv_cbpf_c079_0 conv_bpf_c079_0) inductor l=1.000000000000e-06
RCONVBPF_c079_0 (conv_bpf_c079_0 0) resistor r=7.853981633974e+01
ECONVI_c079_0_00 (conv_i_src_c079_0_00 0 conv_bpf_c079_0 0) vcvs gain=9.807852804032e-01
SCONVI_c079_0_00 (conv_i_src_c079_0_00 conv_i_c079_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_00 (conv_q_src_c079_0_00 0 conv_bpf_c079_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_0_00 (conv_q_src_c079_0_00 conv_q_c079_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_01 (conv_i_src_c079_0_01 0 conv_bpf_c079_0 0) vcvs gain=8.314696123025e-01
SCONVI_c079_0_01 (conv_i_src_c079_0_01 conv_i_c079_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_01 (conv_q_src_c079_0_01 0 conv_bpf_c079_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_0_01 (conv_q_src_c079_0_01 conv_q_c079_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_02 (conv_i_src_c079_0_02 0 conv_bpf_c079_0 0) vcvs gain=5.555702330196e-01
SCONVI_c079_0_02 (conv_i_src_c079_0_02 conv_i_c079_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_02 (conv_q_src_c079_0_02 0 conv_bpf_c079_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_0_02 (conv_q_src_c079_0_02 conv_q_c079_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_03 (conv_i_src_c079_0_03 0 conv_bpf_c079_0 0) vcvs gain=1.950903220161e-01
SCONVI_c079_0_03 (conv_i_src_c079_0_03 conv_i_c079_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_03 (conv_q_src_c079_0_03 0 conv_bpf_c079_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_0_03 (conv_q_src_c079_0_03 conv_q_c079_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_04 (conv_i_src_c079_0_04 0 conv_bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_0_04 (conv_i_src_c079_0_04 conv_i_c079_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_04 (conv_q_src_c079_0_04 0 conv_bpf_c079_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_0_04 (conv_q_src_c079_0_04 conv_q_c079_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_05 (conv_i_src_c079_0_05 0 conv_bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_0_05 (conv_i_src_c079_0_05 conv_i_c079_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_05 (conv_q_src_c079_0_05 0 conv_bpf_c079_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_0_05 (conv_q_src_c079_0_05 conv_q_c079_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_06 (conv_i_src_c079_0_06 0 conv_bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_0_06 (conv_i_src_c079_0_06 conv_i_c079_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_06 (conv_q_src_c079_0_06 0 conv_bpf_c079_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_0_06 (conv_q_src_c079_0_06 conv_q_c079_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_07 (conv_i_src_c079_0_07 0 conv_bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_0_07 (conv_i_src_c079_0_07 conv_i_c079_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_07 (conv_q_src_c079_0_07 0 conv_bpf_c079_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_0_07 (conv_q_src_c079_0_07 conv_q_c079_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_08 (conv_i_src_c079_0_08 0 conv_bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_0_08 (conv_i_src_c079_0_08 conv_i_c079_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_08 (conv_q_src_c079_0_08 0 conv_bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_0_08 (conv_q_src_c079_0_08 conv_q_c079_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_09 (conv_i_src_c079_0_09 0 conv_bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_0_09 (conv_i_src_c079_0_09 conv_i_c079_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_09 (conv_q_src_c079_0_09 0 conv_bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_0_09 (conv_q_src_c079_0_09 conv_q_c079_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_10 (conv_i_src_c079_0_10 0 conv_bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_0_10 (conv_i_src_c079_0_10 conv_i_c079_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_10 (conv_q_src_c079_0_10 0 conv_bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_0_10 (conv_q_src_c079_0_10 conv_q_c079_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_11 (conv_i_src_c079_0_11 0 conv_bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_0_11 (conv_i_src_c079_0_11 conv_i_c079_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_11 (conv_q_src_c079_0_11 0 conv_bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_0_11 (conv_q_src_c079_0_11 conv_q_c079_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_12 (conv_i_src_c079_0_12 0 conv_bpf_c079_0 0) vcvs gain=1.950903220161e-01
SCONVI_c079_0_12 (conv_i_src_c079_0_12 conv_i_c079_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_12 (conv_q_src_c079_0_12 0 conv_bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_0_12 (conv_q_src_c079_0_12 conv_q_c079_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_13 (conv_i_src_c079_0_13 0 conv_bpf_c079_0 0) vcvs gain=5.555702330196e-01
SCONVI_c079_0_13 (conv_i_src_c079_0_13 conv_i_c079_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_13 (conv_q_src_c079_0_13 0 conv_bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_0_13 (conv_q_src_c079_0_13 conv_q_c079_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_14 (conv_i_src_c079_0_14 0 conv_bpf_c079_0 0) vcvs gain=8.314696123025e-01
SCONVI_c079_0_14 (conv_i_src_c079_0_14 conv_i_c079_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_14 (conv_q_src_c079_0_14 0 conv_bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_0_14 (conv_q_src_c079_0_14 conv_q_c079_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_0_15 (conv_i_src_c079_0_15 0 conv_bpf_c079_0 0) vcvs gain=9.807852804032e-01
SCONVI_c079_0_15 (conv_i_src_c079_0_15 conv_i_c079_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_0_15 (conv_q_src_c079_0_15 0 conv_bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_0_15 (conv_q_src_c079_0_15 conv_q_c079_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c079_0 (conv_i_c079_0 0) resistor r=1G
RCONVQ_c079_0 (conv_q_c079_0 0) resistor r=1G
RCONVINTI_c079_0 (conv_i_c079_0 ConvIcar_c079_0) resistor r=1k
CCONVINTI_c079_0 (ConvIcar_c079_0 0) capacitor c=80p
RCONVINTQ_c079_0 (conv_q_c079_0 ConvQcar_c079_0) resistor r=1k
CCONVINTQ_c079_0 (ConvQcar_c079_0 0) capacitor c=80p
save conv_bpf_c079_0 ConvIcar_c079_0 ConvQcar_c079_0

// conventional mixed baseline bl079, carrier_1: 500000000 Hz
CCONVBPF_c079_1 (bl079 n_conv_cbpf_c079_1) capacitor c=1.013211836423e-13
LCONVBPF_c079_1 (n_conv_cbpf_c079_1 conv_bpf_c079_1) inductor l=1.000000000000e-06
RCONVBPF_c079_1 (conv_bpf_c079_1 0) resistor r=1.570796326795e+02
ECONVI_c079_1_00 (conv_i_src_c079_1_00 0 conv_bpf_c079_1 0) vcvs gain=9.807852804032e-01
SCONVI_c079_1_00 (conv_i_src_c079_1_00 conv_i_c079_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_00 (conv_q_src_c079_1_00 0 conv_bpf_c079_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_1_00 (conv_q_src_c079_1_00 conv_q_c079_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_01 (conv_i_src_c079_1_01 0 conv_bpf_c079_1 0) vcvs gain=8.314696123025e-01
SCONVI_c079_1_01 (conv_i_src_c079_1_01 conv_i_c079_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_01 (conv_q_src_c079_1_01 0 conv_bpf_c079_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_1_01 (conv_q_src_c079_1_01 conv_q_c079_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_02 (conv_i_src_c079_1_02 0 conv_bpf_c079_1 0) vcvs gain=5.555702330196e-01
SCONVI_c079_1_02 (conv_i_src_c079_1_02 conv_i_c079_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_02 (conv_q_src_c079_1_02 0 conv_bpf_c079_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_1_02 (conv_q_src_c079_1_02 conv_q_c079_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_03 (conv_i_src_c079_1_03 0 conv_bpf_c079_1 0) vcvs gain=1.950903220161e-01
SCONVI_c079_1_03 (conv_i_src_c079_1_03 conv_i_c079_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_03 (conv_q_src_c079_1_03 0 conv_bpf_c079_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_1_03 (conv_q_src_c079_1_03 conv_q_c079_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_04 (conv_i_src_c079_1_04 0 conv_bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_1_04 (conv_i_src_c079_1_04 conv_i_c079_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_04 (conv_q_src_c079_1_04 0 conv_bpf_c079_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_1_04 (conv_q_src_c079_1_04 conv_q_c079_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_05 (conv_i_src_c079_1_05 0 conv_bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_1_05 (conv_i_src_c079_1_05 conv_i_c079_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_05 (conv_q_src_c079_1_05 0 conv_bpf_c079_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_1_05 (conv_q_src_c079_1_05 conv_q_c079_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_06 (conv_i_src_c079_1_06 0 conv_bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_1_06 (conv_i_src_c079_1_06 conv_i_c079_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_06 (conv_q_src_c079_1_06 0 conv_bpf_c079_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_1_06 (conv_q_src_c079_1_06 conv_q_c079_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_07 (conv_i_src_c079_1_07 0 conv_bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_1_07 (conv_i_src_c079_1_07 conv_i_c079_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_07 (conv_q_src_c079_1_07 0 conv_bpf_c079_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_1_07 (conv_q_src_c079_1_07 conv_q_c079_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_08 (conv_i_src_c079_1_08 0 conv_bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_1_08 (conv_i_src_c079_1_08 conv_i_c079_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_08 (conv_q_src_c079_1_08 0 conv_bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_1_08 (conv_q_src_c079_1_08 conv_q_c079_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_09 (conv_i_src_c079_1_09 0 conv_bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_1_09 (conv_i_src_c079_1_09 conv_i_c079_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_09 (conv_q_src_c079_1_09 0 conv_bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_1_09 (conv_q_src_c079_1_09 conv_q_c079_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_10 (conv_i_src_c079_1_10 0 conv_bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_1_10 (conv_i_src_c079_1_10 conv_i_c079_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_10 (conv_q_src_c079_1_10 0 conv_bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_1_10 (conv_q_src_c079_1_10 conv_q_c079_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_11 (conv_i_src_c079_1_11 0 conv_bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_1_11 (conv_i_src_c079_1_11 conv_i_c079_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_11 (conv_q_src_c079_1_11 0 conv_bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_1_11 (conv_q_src_c079_1_11 conv_q_c079_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_12 (conv_i_src_c079_1_12 0 conv_bpf_c079_1 0) vcvs gain=1.950903220161e-01
SCONVI_c079_1_12 (conv_i_src_c079_1_12 conv_i_c079_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_12 (conv_q_src_c079_1_12 0 conv_bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_1_12 (conv_q_src_c079_1_12 conv_q_c079_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_13 (conv_i_src_c079_1_13 0 conv_bpf_c079_1 0) vcvs gain=5.555702330196e-01
SCONVI_c079_1_13 (conv_i_src_c079_1_13 conv_i_c079_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_13 (conv_q_src_c079_1_13 0 conv_bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_1_13 (conv_q_src_c079_1_13 conv_q_c079_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_14 (conv_i_src_c079_1_14 0 conv_bpf_c079_1 0) vcvs gain=8.314696123025e-01
SCONVI_c079_1_14 (conv_i_src_c079_1_14 conv_i_c079_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_14 (conv_q_src_c079_1_14 0 conv_bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_1_14 (conv_q_src_c079_1_14 conv_q_c079_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_1_15 (conv_i_src_c079_1_15 0 conv_bpf_c079_1 0) vcvs gain=9.807852804032e-01
SCONVI_c079_1_15 (conv_i_src_c079_1_15 conv_i_c079_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_1_15 (conv_q_src_c079_1_15 0 conv_bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_1_15 (conv_q_src_c079_1_15 conv_q_c079_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c079_1 (conv_i_c079_1 0) resistor r=1G
RCONVQ_c079_1 (conv_q_c079_1 0) resistor r=1G
RCONVINTI_c079_1 (conv_i_c079_1 ConvIcar_c079_1) resistor r=1k
CCONVINTI_c079_1 (ConvIcar_c079_1 0) capacitor c=80p
RCONVINTQ_c079_1 (conv_q_c079_1 ConvQcar_c079_1) resistor r=1k
CCONVINTQ_c079_1 (ConvQcar_c079_1 0) capacitor c=80p
save conv_bpf_c079_1 ConvIcar_c079_1 ConvQcar_c079_1

// conventional mixed baseline bl079, carrier_2: 750000000 Hz
CCONVBPF_c079_2 (bl079 n_conv_cbpf_c079_2) capacitor c=4.503163717437e-14
LCONVBPF_c079_2 (n_conv_cbpf_c079_2 conv_bpf_c079_2) inductor l=1.000000000000e-06
RCONVBPF_c079_2 (conv_bpf_c079_2 0) resistor r=2.356194490192e+02
ECONVI_c079_2_00 (conv_i_src_c079_2_00 0 conv_bpf_c079_2 0) vcvs gain=9.807852804032e-01
SCONVI_c079_2_00 (conv_i_src_c079_2_00 conv_i_c079_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_00 (conv_q_src_c079_2_00 0 conv_bpf_c079_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_2_00 (conv_q_src_c079_2_00 conv_q_c079_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_01 (conv_i_src_c079_2_01 0 conv_bpf_c079_2 0) vcvs gain=8.314696123025e-01
SCONVI_c079_2_01 (conv_i_src_c079_2_01 conv_i_c079_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_01 (conv_q_src_c079_2_01 0 conv_bpf_c079_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_2_01 (conv_q_src_c079_2_01 conv_q_c079_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_02 (conv_i_src_c079_2_02 0 conv_bpf_c079_2 0) vcvs gain=5.555702330196e-01
SCONVI_c079_2_02 (conv_i_src_c079_2_02 conv_i_c079_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_02 (conv_q_src_c079_2_02 0 conv_bpf_c079_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_2_02 (conv_q_src_c079_2_02 conv_q_c079_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_03 (conv_i_src_c079_2_03 0 conv_bpf_c079_2 0) vcvs gain=1.950903220161e-01
SCONVI_c079_2_03 (conv_i_src_c079_2_03 conv_i_c079_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_03 (conv_q_src_c079_2_03 0 conv_bpf_c079_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_2_03 (conv_q_src_c079_2_03 conv_q_c079_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_04 (conv_i_src_c079_2_04 0 conv_bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_2_04 (conv_i_src_c079_2_04 conv_i_c079_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_04 (conv_q_src_c079_2_04 0 conv_bpf_c079_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_2_04 (conv_q_src_c079_2_04 conv_q_c079_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_05 (conv_i_src_c079_2_05 0 conv_bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_2_05 (conv_i_src_c079_2_05 conv_i_c079_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_05 (conv_q_src_c079_2_05 0 conv_bpf_c079_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_2_05 (conv_q_src_c079_2_05 conv_q_c079_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_06 (conv_i_src_c079_2_06 0 conv_bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_2_06 (conv_i_src_c079_2_06 conv_i_c079_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_06 (conv_q_src_c079_2_06 0 conv_bpf_c079_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_2_06 (conv_q_src_c079_2_06 conv_q_c079_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_07 (conv_i_src_c079_2_07 0 conv_bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_2_07 (conv_i_src_c079_2_07 conv_i_c079_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_07 (conv_q_src_c079_2_07 0 conv_bpf_c079_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_2_07 (conv_q_src_c079_2_07 conv_q_c079_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_08 (conv_i_src_c079_2_08 0 conv_bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_2_08 (conv_i_src_c079_2_08 conv_i_c079_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_08 (conv_q_src_c079_2_08 0 conv_bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_2_08 (conv_q_src_c079_2_08 conv_q_c079_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_09 (conv_i_src_c079_2_09 0 conv_bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_2_09 (conv_i_src_c079_2_09 conv_i_c079_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_09 (conv_q_src_c079_2_09 0 conv_bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_2_09 (conv_q_src_c079_2_09 conv_q_c079_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_10 (conv_i_src_c079_2_10 0 conv_bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_2_10 (conv_i_src_c079_2_10 conv_i_c079_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_10 (conv_q_src_c079_2_10 0 conv_bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_2_10 (conv_q_src_c079_2_10 conv_q_c079_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_11 (conv_i_src_c079_2_11 0 conv_bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_2_11 (conv_i_src_c079_2_11 conv_i_c079_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_11 (conv_q_src_c079_2_11 0 conv_bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_2_11 (conv_q_src_c079_2_11 conv_q_c079_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_12 (conv_i_src_c079_2_12 0 conv_bpf_c079_2 0) vcvs gain=1.950903220161e-01
SCONVI_c079_2_12 (conv_i_src_c079_2_12 conv_i_c079_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_12 (conv_q_src_c079_2_12 0 conv_bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_2_12 (conv_q_src_c079_2_12 conv_q_c079_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_13 (conv_i_src_c079_2_13 0 conv_bpf_c079_2 0) vcvs gain=5.555702330196e-01
SCONVI_c079_2_13 (conv_i_src_c079_2_13 conv_i_c079_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_13 (conv_q_src_c079_2_13 0 conv_bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_2_13 (conv_q_src_c079_2_13 conv_q_c079_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_14 (conv_i_src_c079_2_14 0 conv_bpf_c079_2 0) vcvs gain=8.314696123025e-01
SCONVI_c079_2_14 (conv_i_src_c079_2_14 conv_i_c079_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_14 (conv_q_src_c079_2_14 0 conv_bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_2_14 (conv_q_src_c079_2_14 conv_q_c079_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_2_15 (conv_i_src_c079_2_15 0 conv_bpf_c079_2 0) vcvs gain=9.807852804032e-01
SCONVI_c079_2_15 (conv_i_src_c079_2_15 conv_i_c079_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_2_15 (conv_q_src_c079_2_15 0 conv_bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_2_15 (conv_q_src_c079_2_15 conv_q_c079_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c079_2 (conv_i_c079_2 0) resistor r=1G
RCONVQ_c079_2 (conv_q_c079_2 0) resistor r=1G
RCONVINTI_c079_2 (conv_i_c079_2 ConvIcar_c079_2) resistor r=1k
CCONVINTI_c079_2 (ConvIcar_c079_2 0) capacitor c=80p
RCONVINTQ_c079_2 (conv_q_c079_2 ConvQcar_c079_2) resistor r=1k
CCONVINTQ_c079_2 (ConvQcar_c079_2 0) capacitor c=80p
save conv_bpf_c079_2 ConvIcar_c079_2 ConvQcar_c079_2

// conventional mixed baseline bl079, carrier_3: 1000000000 Hz
CCONVBPF_c079_3 (bl079 n_conv_cbpf_c079_3) capacitor c=2.533029591058e-14
LCONVBPF_c079_3 (n_conv_cbpf_c079_3 conv_bpf_c079_3) inductor l=1.000000000000e-06
RCONVBPF_c079_3 (conv_bpf_c079_3 0) resistor r=3.141592653590e+02
ECONVI_c079_3_00 (conv_i_src_c079_3_00 0 conv_bpf_c079_3 0) vcvs gain=9.807852804032e-01
SCONVI_c079_3_00 (conv_i_src_c079_3_00 conv_i_c079_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_00 (conv_q_src_c079_3_00 0 conv_bpf_c079_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_3_00 (conv_q_src_c079_3_00 conv_q_c079_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_01 (conv_i_src_c079_3_01 0 conv_bpf_c079_3 0) vcvs gain=8.314696123025e-01
SCONVI_c079_3_01 (conv_i_src_c079_3_01 conv_i_c079_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_01 (conv_q_src_c079_3_01 0 conv_bpf_c079_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_3_01 (conv_q_src_c079_3_01 conv_q_c079_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_02 (conv_i_src_c079_3_02 0 conv_bpf_c079_3 0) vcvs gain=5.555702330196e-01
SCONVI_c079_3_02 (conv_i_src_c079_3_02 conv_i_c079_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_02 (conv_q_src_c079_3_02 0 conv_bpf_c079_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_3_02 (conv_q_src_c079_3_02 conv_q_c079_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_03 (conv_i_src_c079_3_03 0 conv_bpf_c079_3 0) vcvs gain=1.950903220161e-01
SCONVI_c079_3_03 (conv_i_src_c079_3_03 conv_i_c079_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_03 (conv_q_src_c079_3_03 0 conv_bpf_c079_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_3_03 (conv_q_src_c079_3_03 conv_q_c079_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_04 (conv_i_src_c079_3_04 0 conv_bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_3_04 (conv_i_src_c079_3_04 conv_i_c079_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_04 (conv_q_src_c079_3_04 0 conv_bpf_c079_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c079_3_04 (conv_q_src_c079_3_04 conv_q_c079_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_05 (conv_i_src_c079_3_05 0 conv_bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_3_05 (conv_i_src_c079_3_05 conv_i_c079_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_05 (conv_q_src_c079_3_05 0 conv_bpf_c079_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c079_3_05 (conv_q_src_c079_3_05 conv_q_c079_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_06 (conv_i_src_c079_3_06 0 conv_bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_3_06 (conv_i_src_c079_3_06 conv_i_c079_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_06 (conv_q_src_c079_3_06 0 conv_bpf_c079_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c079_3_06 (conv_q_src_c079_3_06 conv_q_c079_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_07 (conv_i_src_c079_3_07 0 conv_bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_3_07 (conv_i_src_c079_3_07 conv_i_c079_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_07 (conv_q_src_c079_3_07 0 conv_bpf_c079_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c079_3_07 (conv_q_src_c079_3_07 conv_q_c079_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_08 (conv_i_src_c079_3_08 0 conv_bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c079_3_08 (conv_i_src_c079_3_08 conv_i_c079_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_08 (conv_q_src_c079_3_08 0 conv_bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_3_08 (conv_q_src_c079_3_08 conv_q_c079_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_09 (conv_i_src_c079_3_09 0 conv_bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c079_3_09 (conv_i_src_c079_3_09 conv_i_c079_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_09 (conv_q_src_c079_3_09 0 conv_bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_3_09 (conv_q_src_c079_3_09 conv_q_c079_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_10 (conv_i_src_c079_3_10 0 conv_bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c079_3_10 (conv_i_src_c079_3_10 conv_i_c079_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_10 (conv_q_src_c079_3_10 0 conv_bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_3_10 (conv_q_src_c079_3_10 conv_q_c079_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_11 (conv_i_src_c079_3_11 0 conv_bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c079_3_11 (conv_i_src_c079_3_11 conv_i_c079_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_11 (conv_q_src_c079_3_11 0 conv_bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_3_11 (conv_q_src_c079_3_11 conv_q_c079_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_12 (conv_i_src_c079_3_12 0 conv_bpf_c079_3 0) vcvs gain=1.950903220161e-01
SCONVI_c079_3_12 (conv_i_src_c079_3_12 conv_i_c079_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_12 (conv_q_src_c079_3_12 0 conv_bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c079_3_12 (conv_q_src_c079_3_12 conv_q_c079_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_13 (conv_i_src_c079_3_13 0 conv_bpf_c079_3 0) vcvs gain=5.555702330196e-01
SCONVI_c079_3_13 (conv_i_src_c079_3_13 conv_i_c079_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_13 (conv_q_src_c079_3_13 0 conv_bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c079_3_13 (conv_q_src_c079_3_13 conv_q_c079_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_14 (conv_i_src_c079_3_14 0 conv_bpf_c079_3 0) vcvs gain=8.314696123025e-01
SCONVI_c079_3_14 (conv_i_src_c079_3_14 conv_i_c079_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_14 (conv_q_src_c079_3_14 0 conv_bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c079_3_14 (conv_q_src_c079_3_14 conv_q_c079_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c079_3_15 (conv_i_src_c079_3_15 0 conv_bpf_c079_3 0) vcvs gain=9.807852804032e-01
SCONVI_c079_3_15 (conv_i_src_c079_3_15 conv_i_c079_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c079_3_15 (conv_q_src_c079_3_15 0 conv_bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c079_3_15 (conv_q_src_c079_3_15 conv_q_c079_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c079_3 (conv_i_c079_3 0) resistor r=1G
RCONVQ_c079_3 (conv_q_c079_3 0) resistor r=1G
RCONVINTI_c079_3 (conv_i_c079_3 ConvIcar_c079_3) resistor r=1k
CCONVINTI_c079_3 (ConvIcar_c079_3 0) capacitor c=80p
RCONVINTQ_c079_3 (conv_q_c079_3 ConvQcar_c079_3) resistor r=1k
CCONVINTQ_c079_3 (ConvQcar_c079_3 0) capacitor c=80p
save conv_bpf_c079_3 ConvIcar_c079_3 ConvQcar_c079_3

// conventional mixed baseline bl080, carrier_0: 250000000 Hz
CCONVBPF_c080_0 (bl080 n_conv_cbpf_c080_0) capacitor c=4.052847345694e-13
LCONVBPF_c080_0 (n_conv_cbpf_c080_0 conv_bpf_c080_0) inductor l=1.000000000000e-06
RCONVBPF_c080_0 (conv_bpf_c080_0 0) resistor r=7.853981633974e+01
ECONVI_c080_0_00 (conv_i_src_c080_0_00 0 conv_bpf_c080_0 0) vcvs gain=9.807852804032e-01
SCONVI_c080_0_00 (conv_i_src_c080_0_00 conv_i_c080_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_00 (conv_q_src_c080_0_00 0 conv_bpf_c080_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_0_00 (conv_q_src_c080_0_00 conv_q_c080_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_01 (conv_i_src_c080_0_01 0 conv_bpf_c080_0 0) vcvs gain=8.314696123025e-01
SCONVI_c080_0_01 (conv_i_src_c080_0_01 conv_i_c080_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_01 (conv_q_src_c080_0_01 0 conv_bpf_c080_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_0_01 (conv_q_src_c080_0_01 conv_q_c080_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_02 (conv_i_src_c080_0_02 0 conv_bpf_c080_0 0) vcvs gain=5.555702330196e-01
SCONVI_c080_0_02 (conv_i_src_c080_0_02 conv_i_c080_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_02 (conv_q_src_c080_0_02 0 conv_bpf_c080_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_0_02 (conv_q_src_c080_0_02 conv_q_c080_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_03 (conv_i_src_c080_0_03 0 conv_bpf_c080_0 0) vcvs gain=1.950903220161e-01
SCONVI_c080_0_03 (conv_i_src_c080_0_03 conv_i_c080_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_03 (conv_q_src_c080_0_03 0 conv_bpf_c080_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_0_03 (conv_q_src_c080_0_03 conv_q_c080_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_04 (conv_i_src_c080_0_04 0 conv_bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_0_04 (conv_i_src_c080_0_04 conv_i_c080_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_04 (conv_q_src_c080_0_04 0 conv_bpf_c080_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_0_04 (conv_q_src_c080_0_04 conv_q_c080_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_05 (conv_i_src_c080_0_05 0 conv_bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_0_05 (conv_i_src_c080_0_05 conv_i_c080_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_05 (conv_q_src_c080_0_05 0 conv_bpf_c080_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_0_05 (conv_q_src_c080_0_05 conv_q_c080_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_06 (conv_i_src_c080_0_06 0 conv_bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_0_06 (conv_i_src_c080_0_06 conv_i_c080_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_06 (conv_q_src_c080_0_06 0 conv_bpf_c080_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_0_06 (conv_q_src_c080_0_06 conv_q_c080_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_07 (conv_i_src_c080_0_07 0 conv_bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_0_07 (conv_i_src_c080_0_07 conv_i_c080_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_07 (conv_q_src_c080_0_07 0 conv_bpf_c080_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_0_07 (conv_q_src_c080_0_07 conv_q_c080_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_08 (conv_i_src_c080_0_08 0 conv_bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_0_08 (conv_i_src_c080_0_08 conv_i_c080_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_08 (conv_q_src_c080_0_08 0 conv_bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_0_08 (conv_q_src_c080_0_08 conv_q_c080_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_09 (conv_i_src_c080_0_09 0 conv_bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_0_09 (conv_i_src_c080_0_09 conv_i_c080_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_09 (conv_q_src_c080_0_09 0 conv_bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_0_09 (conv_q_src_c080_0_09 conv_q_c080_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_10 (conv_i_src_c080_0_10 0 conv_bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_0_10 (conv_i_src_c080_0_10 conv_i_c080_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_10 (conv_q_src_c080_0_10 0 conv_bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_0_10 (conv_q_src_c080_0_10 conv_q_c080_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_11 (conv_i_src_c080_0_11 0 conv_bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_0_11 (conv_i_src_c080_0_11 conv_i_c080_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_11 (conv_q_src_c080_0_11 0 conv_bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_0_11 (conv_q_src_c080_0_11 conv_q_c080_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_12 (conv_i_src_c080_0_12 0 conv_bpf_c080_0 0) vcvs gain=1.950903220161e-01
SCONVI_c080_0_12 (conv_i_src_c080_0_12 conv_i_c080_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_12 (conv_q_src_c080_0_12 0 conv_bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_0_12 (conv_q_src_c080_0_12 conv_q_c080_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_13 (conv_i_src_c080_0_13 0 conv_bpf_c080_0 0) vcvs gain=5.555702330196e-01
SCONVI_c080_0_13 (conv_i_src_c080_0_13 conv_i_c080_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_13 (conv_q_src_c080_0_13 0 conv_bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_0_13 (conv_q_src_c080_0_13 conv_q_c080_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_14 (conv_i_src_c080_0_14 0 conv_bpf_c080_0 0) vcvs gain=8.314696123025e-01
SCONVI_c080_0_14 (conv_i_src_c080_0_14 conv_i_c080_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_14 (conv_q_src_c080_0_14 0 conv_bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_0_14 (conv_q_src_c080_0_14 conv_q_c080_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_0_15 (conv_i_src_c080_0_15 0 conv_bpf_c080_0 0) vcvs gain=9.807852804032e-01
SCONVI_c080_0_15 (conv_i_src_c080_0_15 conv_i_c080_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_0_15 (conv_q_src_c080_0_15 0 conv_bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_0_15 (conv_q_src_c080_0_15 conv_q_c080_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c080_0 (conv_i_c080_0 0) resistor r=1G
RCONVQ_c080_0 (conv_q_c080_0 0) resistor r=1G
RCONVINTI_c080_0 (conv_i_c080_0 ConvIcar_c080_0) resistor r=1k
CCONVINTI_c080_0 (ConvIcar_c080_0 0) capacitor c=80p
RCONVINTQ_c080_0 (conv_q_c080_0 ConvQcar_c080_0) resistor r=1k
CCONVINTQ_c080_0 (ConvQcar_c080_0 0) capacitor c=80p
save conv_bpf_c080_0 ConvIcar_c080_0 ConvQcar_c080_0

// conventional mixed baseline bl080, carrier_1: 500000000 Hz
CCONVBPF_c080_1 (bl080 n_conv_cbpf_c080_1) capacitor c=1.013211836423e-13
LCONVBPF_c080_1 (n_conv_cbpf_c080_1 conv_bpf_c080_1) inductor l=1.000000000000e-06
RCONVBPF_c080_1 (conv_bpf_c080_1 0) resistor r=1.570796326795e+02
ECONVI_c080_1_00 (conv_i_src_c080_1_00 0 conv_bpf_c080_1 0) vcvs gain=9.807852804032e-01
SCONVI_c080_1_00 (conv_i_src_c080_1_00 conv_i_c080_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_00 (conv_q_src_c080_1_00 0 conv_bpf_c080_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_1_00 (conv_q_src_c080_1_00 conv_q_c080_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_01 (conv_i_src_c080_1_01 0 conv_bpf_c080_1 0) vcvs gain=8.314696123025e-01
SCONVI_c080_1_01 (conv_i_src_c080_1_01 conv_i_c080_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_01 (conv_q_src_c080_1_01 0 conv_bpf_c080_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_1_01 (conv_q_src_c080_1_01 conv_q_c080_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_02 (conv_i_src_c080_1_02 0 conv_bpf_c080_1 0) vcvs gain=5.555702330196e-01
SCONVI_c080_1_02 (conv_i_src_c080_1_02 conv_i_c080_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_02 (conv_q_src_c080_1_02 0 conv_bpf_c080_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_1_02 (conv_q_src_c080_1_02 conv_q_c080_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_03 (conv_i_src_c080_1_03 0 conv_bpf_c080_1 0) vcvs gain=1.950903220161e-01
SCONVI_c080_1_03 (conv_i_src_c080_1_03 conv_i_c080_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_03 (conv_q_src_c080_1_03 0 conv_bpf_c080_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_1_03 (conv_q_src_c080_1_03 conv_q_c080_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_04 (conv_i_src_c080_1_04 0 conv_bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_1_04 (conv_i_src_c080_1_04 conv_i_c080_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_04 (conv_q_src_c080_1_04 0 conv_bpf_c080_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_1_04 (conv_q_src_c080_1_04 conv_q_c080_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_05 (conv_i_src_c080_1_05 0 conv_bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_1_05 (conv_i_src_c080_1_05 conv_i_c080_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_05 (conv_q_src_c080_1_05 0 conv_bpf_c080_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_1_05 (conv_q_src_c080_1_05 conv_q_c080_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_06 (conv_i_src_c080_1_06 0 conv_bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_1_06 (conv_i_src_c080_1_06 conv_i_c080_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_06 (conv_q_src_c080_1_06 0 conv_bpf_c080_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_1_06 (conv_q_src_c080_1_06 conv_q_c080_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_07 (conv_i_src_c080_1_07 0 conv_bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_1_07 (conv_i_src_c080_1_07 conv_i_c080_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_07 (conv_q_src_c080_1_07 0 conv_bpf_c080_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_1_07 (conv_q_src_c080_1_07 conv_q_c080_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_08 (conv_i_src_c080_1_08 0 conv_bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_1_08 (conv_i_src_c080_1_08 conv_i_c080_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_08 (conv_q_src_c080_1_08 0 conv_bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_1_08 (conv_q_src_c080_1_08 conv_q_c080_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_09 (conv_i_src_c080_1_09 0 conv_bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_1_09 (conv_i_src_c080_1_09 conv_i_c080_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_09 (conv_q_src_c080_1_09 0 conv_bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_1_09 (conv_q_src_c080_1_09 conv_q_c080_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_10 (conv_i_src_c080_1_10 0 conv_bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_1_10 (conv_i_src_c080_1_10 conv_i_c080_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_10 (conv_q_src_c080_1_10 0 conv_bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_1_10 (conv_q_src_c080_1_10 conv_q_c080_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_11 (conv_i_src_c080_1_11 0 conv_bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_1_11 (conv_i_src_c080_1_11 conv_i_c080_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_11 (conv_q_src_c080_1_11 0 conv_bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_1_11 (conv_q_src_c080_1_11 conv_q_c080_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_12 (conv_i_src_c080_1_12 0 conv_bpf_c080_1 0) vcvs gain=1.950903220161e-01
SCONVI_c080_1_12 (conv_i_src_c080_1_12 conv_i_c080_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_12 (conv_q_src_c080_1_12 0 conv_bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_1_12 (conv_q_src_c080_1_12 conv_q_c080_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_13 (conv_i_src_c080_1_13 0 conv_bpf_c080_1 0) vcvs gain=5.555702330196e-01
SCONVI_c080_1_13 (conv_i_src_c080_1_13 conv_i_c080_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_13 (conv_q_src_c080_1_13 0 conv_bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_1_13 (conv_q_src_c080_1_13 conv_q_c080_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_14 (conv_i_src_c080_1_14 0 conv_bpf_c080_1 0) vcvs gain=8.314696123025e-01
SCONVI_c080_1_14 (conv_i_src_c080_1_14 conv_i_c080_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_14 (conv_q_src_c080_1_14 0 conv_bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_1_14 (conv_q_src_c080_1_14 conv_q_c080_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_1_15 (conv_i_src_c080_1_15 0 conv_bpf_c080_1 0) vcvs gain=9.807852804032e-01
SCONVI_c080_1_15 (conv_i_src_c080_1_15 conv_i_c080_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_1_15 (conv_q_src_c080_1_15 0 conv_bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_1_15 (conv_q_src_c080_1_15 conv_q_c080_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c080_1 (conv_i_c080_1 0) resistor r=1G
RCONVQ_c080_1 (conv_q_c080_1 0) resistor r=1G
RCONVINTI_c080_1 (conv_i_c080_1 ConvIcar_c080_1) resistor r=1k
CCONVINTI_c080_1 (ConvIcar_c080_1 0) capacitor c=80p
RCONVINTQ_c080_1 (conv_q_c080_1 ConvQcar_c080_1) resistor r=1k
CCONVINTQ_c080_1 (ConvQcar_c080_1 0) capacitor c=80p
save conv_bpf_c080_1 ConvIcar_c080_1 ConvQcar_c080_1

// conventional mixed baseline bl080, carrier_2: 750000000 Hz
CCONVBPF_c080_2 (bl080 n_conv_cbpf_c080_2) capacitor c=4.503163717437e-14
LCONVBPF_c080_2 (n_conv_cbpf_c080_2 conv_bpf_c080_2) inductor l=1.000000000000e-06
RCONVBPF_c080_2 (conv_bpf_c080_2 0) resistor r=2.356194490192e+02
ECONVI_c080_2_00 (conv_i_src_c080_2_00 0 conv_bpf_c080_2 0) vcvs gain=9.807852804032e-01
SCONVI_c080_2_00 (conv_i_src_c080_2_00 conv_i_c080_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_00 (conv_q_src_c080_2_00 0 conv_bpf_c080_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_2_00 (conv_q_src_c080_2_00 conv_q_c080_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_01 (conv_i_src_c080_2_01 0 conv_bpf_c080_2 0) vcvs gain=8.314696123025e-01
SCONVI_c080_2_01 (conv_i_src_c080_2_01 conv_i_c080_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_01 (conv_q_src_c080_2_01 0 conv_bpf_c080_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_2_01 (conv_q_src_c080_2_01 conv_q_c080_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_02 (conv_i_src_c080_2_02 0 conv_bpf_c080_2 0) vcvs gain=5.555702330196e-01
SCONVI_c080_2_02 (conv_i_src_c080_2_02 conv_i_c080_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_02 (conv_q_src_c080_2_02 0 conv_bpf_c080_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_2_02 (conv_q_src_c080_2_02 conv_q_c080_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_03 (conv_i_src_c080_2_03 0 conv_bpf_c080_2 0) vcvs gain=1.950903220161e-01
SCONVI_c080_2_03 (conv_i_src_c080_2_03 conv_i_c080_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_03 (conv_q_src_c080_2_03 0 conv_bpf_c080_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_2_03 (conv_q_src_c080_2_03 conv_q_c080_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_04 (conv_i_src_c080_2_04 0 conv_bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_2_04 (conv_i_src_c080_2_04 conv_i_c080_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_04 (conv_q_src_c080_2_04 0 conv_bpf_c080_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_2_04 (conv_q_src_c080_2_04 conv_q_c080_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_05 (conv_i_src_c080_2_05 0 conv_bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_2_05 (conv_i_src_c080_2_05 conv_i_c080_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_05 (conv_q_src_c080_2_05 0 conv_bpf_c080_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_2_05 (conv_q_src_c080_2_05 conv_q_c080_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_06 (conv_i_src_c080_2_06 0 conv_bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_2_06 (conv_i_src_c080_2_06 conv_i_c080_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_06 (conv_q_src_c080_2_06 0 conv_bpf_c080_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_2_06 (conv_q_src_c080_2_06 conv_q_c080_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_07 (conv_i_src_c080_2_07 0 conv_bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_2_07 (conv_i_src_c080_2_07 conv_i_c080_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_07 (conv_q_src_c080_2_07 0 conv_bpf_c080_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_2_07 (conv_q_src_c080_2_07 conv_q_c080_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_08 (conv_i_src_c080_2_08 0 conv_bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_2_08 (conv_i_src_c080_2_08 conv_i_c080_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_08 (conv_q_src_c080_2_08 0 conv_bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_2_08 (conv_q_src_c080_2_08 conv_q_c080_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_09 (conv_i_src_c080_2_09 0 conv_bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_2_09 (conv_i_src_c080_2_09 conv_i_c080_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_09 (conv_q_src_c080_2_09 0 conv_bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_2_09 (conv_q_src_c080_2_09 conv_q_c080_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_10 (conv_i_src_c080_2_10 0 conv_bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_2_10 (conv_i_src_c080_2_10 conv_i_c080_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_10 (conv_q_src_c080_2_10 0 conv_bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_2_10 (conv_q_src_c080_2_10 conv_q_c080_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_11 (conv_i_src_c080_2_11 0 conv_bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_2_11 (conv_i_src_c080_2_11 conv_i_c080_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_11 (conv_q_src_c080_2_11 0 conv_bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_2_11 (conv_q_src_c080_2_11 conv_q_c080_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_12 (conv_i_src_c080_2_12 0 conv_bpf_c080_2 0) vcvs gain=1.950903220161e-01
SCONVI_c080_2_12 (conv_i_src_c080_2_12 conv_i_c080_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_12 (conv_q_src_c080_2_12 0 conv_bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_2_12 (conv_q_src_c080_2_12 conv_q_c080_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_13 (conv_i_src_c080_2_13 0 conv_bpf_c080_2 0) vcvs gain=5.555702330196e-01
SCONVI_c080_2_13 (conv_i_src_c080_2_13 conv_i_c080_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_13 (conv_q_src_c080_2_13 0 conv_bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_2_13 (conv_q_src_c080_2_13 conv_q_c080_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_14 (conv_i_src_c080_2_14 0 conv_bpf_c080_2 0) vcvs gain=8.314696123025e-01
SCONVI_c080_2_14 (conv_i_src_c080_2_14 conv_i_c080_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_14 (conv_q_src_c080_2_14 0 conv_bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_2_14 (conv_q_src_c080_2_14 conv_q_c080_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_2_15 (conv_i_src_c080_2_15 0 conv_bpf_c080_2 0) vcvs gain=9.807852804032e-01
SCONVI_c080_2_15 (conv_i_src_c080_2_15 conv_i_c080_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_2_15 (conv_q_src_c080_2_15 0 conv_bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_2_15 (conv_q_src_c080_2_15 conv_q_c080_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c080_2 (conv_i_c080_2 0) resistor r=1G
RCONVQ_c080_2 (conv_q_c080_2 0) resistor r=1G
RCONVINTI_c080_2 (conv_i_c080_2 ConvIcar_c080_2) resistor r=1k
CCONVINTI_c080_2 (ConvIcar_c080_2 0) capacitor c=80p
RCONVINTQ_c080_2 (conv_q_c080_2 ConvQcar_c080_2) resistor r=1k
CCONVINTQ_c080_2 (ConvQcar_c080_2 0) capacitor c=80p
save conv_bpf_c080_2 ConvIcar_c080_2 ConvQcar_c080_2

// conventional mixed baseline bl080, carrier_3: 1000000000 Hz
CCONVBPF_c080_3 (bl080 n_conv_cbpf_c080_3) capacitor c=2.533029591058e-14
LCONVBPF_c080_3 (n_conv_cbpf_c080_3 conv_bpf_c080_3) inductor l=1.000000000000e-06
RCONVBPF_c080_3 (conv_bpf_c080_3 0) resistor r=3.141592653590e+02
ECONVI_c080_3_00 (conv_i_src_c080_3_00 0 conv_bpf_c080_3 0) vcvs gain=9.807852804032e-01
SCONVI_c080_3_00 (conv_i_src_c080_3_00 conv_i_c080_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_00 (conv_q_src_c080_3_00 0 conv_bpf_c080_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_3_00 (conv_q_src_c080_3_00 conv_q_c080_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_01 (conv_i_src_c080_3_01 0 conv_bpf_c080_3 0) vcvs gain=8.314696123025e-01
SCONVI_c080_3_01 (conv_i_src_c080_3_01 conv_i_c080_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_01 (conv_q_src_c080_3_01 0 conv_bpf_c080_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_3_01 (conv_q_src_c080_3_01 conv_q_c080_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_02 (conv_i_src_c080_3_02 0 conv_bpf_c080_3 0) vcvs gain=5.555702330196e-01
SCONVI_c080_3_02 (conv_i_src_c080_3_02 conv_i_c080_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_02 (conv_q_src_c080_3_02 0 conv_bpf_c080_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_3_02 (conv_q_src_c080_3_02 conv_q_c080_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_03 (conv_i_src_c080_3_03 0 conv_bpf_c080_3 0) vcvs gain=1.950903220161e-01
SCONVI_c080_3_03 (conv_i_src_c080_3_03 conv_i_c080_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_03 (conv_q_src_c080_3_03 0 conv_bpf_c080_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_3_03 (conv_q_src_c080_3_03 conv_q_c080_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_04 (conv_i_src_c080_3_04 0 conv_bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_3_04 (conv_i_src_c080_3_04 conv_i_c080_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_04 (conv_q_src_c080_3_04 0 conv_bpf_c080_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c080_3_04 (conv_q_src_c080_3_04 conv_q_c080_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_05 (conv_i_src_c080_3_05 0 conv_bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_3_05 (conv_i_src_c080_3_05 conv_i_c080_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_05 (conv_q_src_c080_3_05 0 conv_bpf_c080_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c080_3_05 (conv_q_src_c080_3_05 conv_q_c080_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_06 (conv_i_src_c080_3_06 0 conv_bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_3_06 (conv_i_src_c080_3_06 conv_i_c080_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_06 (conv_q_src_c080_3_06 0 conv_bpf_c080_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c080_3_06 (conv_q_src_c080_3_06 conv_q_c080_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_07 (conv_i_src_c080_3_07 0 conv_bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_3_07 (conv_i_src_c080_3_07 conv_i_c080_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_07 (conv_q_src_c080_3_07 0 conv_bpf_c080_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c080_3_07 (conv_q_src_c080_3_07 conv_q_c080_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_08 (conv_i_src_c080_3_08 0 conv_bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c080_3_08 (conv_i_src_c080_3_08 conv_i_c080_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_08 (conv_q_src_c080_3_08 0 conv_bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_3_08 (conv_q_src_c080_3_08 conv_q_c080_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_09 (conv_i_src_c080_3_09 0 conv_bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c080_3_09 (conv_i_src_c080_3_09 conv_i_c080_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_09 (conv_q_src_c080_3_09 0 conv_bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_3_09 (conv_q_src_c080_3_09 conv_q_c080_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_10 (conv_i_src_c080_3_10 0 conv_bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c080_3_10 (conv_i_src_c080_3_10 conv_i_c080_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_10 (conv_q_src_c080_3_10 0 conv_bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_3_10 (conv_q_src_c080_3_10 conv_q_c080_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_11 (conv_i_src_c080_3_11 0 conv_bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c080_3_11 (conv_i_src_c080_3_11 conv_i_c080_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_11 (conv_q_src_c080_3_11 0 conv_bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_3_11 (conv_q_src_c080_3_11 conv_q_c080_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_12 (conv_i_src_c080_3_12 0 conv_bpf_c080_3 0) vcvs gain=1.950903220161e-01
SCONVI_c080_3_12 (conv_i_src_c080_3_12 conv_i_c080_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_12 (conv_q_src_c080_3_12 0 conv_bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c080_3_12 (conv_q_src_c080_3_12 conv_q_c080_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_13 (conv_i_src_c080_3_13 0 conv_bpf_c080_3 0) vcvs gain=5.555702330196e-01
SCONVI_c080_3_13 (conv_i_src_c080_3_13 conv_i_c080_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_13 (conv_q_src_c080_3_13 0 conv_bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c080_3_13 (conv_q_src_c080_3_13 conv_q_c080_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_14 (conv_i_src_c080_3_14 0 conv_bpf_c080_3 0) vcvs gain=8.314696123025e-01
SCONVI_c080_3_14 (conv_i_src_c080_3_14 conv_i_c080_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_14 (conv_q_src_c080_3_14 0 conv_bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c080_3_14 (conv_q_src_c080_3_14 conv_q_c080_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c080_3_15 (conv_i_src_c080_3_15 0 conv_bpf_c080_3 0) vcvs gain=9.807852804032e-01
SCONVI_c080_3_15 (conv_i_src_c080_3_15 conv_i_c080_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c080_3_15 (conv_q_src_c080_3_15 0 conv_bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c080_3_15 (conv_q_src_c080_3_15 conv_q_c080_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c080_3 (conv_i_c080_3 0) resistor r=1G
RCONVQ_c080_3 (conv_q_c080_3 0) resistor r=1G
RCONVINTI_c080_3 (conv_i_c080_3 ConvIcar_c080_3) resistor r=1k
CCONVINTI_c080_3 (ConvIcar_c080_3 0) capacitor c=80p
RCONVINTQ_c080_3 (conv_q_c080_3 ConvQcar_c080_3) resistor r=1k
CCONVINTQ_c080_3 (ConvQcar_c080_3 0) capacitor c=80p
save conv_bpf_c080_3 ConvIcar_c080_3 ConvQcar_c080_3

// conventional mixed baseline bl081, carrier_0: 250000000 Hz
CCONVBPF_c081_0 (bl081 n_conv_cbpf_c081_0) capacitor c=4.052847345694e-13
LCONVBPF_c081_0 (n_conv_cbpf_c081_0 conv_bpf_c081_0) inductor l=1.000000000000e-06
RCONVBPF_c081_0 (conv_bpf_c081_0 0) resistor r=7.853981633974e+01
ECONVI_c081_0_00 (conv_i_src_c081_0_00 0 conv_bpf_c081_0 0) vcvs gain=9.807852804032e-01
SCONVI_c081_0_00 (conv_i_src_c081_0_00 conv_i_c081_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_00 (conv_q_src_c081_0_00 0 conv_bpf_c081_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_0_00 (conv_q_src_c081_0_00 conv_q_c081_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_01 (conv_i_src_c081_0_01 0 conv_bpf_c081_0 0) vcvs gain=8.314696123025e-01
SCONVI_c081_0_01 (conv_i_src_c081_0_01 conv_i_c081_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_01 (conv_q_src_c081_0_01 0 conv_bpf_c081_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_0_01 (conv_q_src_c081_0_01 conv_q_c081_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_02 (conv_i_src_c081_0_02 0 conv_bpf_c081_0 0) vcvs gain=5.555702330196e-01
SCONVI_c081_0_02 (conv_i_src_c081_0_02 conv_i_c081_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_02 (conv_q_src_c081_0_02 0 conv_bpf_c081_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_0_02 (conv_q_src_c081_0_02 conv_q_c081_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_03 (conv_i_src_c081_0_03 0 conv_bpf_c081_0 0) vcvs gain=1.950903220161e-01
SCONVI_c081_0_03 (conv_i_src_c081_0_03 conv_i_c081_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_03 (conv_q_src_c081_0_03 0 conv_bpf_c081_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_0_03 (conv_q_src_c081_0_03 conv_q_c081_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_04 (conv_i_src_c081_0_04 0 conv_bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_0_04 (conv_i_src_c081_0_04 conv_i_c081_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_04 (conv_q_src_c081_0_04 0 conv_bpf_c081_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_0_04 (conv_q_src_c081_0_04 conv_q_c081_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_05 (conv_i_src_c081_0_05 0 conv_bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_0_05 (conv_i_src_c081_0_05 conv_i_c081_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_05 (conv_q_src_c081_0_05 0 conv_bpf_c081_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_0_05 (conv_q_src_c081_0_05 conv_q_c081_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_06 (conv_i_src_c081_0_06 0 conv_bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_0_06 (conv_i_src_c081_0_06 conv_i_c081_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_06 (conv_q_src_c081_0_06 0 conv_bpf_c081_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_0_06 (conv_q_src_c081_0_06 conv_q_c081_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_07 (conv_i_src_c081_0_07 0 conv_bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_0_07 (conv_i_src_c081_0_07 conv_i_c081_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_07 (conv_q_src_c081_0_07 0 conv_bpf_c081_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_0_07 (conv_q_src_c081_0_07 conv_q_c081_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_08 (conv_i_src_c081_0_08 0 conv_bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_0_08 (conv_i_src_c081_0_08 conv_i_c081_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_08 (conv_q_src_c081_0_08 0 conv_bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_0_08 (conv_q_src_c081_0_08 conv_q_c081_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_09 (conv_i_src_c081_0_09 0 conv_bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_0_09 (conv_i_src_c081_0_09 conv_i_c081_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_09 (conv_q_src_c081_0_09 0 conv_bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_0_09 (conv_q_src_c081_0_09 conv_q_c081_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_10 (conv_i_src_c081_0_10 0 conv_bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_0_10 (conv_i_src_c081_0_10 conv_i_c081_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_10 (conv_q_src_c081_0_10 0 conv_bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_0_10 (conv_q_src_c081_0_10 conv_q_c081_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_11 (conv_i_src_c081_0_11 0 conv_bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_0_11 (conv_i_src_c081_0_11 conv_i_c081_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_11 (conv_q_src_c081_0_11 0 conv_bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_0_11 (conv_q_src_c081_0_11 conv_q_c081_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_12 (conv_i_src_c081_0_12 0 conv_bpf_c081_0 0) vcvs gain=1.950903220161e-01
SCONVI_c081_0_12 (conv_i_src_c081_0_12 conv_i_c081_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_12 (conv_q_src_c081_0_12 0 conv_bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_0_12 (conv_q_src_c081_0_12 conv_q_c081_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_13 (conv_i_src_c081_0_13 0 conv_bpf_c081_0 0) vcvs gain=5.555702330196e-01
SCONVI_c081_0_13 (conv_i_src_c081_0_13 conv_i_c081_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_13 (conv_q_src_c081_0_13 0 conv_bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_0_13 (conv_q_src_c081_0_13 conv_q_c081_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_14 (conv_i_src_c081_0_14 0 conv_bpf_c081_0 0) vcvs gain=8.314696123025e-01
SCONVI_c081_0_14 (conv_i_src_c081_0_14 conv_i_c081_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_14 (conv_q_src_c081_0_14 0 conv_bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_0_14 (conv_q_src_c081_0_14 conv_q_c081_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_0_15 (conv_i_src_c081_0_15 0 conv_bpf_c081_0 0) vcvs gain=9.807852804032e-01
SCONVI_c081_0_15 (conv_i_src_c081_0_15 conv_i_c081_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_0_15 (conv_q_src_c081_0_15 0 conv_bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_0_15 (conv_q_src_c081_0_15 conv_q_c081_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c081_0 (conv_i_c081_0 0) resistor r=1G
RCONVQ_c081_0 (conv_q_c081_0 0) resistor r=1G
RCONVINTI_c081_0 (conv_i_c081_0 ConvIcar_c081_0) resistor r=1k
CCONVINTI_c081_0 (ConvIcar_c081_0 0) capacitor c=80p
RCONVINTQ_c081_0 (conv_q_c081_0 ConvQcar_c081_0) resistor r=1k
CCONVINTQ_c081_0 (ConvQcar_c081_0 0) capacitor c=80p
save conv_bpf_c081_0 ConvIcar_c081_0 ConvQcar_c081_0

// conventional mixed baseline bl081, carrier_1: 500000000 Hz
CCONVBPF_c081_1 (bl081 n_conv_cbpf_c081_1) capacitor c=1.013211836423e-13
LCONVBPF_c081_1 (n_conv_cbpf_c081_1 conv_bpf_c081_1) inductor l=1.000000000000e-06
RCONVBPF_c081_1 (conv_bpf_c081_1 0) resistor r=1.570796326795e+02
ECONVI_c081_1_00 (conv_i_src_c081_1_00 0 conv_bpf_c081_1 0) vcvs gain=9.807852804032e-01
SCONVI_c081_1_00 (conv_i_src_c081_1_00 conv_i_c081_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_00 (conv_q_src_c081_1_00 0 conv_bpf_c081_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_1_00 (conv_q_src_c081_1_00 conv_q_c081_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_01 (conv_i_src_c081_1_01 0 conv_bpf_c081_1 0) vcvs gain=8.314696123025e-01
SCONVI_c081_1_01 (conv_i_src_c081_1_01 conv_i_c081_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_01 (conv_q_src_c081_1_01 0 conv_bpf_c081_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_1_01 (conv_q_src_c081_1_01 conv_q_c081_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_02 (conv_i_src_c081_1_02 0 conv_bpf_c081_1 0) vcvs gain=5.555702330196e-01
SCONVI_c081_1_02 (conv_i_src_c081_1_02 conv_i_c081_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_02 (conv_q_src_c081_1_02 0 conv_bpf_c081_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_1_02 (conv_q_src_c081_1_02 conv_q_c081_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_03 (conv_i_src_c081_1_03 0 conv_bpf_c081_1 0) vcvs gain=1.950903220161e-01
SCONVI_c081_1_03 (conv_i_src_c081_1_03 conv_i_c081_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_03 (conv_q_src_c081_1_03 0 conv_bpf_c081_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_1_03 (conv_q_src_c081_1_03 conv_q_c081_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_04 (conv_i_src_c081_1_04 0 conv_bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_1_04 (conv_i_src_c081_1_04 conv_i_c081_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_04 (conv_q_src_c081_1_04 0 conv_bpf_c081_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_1_04 (conv_q_src_c081_1_04 conv_q_c081_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_05 (conv_i_src_c081_1_05 0 conv_bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_1_05 (conv_i_src_c081_1_05 conv_i_c081_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_05 (conv_q_src_c081_1_05 0 conv_bpf_c081_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_1_05 (conv_q_src_c081_1_05 conv_q_c081_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_06 (conv_i_src_c081_1_06 0 conv_bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_1_06 (conv_i_src_c081_1_06 conv_i_c081_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_06 (conv_q_src_c081_1_06 0 conv_bpf_c081_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_1_06 (conv_q_src_c081_1_06 conv_q_c081_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_07 (conv_i_src_c081_1_07 0 conv_bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_1_07 (conv_i_src_c081_1_07 conv_i_c081_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_07 (conv_q_src_c081_1_07 0 conv_bpf_c081_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_1_07 (conv_q_src_c081_1_07 conv_q_c081_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_08 (conv_i_src_c081_1_08 0 conv_bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_1_08 (conv_i_src_c081_1_08 conv_i_c081_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_08 (conv_q_src_c081_1_08 0 conv_bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_1_08 (conv_q_src_c081_1_08 conv_q_c081_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_09 (conv_i_src_c081_1_09 0 conv_bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_1_09 (conv_i_src_c081_1_09 conv_i_c081_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_09 (conv_q_src_c081_1_09 0 conv_bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_1_09 (conv_q_src_c081_1_09 conv_q_c081_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_10 (conv_i_src_c081_1_10 0 conv_bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_1_10 (conv_i_src_c081_1_10 conv_i_c081_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_10 (conv_q_src_c081_1_10 0 conv_bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_1_10 (conv_q_src_c081_1_10 conv_q_c081_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_11 (conv_i_src_c081_1_11 0 conv_bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_1_11 (conv_i_src_c081_1_11 conv_i_c081_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_11 (conv_q_src_c081_1_11 0 conv_bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_1_11 (conv_q_src_c081_1_11 conv_q_c081_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_12 (conv_i_src_c081_1_12 0 conv_bpf_c081_1 0) vcvs gain=1.950903220161e-01
SCONVI_c081_1_12 (conv_i_src_c081_1_12 conv_i_c081_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_12 (conv_q_src_c081_1_12 0 conv_bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_1_12 (conv_q_src_c081_1_12 conv_q_c081_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_13 (conv_i_src_c081_1_13 0 conv_bpf_c081_1 0) vcvs gain=5.555702330196e-01
SCONVI_c081_1_13 (conv_i_src_c081_1_13 conv_i_c081_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_13 (conv_q_src_c081_1_13 0 conv_bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_1_13 (conv_q_src_c081_1_13 conv_q_c081_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_14 (conv_i_src_c081_1_14 0 conv_bpf_c081_1 0) vcvs gain=8.314696123025e-01
SCONVI_c081_1_14 (conv_i_src_c081_1_14 conv_i_c081_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_14 (conv_q_src_c081_1_14 0 conv_bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_1_14 (conv_q_src_c081_1_14 conv_q_c081_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_1_15 (conv_i_src_c081_1_15 0 conv_bpf_c081_1 0) vcvs gain=9.807852804032e-01
SCONVI_c081_1_15 (conv_i_src_c081_1_15 conv_i_c081_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_1_15 (conv_q_src_c081_1_15 0 conv_bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_1_15 (conv_q_src_c081_1_15 conv_q_c081_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c081_1 (conv_i_c081_1 0) resistor r=1G
RCONVQ_c081_1 (conv_q_c081_1 0) resistor r=1G
RCONVINTI_c081_1 (conv_i_c081_1 ConvIcar_c081_1) resistor r=1k
CCONVINTI_c081_1 (ConvIcar_c081_1 0) capacitor c=80p
RCONVINTQ_c081_1 (conv_q_c081_1 ConvQcar_c081_1) resistor r=1k
CCONVINTQ_c081_1 (ConvQcar_c081_1 0) capacitor c=80p
save conv_bpf_c081_1 ConvIcar_c081_1 ConvQcar_c081_1

// conventional mixed baseline bl081, carrier_2: 750000000 Hz
CCONVBPF_c081_2 (bl081 n_conv_cbpf_c081_2) capacitor c=4.503163717437e-14
LCONVBPF_c081_2 (n_conv_cbpf_c081_2 conv_bpf_c081_2) inductor l=1.000000000000e-06
RCONVBPF_c081_2 (conv_bpf_c081_2 0) resistor r=2.356194490192e+02
ECONVI_c081_2_00 (conv_i_src_c081_2_00 0 conv_bpf_c081_2 0) vcvs gain=9.807852804032e-01
SCONVI_c081_2_00 (conv_i_src_c081_2_00 conv_i_c081_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_00 (conv_q_src_c081_2_00 0 conv_bpf_c081_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_2_00 (conv_q_src_c081_2_00 conv_q_c081_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_01 (conv_i_src_c081_2_01 0 conv_bpf_c081_2 0) vcvs gain=8.314696123025e-01
SCONVI_c081_2_01 (conv_i_src_c081_2_01 conv_i_c081_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_01 (conv_q_src_c081_2_01 0 conv_bpf_c081_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_2_01 (conv_q_src_c081_2_01 conv_q_c081_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_02 (conv_i_src_c081_2_02 0 conv_bpf_c081_2 0) vcvs gain=5.555702330196e-01
SCONVI_c081_2_02 (conv_i_src_c081_2_02 conv_i_c081_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_02 (conv_q_src_c081_2_02 0 conv_bpf_c081_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_2_02 (conv_q_src_c081_2_02 conv_q_c081_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_03 (conv_i_src_c081_2_03 0 conv_bpf_c081_2 0) vcvs gain=1.950903220161e-01
SCONVI_c081_2_03 (conv_i_src_c081_2_03 conv_i_c081_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_03 (conv_q_src_c081_2_03 0 conv_bpf_c081_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_2_03 (conv_q_src_c081_2_03 conv_q_c081_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_04 (conv_i_src_c081_2_04 0 conv_bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_2_04 (conv_i_src_c081_2_04 conv_i_c081_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_04 (conv_q_src_c081_2_04 0 conv_bpf_c081_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_2_04 (conv_q_src_c081_2_04 conv_q_c081_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_05 (conv_i_src_c081_2_05 0 conv_bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_2_05 (conv_i_src_c081_2_05 conv_i_c081_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_05 (conv_q_src_c081_2_05 0 conv_bpf_c081_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_2_05 (conv_q_src_c081_2_05 conv_q_c081_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_06 (conv_i_src_c081_2_06 0 conv_bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_2_06 (conv_i_src_c081_2_06 conv_i_c081_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_06 (conv_q_src_c081_2_06 0 conv_bpf_c081_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_2_06 (conv_q_src_c081_2_06 conv_q_c081_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_07 (conv_i_src_c081_2_07 0 conv_bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_2_07 (conv_i_src_c081_2_07 conv_i_c081_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_07 (conv_q_src_c081_2_07 0 conv_bpf_c081_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_2_07 (conv_q_src_c081_2_07 conv_q_c081_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_08 (conv_i_src_c081_2_08 0 conv_bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_2_08 (conv_i_src_c081_2_08 conv_i_c081_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_08 (conv_q_src_c081_2_08 0 conv_bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_2_08 (conv_q_src_c081_2_08 conv_q_c081_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_09 (conv_i_src_c081_2_09 0 conv_bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_2_09 (conv_i_src_c081_2_09 conv_i_c081_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_09 (conv_q_src_c081_2_09 0 conv_bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_2_09 (conv_q_src_c081_2_09 conv_q_c081_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_10 (conv_i_src_c081_2_10 0 conv_bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_2_10 (conv_i_src_c081_2_10 conv_i_c081_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_10 (conv_q_src_c081_2_10 0 conv_bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_2_10 (conv_q_src_c081_2_10 conv_q_c081_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_11 (conv_i_src_c081_2_11 0 conv_bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_2_11 (conv_i_src_c081_2_11 conv_i_c081_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_11 (conv_q_src_c081_2_11 0 conv_bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_2_11 (conv_q_src_c081_2_11 conv_q_c081_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_12 (conv_i_src_c081_2_12 0 conv_bpf_c081_2 0) vcvs gain=1.950903220161e-01
SCONVI_c081_2_12 (conv_i_src_c081_2_12 conv_i_c081_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_12 (conv_q_src_c081_2_12 0 conv_bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_2_12 (conv_q_src_c081_2_12 conv_q_c081_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_13 (conv_i_src_c081_2_13 0 conv_bpf_c081_2 0) vcvs gain=5.555702330196e-01
SCONVI_c081_2_13 (conv_i_src_c081_2_13 conv_i_c081_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_13 (conv_q_src_c081_2_13 0 conv_bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_2_13 (conv_q_src_c081_2_13 conv_q_c081_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_14 (conv_i_src_c081_2_14 0 conv_bpf_c081_2 0) vcvs gain=8.314696123025e-01
SCONVI_c081_2_14 (conv_i_src_c081_2_14 conv_i_c081_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_14 (conv_q_src_c081_2_14 0 conv_bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_2_14 (conv_q_src_c081_2_14 conv_q_c081_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_2_15 (conv_i_src_c081_2_15 0 conv_bpf_c081_2 0) vcvs gain=9.807852804032e-01
SCONVI_c081_2_15 (conv_i_src_c081_2_15 conv_i_c081_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_2_15 (conv_q_src_c081_2_15 0 conv_bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_2_15 (conv_q_src_c081_2_15 conv_q_c081_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c081_2 (conv_i_c081_2 0) resistor r=1G
RCONVQ_c081_2 (conv_q_c081_2 0) resistor r=1G
RCONVINTI_c081_2 (conv_i_c081_2 ConvIcar_c081_2) resistor r=1k
CCONVINTI_c081_2 (ConvIcar_c081_2 0) capacitor c=80p
RCONVINTQ_c081_2 (conv_q_c081_2 ConvQcar_c081_2) resistor r=1k
CCONVINTQ_c081_2 (ConvQcar_c081_2 0) capacitor c=80p
save conv_bpf_c081_2 ConvIcar_c081_2 ConvQcar_c081_2

// conventional mixed baseline bl081, carrier_3: 1000000000 Hz
CCONVBPF_c081_3 (bl081 n_conv_cbpf_c081_3) capacitor c=2.533029591058e-14
LCONVBPF_c081_3 (n_conv_cbpf_c081_3 conv_bpf_c081_3) inductor l=1.000000000000e-06
RCONVBPF_c081_3 (conv_bpf_c081_3 0) resistor r=3.141592653590e+02
ECONVI_c081_3_00 (conv_i_src_c081_3_00 0 conv_bpf_c081_3 0) vcvs gain=9.807852804032e-01
SCONVI_c081_3_00 (conv_i_src_c081_3_00 conv_i_c081_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_00 (conv_q_src_c081_3_00 0 conv_bpf_c081_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_3_00 (conv_q_src_c081_3_00 conv_q_c081_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_01 (conv_i_src_c081_3_01 0 conv_bpf_c081_3 0) vcvs gain=8.314696123025e-01
SCONVI_c081_3_01 (conv_i_src_c081_3_01 conv_i_c081_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_01 (conv_q_src_c081_3_01 0 conv_bpf_c081_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_3_01 (conv_q_src_c081_3_01 conv_q_c081_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_02 (conv_i_src_c081_3_02 0 conv_bpf_c081_3 0) vcvs gain=5.555702330196e-01
SCONVI_c081_3_02 (conv_i_src_c081_3_02 conv_i_c081_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_02 (conv_q_src_c081_3_02 0 conv_bpf_c081_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_3_02 (conv_q_src_c081_3_02 conv_q_c081_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_03 (conv_i_src_c081_3_03 0 conv_bpf_c081_3 0) vcvs gain=1.950903220161e-01
SCONVI_c081_3_03 (conv_i_src_c081_3_03 conv_i_c081_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_03 (conv_q_src_c081_3_03 0 conv_bpf_c081_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_3_03 (conv_q_src_c081_3_03 conv_q_c081_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_04 (conv_i_src_c081_3_04 0 conv_bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_3_04 (conv_i_src_c081_3_04 conv_i_c081_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_04 (conv_q_src_c081_3_04 0 conv_bpf_c081_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c081_3_04 (conv_q_src_c081_3_04 conv_q_c081_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_05 (conv_i_src_c081_3_05 0 conv_bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_3_05 (conv_i_src_c081_3_05 conv_i_c081_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_05 (conv_q_src_c081_3_05 0 conv_bpf_c081_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c081_3_05 (conv_q_src_c081_3_05 conv_q_c081_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_06 (conv_i_src_c081_3_06 0 conv_bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_3_06 (conv_i_src_c081_3_06 conv_i_c081_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_06 (conv_q_src_c081_3_06 0 conv_bpf_c081_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c081_3_06 (conv_q_src_c081_3_06 conv_q_c081_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_07 (conv_i_src_c081_3_07 0 conv_bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_3_07 (conv_i_src_c081_3_07 conv_i_c081_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_07 (conv_q_src_c081_3_07 0 conv_bpf_c081_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c081_3_07 (conv_q_src_c081_3_07 conv_q_c081_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_08 (conv_i_src_c081_3_08 0 conv_bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c081_3_08 (conv_i_src_c081_3_08 conv_i_c081_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_08 (conv_q_src_c081_3_08 0 conv_bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_3_08 (conv_q_src_c081_3_08 conv_q_c081_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_09 (conv_i_src_c081_3_09 0 conv_bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c081_3_09 (conv_i_src_c081_3_09 conv_i_c081_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_09 (conv_q_src_c081_3_09 0 conv_bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_3_09 (conv_q_src_c081_3_09 conv_q_c081_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_10 (conv_i_src_c081_3_10 0 conv_bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c081_3_10 (conv_i_src_c081_3_10 conv_i_c081_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_10 (conv_q_src_c081_3_10 0 conv_bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_3_10 (conv_q_src_c081_3_10 conv_q_c081_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_11 (conv_i_src_c081_3_11 0 conv_bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c081_3_11 (conv_i_src_c081_3_11 conv_i_c081_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_11 (conv_q_src_c081_3_11 0 conv_bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_3_11 (conv_q_src_c081_3_11 conv_q_c081_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_12 (conv_i_src_c081_3_12 0 conv_bpf_c081_3 0) vcvs gain=1.950903220161e-01
SCONVI_c081_3_12 (conv_i_src_c081_3_12 conv_i_c081_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_12 (conv_q_src_c081_3_12 0 conv_bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c081_3_12 (conv_q_src_c081_3_12 conv_q_c081_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_13 (conv_i_src_c081_3_13 0 conv_bpf_c081_3 0) vcvs gain=5.555702330196e-01
SCONVI_c081_3_13 (conv_i_src_c081_3_13 conv_i_c081_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_13 (conv_q_src_c081_3_13 0 conv_bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c081_3_13 (conv_q_src_c081_3_13 conv_q_c081_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_14 (conv_i_src_c081_3_14 0 conv_bpf_c081_3 0) vcvs gain=8.314696123025e-01
SCONVI_c081_3_14 (conv_i_src_c081_3_14 conv_i_c081_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_14 (conv_q_src_c081_3_14 0 conv_bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c081_3_14 (conv_q_src_c081_3_14 conv_q_c081_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c081_3_15 (conv_i_src_c081_3_15 0 conv_bpf_c081_3 0) vcvs gain=9.807852804032e-01
SCONVI_c081_3_15 (conv_i_src_c081_3_15 conv_i_c081_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c081_3_15 (conv_q_src_c081_3_15 0 conv_bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c081_3_15 (conv_q_src_c081_3_15 conv_q_c081_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c081_3 (conv_i_c081_3 0) resistor r=1G
RCONVQ_c081_3 (conv_q_c081_3 0) resistor r=1G
RCONVINTI_c081_3 (conv_i_c081_3 ConvIcar_c081_3) resistor r=1k
CCONVINTI_c081_3 (ConvIcar_c081_3 0) capacitor c=80p
RCONVINTQ_c081_3 (conv_q_c081_3 ConvQcar_c081_3) resistor r=1k
CCONVINTQ_c081_3 (ConvQcar_c081_3 0) capacitor c=80p
save conv_bpf_c081_3 ConvIcar_c081_3 ConvQcar_c081_3

// conventional mixed baseline bl082, carrier_0: 250000000 Hz
CCONVBPF_c082_0 (bl082 n_conv_cbpf_c082_0) capacitor c=4.052847345694e-13
LCONVBPF_c082_0 (n_conv_cbpf_c082_0 conv_bpf_c082_0) inductor l=1.000000000000e-06
RCONVBPF_c082_0 (conv_bpf_c082_0 0) resistor r=7.853981633974e+01
ECONVI_c082_0_00 (conv_i_src_c082_0_00 0 conv_bpf_c082_0 0) vcvs gain=9.807852804032e-01
SCONVI_c082_0_00 (conv_i_src_c082_0_00 conv_i_c082_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_00 (conv_q_src_c082_0_00 0 conv_bpf_c082_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_0_00 (conv_q_src_c082_0_00 conv_q_c082_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_01 (conv_i_src_c082_0_01 0 conv_bpf_c082_0 0) vcvs gain=8.314696123025e-01
SCONVI_c082_0_01 (conv_i_src_c082_0_01 conv_i_c082_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_01 (conv_q_src_c082_0_01 0 conv_bpf_c082_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_0_01 (conv_q_src_c082_0_01 conv_q_c082_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_02 (conv_i_src_c082_0_02 0 conv_bpf_c082_0 0) vcvs gain=5.555702330196e-01
SCONVI_c082_0_02 (conv_i_src_c082_0_02 conv_i_c082_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_02 (conv_q_src_c082_0_02 0 conv_bpf_c082_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_0_02 (conv_q_src_c082_0_02 conv_q_c082_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_03 (conv_i_src_c082_0_03 0 conv_bpf_c082_0 0) vcvs gain=1.950903220161e-01
SCONVI_c082_0_03 (conv_i_src_c082_0_03 conv_i_c082_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_03 (conv_q_src_c082_0_03 0 conv_bpf_c082_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_0_03 (conv_q_src_c082_0_03 conv_q_c082_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_04 (conv_i_src_c082_0_04 0 conv_bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_0_04 (conv_i_src_c082_0_04 conv_i_c082_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_04 (conv_q_src_c082_0_04 0 conv_bpf_c082_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_0_04 (conv_q_src_c082_0_04 conv_q_c082_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_05 (conv_i_src_c082_0_05 0 conv_bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_0_05 (conv_i_src_c082_0_05 conv_i_c082_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_05 (conv_q_src_c082_0_05 0 conv_bpf_c082_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_0_05 (conv_q_src_c082_0_05 conv_q_c082_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_06 (conv_i_src_c082_0_06 0 conv_bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_0_06 (conv_i_src_c082_0_06 conv_i_c082_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_06 (conv_q_src_c082_0_06 0 conv_bpf_c082_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_0_06 (conv_q_src_c082_0_06 conv_q_c082_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_07 (conv_i_src_c082_0_07 0 conv_bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_0_07 (conv_i_src_c082_0_07 conv_i_c082_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_07 (conv_q_src_c082_0_07 0 conv_bpf_c082_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_0_07 (conv_q_src_c082_0_07 conv_q_c082_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_08 (conv_i_src_c082_0_08 0 conv_bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_0_08 (conv_i_src_c082_0_08 conv_i_c082_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_08 (conv_q_src_c082_0_08 0 conv_bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_0_08 (conv_q_src_c082_0_08 conv_q_c082_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_09 (conv_i_src_c082_0_09 0 conv_bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_0_09 (conv_i_src_c082_0_09 conv_i_c082_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_09 (conv_q_src_c082_0_09 0 conv_bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_0_09 (conv_q_src_c082_0_09 conv_q_c082_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_10 (conv_i_src_c082_0_10 0 conv_bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_0_10 (conv_i_src_c082_0_10 conv_i_c082_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_10 (conv_q_src_c082_0_10 0 conv_bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_0_10 (conv_q_src_c082_0_10 conv_q_c082_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_11 (conv_i_src_c082_0_11 0 conv_bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_0_11 (conv_i_src_c082_0_11 conv_i_c082_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_11 (conv_q_src_c082_0_11 0 conv_bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_0_11 (conv_q_src_c082_0_11 conv_q_c082_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_12 (conv_i_src_c082_0_12 0 conv_bpf_c082_0 0) vcvs gain=1.950903220161e-01
SCONVI_c082_0_12 (conv_i_src_c082_0_12 conv_i_c082_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_12 (conv_q_src_c082_0_12 0 conv_bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_0_12 (conv_q_src_c082_0_12 conv_q_c082_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_13 (conv_i_src_c082_0_13 0 conv_bpf_c082_0 0) vcvs gain=5.555702330196e-01
SCONVI_c082_0_13 (conv_i_src_c082_0_13 conv_i_c082_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_13 (conv_q_src_c082_0_13 0 conv_bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_0_13 (conv_q_src_c082_0_13 conv_q_c082_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_14 (conv_i_src_c082_0_14 0 conv_bpf_c082_0 0) vcvs gain=8.314696123025e-01
SCONVI_c082_0_14 (conv_i_src_c082_0_14 conv_i_c082_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_14 (conv_q_src_c082_0_14 0 conv_bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_0_14 (conv_q_src_c082_0_14 conv_q_c082_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_0_15 (conv_i_src_c082_0_15 0 conv_bpf_c082_0 0) vcvs gain=9.807852804032e-01
SCONVI_c082_0_15 (conv_i_src_c082_0_15 conv_i_c082_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_0_15 (conv_q_src_c082_0_15 0 conv_bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_0_15 (conv_q_src_c082_0_15 conv_q_c082_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c082_0 (conv_i_c082_0 0) resistor r=1G
RCONVQ_c082_0 (conv_q_c082_0 0) resistor r=1G
RCONVINTI_c082_0 (conv_i_c082_0 ConvIcar_c082_0) resistor r=1k
CCONVINTI_c082_0 (ConvIcar_c082_0 0) capacitor c=80p
RCONVINTQ_c082_0 (conv_q_c082_0 ConvQcar_c082_0) resistor r=1k
CCONVINTQ_c082_0 (ConvQcar_c082_0 0) capacitor c=80p
save conv_bpf_c082_0 ConvIcar_c082_0 ConvQcar_c082_0

// conventional mixed baseline bl082, carrier_1: 500000000 Hz
CCONVBPF_c082_1 (bl082 n_conv_cbpf_c082_1) capacitor c=1.013211836423e-13
LCONVBPF_c082_1 (n_conv_cbpf_c082_1 conv_bpf_c082_1) inductor l=1.000000000000e-06
RCONVBPF_c082_1 (conv_bpf_c082_1 0) resistor r=1.570796326795e+02
ECONVI_c082_1_00 (conv_i_src_c082_1_00 0 conv_bpf_c082_1 0) vcvs gain=9.807852804032e-01
SCONVI_c082_1_00 (conv_i_src_c082_1_00 conv_i_c082_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_00 (conv_q_src_c082_1_00 0 conv_bpf_c082_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_1_00 (conv_q_src_c082_1_00 conv_q_c082_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_01 (conv_i_src_c082_1_01 0 conv_bpf_c082_1 0) vcvs gain=8.314696123025e-01
SCONVI_c082_1_01 (conv_i_src_c082_1_01 conv_i_c082_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_01 (conv_q_src_c082_1_01 0 conv_bpf_c082_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_1_01 (conv_q_src_c082_1_01 conv_q_c082_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_02 (conv_i_src_c082_1_02 0 conv_bpf_c082_1 0) vcvs gain=5.555702330196e-01
SCONVI_c082_1_02 (conv_i_src_c082_1_02 conv_i_c082_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_02 (conv_q_src_c082_1_02 0 conv_bpf_c082_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_1_02 (conv_q_src_c082_1_02 conv_q_c082_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_03 (conv_i_src_c082_1_03 0 conv_bpf_c082_1 0) vcvs gain=1.950903220161e-01
SCONVI_c082_1_03 (conv_i_src_c082_1_03 conv_i_c082_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_03 (conv_q_src_c082_1_03 0 conv_bpf_c082_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_1_03 (conv_q_src_c082_1_03 conv_q_c082_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_04 (conv_i_src_c082_1_04 0 conv_bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_1_04 (conv_i_src_c082_1_04 conv_i_c082_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_04 (conv_q_src_c082_1_04 0 conv_bpf_c082_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_1_04 (conv_q_src_c082_1_04 conv_q_c082_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_05 (conv_i_src_c082_1_05 0 conv_bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_1_05 (conv_i_src_c082_1_05 conv_i_c082_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_05 (conv_q_src_c082_1_05 0 conv_bpf_c082_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_1_05 (conv_q_src_c082_1_05 conv_q_c082_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_06 (conv_i_src_c082_1_06 0 conv_bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_1_06 (conv_i_src_c082_1_06 conv_i_c082_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_06 (conv_q_src_c082_1_06 0 conv_bpf_c082_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_1_06 (conv_q_src_c082_1_06 conv_q_c082_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_07 (conv_i_src_c082_1_07 0 conv_bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_1_07 (conv_i_src_c082_1_07 conv_i_c082_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_07 (conv_q_src_c082_1_07 0 conv_bpf_c082_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_1_07 (conv_q_src_c082_1_07 conv_q_c082_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_08 (conv_i_src_c082_1_08 0 conv_bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_1_08 (conv_i_src_c082_1_08 conv_i_c082_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_08 (conv_q_src_c082_1_08 0 conv_bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_1_08 (conv_q_src_c082_1_08 conv_q_c082_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_09 (conv_i_src_c082_1_09 0 conv_bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_1_09 (conv_i_src_c082_1_09 conv_i_c082_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_09 (conv_q_src_c082_1_09 0 conv_bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_1_09 (conv_q_src_c082_1_09 conv_q_c082_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_10 (conv_i_src_c082_1_10 0 conv_bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_1_10 (conv_i_src_c082_1_10 conv_i_c082_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_10 (conv_q_src_c082_1_10 0 conv_bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_1_10 (conv_q_src_c082_1_10 conv_q_c082_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_11 (conv_i_src_c082_1_11 0 conv_bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_1_11 (conv_i_src_c082_1_11 conv_i_c082_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_11 (conv_q_src_c082_1_11 0 conv_bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_1_11 (conv_q_src_c082_1_11 conv_q_c082_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_12 (conv_i_src_c082_1_12 0 conv_bpf_c082_1 0) vcvs gain=1.950903220161e-01
SCONVI_c082_1_12 (conv_i_src_c082_1_12 conv_i_c082_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_12 (conv_q_src_c082_1_12 0 conv_bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_1_12 (conv_q_src_c082_1_12 conv_q_c082_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_13 (conv_i_src_c082_1_13 0 conv_bpf_c082_1 0) vcvs gain=5.555702330196e-01
SCONVI_c082_1_13 (conv_i_src_c082_1_13 conv_i_c082_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_13 (conv_q_src_c082_1_13 0 conv_bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_1_13 (conv_q_src_c082_1_13 conv_q_c082_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_14 (conv_i_src_c082_1_14 0 conv_bpf_c082_1 0) vcvs gain=8.314696123025e-01
SCONVI_c082_1_14 (conv_i_src_c082_1_14 conv_i_c082_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_14 (conv_q_src_c082_1_14 0 conv_bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_1_14 (conv_q_src_c082_1_14 conv_q_c082_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_1_15 (conv_i_src_c082_1_15 0 conv_bpf_c082_1 0) vcvs gain=9.807852804032e-01
SCONVI_c082_1_15 (conv_i_src_c082_1_15 conv_i_c082_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_1_15 (conv_q_src_c082_1_15 0 conv_bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_1_15 (conv_q_src_c082_1_15 conv_q_c082_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c082_1 (conv_i_c082_1 0) resistor r=1G
RCONVQ_c082_1 (conv_q_c082_1 0) resistor r=1G
RCONVINTI_c082_1 (conv_i_c082_1 ConvIcar_c082_1) resistor r=1k
CCONVINTI_c082_1 (ConvIcar_c082_1 0) capacitor c=80p
RCONVINTQ_c082_1 (conv_q_c082_1 ConvQcar_c082_1) resistor r=1k
CCONVINTQ_c082_1 (ConvQcar_c082_1 0) capacitor c=80p
save conv_bpf_c082_1 ConvIcar_c082_1 ConvQcar_c082_1

// conventional mixed baseline bl082, carrier_2: 750000000 Hz
CCONVBPF_c082_2 (bl082 n_conv_cbpf_c082_2) capacitor c=4.503163717437e-14
LCONVBPF_c082_2 (n_conv_cbpf_c082_2 conv_bpf_c082_2) inductor l=1.000000000000e-06
RCONVBPF_c082_2 (conv_bpf_c082_2 0) resistor r=2.356194490192e+02
ECONVI_c082_2_00 (conv_i_src_c082_2_00 0 conv_bpf_c082_2 0) vcvs gain=9.807852804032e-01
SCONVI_c082_2_00 (conv_i_src_c082_2_00 conv_i_c082_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_00 (conv_q_src_c082_2_00 0 conv_bpf_c082_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_2_00 (conv_q_src_c082_2_00 conv_q_c082_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_01 (conv_i_src_c082_2_01 0 conv_bpf_c082_2 0) vcvs gain=8.314696123025e-01
SCONVI_c082_2_01 (conv_i_src_c082_2_01 conv_i_c082_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_01 (conv_q_src_c082_2_01 0 conv_bpf_c082_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_2_01 (conv_q_src_c082_2_01 conv_q_c082_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_02 (conv_i_src_c082_2_02 0 conv_bpf_c082_2 0) vcvs gain=5.555702330196e-01
SCONVI_c082_2_02 (conv_i_src_c082_2_02 conv_i_c082_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_02 (conv_q_src_c082_2_02 0 conv_bpf_c082_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_2_02 (conv_q_src_c082_2_02 conv_q_c082_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_03 (conv_i_src_c082_2_03 0 conv_bpf_c082_2 0) vcvs gain=1.950903220161e-01
SCONVI_c082_2_03 (conv_i_src_c082_2_03 conv_i_c082_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_03 (conv_q_src_c082_2_03 0 conv_bpf_c082_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_2_03 (conv_q_src_c082_2_03 conv_q_c082_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_04 (conv_i_src_c082_2_04 0 conv_bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_2_04 (conv_i_src_c082_2_04 conv_i_c082_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_04 (conv_q_src_c082_2_04 0 conv_bpf_c082_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_2_04 (conv_q_src_c082_2_04 conv_q_c082_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_05 (conv_i_src_c082_2_05 0 conv_bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_2_05 (conv_i_src_c082_2_05 conv_i_c082_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_05 (conv_q_src_c082_2_05 0 conv_bpf_c082_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_2_05 (conv_q_src_c082_2_05 conv_q_c082_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_06 (conv_i_src_c082_2_06 0 conv_bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_2_06 (conv_i_src_c082_2_06 conv_i_c082_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_06 (conv_q_src_c082_2_06 0 conv_bpf_c082_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_2_06 (conv_q_src_c082_2_06 conv_q_c082_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_07 (conv_i_src_c082_2_07 0 conv_bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_2_07 (conv_i_src_c082_2_07 conv_i_c082_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_07 (conv_q_src_c082_2_07 0 conv_bpf_c082_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_2_07 (conv_q_src_c082_2_07 conv_q_c082_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_08 (conv_i_src_c082_2_08 0 conv_bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_2_08 (conv_i_src_c082_2_08 conv_i_c082_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_08 (conv_q_src_c082_2_08 0 conv_bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_2_08 (conv_q_src_c082_2_08 conv_q_c082_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_09 (conv_i_src_c082_2_09 0 conv_bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_2_09 (conv_i_src_c082_2_09 conv_i_c082_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_09 (conv_q_src_c082_2_09 0 conv_bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_2_09 (conv_q_src_c082_2_09 conv_q_c082_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_10 (conv_i_src_c082_2_10 0 conv_bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_2_10 (conv_i_src_c082_2_10 conv_i_c082_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_10 (conv_q_src_c082_2_10 0 conv_bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_2_10 (conv_q_src_c082_2_10 conv_q_c082_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_11 (conv_i_src_c082_2_11 0 conv_bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_2_11 (conv_i_src_c082_2_11 conv_i_c082_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_11 (conv_q_src_c082_2_11 0 conv_bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_2_11 (conv_q_src_c082_2_11 conv_q_c082_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_12 (conv_i_src_c082_2_12 0 conv_bpf_c082_2 0) vcvs gain=1.950903220161e-01
SCONVI_c082_2_12 (conv_i_src_c082_2_12 conv_i_c082_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_12 (conv_q_src_c082_2_12 0 conv_bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_2_12 (conv_q_src_c082_2_12 conv_q_c082_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_13 (conv_i_src_c082_2_13 0 conv_bpf_c082_2 0) vcvs gain=5.555702330196e-01
SCONVI_c082_2_13 (conv_i_src_c082_2_13 conv_i_c082_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_13 (conv_q_src_c082_2_13 0 conv_bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_2_13 (conv_q_src_c082_2_13 conv_q_c082_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_14 (conv_i_src_c082_2_14 0 conv_bpf_c082_2 0) vcvs gain=8.314696123025e-01
SCONVI_c082_2_14 (conv_i_src_c082_2_14 conv_i_c082_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_14 (conv_q_src_c082_2_14 0 conv_bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_2_14 (conv_q_src_c082_2_14 conv_q_c082_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_2_15 (conv_i_src_c082_2_15 0 conv_bpf_c082_2 0) vcvs gain=9.807852804032e-01
SCONVI_c082_2_15 (conv_i_src_c082_2_15 conv_i_c082_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_2_15 (conv_q_src_c082_2_15 0 conv_bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_2_15 (conv_q_src_c082_2_15 conv_q_c082_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c082_2 (conv_i_c082_2 0) resistor r=1G
RCONVQ_c082_2 (conv_q_c082_2 0) resistor r=1G
RCONVINTI_c082_2 (conv_i_c082_2 ConvIcar_c082_2) resistor r=1k
CCONVINTI_c082_2 (ConvIcar_c082_2 0) capacitor c=80p
RCONVINTQ_c082_2 (conv_q_c082_2 ConvQcar_c082_2) resistor r=1k
CCONVINTQ_c082_2 (ConvQcar_c082_2 0) capacitor c=80p
save conv_bpf_c082_2 ConvIcar_c082_2 ConvQcar_c082_2

// conventional mixed baseline bl082, carrier_3: 1000000000 Hz
CCONVBPF_c082_3 (bl082 n_conv_cbpf_c082_3) capacitor c=2.533029591058e-14
LCONVBPF_c082_3 (n_conv_cbpf_c082_3 conv_bpf_c082_3) inductor l=1.000000000000e-06
RCONVBPF_c082_3 (conv_bpf_c082_3 0) resistor r=3.141592653590e+02
ECONVI_c082_3_00 (conv_i_src_c082_3_00 0 conv_bpf_c082_3 0) vcvs gain=9.807852804032e-01
SCONVI_c082_3_00 (conv_i_src_c082_3_00 conv_i_c082_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_00 (conv_q_src_c082_3_00 0 conv_bpf_c082_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_3_00 (conv_q_src_c082_3_00 conv_q_c082_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_01 (conv_i_src_c082_3_01 0 conv_bpf_c082_3 0) vcvs gain=8.314696123025e-01
SCONVI_c082_3_01 (conv_i_src_c082_3_01 conv_i_c082_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_01 (conv_q_src_c082_3_01 0 conv_bpf_c082_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_3_01 (conv_q_src_c082_3_01 conv_q_c082_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_02 (conv_i_src_c082_3_02 0 conv_bpf_c082_3 0) vcvs gain=5.555702330196e-01
SCONVI_c082_3_02 (conv_i_src_c082_3_02 conv_i_c082_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_02 (conv_q_src_c082_3_02 0 conv_bpf_c082_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_3_02 (conv_q_src_c082_3_02 conv_q_c082_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_03 (conv_i_src_c082_3_03 0 conv_bpf_c082_3 0) vcvs gain=1.950903220161e-01
SCONVI_c082_3_03 (conv_i_src_c082_3_03 conv_i_c082_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_03 (conv_q_src_c082_3_03 0 conv_bpf_c082_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_3_03 (conv_q_src_c082_3_03 conv_q_c082_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_04 (conv_i_src_c082_3_04 0 conv_bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_3_04 (conv_i_src_c082_3_04 conv_i_c082_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_04 (conv_q_src_c082_3_04 0 conv_bpf_c082_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c082_3_04 (conv_q_src_c082_3_04 conv_q_c082_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_05 (conv_i_src_c082_3_05 0 conv_bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_3_05 (conv_i_src_c082_3_05 conv_i_c082_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_05 (conv_q_src_c082_3_05 0 conv_bpf_c082_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c082_3_05 (conv_q_src_c082_3_05 conv_q_c082_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_06 (conv_i_src_c082_3_06 0 conv_bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_3_06 (conv_i_src_c082_3_06 conv_i_c082_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_06 (conv_q_src_c082_3_06 0 conv_bpf_c082_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c082_3_06 (conv_q_src_c082_3_06 conv_q_c082_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_07 (conv_i_src_c082_3_07 0 conv_bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_3_07 (conv_i_src_c082_3_07 conv_i_c082_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_07 (conv_q_src_c082_3_07 0 conv_bpf_c082_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c082_3_07 (conv_q_src_c082_3_07 conv_q_c082_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_08 (conv_i_src_c082_3_08 0 conv_bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c082_3_08 (conv_i_src_c082_3_08 conv_i_c082_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_08 (conv_q_src_c082_3_08 0 conv_bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_3_08 (conv_q_src_c082_3_08 conv_q_c082_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_09 (conv_i_src_c082_3_09 0 conv_bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c082_3_09 (conv_i_src_c082_3_09 conv_i_c082_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_09 (conv_q_src_c082_3_09 0 conv_bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_3_09 (conv_q_src_c082_3_09 conv_q_c082_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_10 (conv_i_src_c082_3_10 0 conv_bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c082_3_10 (conv_i_src_c082_3_10 conv_i_c082_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_10 (conv_q_src_c082_3_10 0 conv_bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_3_10 (conv_q_src_c082_3_10 conv_q_c082_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_11 (conv_i_src_c082_3_11 0 conv_bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c082_3_11 (conv_i_src_c082_3_11 conv_i_c082_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_11 (conv_q_src_c082_3_11 0 conv_bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_3_11 (conv_q_src_c082_3_11 conv_q_c082_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_12 (conv_i_src_c082_3_12 0 conv_bpf_c082_3 0) vcvs gain=1.950903220161e-01
SCONVI_c082_3_12 (conv_i_src_c082_3_12 conv_i_c082_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_12 (conv_q_src_c082_3_12 0 conv_bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c082_3_12 (conv_q_src_c082_3_12 conv_q_c082_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_13 (conv_i_src_c082_3_13 0 conv_bpf_c082_3 0) vcvs gain=5.555702330196e-01
SCONVI_c082_3_13 (conv_i_src_c082_3_13 conv_i_c082_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_13 (conv_q_src_c082_3_13 0 conv_bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c082_3_13 (conv_q_src_c082_3_13 conv_q_c082_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_14 (conv_i_src_c082_3_14 0 conv_bpf_c082_3 0) vcvs gain=8.314696123025e-01
SCONVI_c082_3_14 (conv_i_src_c082_3_14 conv_i_c082_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_14 (conv_q_src_c082_3_14 0 conv_bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c082_3_14 (conv_q_src_c082_3_14 conv_q_c082_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c082_3_15 (conv_i_src_c082_3_15 0 conv_bpf_c082_3 0) vcvs gain=9.807852804032e-01
SCONVI_c082_3_15 (conv_i_src_c082_3_15 conv_i_c082_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c082_3_15 (conv_q_src_c082_3_15 0 conv_bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c082_3_15 (conv_q_src_c082_3_15 conv_q_c082_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c082_3 (conv_i_c082_3 0) resistor r=1G
RCONVQ_c082_3 (conv_q_c082_3 0) resistor r=1G
RCONVINTI_c082_3 (conv_i_c082_3 ConvIcar_c082_3) resistor r=1k
CCONVINTI_c082_3 (ConvIcar_c082_3 0) capacitor c=80p
RCONVINTQ_c082_3 (conv_q_c082_3 ConvQcar_c082_3) resistor r=1k
CCONVINTQ_c082_3 (ConvQcar_c082_3 0) capacitor c=80p
save conv_bpf_c082_3 ConvIcar_c082_3 ConvQcar_c082_3

// conventional mixed baseline bl083, carrier_0: 250000000 Hz
CCONVBPF_c083_0 (bl083 n_conv_cbpf_c083_0) capacitor c=4.052847345694e-13
LCONVBPF_c083_0 (n_conv_cbpf_c083_0 conv_bpf_c083_0) inductor l=1.000000000000e-06
RCONVBPF_c083_0 (conv_bpf_c083_0 0) resistor r=7.853981633974e+01
ECONVI_c083_0_00 (conv_i_src_c083_0_00 0 conv_bpf_c083_0 0) vcvs gain=9.807852804032e-01
SCONVI_c083_0_00 (conv_i_src_c083_0_00 conv_i_c083_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_00 (conv_q_src_c083_0_00 0 conv_bpf_c083_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_0_00 (conv_q_src_c083_0_00 conv_q_c083_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_01 (conv_i_src_c083_0_01 0 conv_bpf_c083_0 0) vcvs gain=8.314696123025e-01
SCONVI_c083_0_01 (conv_i_src_c083_0_01 conv_i_c083_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_01 (conv_q_src_c083_0_01 0 conv_bpf_c083_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_0_01 (conv_q_src_c083_0_01 conv_q_c083_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_02 (conv_i_src_c083_0_02 0 conv_bpf_c083_0 0) vcvs gain=5.555702330196e-01
SCONVI_c083_0_02 (conv_i_src_c083_0_02 conv_i_c083_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_02 (conv_q_src_c083_0_02 0 conv_bpf_c083_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_0_02 (conv_q_src_c083_0_02 conv_q_c083_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_03 (conv_i_src_c083_0_03 0 conv_bpf_c083_0 0) vcvs gain=1.950903220161e-01
SCONVI_c083_0_03 (conv_i_src_c083_0_03 conv_i_c083_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_03 (conv_q_src_c083_0_03 0 conv_bpf_c083_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_0_03 (conv_q_src_c083_0_03 conv_q_c083_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_04 (conv_i_src_c083_0_04 0 conv_bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_0_04 (conv_i_src_c083_0_04 conv_i_c083_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_04 (conv_q_src_c083_0_04 0 conv_bpf_c083_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_0_04 (conv_q_src_c083_0_04 conv_q_c083_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_05 (conv_i_src_c083_0_05 0 conv_bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_0_05 (conv_i_src_c083_0_05 conv_i_c083_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_05 (conv_q_src_c083_0_05 0 conv_bpf_c083_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_0_05 (conv_q_src_c083_0_05 conv_q_c083_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_06 (conv_i_src_c083_0_06 0 conv_bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_0_06 (conv_i_src_c083_0_06 conv_i_c083_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_06 (conv_q_src_c083_0_06 0 conv_bpf_c083_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_0_06 (conv_q_src_c083_0_06 conv_q_c083_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_07 (conv_i_src_c083_0_07 0 conv_bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_0_07 (conv_i_src_c083_0_07 conv_i_c083_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_07 (conv_q_src_c083_0_07 0 conv_bpf_c083_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_0_07 (conv_q_src_c083_0_07 conv_q_c083_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_08 (conv_i_src_c083_0_08 0 conv_bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_0_08 (conv_i_src_c083_0_08 conv_i_c083_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_08 (conv_q_src_c083_0_08 0 conv_bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_0_08 (conv_q_src_c083_0_08 conv_q_c083_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_09 (conv_i_src_c083_0_09 0 conv_bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_0_09 (conv_i_src_c083_0_09 conv_i_c083_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_09 (conv_q_src_c083_0_09 0 conv_bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_0_09 (conv_q_src_c083_0_09 conv_q_c083_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_10 (conv_i_src_c083_0_10 0 conv_bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_0_10 (conv_i_src_c083_0_10 conv_i_c083_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_10 (conv_q_src_c083_0_10 0 conv_bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_0_10 (conv_q_src_c083_0_10 conv_q_c083_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_11 (conv_i_src_c083_0_11 0 conv_bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_0_11 (conv_i_src_c083_0_11 conv_i_c083_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_11 (conv_q_src_c083_0_11 0 conv_bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_0_11 (conv_q_src_c083_0_11 conv_q_c083_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_12 (conv_i_src_c083_0_12 0 conv_bpf_c083_0 0) vcvs gain=1.950903220161e-01
SCONVI_c083_0_12 (conv_i_src_c083_0_12 conv_i_c083_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_12 (conv_q_src_c083_0_12 0 conv_bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_0_12 (conv_q_src_c083_0_12 conv_q_c083_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_13 (conv_i_src_c083_0_13 0 conv_bpf_c083_0 0) vcvs gain=5.555702330196e-01
SCONVI_c083_0_13 (conv_i_src_c083_0_13 conv_i_c083_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_13 (conv_q_src_c083_0_13 0 conv_bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_0_13 (conv_q_src_c083_0_13 conv_q_c083_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_14 (conv_i_src_c083_0_14 0 conv_bpf_c083_0 0) vcvs gain=8.314696123025e-01
SCONVI_c083_0_14 (conv_i_src_c083_0_14 conv_i_c083_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_14 (conv_q_src_c083_0_14 0 conv_bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_0_14 (conv_q_src_c083_0_14 conv_q_c083_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_0_15 (conv_i_src_c083_0_15 0 conv_bpf_c083_0 0) vcvs gain=9.807852804032e-01
SCONVI_c083_0_15 (conv_i_src_c083_0_15 conv_i_c083_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_0_15 (conv_q_src_c083_0_15 0 conv_bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_0_15 (conv_q_src_c083_0_15 conv_q_c083_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c083_0 (conv_i_c083_0 0) resistor r=1G
RCONVQ_c083_0 (conv_q_c083_0 0) resistor r=1G
RCONVINTI_c083_0 (conv_i_c083_0 ConvIcar_c083_0) resistor r=1k
CCONVINTI_c083_0 (ConvIcar_c083_0 0) capacitor c=80p
RCONVINTQ_c083_0 (conv_q_c083_0 ConvQcar_c083_0) resistor r=1k
CCONVINTQ_c083_0 (ConvQcar_c083_0 0) capacitor c=80p
save conv_bpf_c083_0 ConvIcar_c083_0 ConvQcar_c083_0

// conventional mixed baseline bl083, carrier_1: 500000000 Hz
CCONVBPF_c083_1 (bl083 n_conv_cbpf_c083_1) capacitor c=1.013211836423e-13
LCONVBPF_c083_1 (n_conv_cbpf_c083_1 conv_bpf_c083_1) inductor l=1.000000000000e-06
RCONVBPF_c083_1 (conv_bpf_c083_1 0) resistor r=1.570796326795e+02
ECONVI_c083_1_00 (conv_i_src_c083_1_00 0 conv_bpf_c083_1 0) vcvs gain=9.807852804032e-01
SCONVI_c083_1_00 (conv_i_src_c083_1_00 conv_i_c083_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_00 (conv_q_src_c083_1_00 0 conv_bpf_c083_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_1_00 (conv_q_src_c083_1_00 conv_q_c083_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_01 (conv_i_src_c083_1_01 0 conv_bpf_c083_1 0) vcvs gain=8.314696123025e-01
SCONVI_c083_1_01 (conv_i_src_c083_1_01 conv_i_c083_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_01 (conv_q_src_c083_1_01 0 conv_bpf_c083_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_1_01 (conv_q_src_c083_1_01 conv_q_c083_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_02 (conv_i_src_c083_1_02 0 conv_bpf_c083_1 0) vcvs gain=5.555702330196e-01
SCONVI_c083_1_02 (conv_i_src_c083_1_02 conv_i_c083_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_02 (conv_q_src_c083_1_02 0 conv_bpf_c083_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_1_02 (conv_q_src_c083_1_02 conv_q_c083_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_03 (conv_i_src_c083_1_03 0 conv_bpf_c083_1 0) vcvs gain=1.950903220161e-01
SCONVI_c083_1_03 (conv_i_src_c083_1_03 conv_i_c083_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_03 (conv_q_src_c083_1_03 0 conv_bpf_c083_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_1_03 (conv_q_src_c083_1_03 conv_q_c083_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_04 (conv_i_src_c083_1_04 0 conv_bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_1_04 (conv_i_src_c083_1_04 conv_i_c083_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_04 (conv_q_src_c083_1_04 0 conv_bpf_c083_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_1_04 (conv_q_src_c083_1_04 conv_q_c083_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_05 (conv_i_src_c083_1_05 0 conv_bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_1_05 (conv_i_src_c083_1_05 conv_i_c083_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_05 (conv_q_src_c083_1_05 0 conv_bpf_c083_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_1_05 (conv_q_src_c083_1_05 conv_q_c083_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_06 (conv_i_src_c083_1_06 0 conv_bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_1_06 (conv_i_src_c083_1_06 conv_i_c083_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_06 (conv_q_src_c083_1_06 0 conv_bpf_c083_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_1_06 (conv_q_src_c083_1_06 conv_q_c083_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_07 (conv_i_src_c083_1_07 0 conv_bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_1_07 (conv_i_src_c083_1_07 conv_i_c083_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_07 (conv_q_src_c083_1_07 0 conv_bpf_c083_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_1_07 (conv_q_src_c083_1_07 conv_q_c083_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_08 (conv_i_src_c083_1_08 0 conv_bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_1_08 (conv_i_src_c083_1_08 conv_i_c083_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_08 (conv_q_src_c083_1_08 0 conv_bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_1_08 (conv_q_src_c083_1_08 conv_q_c083_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_09 (conv_i_src_c083_1_09 0 conv_bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_1_09 (conv_i_src_c083_1_09 conv_i_c083_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_09 (conv_q_src_c083_1_09 0 conv_bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_1_09 (conv_q_src_c083_1_09 conv_q_c083_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_10 (conv_i_src_c083_1_10 0 conv_bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_1_10 (conv_i_src_c083_1_10 conv_i_c083_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_10 (conv_q_src_c083_1_10 0 conv_bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_1_10 (conv_q_src_c083_1_10 conv_q_c083_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_11 (conv_i_src_c083_1_11 0 conv_bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_1_11 (conv_i_src_c083_1_11 conv_i_c083_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_11 (conv_q_src_c083_1_11 0 conv_bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_1_11 (conv_q_src_c083_1_11 conv_q_c083_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_12 (conv_i_src_c083_1_12 0 conv_bpf_c083_1 0) vcvs gain=1.950903220161e-01
SCONVI_c083_1_12 (conv_i_src_c083_1_12 conv_i_c083_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_12 (conv_q_src_c083_1_12 0 conv_bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_1_12 (conv_q_src_c083_1_12 conv_q_c083_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_13 (conv_i_src_c083_1_13 0 conv_bpf_c083_1 0) vcvs gain=5.555702330196e-01
SCONVI_c083_1_13 (conv_i_src_c083_1_13 conv_i_c083_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_13 (conv_q_src_c083_1_13 0 conv_bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_1_13 (conv_q_src_c083_1_13 conv_q_c083_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_14 (conv_i_src_c083_1_14 0 conv_bpf_c083_1 0) vcvs gain=8.314696123025e-01
SCONVI_c083_1_14 (conv_i_src_c083_1_14 conv_i_c083_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_14 (conv_q_src_c083_1_14 0 conv_bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_1_14 (conv_q_src_c083_1_14 conv_q_c083_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_1_15 (conv_i_src_c083_1_15 0 conv_bpf_c083_1 0) vcvs gain=9.807852804032e-01
SCONVI_c083_1_15 (conv_i_src_c083_1_15 conv_i_c083_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_1_15 (conv_q_src_c083_1_15 0 conv_bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_1_15 (conv_q_src_c083_1_15 conv_q_c083_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c083_1 (conv_i_c083_1 0) resistor r=1G
RCONVQ_c083_1 (conv_q_c083_1 0) resistor r=1G
RCONVINTI_c083_1 (conv_i_c083_1 ConvIcar_c083_1) resistor r=1k
CCONVINTI_c083_1 (ConvIcar_c083_1 0) capacitor c=80p
RCONVINTQ_c083_1 (conv_q_c083_1 ConvQcar_c083_1) resistor r=1k
CCONVINTQ_c083_1 (ConvQcar_c083_1 0) capacitor c=80p
save conv_bpf_c083_1 ConvIcar_c083_1 ConvQcar_c083_1

// conventional mixed baseline bl083, carrier_2: 750000000 Hz
CCONVBPF_c083_2 (bl083 n_conv_cbpf_c083_2) capacitor c=4.503163717437e-14
LCONVBPF_c083_2 (n_conv_cbpf_c083_2 conv_bpf_c083_2) inductor l=1.000000000000e-06
RCONVBPF_c083_2 (conv_bpf_c083_2 0) resistor r=2.356194490192e+02
ECONVI_c083_2_00 (conv_i_src_c083_2_00 0 conv_bpf_c083_2 0) vcvs gain=9.807852804032e-01
SCONVI_c083_2_00 (conv_i_src_c083_2_00 conv_i_c083_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_00 (conv_q_src_c083_2_00 0 conv_bpf_c083_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_2_00 (conv_q_src_c083_2_00 conv_q_c083_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_01 (conv_i_src_c083_2_01 0 conv_bpf_c083_2 0) vcvs gain=8.314696123025e-01
SCONVI_c083_2_01 (conv_i_src_c083_2_01 conv_i_c083_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_01 (conv_q_src_c083_2_01 0 conv_bpf_c083_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_2_01 (conv_q_src_c083_2_01 conv_q_c083_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_02 (conv_i_src_c083_2_02 0 conv_bpf_c083_2 0) vcvs gain=5.555702330196e-01
SCONVI_c083_2_02 (conv_i_src_c083_2_02 conv_i_c083_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_02 (conv_q_src_c083_2_02 0 conv_bpf_c083_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_2_02 (conv_q_src_c083_2_02 conv_q_c083_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_03 (conv_i_src_c083_2_03 0 conv_bpf_c083_2 0) vcvs gain=1.950903220161e-01
SCONVI_c083_2_03 (conv_i_src_c083_2_03 conv_i_c083_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_03 (conv_q_src_c083_2_03 0 conv_bpf_c083_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_2_03 (conv_q_src_c083_2_03 conv_q_c083_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_04 (conv_i_src_c083_2_04 0 conv_bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_2_04 (conv_i_src_c083_2_04 conv_i_c083_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_04 (conv_q_src_c083_2_04 0 conv_bpf_c083_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_2_04 (conv_q_src_c083_2_04 conv_q_c083_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_05 (conv_i_src_c083_2_05 0 conv_bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_2_05 (conv_i_src_c083_2_05 conv_i_c083_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_05 (conv_q_src_c083_2_05 0 conv_bpf_c083_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_2_05 (conv_q_src_c083_2_05 conv_q_c083_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_06 (conv_i_src_c083_2_06 0 conv_bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_2_06 (conv_i_src_c083_2_06 conv_i_c083_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_06 (conv_q_src_c083_2_06 0 conv_bpf_c083_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_2_06 (conv_q_src_c083_2_06 conv_q_c083_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_07 (conv_i_src_c083_2_07 0 conv_bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_2_07 (conv_i_src_c083_2_07 conv_i_c083_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_07 (conv_q_src_c083_2_07 0 conv_bpf_c083_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_2_07 (conv_q_src_c083_2_07 conv_q_c083_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_08 (conv_i_src_c083_2_08 0 conv_bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_2_08 (conv_i_src_c083_2_08 conv_i_c083_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_08 (conv_q_src_c083_2_08 0 conv_bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_2_08 (conv_q_src_c083_2_08 conv_q_c083_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_09 (conv_i_src_c083_2_09 0 conv_bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_2_09 (conv_i_src_c083_2_09 conv_i_c083_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_09 (conv_q_src_c083_2_09 0 conv_bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_2_09 (conv_q_src_c083_2_09 conv_q_c083_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_10 (conv_i_src_c083_2_10 0 conv_bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_2_10 (conv_i_src_c083_2_10 conv_i_c083_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_10 (conv_q_src_c083_2_10 0 conv_bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_2_10 (conv_q_src_c083_2_10 conv_q_c083_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_11 (conv_i_src_c083_2_11 0 conv_bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_2_11 (conv_i_src_c083_2_11 conv_i_c083_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_11 (conv_q_src_c083_2_11 0 conv_bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_2_11 (conv_q_src_c083_2_11 conv_q_c083_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_12 (conv_i_src_c083_2_12 0 conv_bpf_c083_2 0) vcvs gain=1.950903220161e-01
SCONVI_c083_2_12 (conv_i_src_c083_2_12 conv_i_c083_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_12 (conv_q_src_c083_2_12 0 conv_bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_2_12 (conv_q_src_c083_2_12 conv_q_c083_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_13 (conv_i_src_c083_2_13 0 conv_bpf_c083_2 0) vcvs gain=5.555702330196e-01
SCONVI_c083_2_13 (conv_i_src_c083_2_13 conv_i_c083_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_13 (conv_q_src_c083_2_13 0 conv_bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_2_13 (conv_q_src_c083_2_13 conv_q_c083_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_14 (conv_i_src_c083_2_14 0 conv_bpf_c083_2 0) vcvs gain=8.314696123025e-01
SCONVI_c083_2_14 (conv_i_src_c083_2_14 conv_i_c083_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_14 (conv_q_src_c083_2_14 0 conv_bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_2_14 (conv_q_src_c083_2_14 conv_q_c083_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_2_15 (conv_i_src_c083_2_15 0 conv_bpf_c083_2 0) vcvs gain=9.807852804032e-01
SCONVI_c083_2_15 (conv_i_src_c083_2_15 conv_i_c083_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_2_15 (conv_q_src_c083_2_15 0 conv_bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_2_15 (conv_q_src_c083_2_15 conv_q_c083_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c083_2 (conv_i_c083_2 0) resistor r=1G
RCONVQ_c083_2 (conv_q_c083_2 0) resistor r=1G
RCONVINTI_c083_2 (conv_i_c083_2 ConvIcar_c083_2) resistor r=1k
CCONVINTI_c083_2 (ConvIcar_c083_2 0) capacitor c=80p
RCONVINTQ_c083_2 (conv_q_c083_2 ConvQcar_c083_2) resistor r=1k
CCONVINTQ_c083_2 (ConvQcar_c083_2 0) capacitor c=80p
save conv_bpf_c083_2 ConvIcar_c083_2 ConvQcar_c083_2

// conventional mixed baseline bl083, carrier_3: 1000000000 Hz
CCONVBPF_c083_3 (bl083 n_conv_cbpf_c083_3) capacitor c=2.533029591058e-14
LCONVBPF_c083_3 (n_conv_cbpf_c083_3 conv_bpf_c083_3) inductor l=1.000000000000e-06
RCONVBPF_c083_3 (conv_bpf_c083_3 0) resistor r=3.141592653590e+02
ECONVI_c083_3_00 (conv_i_src_c083_3_00 0 conv_bpf_c083_3 0) vcvs gain=9.807852804032e-01
SCONVI_c083_3_00 (conv_i_src_c083_3_00 conv_i_c083_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_00 (conv_q_src_c083_3_00 0 conv_bpf_c083_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_3_00 (conv_q_src_c083_3_00 conv_q_c083_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_01 (conv_i_src_c083_3_01 0 conv_bpf_c083_3 0) vcvs gain=8.314696123025e-01
SCONVI_c083_3_01 (conv_i_src_c083_3_01 conv_i_c083_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_01 (conv_q_src_c083_3_01 0 conv_bpf_c083_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_3_01 (conv_q_src_c083_3_01 conv_q_c083_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_02 (conv_i_src_c083_3_02 0 conv_bpf_c083_3 0) vcvs gain=5.555702330196e-01
SCONVI_c083_3_02 (conv_i_src_c083_3_02 conv_i_c083_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_02 (conv_q_src_c083_3_02 0 conv_bpf_c083_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_3_02 (conv_q_src_c083_3_02 conv_q_c083_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_03 (conv_i_src_c083_3_03 0 conv_bpf_c083_3 0) vcvs gain=1.950903220161e-01
SCONVI_c083_3_03 (conv_i_src_c083_3_03 conv_i_c083_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_03 (conv_q_src_c083_3_03 0 conv_bpf_c083_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_3_03 (conv_q_src_c083_3_03 conv_q_c083_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_04 (conv_i_src_c083_3_04 0 conv_bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_3_04 (conv_i_src_c083_3_04 conv_i_c083_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_04 (conv_q_src_c083_3_04 0 conv_bpf_c083_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c083_3_04 (conv_q_src_c083_3_04 conv_q_c083_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_05 (conv_i_src_c083_3_05 0 conv_bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_3_05 (conv_i_src_c083_3_05 conv_i_c083_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_05 (conv_q_src_c083_3_05 0 conv_bpf_c083_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c083_3_05 (conv_q_src_c083_3_05 conv_q_c083_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_06 (conv_i_src_c083_3_06 0 conv_bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_3_06 (conv_i_src_c083_3_06 conv_i_c083_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_06 (conv_q_src_c083_3_06 0 conv_bpf_c083_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c083_3_06 (conv_q_src_c083_3_06 conv_q_c083_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_07 (conv_i_src_c083_3_07 0 conv_bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_3_07 (conv_i_src_c083_3_07 conv_i_c083_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_07 (conv_q_src_c083_3_07 0 conv_bpf_c083_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c083_3_07 (conv_q_src_c083_3_07 conv_q_c083_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_08 (conv_i_src_c083_3_08 0 conv_bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c083_3_08 (conv_i_src_c083_3_08 conv_i_c083_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_08 (conv_q_src_c083_3_08 0 conv_bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_3_08 (conv_q_src_c083_3_08 conv_q_c083_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_09 (conv_i_src_c083_3_09 0 conv_bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c083_3_09 (conv_i_src_c083_3_09 conv_i_c083_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_09 (conv_q_src_c083_3_09 0 conv_bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_3_09 (conv_q_src_c083_3_09 conv_q_c083_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_10 (conv_i_src_c083_3_10 0 conv_bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c083_3_10 (conv_i_src_c083_3_10 conv_i_c083_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_10 (conv_q_src_c083_3_10 0 conv_bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_3_10 (conv_q_src_c083_3_10 conv_q_c083_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_11 (conv_i_src_c083_3_11 0 conv_bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c083_3_11 (conv_i_src_c083_3_11 conv_i_c083_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_11 (conv_q_src_c083_3_11 0 conv_bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_3_11 (conv_q_src_c083_3_11 conv_q_c083_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_12 (conv_i_src_c083_3_12 0 conv_bpf_c083_3 0) vcvs gain=1.950903220161e-01
SCONVI_c083_3_12 (conv_i_src_c083_3_12 conv_i_c083_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_12 (conv_q_src_c083_3_12 0 conv_bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c083_3_12 (conv_q_src_c083_3_12 conv_q_c083_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_13 (conv_i_src_c083_3_13 0 conv_bpf_c083_3 0) vcvs gain=5.555702330196e-01
SCONVI_c083_3_13 (conv_i_src_c083_3_13 conv_i_c083_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_13 (conv_q_src_c083_3_13 0 conv_bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c083_3_13 (conv_q_src_c083_3_13 conv_q_c083_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_14 (conv_i_src_c083_3_14 0 conv_bpf_c083_3 0) vcvs gain=8.314696123025e-01
SCONVI_c083_3_14 (conv_i_src_c083_3_14 conv_i_c083_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_14 (conv_q_src_c083_3_14 0 conv_bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c083_3_14 (conv_q_src_c083_3_14 conv_q_c083_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c083_3_15 (conv_i_src_c083_3_15 0 conv_bpf_c083_3 0) vcvs gain=9.807852804032e-01
SCONVI_c083_3_15 (conv_i_src_c083_3_15 conv_i_c083_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c083_3_15 (conv_q_src_c083_3_15 0 conv_bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c083_3_15 (conv_q_src_c083_3_15 conv_q_c083_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c083_3 (conv_i_c083_3 0) resistor r=1G
RCONVQ_c083_3 (conv_q_c083_3 0) resistor r=1G
RCONVINTI_c083_3 (conv_i_c083_3 ConvIcar_c083_3) resistor r=1k
CCONVINTI_c083_3 (ConvIcar_c083_3 0) capacitor c=80p
RCONVINTQ_c083_3 (conv_q_c083_3 ConvQcar_c083_3) resistor r=1k
CCONVINTQ_c083_3 (ConvQcar_c083_3 0) capacitor c=80p
save conv_bpf_c083_3 ConvIcar_c083_3 ConvQcar_c083_3

// conventional mixed baseline bl084, carrier_0: 250000000 Hz
CCONVBPF_c084_0 (bl084 n_conv_cbpf_c084_0) capacitor c=4.052847345694e-13
LCONVBPF_c084_0 (n_conv_cbpf_c084_0 conv_bpf_c084_0) inductor l=1.000000000000e-06
RCONVBPF_c084_0 (conv_bpf_c084_0 0) resistor r=7.853981633974e+01
ECONVI_c084_0_00 (conv_i_src_c084_0_00 0 conv_bpf_c084_0 0) vcvs gain=9.807852804032e-01
SCONVI_c084_0_00 (conv_i_src_c084_0_00 conv_i_c084_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_00 (conv_q_src_c084_0_00 0 conv_bpf_c084_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_0_00 (conv_q_src_c084_0_00 conv_q_c084_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_01 (conv_i_src_c084_0_01 0 conv_bpf_c084_0 0) vcvs gain=8.314696123025e-01
SCONVI_c084_0_01 (conv_i_src_c084_0_01 conv_i_c084_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_01 (conv_q_src_c084_0_01 0 conv_bpf_c084_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_0_01 (conv_q_src_c084_0_01 conv_q_c084_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_02 (conv_i_src_c084_0_02 0 conv_bpf_c084_0 0) vcvs gain=5.555702330196e-01
SCONVI_c084_0_02 (conv_i_src_c084_0_02 conv_i_c084_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_02 (conv_q_src_c084_0_02 0 conv_bpf_c084_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_0_02 (conv_q_src_c084_0_02 conv_q_c084_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_03 (conv_i_src_c084_0_03 0 conv_bpf_c084_0 0) vcvs gain=1.950903220161e-01
SCONVI_c084_0_03 (conv_i_src_c084_0_03 conv_i_c084_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_03 (conv_q_src_c084_0_03 0 conv_bpf_c084_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_0_03 (conv_q_src_c084_0_03 conv_q_c084_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_04 (conv_i_src_c084_0_04 0 conv_bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_0_04 (conv_i_src_c084_0_04 conv_i_c084_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_04 (conv_q_src_c084_0_04 0 conv_bpf_c084_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_0_04 (conv_q_src_c084_0_04 conv_q_c084_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_05 (conv_i_src_c084_0_05 0 conv_bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_0_05 (conv_i_src_c084_0_05 conv_i_c084_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_05 (conv_q_src_c084_0_05 0 conv_bpf_c084_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_0_05 (conv_q_src_c084_0_05 conv_q_c084_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_06 (conv_i_src_c084_0_06 0 conv_bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_0_06 (conv_i_src_c084_0_06 conv_i_c084_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_06 (conv_q_src_c084_0_06 0 conv_bpf_c084_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_0_06 (conv_q_src_c084_0_06 conv_q_c084_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_07 (conv_i_src_c084_0_07 0 conv_bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_0_07 (conv_i_src_c084_0_07 conv_i_c084_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_07 (conv_q_src_c084_0_07 0 conv_bpf_c084_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_0_07 (conv_q_src_c084_0_07 conv_q_c084_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_08 (conv_i_src_c084_0_08 0 conv_bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_0_08 (conv_i_src_c084_0_08 conv_i_c084_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_08 (conv_q_src_c084_0_08 0 conv_bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_0_08 (conv_q_src_c084_0_08 conv_q_c084_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_09 (conv_i_src_c084_0_09 0 conv_bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_0_09 (conv_i_src_c084_0_09 conv_i_c084_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_09 (conv_q_src_c084_0_09 0 conv_bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_0_09 (conv_q_src_c084_0_09 conv_q_c084_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_10 (conv_i_src_c084_0_10 0 conv_bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_0_10 (conv_i_src_c084_0_10 conv_i_c084_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_10 (conv_q_src_c084_0_10 0 conv_bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_0_10 (conv_q_src_c084_0_10 conv_q_c084_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_11 (conv_i_src_c084_0_11 0 conv_bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_0_11 (conv_i_src_c084_0_11 conv_i_c084_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_11 (conv_q_src_c084_0_11 0 conv_bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_0_11 (conv_q_src_c084_0_11 conv_q_c084_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_12 (conv_i_src_c084_0_12 0 conv_bpf_c084_0 0) vcvs gain=1.950903220161e-01
SCONVI_c084_0_12 (conv_i_src_c084_0_12 conv_i_c084_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_12 (conv_q_src_c084_0_12 0 conv_bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_0_12 (conv_q_src_c084_0_12 conv_q_c084_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_13 (conv_i_src_c084_0_13 0 conv_bpf_c084_0 0) vcvs gain=5.555702330196e-01
SCONVI_c084_0_13 (conv_i_src_c084_0_13 conv_i_c084_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_13 (conv_q_src_c084_0_13 0 conv_bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_0_13 (conv_q_src_c084_0_13 conv_q_c084_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_14 (conv_i_src_c084_0_14 0 conv_bpf_c084_0 0) vcvs gain=8.314696123025e-01
SCONVI_c084_0_14 (conv_i_src_c084_0_14 conv_i_c084_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_14 (conv_q_src_c084_0_14 0 conv_bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_0_14 (conv_q_src_c084_0_14 conv_q_c084_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_0_15 (conv_i_src_c084_0_15 0 conv_bpf_c084_0 0) vcvs gain=9.807852804032e-01
SCONVI_c084_0_15 (conv_i_src_c084_0_15 conv_i_c084_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_0_15 (conv_q_src_c084_0_15 0 conv_bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_0_15 (conv_q_src_c084_0_15 conv_q_c084_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c084_0 (conv_i_c084_0 0) resistor r=1G
RCONVQ_c084_0 (conv_q_c084_0 0) resistor r=1G
RCONVINTI_c084_0 (conv_i_c084_0 ConvIcar_c084_0) resistor r=1k
CCONVINTI_c084_0 (ConvIcar_c084_0 0) capacitor c=80p
RCONVINTQ_c084_0 (conv_q_c084_0 ConvQcar_c084_0) resistor r=1k
CCONVINTQ_c084_0 (ConvQcar_c084_0 0) capacitor c=80p
save conv_bpf_c084_0 ConvIcar_c084_0 ConvQcar_c084_0

// conventional mixed baseline bl084, carrier_1: 500000000 Hz
CCONVBPF_c084_1 (bl084 n_conv_cbpf_c084_1) capacitor c=1.013211836423e-13
LCONVBPF_c084_1 (n_conv_cbpf_c084_1 conv_bpf_c084_1) inductor l=1.000000000000e-06
RCONVBPF_c084_1 (conv_bpf_c084_1 0) resistor r=1.570796326795e+02
ECONVI_c084_1_00 (conv_i_src_c084_1_00 0 conv_bpf_c084_1 0) vcvs gain=9.807852804032e-01
SCONVI_c084_1_00 (conv_i_src_c084_1_00 conv_i_c084_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_00 (conv_q_src_c084_1_00 0 conv_bpf_c084_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_1_00 (conv_q_src_c084_1_00 conv_q_c084_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_01 (conv_i_src_c084_1_01 0 conv_bpf_c084_1 0) vcvs gain=8.314696123025e-01
SCONVI_c084_1_01 (conv_i_src_c084_1_01 conv_i_c084_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_01 (conv_q_src_c084_1_01 0 conv_bpf_c084_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_1_01 (conv_q_src_c084_1_01 conv_q_c084_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_02 (conv_i_src_c084_1_02 0 conv_bpf_c084_1 0) vcvs gain=5.555702330196e-01
SCONVI_c084_1_02 (conv_i_src_c084_1_02 conv_i_c084_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_02 (conv_q_src_c084_1_02 0 conv_bpf_c084_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_1_02 (conv_q_src_c084_1_02 conv_q_c084_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_03 (conv_i_src_c084_1_03 0 conv_bpf_c084_1 0) vcvs gain=1.950903220161e-01
SCONVI_c084_1_03 (conv_i_src_c084_1_03 conv_i_c084_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_03 (conv_q_src_c084_1_03 0 conv_bpf_c084_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_1_03 (conv_q_src_c084_1_03 conv_q_c084_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_04 (conv_i_src_c084_1_04 0 conv_bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_1_04 (conv_i_src_c084_1_04 conv_i_c084_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_04 (conv_q_src_c084_1_04 0 conv_bpf_c084_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_1_04 (conv_q_src_c084_1_04 conv_q_c084_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_05 (conv_i_src_c084_1_05 0 conv_bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_1_05 (conv_i_src_c084_1_05 conv_i_c084_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_05 (conv_q_src_c084_1_05 0 conv_bpf_c084_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_1_05 (conv_q_src_c084_1_05 conv_q_c084_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_06 (conv_i_src_c084_1_06 0 conv_bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_1_06 (conv_i_src_c084_1_06 conv_i_c084_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_06 (conv_q_src_c084_1_06 0 conv_bpf_c084_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_1_06 (conv_q_src_c084_1_06 conv_q_c084_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_07 (conv_i_src_c084_1_07 0 conv_bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_1_07 (conv_i_src_c084_1_07 conv_i_c084_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_07 (conv_q_src_c084_1_07 0 conv_bpf_c084_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_1_07 (conv_q_src_c084_1_07 conv_q_c084_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_08 (conv_i_src_c084_1_08 0 conv_bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_1_08 (conv_i_src_c084_1_08 conv_i_c084_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_08 (conv_q_src_c084_1_08 0 conv_bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_1_08 (conv_q_src_c084_1_08 conv_q_c084_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_09 (conv_i_src_c084_1_09 0 conv_bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_1_09 (conv_i_src_c084_1_09 conv_i_c084_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_09 (conv_q_src_c084_1_09 0 conv_bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_1_09 (conv_q_src_c084_1_09 conv_q_c084_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_10 (conv_i_src_c084_1_10 0 conv_bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_1_10 (conv_i_src_c084_1_10 conv_i_c084_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_10 (conv_q_src_c084_1_10 0 conv_bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_1_10 (conv_q_src_c084_1_10 conv_q_c084_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_11 (conv_i_src_c084_1_11 0 conv_bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_1_11 (conv_i_src_c084_1_11 conv_i_c084_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_11 (conv_q_src_c084_1_11 0 conv_bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_1_11 (conv_q_src_c084_1_11 conv_q_c084_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_12 (conv_i_src_c084_1_12 0 conv_bpf_c084_1 0) vcvs gain=1.950903220161e-01
SCONVI_c084_1_12 (conv_i_src_c084_1_12 conv_i_c084_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_12 (conv_q_src_c084_1_12 0 conv_bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_1_12 (conv_q_src_c084_1_12 conv_q_c084_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_13 (conv_i_src_c084_1_13 0 conv_bpf_c084_1 0) vcvs gain=5.555702330196e-01
SCONVI_c084_1_13 (conv_i_src_c084_1_13 conv_i_c084_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_13 (conv_q_src_c084_1_13 0 conv_bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_1_13 (conv_q_src_c084_1_13 conv_q_c084_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_14 (conv_i_src_c084_1_14 0 conv_bpf_c084_1 0) vcvs gain=8.314696123025e-01
SCONVI_c084_1_14 (conv_i_src_c084_1_14 conv_i_c084_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_14 (conv_q_src_c084_1_14 0 conv_bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_1_14 (conv_q_src_c084_1_14 conv_q_c084_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_1_15 (conv_i_src_c084_1_15 0 conv_bpf_c084_1 0) vcvs gain=9.807852804032e-01
SCONVI_c084_1_15 (conv_i_src_c084_1_15 conv_i_c084_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_1_15 (conv_q_src_c084_1_15 0 conv_bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_1_15 (conv_q_src_c084_1_15 conv_q_c084_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c084_1 (conv_i_c084_1 0) resistor r=1G
RCONVQ_c084_1 (conv_q_c084_1 0) resistor r=1G
RCONVINTI_c084_1 (conv_i_c084_1 ConvIcar_c084_1) resistor r=1k
CCONVINTI_c084_1 (ConvIcar_c084_1 0) capacitor c=80p
RCONVINTQ_c084_1 (conv_q_c084_1 ConvQcar_c084_1) resistor r=1k
CCONVINTQ_c084_1 (ConvQcar_c084_1 0) capacitor c=80p
save conv_bpf_c084_1 ConvIcar_c084_1 ConvQcar_c084_1

// conventional mixed baseline bl084, carrier_2: 750000000 Hz
CCONVBPF_c084_2 (bl084 n_conv_cbpf_c084_2) capacitor c=4.503163717437e-14
LCONVBPF_c084_2 (n_conv_cbpf_c084_2 conv_bpf_c084_2) inductor l=1.000000000000e-06
RCONVBPF_c084_2 (conv_bpf_c084_2 0) resistor r=2.356194490192e+02
ECONVI_c084_2_00 (conv_i_src_c084_2_00 0 conv_bpf_c084_2 0) vcvs gain=9.807852804032e-01
SCONVI_c084_2_00 (conv_i_src_c084_2_00 conv_i_c084_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_00 (conv_q_src_c084_2_00 0 conv_bpf_c084_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_2_00 (conv_q_src_c084_2_00 conv_q_c084_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_01 (conv_i_src_c084_2_01 0 conv_bpf_c084_2 0) vcvs gain=8.314696123025e-01
SCONVI_c084_2_01 (conv_i_src_c084_2_01 conv_i_c084_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_01 (conv_q_src_c084_2_01 0 conv_bpf_c084_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_2_01 (conv_q_src_c084_2_01 conv_q_c084_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_02 (conv_i_src_c084_2_02 0 conv_bpf_c084_2 0) vcvs gain=5.555702330196e-01
SCONVI_c084_2_02 (conv_i_src_c084_2_02 conv_i_c084_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_02 (conv_q_src_c084_2_02 0 conv_bpf_c084_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_2_02 (conv_q_src_c084_2_02 conv_q_c084_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_03 (conv_i_src_c084_2_03 0 conv_bpf_c084_2 0) vcvs gain=1.950903220161e-01
SCONVI_c084_2_03 (conv_i_src_c084_2_03 conv_i_c084_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_03 (conv_q_src_c084_2_03 0 conv_bpf_c084_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_2_03 (conv_q_src_c084_2_03 conv_q_c084_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_04 (conv_i_src_c084_2_04 0 conv_bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_2_04 (conv_i_src_c084_2_04 conv_i_c084_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_04 (conv_q_src_c084_2_04 0 conv_bpf_c084_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_2_04 (conv_q_src_c084_2_04 conv_q_c084_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_05 (conv_i_src_c084_2_05 0 conv_bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_2_05 (conv_i_src_c084_2_05 conv_i_c084_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_05 (conv_q_src_c084_2_05 0 conv_bpf_c084_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_2_05 (conv_q_src_c084_2_05 conv_q_c084_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_06 (conv_i_src_c084_2_06 0 conv_bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_2_06 (conv_i_src_c084_2_06 conv_i_c084_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_06 (conv_q_src_c084_2_06 0 conv_bpf_c084_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_2_06 (conv_q_src_c084_2_06 conv_q_c084_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_07 (conv_i_src_c084_2_07 0 conv_bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_2_07 (conv_i_src_c084_2_07 conv_i_c084_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_07 (conv_q_src_c084_2_07 0 conv_bpf_c084_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_2_07 (conv_q_src_c084_2_07 conv_q_c084_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_08 (conv_i_src_c084_2_08 0 conv_bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_2_08 (conv_i_src_c084_2_08 conv_i_c084_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_08 (conv_q_src_c084_2_08 0 conv_bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_2_08 (conv_q_src_c084_2_08 conv_q_c084_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_09 (conv_i_src_c084_2_09 0 conv_bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_2_09 (conv_i_src_c084_2_09 conv_i_c084_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_09 (conv_q_src_c084_2_09 0 conv_bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_2_09 (conv_q_src_c084_2_09 conv_q_c084_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_10 (conv_i_src_c084_2_10 0 conv_bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_2_10 (conv_i_src_c084_2_10 conv_i_c084_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_10 (conv_q_src_c084_2_10 0 conv_bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_2_10 (conv_q_src_c084_2_10 conv_q_c084_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_11 (conv_i_src_c084_2_11 0 conv_bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_2_11 (conv_i_src_c084_2_11 conv_i_c084_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_11 (conv_q_src_c084_2_11 0 conv_bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_2_11 (conv_q_src_c084_2_11 conv_q_c084_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_12 (conv_i_src_c084_2_12 0 conv_bpf_c084_2 0) vcvs gain=1.950903220161e-01
SCONVI_c084_2_12 (conv_i_src_c084_2_12 conv_i_c084_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_12 (conv_q_src_c084_2_12 0 conv_bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_2_12 (conv_q_src_c084_2_12 conv_q_c084_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_13 (conv_i_src_c084_2_13 0 conv_bpf_c084_2 0) vcvs gain=5.555702330196e-01
SCONVI_c084_2_13 (conv_i_src_c084_2_13 conv_i_c084_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_13 (conv_q_src_c084_2_13 0 conv_bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_2_13 (conv_q_src_c084_2_13 conv_q_c084_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_14 (conv_i_src_c084_2_14 0 conv_bpf_c084_2 0) vcvs gain=8.314696123025e-01
SCONVI_c084_2_14 (conv_i_src_c084_2_14 conv_i_c084_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_14 (conv_q_src_c084_2_14 0 conv_bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_2_14 (conv_q_src_c084_2_14 conv_q_c084_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_2_15 (conv_i_src_c084_2_15 0 conv_bpf_c084_2 0) vcvs gain=9.807852804032e-01
SCONVI_c084_2_15 (conv_i_src_c084_2_15 conv_i_c084_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_2_15 (conv_q_src_c084_2_15 0 conv_bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_2_15 (conv_q_src_c084_2_15 conv_q_c084_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c084_2 (conv_i_c084_2 0) resistor r=1G
RCONVQ_c084_2 (conv_q_c084_2 0) resistor r=1G
RCONVINTI_c084_2 (conv_i_c084_2 ConvIcar_c084_2) resistor r=1k
CCONVINTI_c084_2 (ConvIcar_c084_2 0) capacitor c=80p
RCONVINTQ_c084_2 (conv_q_c084_2 ConvQcar_c084_2) resistor r=1k
CCONVINTQ_c084_2 (ConvQcar_c084_2 0) capacitor c=80p
save conv_bpf_c084_2 ConvIcar_c084_2 ConvQcar_c084_2

// conventional mixed baseline bl084, carrier_3: 1000000000 Hz
CCONVBPF_c084_3 (bl084 n_conv_cbpf_c084_3) capacitor c=2.533029591058e-14
LCONVBPF_c084_3 (n_conv_cbpf_c084_3 conv_bpf_c084_3) inductor l=1.000000000000e-06
RCONVBPF_c084_3 (conv_bpf_c084_3 0) resistor r=3.141592653590e+02
ECONVI_c084_3_00 (conv_i_src_c084_3_00 0 conv_bpf_c084_3 0) vcvs gain=9.807852804032e-01
SCONVI_c084_3_00 (conv_i_src_c084_3_00 conv_i_c084_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_00 (conv_q_src_c084_3_00 0 conv_bpf_c084_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_3_00 (conv_q_src_c084_3_00 conv_q_c084_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_01 (conv_i_src_c084_3_01 0 conv_bpf_c084_3 0) vcvs gain=8.314696123025e-01
SCONVI_c084_3_01 (conv_i_src_c084_3_01 conv_i_c084_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_01 (conv_q_src_c084_3_01 0 conv_bpf_c084_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_3_01 (conv_q_src_c084_3_01 conv_q_c084_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_02 (conv_i_src_c084_3_02 0 conv_bpf_c084_3 0) vcvs gain=5.555702330196e-01
SCONVI_c084_3_02 (conv_i_src_c084_3_02 conv_i_c084_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_02 (conv_q_src_c084_3_02 0 conv_bpf_c084_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_3_02 (conv_q_src_c084_3_02 conv_q_c084_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_03 (conv_i_src_c084_3_03 0 conv_bpf_c084_3 0) vcvs gain=1.950903220161e-01
SCONVI_c084_3_03 (conv_i_src_c084_3_03 conv_i_c084_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_03 (conv_q_src_c084_3_03 0 conv_bpf_c084_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_3_03 (conv_q_src_c084_3_03 conv_q_c084_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_04 (conv_i_src_c084_3_04 0 conv_bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_3_04 (conv_i_src_c084_3_04 conv_i_c084_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_04 (conv_q_src_c084_3_04 0 conv_bpf_c084_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c084_3_04 (conv_q_src_c084_3_04 conv_q_c084_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_05 (conv_i_src_c084_3_05 0 conv_bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_3_05 (conv_i_src_c084_3_05 conv_i_c084_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_05 (conv_q_src_c084_3_05 0 conv_bpf_c084_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c084_3_05 (conv_q_src_c084_3_05 conv_q_c084_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_06 (conv_i_src_c084_3_06 0 conv_bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_3_06 (conv_i_src_c084_3_06 conv_i_c084_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_06 (conv_q_src_c084_3_06 0 conv_bpf_c084_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c084_3_06 (conv_q_src_c084_3_06 conv_q_c084_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_07 (conv_i_src_c084_3_07 0 conv_bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_3_07 (conv_i_src_c084_3_07 conv_i_c084_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_07 (conv_q_src_c084_3_07 0 conv_bpf_c084_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c084_3_07 (conv_q_src_c084_3_07 conv_q_c084_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_08 (conv_i_src_c084_3_08 0 conv_bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c084_3_08 (conv_i_src_c084_3_08 conv_i_c084_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_08 (conv_q_src_c084_3_08 0 conv_bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_3_08 (conv_q_src_c084_3_08 conv_q_c084_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_09 (conv_i_src_c084_3_09 0 conv_bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c084_3_09 (conv_i_src_c084_3_09 conv_i_c084_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_09 (conv_q_src_c084_3_09 0 conv_bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_3_09 (conv_q_src_c084_3_09 conv_q_c084_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_10 (conv_i_src_c084_3_10 0 conv_bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c084_3_10 (conv_i_src_c084_3_10 conv_i_c084_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_10 (conv_q_src_c084_3_10 0 conv_bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_3_10 (conv_q_src_c084_3_10 conv_q_c084_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_11 (conv_i_src_c084_3_11 0 conv_bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c084_3_11 (conv_i_src_c084_3_11 conv_i_c084_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_11 (conv_q_src_c084_3_11 0 conv_bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_3_11 (conv_q_src_c084_3_11 conv_q_c084_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_12 (conv_i_src_c084_3_12 0 conv_bpf_c084_3 0) vcvs gain=1.950903220161e-01
SCONVI_c084_3_12 (conv_i_src_c084_3_12 conv_i_c084_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_12 (conv_q_src_c084_3_12 0 conv_bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c084_3_12 (conv_q_src_c084_3_12 conv_q_c084_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_13 (conv_i_src_c084_3_13 0 conv_bpf_c084_3 0) vcvs gain=5.555702330196e-01
SCONVI_c084_3_13 (conv_i_src_c084_3_13 conv_i_c084_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_13 (conv_q_src_c084_3_13 0 conv_bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c084_3_13 (conv_q_src_c084_3_13 conv_q_c084_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_14 (conv_i_src_c084_3_14 0 conv_bpf_c084_3 0) vcvs gain=8.314696123025e-01
SCONVI_c084_3_14 (conv_i_src_c084_3_14 conv_i_c084_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_14 (conv_q_src_c084_3_14 0 conv_bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c084_3_14 (conv_q_src_c084_3_14 conv_q_c084_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c084_3_15 (conv_i_src_c084_3_15 0 conv_bpf_c084_3 0) vcvs gain=9.807852804032e-01
SCONVI_c084_3_15 (conv_i_src_c084_3_15 conv_i_c084_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c084_3_15 (conv_q_src_c084_3_15 0 conv_bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c084_3_15 (conv_q_src_c084_3_15 conv_q_c084_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c084_3 (conv_i_c084_3 0) resistor r=1G
RCONVQ_c084_3 (conv_q_c084_3 0) resistor r=1G
RCONVINTI_c084_3 (conv_i_c084_3 ConvIcar_c084_3) resistor r=1k
CCONVINTI_c084_3 (ConvIcar_c084_3 0) capacitor c=80p
RCONVINTQ_c084_3 (conv_q_c084_3 ConvQcar_c084_3) resistor r=1k
CCONVINTQ_c084_3 (ConvQcar_c084_3 0) capacitor c=80p
save conv_bpf_c084_3 ConvIcar_c084_3 ConvQcar_c084_3

// conventional mixed baseline bl085, carrier_0: 250000000 Hz
CCONVBPF_c085_0 (bl085 n_conv_cbpf_c085_0) capacitor c=4.052847345694e-13
LCONVBPF_c085_0 (n_conv_cbpf_c085_0 conv_bpf_c085_0) inductor l=1.000000000000e-06
RCONVBPF_c085_0 (conv_bpf_c085_0 0) resistor r=7.853981633974e+01
ECONVI_c085_0_00 (conv_i_src_c085_0_00 0 conv_bpf_c085_0 0) vcvs gain=9.807852804032e-01
SCONVI_c085_0_00 (conv_i_src_c085_0_00 conv_i_c085_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_00 (conv_q_src_c085_0_00 0 conv_bpf_c085_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_0_00 (conv_q_src_c085_0_00 conv_q_c085_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_01 (conv_i_src_c085_0_01 0 conv_bpf_c085_0 0) vcvs gain=8.314696123025e-01
SCONVI_c085_0_01 (conv_i_src_c085_0_01 conv_i_c085_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_01 (conv_q_src_c085_0_01 0 conv_bpf_c085_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_0_01 (conv_q_src_c085_0_01 conv_q_c085_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_02 (conv_i_src_c085_0_02 0 conv_bpf_c085_0 0) vcvs gain=5.555702330196e-01
SCONVI_c085_0_02 (conv_i_src_c085_0_02 conv_i_c085_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_02 (conv_q_src_c085_0_02 0 conv_bpf_c085_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_0_02 (conv_q_src_c085_0_02 conv_q_c085_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_03 (conv_i_src_c085_0_03 0 conv_bpf_c085_0 0) vcvs gain=1.950903220161e-01
SCONVI_c085_0_03 (conv_i_src_c085_0_03 conv_i_c085_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_03 (conv_q_src_c085_0_03 0 conv_bpf_c085_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_0_03 (conv_q_src_c085_0_03 conv_q_c085_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_04 (conv_i_src_c085_0_04 0 conv_bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_0_04 (conv_i_src_c085_0_04 conv_i_c085_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_04 (conv_q_src_c085_0_04 0 conv_bpf_c085_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_0_04 (conv_q_src_c085_0_04 conv_q_c085_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_05 (conv_i_src_c085_0_05 0 conv_bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_0_05 (conv_i_src_c085_0_05 conv_i_c085_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_05 (conv_q_src_c085_0_05 0 conv_bpf_c085_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_0_05 (conv_q_src_c085_0_05 conv_q_c085_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_06 (conv_i_src_c085_0_06 0 conv_bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_0_06 (conv_i_src_c085_0_06 conv_i_c085_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_06 (conv_q_src_c085_0_06 0 conv_bpf_c085_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_0_06 (conv_q_src_c085_0_06 conv_q_c085_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_07 (conv_i_src_c085_0_07 0 conv_bpf_c085_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_0_07 (conv_i_src_c085_0_07 conv_i_c085_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_07 (conv_q_src_c085_0_07 0 conv_bpf_c085_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_0_07 (conv_q_src_c085_0_07 conv_q_c085_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_08 (conv_i_src_c085_0_08 0 conv_bpf_c085_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_0_08 (conv_i_src_c085_0_08 conv_i_c085_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_08 (conv_q_src_c085_0_08 0 conv_bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_0_08 (conv_q_src_c085_0_08 conv_q_c085_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_09 (conv_i_src_c085_0_09 0 conv_bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_0_09 (conv_i_src_c085_0_09 conv_i_c085_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_09 (conv_q_src_c085_0_09 0 conv_bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_0_09 (conv_q_src_c085_0_09 conv_q_c085_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_10 (conv_i_src_c085_0_10 0 conv_bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_0_10 (conv_i_src_c085_0_10 conv_i_c085_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_10 (conv_q_src_c085_0_10 0 conv_bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_0_10 (conv_q_src_c085_0_10 conv_q_c085_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_11 (conv_i_src_c085_0_11 0 conv_bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_0_11 (conv_i_src_c085_0_11 conv_i_c085_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_11 (conv_q_src_c085_0_11 0 conv_bpf_c085_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_0_11 (conv_q_src_c085_0_11 conv_q_c085_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_12 (conv_i_src_c085_0_12 0 conv_bpf_c085_0 0) vcvs gain=1.950903220161e-01
SCONVI_c085_0_12 (conv_i_src_c085_0_12 conv_i_c085_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_12 (conv_q_src_c085_0_12 0 conv_bpf_c085_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_0_12 (conv_q_src_c085_0_12 conv_q_c085_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_13 (conv_i_src_c085_0_13 0 conv_bpf_c085_0 0) vcvs gain=5.555702330196e-01
SCONVI_c085_0_13 (conv_i_src_c085_0_13 conv_i_c085_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_13 (conv_q_src_c085_0_13 0 conv_bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_0_13 (conv_q_src_c085_0_13 conv_q_c085_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_14 (conv_i_src_c085_0_14 0 conv_bpf_c085_0 0) vcvs gain=8.314696123025e-01
SCONVI_c085_0_14 (conv_i_src_c085_0_14 conv_i_c085_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_14 (conv_q_src_c085_0_14 0 conv_bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_0_14 (conv_q_src_c085_0_14 conv_q_c085_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_0_15 (conv_i_src_c085_0_15 0 conv_bpf_c085_0 0) vcvs gain=9.807852804032e-01
SCONVI_c085_0_15 (conv_i_src_c085_0_15 conv_i_c085_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_0_15 (conv_q_src_c085_0_15 0 conv_bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_0_15 (conv_q_src_c085_0_15 conv_q_c085_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c085_0 (conv_i_c085_0 0) resistor r=1G
RCONVQ_c085_0 (conv_q_c085_0 0) resistor r=1G
RCONVINTI_c085_0 (conv_i_c085_0 ConvIcar_c085_0) resistor r=1k
CCONVINTI_c085_0 (ConvIcar_c085_0 0) capacitor c=80p
RCONVINTQ_c085_0 (conv_q_c085_0 ConvQcar_c085_0) resistor r=1k
CCONVINTQ_c085_0 (ConvQcar_c085_0 0) capacitor c=80p
save conv_bpf_c085_0 ConvIcar_c085_0 ConvQcar_c085_0

// conventional mixed baseline bl085, carrier_1: 500000000 Hz
CCONVBPF_c085_1 (bl085 n_conv_cbpf_c085_1) capacitor c=1.013211836423e-13
LCONVBPF_c085_1 (n_conv_cbpf_c085_1 conv_bpf_c085_1) inductor l=1.000000000000e-06
RCONVBPF_c085_1 (conv_bpf_c085_1 0) resistor r=1.570796326795e+02
ECONVI_c085_1_00 (conv_i_src_c085_1_00 0 conv_bpf_c085_1 0) vcvs gain=9.807852804032e-01
SCONVI_c085_1_00 (conv_i_src_c085_1_00 conv_i_c085_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_00 (conv_q_src_c085_1_00 0 conv_bpf_c085_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_1_00 (conv_q_src_c085_1_00 conv_q_c085_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_01 (conv_i_src_c085_1_01 0 conv_bpf_c085_1 0) vcvs gain=8.314696123025e-01
SCONVI_c085_1_01 (conv_i_src_c085_1_01 conv_i_c085_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_01 (conv_q_src_c085_1_01 0 conv_bpf_c085_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_1_01 (conv_q_src_c085_1_01 conv_q_c085_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_02 (conv_i_src_c085_1_02 0 conv_bpf_c085_1 0) vcvs gain=5.555702330196e-01
SCONVI_c085_1_02 (conv_i_src_c085_1_02 conv_i_c085_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_02 (conv_q_src_c085_1_02 0 conv_bpf_c085_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_1_02 (conv_q_src_c085_1_02 conv_q_c085_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_03 (conv_i_src_c085_1_03 0 conv_bpf_c085_1 0) vcvs gain=1.950903220161e-01
SCONVI_c085_1_03 (conv_i_src_c085_1_03 conv_i_c085_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_03 (conv_q_src_c085_1_03 0 conv_bpf_c085_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_1_03 (conv_q_src_c085_1_03 conv_q_c085_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_04 (conv_i_src_c085_1_04 0 conv_bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_1_04 (conv_i_src_c085_1_04 conv_i_c085_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_04 (conv_q_src_c085_1_04 0 conv_bpf_c085_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_1_04 (conv_q_src_c085_1_04 conv_q_c085_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_05 (conv_i_src_c085_1_05 0 conv_bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_1_05 (conv_i_src_c085_1_05 conv_i_c085_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_05 (conv_q_src_c085_1_05 0 conv_bpf_c085_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_1_05 (conv_q_src_c085_1_05 conv_q_c085_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_06 (conv_i_src_c085_1_06 0 conv_bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_1_06 (conv_i_src_c085_1_06 conv_i_c085_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_06 (conv_q_src_c085_1_06 0 conv_bpf_c085_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_1_06 (conv_q_src_c085_1_06 conv_q_c085_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_07 (conv_i_src_c085_1_07 0 conv_bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_1_07 (conv_i_src_c085_1_07 conv_i_c085_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_07 (conv_q_src_c085_1_07 0 conv_bpf_c085_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_1_07 (conv_q_src_c085_1_07 conv_q_c085_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_08 (conv_i_src_c085_1_08 0 conv_bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_1_08 (conv_i_src_c085_1_08 conv_i_c085_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_08 (conv_q_src_c085_1_08 0 conv_bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_1_08 (conv_q_src_c085_1_08 conv_q_c085_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_09 (conv_i_src_c085_1_09 0 conv_bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_1_09 (conv_i_src_c085_1_09 conv_i_c085_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_09 (conv_q_src_c085_1_09 0 conv_bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_1_09 (conv_q_src_c085_1_09 conv_q_c085_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_10 (conv_i_src_c085_1_10 0 conv_bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_1_10 (conv_i_src_c085_1_10 conv_i_c085_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_10 (conv_q_src_c085_1_10 0 conv_bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_1_10 (conv_q_src_c085_1_10 conv_q_c085_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_11 (conv_i_src_c085_1_11 0 conv_bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_1_11 (conv_i_src_c085_1_11 conv_i_c085_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_11 (conv_q_src_c085_1_11 0 conv_bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_1_11 (conv_q_src_c085_1_11 conv_q_c085_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_12 (conv_i_src_c085_1_12 0 conv_bpf_c085_1 0) vcvs gain=1.950903220161e-01
SCONVI_c085_1_12 (conv_i_src_c085_1_12 conv_i_c085_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_12 (conv_q_src_c085_1_12 0 conv_bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_1_12 (conv_q_src_c085_1_12 conv_q_c085_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_13 (conv_i_src_c085_1_13 0 conv_bpf_c085_1 0) vcvs gain=5.555702330196e-01
SCONVI_c085_1_13 (conv_i_src_c085_1_13 conv_i_c085_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_13 (conv_q_src_c085_1_13 0 conv_bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_1_13 (conv_q_src_c085_1_13 conv_q_c085_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_14 (conv_i_src_c085_1_14 0 conv_bpf_c085_1 0) vcvs gain=8.314696123025e-01
SCONVI_c085_1_14 (conv_i_src_c085_1_14 conv_i_c085_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_14 (conv_q_src_c085_1_14 0 conv_bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_1_14 (conv_q_src_c085_1_14 conv_q_c085_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_1_15 (conv_i_src_c085_1_15 0 conv_bpf_c085_1 0) vcvs gain=9.807852804032e-01
SCONVI_c085_1_15 (conv_i_src_c085_1_15 conv_i_c085_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_1_15 (conv_q_src_c085_1_15 0 conv_bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_1_15 (conv_q_src_c085_1_15 conv_q_c085_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c085_1 (conv_i_c085_1 0) resistor r=1G
RCONVQ_c085_1 (conv_q_c085_1 0) resistor r=1G
RCONVINTI_c085_1 (conv_i_c085_1 ConvIcar_c085_1) resistor r=1k
CCONVINTI_c085_1 (ConvIcar_c085_1 0) capacitor c=80p
RCONVINTQ_c085_1 (conv_q_c085_1 ConvQcar_c085_1) resistor r=1k
CCONVINTQ_c085_1 (ConvQcar_c085_1 0) capacitor c=80p
save conv_bpf_c085_1 ConvIcar_c085_1 ConvQcar_c085_1

// conventional mixed baseline bl085, carrier_2: 750000000 Hz
CCONVBPF_c085_2 (bl085 n_conv_cbpf_c085_2) capacitor c=4.503163717437e-14
LCONVBPF_c085_2 (n_conv_cbpf_c085_2 conv_bpf_c085_2) inductor l=1.000000000000e-06
RCONVBPF_c085_2 (conv_bpf_c085_2 0) resistor r=2.356194490192e+02
ECONVI_c085_2_00 (conv_i_src_c085_2_00 0 conv_bpf_c085_2 0) vcvs gain=9.807852804032e-01
SCONVI_c085_2_00 (conv_i_src_c085_2_00 conv_i_c085_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_00 (conv_q_src_c085_2_00 0 conv_bpf_c085_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_2_00 (conv_q_src_c085_2_00 conv_q_c085_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_01 (conv_i_src_c085_2_01 0 conv_bpf_c085_2 0) vcvs gain=8.314696123025e-01
SCONVI_c085_2_01 (conv_i_src_c085_2_01 conv_i_c085_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_01 (conv_q_src_c085_2_01 0 conv_bpf_c085_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_2_01 (conv_q_src_c085_2_01 conv_q_c085_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_02 (conv_i_src_c085_2_02 0 conv_bpf_c085_2 0) vcvs gain=5.555702330196e-01
SCONVI_c085_2_02 (conv_i_src_c085_2_02 conv_i_c085_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_02 (conv_q_src_c085_2_02 0 conv_bpf_c085_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_2_02 (conv_q_src_c085_2_02 conv_q_c085_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_03 (conv_i_src_c085_2_03 0 conv_bpf_c085_2 0) vcvs gain=1.950903220161e-01
SCONVI_c085_2_03 (conv_i_src_c085_2_03 conv_i_c085_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_03 (conv_q_src_c085_2_03 0 conv_bpf_c085_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_2_03 (conv_q_src_c085_2_03 conv_q_c085_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_04 (conv_i_src_c085_2_04 0 conv_bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_2_04 (conv_i_src_c085_2_04 conv_i_c085_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_04 (conv_q_src_c085_2_04 0 conv_bpf_c085_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_2_04 (conv_q_src_c085_2_04 conv_q_c085_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_05 (conv_i_src_c085_2_05 0 conv_bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_2_05 (conv_i_src_c085_2_05 conv_i_c085_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_05 (conv_q_src_c085_2_05 0 conv_bpf_c085_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_2_05 (conv_q_src_c085_2_05 conv_q_c085_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_06 (conv_i_src_c085_2_06 0 conv_bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_2_06 (conv_i_src_c085_2_06 conv_i_c085_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_06 (conv_q_src_c085_2_06 0 conv_bpf_c085_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_2_06 (conv_q_src_c085_2_06 conv_q_c085_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_07 (conv_i_src_c085_2_07 0 conv_bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_2_07 (conv_i_src_c085_2_07 conv_i_c085_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_07 (conv_q_src_c085_2_07 0 conv_bpf_c085_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_2_07 (conv_q_src_c085_2_07 conv_q_c085_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_08 (conv_i_src_c085_2_08 0 conv_bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_2_08 (conv_i_src_c085_2_08 conv_i_c085_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_08 (conv_q_src_c085_2_08 0 conv_bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_2_08 (conv_q_src_c085_2_08 conv_q_c085_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_09 (conv_i_src_c085_2_09 0 conv_bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_2_09 (conv_i_src_c085_2_09 conv_i_c085_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_09 (conv_q_src_c085_2_09 0 conv_bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_2_09 (conv_q_src_c085_2_09 conv_q_c085_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_10 (conv_i_src_c085_2_10 0 conv_bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_2_10 (conv_i_src_c085_2_10 conv_i_c085_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_10 (conv_q_src_c085_2_10 0 conv_bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_2_10 (conv_q_src_c085_2_10 conv_q_c085_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_11 (conv_i_src_c085_2_11 0 conv_bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_2_11 (conv_i_src_c085_2_11 conv_i_c085_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_11 (conv_q_src_c085_2_11 0 conv_bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_2_11 (conv_q_src_c085_2_11 conv_q_c085_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_12 (conv_i_src_c085_2_12 0 conv_bpf_c085_2 0) vcvs gain=1.950903220161e-01
SCONVI_c085_2_12 (conv_i_src_c085_2_12 conv_i_c085_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_12 (conv_q_src_c085_2_12 0 conv_bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_2_12 (conv_q_src_c085_2_12 conv_q_c085_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_13 (conv_i_src_c085_2_13 0 conv_bpf_c085_2 0) vcvs gain=5.555702330196e-01
SCONVI_c085_2_13 (conv_i_src_c085_2_13 conv_i_c085_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_13 (conv_q_src_c085_2_13 0 conv_bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_2_13 (conv_q_src_c085_2_13 conv_q_c085_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_14 (conv_i_src_c085_2_14 0 conv_bpf_c085_2 0) vcvs gain=8.314696123025e-01
SCONVI_c085_2_14 (conv_i_src_c085_2_14 conv_i_c085_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_14 (conv_q_src_c085_2_14 0 conv_bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_2_14 (conv_q_src_c085_2_14 conv_q_c085_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_2_15 (conv_i_src_c085_2_15 0 conv_bpf_c085_2 0) vcvs gain=9.807852804032e-01
SCONVI_c085_2_15 (conv_i_src_c085_2_15 conv_i_c085_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_2_15 (conv_q_src_c085_2_15 0 conv_bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_2_15 (conv_q_src_c085_2_15 conv_q_c085_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c085_2 (conv_i_c085_2 0) resistor r=1G
RCONVQ_c085_2 (conv_q_c085_2 0) resistor r=1G
RCONVINTI_c085_2 (conv_i_c085_2 ConvIcar_c085_2) resistor r=1k
CCONVINTI_c085_2 (ConvIcar_c085_2 0) capacitor c=80p
RCONVINTQ_c085_2 (conv_q_c085_2 ConvQcar_c085_2) resistor r=1k
CCONVINTQ_c085_2 (ConvQcar_c085_2 0) capacitor c=80p
save conv_bpf_c085_2 ConvIcar_c085_2 ConvQcar_c085_2

// conventional mixed baseline bl085, carrier_3: 1000000000 Hz
CCONVBPF_c085_3 (bl085 n_conv_cbpf_c085_3) capacitor c=2.533029591058e-14
LCONVBPF_c085_3 (n_conv_cbpf_c085_3 conv_bpf_c085_3) inductor l=1.000000000000e-06
RCONVBPF_c085_3 (conv_bpf_c085_3 0) resistor r=3.141592653590e+02
ECONVI_c085_3_00 (conv_i_src_c085_3_00 0 conv_bpf_c085_3 0) vcvs gain=9.807852804032e-01
SCONVI_c085_3_00 (conv_i_src_c085_3_00 conv_i_c085_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_00 (conv_q_src_c085_3_00 0 conv_bpf_c085_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_3_00 (conv_q_src_c085_3_00 conv_q_c085_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_01 (conv_i_src_c085_3_01 0 conv_bpf_c085_3 0) vcvs gain=8.314696123025e-01
SCONVI_c085_3_01 (conv_i_src_c085_3_01 conv_i_c085_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_01 (conv_q_src_c085_3_01 0 conv_bpf_c085_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_3_01 (conv_q_src_c085_3_01 conv_q_c085_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_02 (conv_i_src_c085_3_02 0 conv_bpf_c085_3 0) vcvs gain=5.555702330196e-01
SCONVI_c085_3_02 (conv_i_src_c085_3_02 conv_i_c085_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_02 (conv_q_src_c085_3_02 0 conv_bpf_c085_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_3_02 (conv_q_src_c085_3_02 conv_q_c085_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_03 (conv_i_src_c085_3_03 0 conv_bpf_c085_3 0) vcvs gain=1.950903220161e-01
SCONVI_c085_3_03 (conv_i_src_c085_3_03 conv_i_c085_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_03 (conv_q_src_c085_3_03 0 conv_bpf_c085_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_3_03 (conv_q_src_c085_3_03 conv_q_c085_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_04 (conv_i_src_c085_3_04 0 conv_bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_3_04 (conv_i_src_c085_3_04 conv_i_c085_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_04 (conv_q_src_c085_3_04 0 conv_bpf_c085_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c085_3_04 (conv_q_src_c085_3_04 conv_q_c085_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_05 (conv_i_src_c085_3_05 0 conv_bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_3_05 (conv_i_src_c085_3_05 conv_i_c085_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_05 (conv_q_src_c085_3_05 0 conv_bpf_c085_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c085_3_05 (conv_q_src_c085_3_05 conv_q_c085_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_06 (conv_i_src_c085_3_06 0 conv_bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_3_06 (conv_i_src_c085_3_06 conv_i_c085_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_06 (conv_q_src_c085_3_06 0 conv_bpf_c085_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c085_3_06 (conv_q_src_c085_3_06 conv_q_c085_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_07 (conv_i_src_c085_3_07 0 conv_bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_3_07 (conv_i_src_c085_3_07 conv_i_c085_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_07 (conv_q_src_c085_3_07 0 conv_bpf_c085_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c085_3_07 (conv_q_src_c085_3_07 conv_q_c085_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_08 (conv_i_src_c085_3_08 0 conv_bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c085_3_08 (conv_i_src_c085_3_08 conv_i_c085_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_08 (conv_q_src_c085_3_08 0 conv_bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_3_08 (conv_q_src_c085_3_08 conv_q_c085_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_09 (conv_i_src_c085_3_09 0 conv_bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c085_3_09 (conv_i_src_c085_3_09 conv_i_c085_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_09 (conv_q_src_c085_3_09 0 conv_bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_3_09 (conv_q_src_c085_3_09 conv_q_c085_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_10 (conv_i_src_c085_3_10 0 conv_bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c085_3_10 (conv_i_src_c085_3_10 conv_i_c085_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_10 (conv_q_src_c085_3_10 0 conv_bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_3_10 (conv_q_src_c085_3_10 conv_q_c085_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_11 (conv_i_src_c085_3_11 0 conv_bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c085_3_11 (conv_i_src_c085_3_11 conv_i_c085_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_11 (conv_q_src_c085_3_11 0 conv_bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_3_11 (conv_q_src_c085_3_11 conv_q_c085_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_12 (conv_i_src_c085_3_12 0 conv_bpf_c085_3 0) vcvs gain=1.950903220161e-01
SCONVI_c085_3_12 (conv_i_src_c085_3_12 conv_i_c085_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_12 (conv_q_src_c085_3_12 0 conv_bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c085_3_12 (conv_q_src_c085_3_12 conv_q_c085_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_13 (conv_i_src_c085_3_13 0 conv_bpf_c085_3 0) vcvs gain=5.555702330196e-01
SCONVI_c085_3_13 (conv_i_src_c085_3_13 conv_i_c085_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_13 (conv_q_src_c085_3_13 0 conv_bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c085_3_13 (conv_q_src_c085_3_13 conv_q_c085_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_14 (conv_i_src_c085_3_14 0 conv_bpf_c085_3 0) vcvs gain=8.314696123025e-01
SCONVI_c085_3_14 (conv_i_src_c085_3_14 conv_i_c085_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_14 (conv_q_src_c085_3_14 0 conv_bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c085_3_14 (conv_q_src_c085_3_14 conv_q_c085_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c085_3_15 (conv_i_src_c085_3_15 0 conv_bpf_c085_3 0) vcvs gain=9.807852804032e-01
SCONVI_c085_3_15 (conv_i_src_c085_3_15 conv_i_c085_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c085_3_15 (conv_q_src_c085_3_15 0 conv_bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c085_3_15 (conv_q_src_c085_3_15 conv_q_c085_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c085_3 (conv_i_c085_3 0) resistor r=1G
RCONVQ_c085_3 (conv_q_c085_3 0) resistor r=1G
RCONVINTI_c085_3 (conv_i_c085_3 ConvIcar_c085_3) resistor r=1k
CCONVINTI_c085_3 (ConvIcar_c085_3 0) capacitor c=80p
RCONVINTQ_c085_3 (conv_q_c085_3 ConvQcar_c085_3) resistor r=1k
CCONVINTQ_c085_3 (ConvQcar_c085_3 0) capacitor c=80p
save conv_bpf_c085_3 ConvIcar_c085_3 ConvQcar_c085_3

// conventional mixed baseline bl086, carrier_0: 250000000 Hz
CCONVBPF_c086_0 (bl086 n_conv_cbpf_c086_0) capacitor c=4.052847345694e-13
LCONVBPF_c086_0 (n_conv_cbpf_c086_0 conv_bpf_c086_0) inductor l=1.000000000000e-06
RCONVBPF_c086_0 (conv_bpf_c086_0 0) resistor r=7.853981633974e+01
ECONVI_c086_0_00 (conv_i_src_c086_0_00 0 conv_bpf_c086_0 0) vcvs gain=9.807852804032e-01
SCONVI_c086_0_00 (conv_i_src_c086_0_00 conv_i_c086_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_00 (conv_q_src_c086_0_00 0 conv_bpf_c086_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_0_00 (conv_q_src_c086_0_00 conv_q_c086_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_01 (conv_i_src_c086_0_01 0 conv_bpf_c086_0 0) vcvs gain=8.314696123025e-01
SCONVI_c086_0_01 (conv_i_src_c086_0_01 conv_i_c086_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_01 (conv_q_src_c086_0_01 0 conv_bpf_c086_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_0_01 (conv_q_src_c086_0_01 conv_q_c086_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_02 (conv_i_src_c086_0_02 0 conv_bpf_c086_0 0) vcvs gain=5.555702330196e-01
SCONVI_c086_0_02 (conv_i_src_c086_0_02 conv_i_c086_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_02 (conv_q_src_c086_0_02 0 conv_bpf_c086_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_0_02 (conv_q_src_c086_0_02 conv_q_c086_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_03 (conv_i_src_c086_0_03 0 conv_bpf_c086_0 0) vcvs gain=1.950903220161e-01
SCONVI_c086_0_03 (conv_i_src_c086_0_03 conv_i_c086_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_03 (conv_q_src_c086_0_03 0 conv_bpf_c086_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_0_03 (conv_q_src_c086_0_03 conv_q_c086_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_04 (conv_i_src_c086_0_04 0 conv_bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_0_04 (conv_i_src_c086_0_04 conv_i_c086_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_04 (conv_q_src_c086_0_04 0 conv_bpf_c086_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_0_04 (conv_q_src_c086_0_04 conv_q_c086_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_05 (conv_i_src_c086_0_05 0 conv_bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_0_05 (conv_i_src_c086_0_05 conv_i_c086_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_05 (conv_q_src_c086_0_05 0 conv_bpf_c086_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_0_05 (conv_q_src_c086_0_05 conv_q_c086_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_06 (conv_i_src_c086_0_06 0 conv_bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_0_06 (conv_i_src_c086_0_06 conv_i_c086_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_06 (conv_q_src_c086_0_06 0 conv_bpf_c086_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_0_06 (conv_q_src_c086_0_06 conv_q_c086_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_07 (conv_i_src_c086_0_07 0 conv_bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_0_07 (conv_i_src_c086_0_07 conv_i_c086_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_07 (conv_q_src_c086_0_07 0 conv_bpf_c086_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_0_07 (conv_q_src_c086_0_07 conv_q_c086_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_08 (conv_i_src_c086_0_08 0 conv_bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_0_08 (conv_i_src_c086_0_08 conv_i_c086_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_08 (conv_q_src_c086_0_08 0 conv_bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_0_08 (conv_q_src_c086_0_08 conv_q_c086_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_09 (conv_i_src_c086_0_09 0 conv_bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_0_09 (conv_i_src_c086_0_09 conv_i_c086_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_09 (conv_q_src_c086_0_09 0 conv_bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_0_09 (conv_q_src_c086_0_09 conv_q_c086_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_10 (conv_i_src_c086_0_10 0 conv_bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_0_10 (conv_i_src_c086_0_10 conv_i_c086_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_10 (conv_q_src_c086_0_10 0 conv_bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_0_10 (conv_q_src_c086_0_10 conv_q_c086_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_11 (conv_i_src_c086_0_11 0 conv_bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_0_11 (conv_i_src_c086_0_11 conv_i_c086_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_11 (conv_q_src_c086_0_11 0 conv_bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_0_11 (conv_q_src_c086_0_11 conv_q_c086_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_12 (conv_i_src_c086_0_12 0 conv_bpf_c086_0 0) vcvs gain=1.950903220161e-01
SCONVI_c086_0_12 (conv_i_src_c086_0_12 conv_i_c086_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_12 (conv_q_src_c086_0_12 0 conv_bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_0_12 (conv_q_src_c086_0_12 conv_q_c086_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_13 (conv_i_src_c086_0_13 0 conv_bpf_c086_0 0) vcvs gain=5.555702330196e-01
SCONVI_c086_0_13 (conv_i_src_c086_0_13 conv_i_c086_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_13 (conv_q_src_c086_0_13 0 conv_bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_0_13 (conv_q_src_c086_0_13 conv_q_c086_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_14 (conv_i_src_c086_0_14 0 conv_bpf_c086_0 0) vcvs gain=8.314696123025e-01
SCONVI_c086_0_14 (conv_i_src_c086_0_14 conv_i_c086_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_14 (conv_q_src_c086_0_14 0 conv_bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_0_14 (conv_q_src_c086_0_14 conv_q_c086_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_0_15 (conv_i_src_c086_0_15 0 conv_bpf_c086_0 0) vcvs gain=9.807852804032e-01
SCONVI_c086_0_15 (conv_i_src_c086_0_15 conv_i_c086_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_0_15 (conv_q_src_c086_0_15 0 conv_bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_0_15 (conv_q_src_c086_0_15 conv_q_c086_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c086_0 (conv_i_c086_0 0) resistor r=1G
RCONVQ_c086_0 (conv_q_c086_0 0) resistor r=1G
RCONVINTI_c086_0 (conv_i_c086_0 ConvIcar_c086_0) resistor r=1k
CCONVINTI_c086_0 (ConvIcar_c086_0 0) capacitor c=80p
RCONVINTQ_c086_0 (conv_q_c086_0 ConvQcar_c086_0) resistor r=1k
CCONVINTQ_c086_0 (ConvQcar_c086_0 0) capacitor c=80p
save conv_bpf_c086_0 ConvIcar_c086_0 ConvQcar_c086_0

// conventional mixed baseline bl086, carrier_1: 500000000 Hz
CCONVBPF_c086_1 (bl086 n_conv_cbpf_c086_1) capacitor c=1.013211836423e-13
LCONVBPF_c086_1 (n_conv_cbpf_c086_1 conv_bpf_c086_1) inductor l=1.000000000000e-06
RCONVBPF_c086_1 (conv_bpf_c086_1 0) resistor r=1.570796326795e+02
ECONVI_c086_1_00 (conv_i_src_c086_1_00 0 conv_bpf_c086_1 0) vcvs gain=9.807852804032e-01
SCONVI_c086_1_00 (conv_i_src_c086_1_00 conv_i_c086_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_00 (conv_q_src_c086_1_00 0 conv_bpf_c086_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_1_00 (conv_q_src_c086_1_00 conv_q_c086_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_01 (conv_i_src_c086_1_01 0 conv_bpf_c086_1 0) vcvs gain=8.314696123025e-01
SCONVI_c086_1_01 (conv_i_src_c086_1_01 conv_i_c086_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_01 (conv_q_src_c086_1_01 0 conv_bpf_c086_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_1_01 (conv_q_src_c086_1_01 conv_q_c086_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_02 (conv_i_src_c086_1_02 0 conv_bpf_c086_1 0) vcvs gain=5.555702330196e-01
SCONVI_c086_1_02 (conv_i_src_c086_1_02 conv_i_c086_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_02 (conv_q_src_c086_1_02 0 conv_bpf_c086_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_1_02 (conv_q_src_c086_1_02 conv_q_c086_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_03 (conv_i_src_c086_1_03 0 conv_bpf_c086_1 0) vcvs gain=1.950903220161e-01
SCONVI_c086_1_03 (conv_i_src_c086_1_03 conv_i_c086_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_03 (conv_q_src_c086_1_03 0 conv_bpf_c086_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_1_03 (conv_q_src_c086_1_03 conv_q_c086_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_04 (conv_i_src_c086_1_04 0 conv_bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_1_04 (conv_i_src_c086_1_04 conv_i_c086_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_04 (conv_q_src_c086_1_04 0 conv_bpf_c086_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_1_04 (conv_q_src_c086_1_04 conv_q_c086_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_05 (conv_i_src_c086_1_05 0 conv_bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_1_05 (conv_i_src_c086_1_05 conv_i_c086_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_05 (conv_q_src_c086_1_05 0 conv_bpf_c086_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_1_05 (conv_q_src_c086_1_05 conv_q_c086_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_06 (conv_i_src_c086_1_06 0 conv_bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_1_06 (conv_i_src_c086_1_06 conv_i_c086_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_06 (conv_q_src_c086_1_06 0 conv_bpf_c086_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_1_06 (conv_q_src_c086_1_06 conv_q_c086_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_07 (conv_i_src_c086_1_07 0 conv_bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_1_07 (conv_i_src_c086_1_07 conv_i_c086_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_07 (conv_q_src_c086_1_07 0 conv_bpf_c086_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_1_07 (conv_q_src_c086_1_07 conv_q_c086_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_08 (conv_i_src_c086_1_08 0 conv_bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_1_08 (conv_i_src_c086_1_08 conv_i_c086_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_08 (conv_q_src_c086_1_08 0 conv_bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_1_08 (conv_q_src_c086_1_08 conv_q_c086_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_09 (conv_i_src_c086_1_09 0 conv_bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_1_09 (conv_i_src_c086_1_09 conv_i_c086_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_09 (conv_q_src_c086_1_09 0 conv_bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_1_09 (conv_q_src_c086_1_09 conv_q_c086_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_10 (conv_i_src_c086_1_10 0 conv_bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_1_10 (conv_i_src_c086_1_10 conv_i_c086_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_10 (conv_q_src_c086_1_10 0 conv_bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_1_10 (conv_q_src_c086_1_10 conv_q_c086_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_11 (conv_i_src_c086_1_11 0 conv_bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_1_11 (conv_i_src_c086_1_11 conv_i_c086_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_11 (conv_q_src_c086_1_11 0 conv_bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_1_11 (conv_q_src_c086_1_11 conv_q_c086_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_12 (conv_i_src_c086_1_12 0 conv_bpf_c086_1 0) vcvs gain=1.950903220161e-01
SCONVI_c086_1_12 (conv_i_src_c086_1_12 conv_i_c086_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_12 (conv_q_src_c086_1_12 0 conv_bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_1_12 (conv_q_src_c086_1_12 conv_q_c086_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_13 (conv_i_src_c086_1_13 0 conv_bpf_c086_1 0) vcvs gain=5.555702330196e-01
SCONVI_c086_1_13 (conv_i_src_c086_1_13 conv_i_c086_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_13 (conv_q_src_c086_1_13 0 conv_bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_1_13 (conv_q_src_c086_1_13 conv_q_c086_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_14 (conv_i_src_c086_1_14 0 conv_bpf_c086_1 0) vcvs gain=8.314696123025e-01
SCONVI_c086_1_14 (conv_i_src_c086_1_14 conv_i_c086_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_14 (conv_q_src_c086_1_14 0 conv_bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_1_14 (conv_q_src_c086_1_14 conv_q_c086_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_1_15 (conv_i_src_c086_1_15 0 conv_bpf_c086_1 0) vcvs gain=9.807852804032e-01
SCONVI_c086_1_15 (conv_i_src_c086_1_15 conv_i_c086_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_1_15 (conv_q_src_c086_1_15 0 conv_bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_1_15 (conv_q_src_c086_1_15 conv_q_c086_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c086_1 (conv_i_c086_1 0) resistor r=1G
RCONVQ_c086_1 (conv_q_c086_1 0) resistor r=1G
RCONVINTI_c086_1 (conv_i_c086_1 ConvIcar_c086_1) resistor r=1k
CCONVINTI_c086_1 (ConvIcar_c086_1 0) capacitor c=80p
RCONVINTQ_c086_1 (conv_q_c086_1 ConvQcar_c086_1) resistor r=1k
CCONVINTQ_c086_1 (ConvQcar_c086_1 0) capacitor c=80p
save conv_bpf_c086_1 ConvIcar_c086_1 ConvQcar_c086_1

// conventional mixed baseline bl086, carrier_2: 750000000 Hz
CCONVBPF_c086_2 (bl086 n_conv_cbpf_c086_2) capacitor c=4.503163717437e-14
LCONVBPF_c086_2 (n_conv_cbpf_c086_2 conv_bpf_c086_2) inductor l=1.000000000000e-06
RCONVBPF_c086_2 (conv_bpf_c086_2 0) resistor r=2.356194490192e+02
ECONVI_c086_2_00 (conv_i_src_c086_2_00 0 conv_bpf_c086_2 0) vcvs gain=9.807852804032e-01
SCONVI_c086_2_00 (conv_i_src_c086_2_00 conv_i_c086_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_00 (conv_q_src_c086_2_00 0 conv_bpf_c086_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_2_00 (conv_q_src_c086_2_00 conv_q_c086_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_01 (conv_i_src_c086_2_01 0 conv_bpf_c086_2 0) vcvs gain=8.314696123025e-01
SCONVI_c086_2_01 (conv_i_src_c086_2_01 conv_i_c086_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_01 (conv_q_src_c086_2_01 0 conv_bpf_c086_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_2_01 (conv_q_src_c086_2_01 conv_q_c086_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_02 (conv_i_src_c086_2_02 0 conv_bpf_c086_2 0) vcvs gain=5.555702330196e-01
SCONVI_c086_2_02 (conv_i_src_c086_2_02 conv_i_c086_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_02 (conv_q_src_c086_2_02 0 conv_bpf_c086_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_2_02 (conv_q_src_c086_2_02 conv_q_c086_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_03 (conv_i_src_c086_2_03 0 conv_bpf_c086_2 0) vcvs gain=1.950903220161e-01
SCONVI_c086_2_03 (conv_i_src_c086_2_03 conv_i_c086_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_03 (conv_q_src_c086_2_03 0 conv_bpf_c086_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_2_03 (conv_q_src_c086_2_03 conv_q_c086_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_04 (conv_i_src_c086_2_04 0 conv_bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_2_04 (conv_i_src_c086_2_04 conv_i_c086_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_04 (conv_q_src_c086_2_04 0 conv_bpf_c086_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_2_04 (conv_q_src_c086_2_04 conv_q_c086_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_05 (conv_i_src_c086_2_05 0 conv_bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_2_05 (conv_i_src_c086_2_05 conv_i_c086_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_05 (conv_q_src_c086_2_05 0 conv_bpf_c086_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_2_05 (conv_q_src_c086_2_05 conv_q_c086_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_06 (conv_i_src_c086_2_06 0 conv_bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_2_06 (conv_i_src_c086_2_06 conv_i_c086_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_06 (conv_q_src_c086_2_06 0 conv_bpf_c086_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_2_06 (conv_q_src_c086_2_06 conv_q_c086_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_07 (conv_i_src_c086_2_07 0 conv_bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_2_07 (conv_i_src_c086_2_07 conv_i_c086_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_07 (conv_q_src_c086_2_07 0 conv_bpf_c086_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_2_07 (conv_q_src_c086_2_07 conv_q_c086_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_08 (conv_i_src_c086_2_08 0 conv_bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_2_08 (conv_i_src_c086_2_08 conv_i_c086_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_08 (conv_q_src_c086_2_08 0 conv_bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_2_08 (conv_q_src_c086_2_08 conv_q_c086_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_09 (conv_i_src_c086_2_09 0 conv_bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_2_09 (conv_i_src_c086_2_09 conv_i_c086_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_09 (conv_q_src_c086_2_09 0 conv_bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_2_09 (conv_q_src_c086_2_09 conv_q_c086_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_10 (conv_i_src_c086_2_10 0 conv_bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_2_10 (conv_i_src_c086_2_10 conv_i_c086_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_10 (conv_q_src_c086_2_10 0 conv_bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_2_10 (conv_q_src_c086_2_10 conv_q_c086_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_11 (conv_i_src_c086_2_11 0 conv_bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_2_11 (conv_i_src_c086_2_11 conv_i_c086_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_11 (conv_q_src_c086_2_11 0 conv_bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_2_11 (conv_q_src_c086_2_11 conv_q_c086_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_12 (conv_i_src_c086_2_12 0 conv_bpf_c086_2 0) vcvs gain=1.950903220161e-01
SCONVI_c086_2_12 (conv_i_src_c086_2_12 conv_i_c086_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_12 (conv_q_src_c086_2_12 0 conv_bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_2_12 (conv_q_src_c086_2_12 conv_q_c086_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_13 (conv_i_src_c086_2_13 0 conv_bpf_c086_2 0) vcvs gain=5.555702330196e-01
SCONVI_c086_2_13 (conv_i_src_c086_2_13 conv_i_c086_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_13 (conv_q_src_c086_2_13 0 conv_bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_2_13 (conv_q_src_c086_2_13 conv_q_c086_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_14 (conv_i_src_c086_2_14 0 conv_bpf_c086_2 0) vcvs gain=8.314696123025e-01
SCONVI_c086_2_14 (conv_i_src_c086_2_14 conv_i_c086_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_14 (conv_q_src_c086_2_14 0 conv_bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_2_14 (conv_q_src_c086_2_14 conv_q_c086_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_2_15 (conv_i_src_c086_2_15 0 conv_bpf_c086_2 0) vcvs gain=9.807852804032e-01
SCONVI_c086_2_15 (conv_i_src_c086_2_15 conv_i_c086_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_2_15 (conv_q_src_c086_2_15 0 conv_bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_2_15 (conv_q_src_c086_2_15 conv_q_c086_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c086_2 (conv_i_c086_2 0) resistor r=1G
RCONVQ_c086_2 (conv_q_c086_2 0) resistor r=1G
RCONVINTI_c086_2 (conv_i_c086_2 ConvIcar_c086_2) resistor r=1k
CCONVINTI_c086_2 (ConvIcar_c086_2 0) capacitor c=80p
RCONVINTQ_c086_2 (conv_q_c086_2 ConvQcar_c086_2) resistor r=1k
CCONVINTQ_c086_2 (ConvQcar_c086_2 0) capacitor c=80p
save conv_bpf_c086_2 ConvIcar_c086_2 ConvQcar_c086_2

// conventional mixed baseline bl086, carrier_3: 1000000000 Hz
CCONVBPF_c086_3 (bl086 n_conv_cbpf_c086_3) capacitor c=2.533029591058e-14
LCONVBPF_c086_3 (n_conv_cbpf_c086_3 conv_bpf_c086_3) inductor l=1.000000000000e-06
RCONVBPF_c086_3 (conv_bpf_c086_3 0) resistor r=3.141592653590e+02
ECONVI_c086_3_00 (conv_i_src_c086_3_00 0 conv_bpf_c086_3 0) vcvs gain=9.807852804032e-01
SCONVI_c086_3_00 (conv_i_src_c086_3_00 conv_i_c086_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_00 (conv_q_src_c086_3_00 0 conv_bpf_c086_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_3_00 (conv_q_src_c086_3_00 conv_q_c086_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_01 (conv_i_src_c086_3_01 0 conv_bpf_c086_3 0) vcvs gain=8.314696123025e-01
SCONVI_c086_3_01 (conv_i_src_c086_3_01 conv_i_c086_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_01 (conv_q_src_c086_3_01 0 conv_bpf_c086_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_3_01 (conv_q_src_c086_3_01 conv_q_c086_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_02 (conv_i_src_c086_3_02 0 conv_bpf_c086_3 0) vcvs gain=5.555702330196e-01
SCONVI_c086_3_02 (conv_i_src_c086_3_02 conv_i_c086_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_02 (conv_q_src_c086_3_02 0 conv_bpf_c086_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_3_02 (conv_q_src_c086_3_02 conv_q_c086_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_03 (conv_i_src_c086_3_03 0 conv_bpf_c086_3 0) vcvs gain=1.950903220161e-01
SCONVI_c086_3_03 (conv_i_src_c086_3_03 conv_i_c086_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_03 (conv_q_src_c086_3_03 0 conv_bpf_c086_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_3_03 (conv_q_src_c086_3_03 conv_q_c086_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_04 (conv_i_src_c086_3_04 0 conv_bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_3_04 (conv_i_src_c086_3_04 conv_i_c086_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_04 (conv_q_src_c086_3_04 0 conv_bpf_c086_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c086_3_04 (conv_q_src_c086_3_04 conv_q_c086_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_05 (conv_i_src_c086_3_05 0 conv_bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_3_05 (conv_i_src_c086_3_05 conv_i_c086_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_05 (conv_q_src_c086_3_05 0 conv_bpf_c086_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c086_3_05 (conv_q_src_c086_3_05 conv_q_c086_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_06 (conv_i_src_c086_3_06 0 conv_bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_3_06 (conv_i_src_c086_3_06 conv_i_c086_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_06 (conv_q_src_c086_3_06 0 conv_bpf_c086_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c086_3_06 (conv_q_src_c086_3_06 conv_q_c086_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_07 (conv_i_src_c086_3_07 0 conv_bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_3_07 (conv_i_src_c086_3_07 conv_i_c086_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_07 (conv_q_src_c086_3_07 0 conv_bpf_c086_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c086_3_07 (conv_q_src_c086_3_07 conv_q_c086_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_08 (conv_i_src_c086_3_08 0 conv_bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c086_3_08 (conv_i_src_c086_3_08 conv_i_c086_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_08 (conv_q_src_c086_3_08 0 conv_bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_3_08 (conv_q_src_c086_3_08 conv_q_c086_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_09 (conv_i_src_c086_3_09 0 conv_bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c086_3_09 (conv_i_src_c086_3_09 conv_i_c086_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_09 (conv_q_src_c086_3_09 0 conv_bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_3_09 (conv_q_src_c086_3_09 conv_q_c086_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_10 (conv_i_src_c086_3_10 0 conv_bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c086_3_10 (conv_i_src_c086_3_10 conv_i_c086_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_10 (conv_q_src_c086_3_10 0 conv_bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_3_10 (conv_q_src_c086_3_10 conv_q_c086_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_11 (conv_i_src_c086_3_11 0 conv_bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c086_3_11 (conv_i_src_c086_3_11 conv_i_c086_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_11 (conv_q_src_c086_3_11 0 conv_bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_3_11 (conv_q_src_c086_3_11 conv_q_c086_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_12 (conv_i_src_c086_3_12 0 conv_bpf_c086_3 0) vcvs gain=1.950903220161e-01
SCONVI_c086_3_12 (conv_i_src_c086_3_12 conv_i_c086_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_12 (conv_q_src_c086_3_12 0 conv_bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c086_3_12 (conv_q_src_c086_3_12 conv_q_c086_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_13 (conv_i_src_c086_3_13 0 conv_bpf_c086_3 0) vcvs gain=5.555702330196e-01
SCONVI_c086_3_13 (conv_i_src_c086_3_13 conv_i_c086_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_13 (conv_q_src_c086_3_13 0 conv_bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c086_3_13 (conv_q_src_c086_3_13 conv_q_c086_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_14 (conv_i_src_c086_3_14 0 conv_bpf_c086_3 0) vcvs gain=8.314696123025e-01
SCONVI_c086_3_14 (conv_i_src_c086_3_14 conv_i_c086_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_14 (conv_q_src_c086_3_14 0 conv_bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c086_3_14 (conv_q_src_c086_3_14 conv_q_c086_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c086_3_15 (conv_i_src_c086_3_15 0 conv_bpf_c086_3 0) vcvs gain=9.807852804032e-01
SCONVI_c086_3_15 (conv_i_src_c086_3_15 conv_i_c086_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c086_3_15 (conv_q_src_c086_3_15 0 conv_bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c086_3_15 (conv_q_src_c086_3_15 conv_q_c086_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c086_3 (conv_i_c086_3 0) resistor r=1G
RCONVQ_c086_3 (conv_q_c086_3 0) resistor r=1G
RCONVINTI_c086_3 (conv_i_c086_3 ConvIcar_c086_3) resistor r=1k
CCONVINTI_c086_3 (ConvIcar_c086_3 0) capacitor c=80p
RCONVINTQ_c086_3 (conv_q_c086_3 ConvQcar_c086_3) resistor r=1k
CCONVINTQ_c086_3 (ConvQcar_c086_3 0) capacitor c=80p
save conv_bpf_c086_3 ConvIcar_c086_3 ConvQcar_c086_3

// conventional mixed baseline bl087, carrier_0: 250000000 Hz
CCONVBPF_c087_0 (bl087 n_conv_cbpf_c087_0) capacitor c=4.052847345694e-13
LCONVBPF_c087_0 (n_conv_cbpf_c087_0 conv_bpf_c087_0) inductor l=1.000000000000e-06
RCONVBPF_c087_0 (conv_bpf_c087_0 0) resistor r=7.853981633974e+01
ECONVI_c087_0_00 (conv_i_src_c087_0_00 0 conv_bpf_c087_0 0) vcvs gain=9.807852804032e-01
SCONVI_c087_0_00 (conv_i_src_c087_0_00 conv_i_c087_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_00 (conv_q_src_c087_0_00 0 conv_bpf_c087_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_0_00 (conv_q_src_c087_0_00 conv_q_c087_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_01 (conv_i_src_c087_0_01 0 conv_bpf_c087_0 0) vcvs gain=8.314696123025e-01
SCONVI_c087_0_01 (conv_i_src_c087_0_01 conv_i_c087_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_01 (conv_q_src_c087_0_01 0 conv_bpf_c087_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_0_01 (conv_q_src_c087_0_01 conv_q_c087_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_02 (conv_i_src_c087_0_02 0 conv_bpf_c087_0 0) vcvs gain=5.555702330196e-01
SCONVI_c087_0_02 (conv_i_src_c087_0_02 conv_i_c087_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_02 (conv_q_src_c087_0_02 0 conv_bpf_c087_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_0_02 (conv_q_src_c087_0_02 conv_q_c087_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_03 (conv_i_src_c087_0_03 0 conv_bpf_c087_0 0) vcvs gain=1.950903220161e-01
SCONVI_c087_0_03 (conv_i_src_c087_0_03 conv_i_c087_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_03 (conv_q_src_c087_0_03 0 conv_bpf_c087_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_0_03 (conv_q_src_c087_0_03 conv_q_c087_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_04 (conv_i_src_c087_0_04 0 conv_bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_0_04 (conv_i_src_c087_0_04 conv_i_c087_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_04 (conv_q_src_c087_0_04 0 conv_bpf_c087_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_0_04 (conv_q_src_c087_0_04 conv_q_c087_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_05 (conv_i_src_c087_0_05 0 conv_bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_0_05 (conv_i_src_c087_0_05 conv_i_c087_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_05 (conv_q_src_c087_0_05 0 conv_bpf_c087_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_0_05 (conv_q_src_c087_0_05 conv_q_c087_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_06 (conv_i_src_c087_0_06 0 conv_bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_0_06 (conv_i_src_c087_0_06 conv_i_c087_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_06 (conv_q_src_c087_0_06 0 conv_bpf_c087_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_0_06 (conv_q_src_c087_0_06 conv_q_c087_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_07 (conv_i_src_c087_0_07 0 conv_bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_0_07 (conv_i_src_c087_0_07 conv_i_c087_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_07 (conv_q_src_c087_0_07 0 conv_bpf_c087_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_0_07 (conv_q_src_c087_0_07 conv_q_c087_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_08 (conv_i_src_c087_0_08 0 conv_bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_0_08 (conv_i_src_c087_0_08 conv_i_c087_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_08 (conv_q_src_c087_0_08 0 conv_bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_0_08 (conv_q_src_c087_0_08 conv_q_c087_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_09 (conv_i_src_c087_0_09 0 conv_bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_0_09 (conv_i_src_c087_0_09 conv_i_c087_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_09 (conv_q_src_c087_0_09 0 conv_bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_0_09 (conv_q_src_c087_0_09 conv_q_c087_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_10 (conv_i_src_c087_0_10 0 conv_bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_0_10 (conv_i_src_c087_0_10 conv_i_c087_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_10 (conv_q_src_c087_0_10 0 conv_bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_0_10 (conv_q_src_c087_0_10 conv_q_c087_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_11 (conv_i_src_c087_0_11 0 conv_bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_0_11 (conv_i_src_c087_0_11 conv_i_c087_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_11 (conv_q_src_c087_0_11 0 conv_bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_0_11 (conv_q_src_c087_0_11 conv_q_c087_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_12 (conv_i_src_c087_0_12 0 conv_bpf_c087_0 0) vcvs gain=1.950903220161e-01
SCONVI_c087_0_12 (conv_i_src_c087_0_12 conv_i_c087_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_12 (conv_q_src_c087_0_12 0 conv_bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_0_12 (conv_q_src_c087_0_12 conv_q_c087_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_13 (conv_i_src_c087_0_13 0 conv_bpf_c087_0 0) vcvs gain=5.555702330196e-01
SCONVI_c087_0_13 (conv_i_src_c087_0_13 conv_i_c087_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_13 (conv_q_src_c087_0_13 0 conv_bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_0_13 (conv_q_src_c087_0_13 conv_q_c087_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_14 (conv_i_src_c087_0_14 0 conv_bpf_c087_0 0) vcvs gain=8.314696123025e-01
SCONVI_c087_0_14 (conv_i_src_c087_0_14 conv_i_c087_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_14 (conv_q_src_c087_0_14 0 conv_bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_0_14 (conv_q_src_c087_0_14 conv_q_c087_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_0_15 (conv_i_src_c087_0_15 0 conv_bpf_c087_0 0) vcvs gain=9.807852804032e-01
SCONVI_c087_0_15 (conv_i_src_c087_0_15 conv_i_c087_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_0_15 (conv_q_src_c087_0_15 0 conv_bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_0_15 (conv_q_src_c087_0_15 conv_q_c087_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c087_0 (conv_i_c087_0 0) resistor r=1G
RCONVQ_c087_0 (conv_q_c087_0 0) resistor r=1G
RCONVINTI_c087_0 (conv_i_c087_0 ConvIcar_c087_0) resistor r=1k
CCONVINTI_c087_0 (ConvIcar_c087_0 0) capacitor c=80p
RCONVINTQ_c087_0 (conv_q_c087_0 ConvQcar_c087_0) resistor r=1k
CCONVINTQ_c087_0 (ConvQcar_c087_0 0) capacitor c=80p
save conv_bpf_c087_0 ConvIcar_c087_0 ConvQcar_c087_0

// conventional mixed baseline bl087, carrier_1: 500000000 Hz
CCONVBPF_c087_1 (bl087 n_conv_cbpf_c087_1) capacitor c=1.013211836423e-13
LCONVBPF_c087_1 (n_conv_cbpf_c087_1 conv_bpf_c087_1) inductor l=1.000000000000e-06
RCONVBPF_c087_1 (conv_bpf_c087_1 0) resistor r=1.570796326795e+02
ECONVI_c087_1_00 (conv_i_src_c087_1_00 0 conv_bpf_c087_1 0) vcvs gain=9.807852804032e-01
SCONVI_c087_1_00 (conv_i_src_c087_1_00 conv_i_c087_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_00 (conv_q_src_c087_1_00 0 conv_bpf_c087_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_1_00 (conv_q_src_c087_1_00 conv_q_c087_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_01 (conv_i_src_c087_1_01 0 conv_bpf_c087_1 0) vcvs gain=8.314696123025e-01
SCONVI_c087_1_01 (conv_i_src_c087_1_01 conv_i_c087_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_01 (conv_q_src_c087_1_01 0 conv_bpf_c087_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_1_01 (conv_q_src_c087_1_01 conv_q_c087_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_02 (conv_i_src_c087_1_02 0 conv_bpf_c087_1 0) vcvs gain=5.555702330196e-01
SCONVI_c087_1_02 (conv_i_src_c087_1_02 conv_i_c087_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_02 (conv_q_src_c087_1_02 0 conv_bpf_c087_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_1_02 (conv_q_src_c087_1_02 conv_q_c087_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_03 (conv_i_src_c087_1_03 0 conv_bpf_c087_1 0) vcvs gain=1.950903220161e-01
SCONVI_c087_1_03 (conv_i_src_c087_1_03 conv_i_c087_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_03 (conv_q_src_c087_1_03 0 conv_bpf_c087_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_1_03 (conv_q_src_c087_1_03 conv_q_c087_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_04 (conv_i_src_c087_1_04 0 conv_bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_1_04 (conv_i_src_c087_1_04 conv_i_c087_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_04 (conv_q_src_c087_1_04 0 conv_bpf_c087_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_1_04 (conv_q_src_c087_1_04 conv_q_c087_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_05 (conv_i_src_c087_1_05 0 conv_bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_1_05 (conv_i_src_c087_1_05 conv_i_c087_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_05 (conv_q_src_c087_1_05 0 conv_bpf_c087_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_1_05 (conv_q_src_c087_1_05 conv_q_c087_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_06 (conv_i_src_c087_1_06 0 conv_bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_1_06 (conv_i_src_c087_1_06 conv_i_c087_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_06 (conv_q_src_c087_1_06 0 conv_bpf_c087_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_1_06 (conv_q_src_c087_1_06 conv_q_c087_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_07 (conv_i_src_c087_1_07 0 conv_bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_1_07 (conv_i_src_c087_1_07 conv_i_c087_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_07 (conv_q_src_c087_1_07 0 conv_bpf_c087_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_1_07 (conv_q_src_c087_1_07 conv_q_c087_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_08 (conv_i_src_c087_1_08 0 conv_bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_1_08 (conv_i_src_c087_1_08 conv_i_c087_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_08 (conv_q_src_c087_1_08 0 conv_bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_1_08 (conv_q_src_c087_1_08 conv_q_c087_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_09 (conv_i_src_c087_1_09 0 conv_bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_1_09 (conv_i_src_c087_1_09 conv_i_c087_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_09 (conv_q_src_c087_1_09 0 conv_bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_1_09 (conv_q_src_c087_1_09 conv_q_c087_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_10 (conv_i_src_c087_1_10 0 conv_bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_1_10 (conv_i_src_c087_1_10 conv_i_c087_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_10 (conv_q_src_c087_1_10 0 conv_bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_1_10 (conv_q_src_c087_1_10 conv_q_c087_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_11 (conv_i_src_c087_1_11 0 conv_bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_1_11 (conv_i_src_c087_1_11 conv_i_c087_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_11 (conv_q_src_c087_1_11 0 conv_bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_1_11 (conv_q_src_c087_1_11 conv_q_c087_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_12 (conv_i_src_c087_1_12 0 conv_bpf_c087_1 0) vcvs gain=1.950903220161e-01
SCONVI_c087_1_12 (conv_i_src_c087_1_12 conv_i_c087_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_12 (conv_q_src_c087_1_12 0 conv_bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_1_12 (conv_q_src_c087_1_12 conv_q_c087_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_13 (conv_i_src_c087_1_13 0 conv_bpf_c087_1 0) vcvs gain=5.555702330196e-01
SCONVI_c087_1_13 (conv_i_src_c087_1_13 conv_i_c087_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_13 (conv_q_src_c087_1_13 0 conv_bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_1_13 (conv_q_src_c087_1_13 conv_q_c087_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_14 (conv_i_src_c087_1_14 0 conv_bpf_c087_1 0) vcvs gain=8.314696123025e-01
SCONVI_c087_1_14 (conv_i_src_c087_1_14 conv_i_c087_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_14 (conv_q_src_c087_1_14 0 conv_bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_1_14 (conv_q_src_c087_1_14 conv_q_c087_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_1_15 (conv_i_src_c087_1_15 0 conv_bpf_c087_1 0) vcvs gain=9.807852804032e-01
SCONVI_c087_1_15 (conv_i_src_c087_1_15 conv_i_c087_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_1_15 (conv_q_src_c087_1_15 0 conv_bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_1_15 (conv_q_src_c087_1_15 conv_q_c087_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c087_1 (conv_i_c087_1 0) resistor r=1G
RCONVQ_c087_1 (conv_q_c087_1 0) resistor r=1G
RCONVINTI_c087_1 (conv_i_c087_1 ConvIcar_c087_1) resistor r=1k
CCONVINTI_c087_1 (ConvIcar_c087_1 0) capacitor c=80p
RCONVINTQ_c087_1 (conv_q_c087_1 ConvQcar_c087_1) resistor r=1k
CCONVINTQ_c087_1 (ConvQcar_c087_1 0) capacitor c=80p
save conv_bpf_c087_1 ConvIcar_c087_1 ConvQcar_c087_1

// conventional mixed baseline bl087, carrier_2: 750000000 Hz
CCONVBPF_c087_2 (bl087 n_conv_cbpf_c087_2) capacitor c=4.503163717437e-14
LCONVBPF_c087_2 (n_conv_cbpf_c087_2 conv_bpf_c087_2) inductor l=1.000000000000e-06
RCONVBPF_c087_2 (conv_bpf_c087_2 0) resistor r=2.356194490192e+02
ECONVI_c087_2_00 (conv_i_src_c087_2_00 0 conv_bpf_c087_2 0) vcvs gain=9.807852804032e-01
SCONVI_c087_2_00 (conv_i_src_c087_2_00 conv_i_c087_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_00 (conv_q_src_c087_2_00 0 conv_bpf_c087_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_2_00 (conv_q_src_c087_2_00 conv_q_c087_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_01 (conv_i_src_c087_2_01 0 conv_bpf_c087_2 0) vcvs gain=8.314696123025e-01
SCONVI_c087_2_01 (conv_i_src_c087_2_01 conv_i_c087_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_01 (conv_q_src_c087_2_01 0 conv_bpf_c087_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_2_01 (conv_q_src_c087_2_01 conv_q_c087_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_02 (conv_i_src_c087_2_02 0 conv_bpf_c087_2 0) vcvs gain=5.555702330196e-01
SCONVI_c087_2_02 (conv_i_src_c087_2_02 conv_i_c087_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_02 (conv_q_src_c087_2_02 0 conv_bpf_c087_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_2_02 (conv_q_src_c087_2_02 conv_q_c087_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_03 (conv_i_src_c087_2_03 0 conv_bpf_c087_2 0) vcvs gain=1.950903220161e-01
SCONVI_c087_2_03 (conv_i_src_c087_2_03 conv_i_c087_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_03 (conv_q_src_c087_2_03 0 conv_bpf_c087_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_2_03 (conv_q_src_c087_2_03 conv_q_c087_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_04 (conv_i_src_c087_2_04 0 conv_bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_2_04 (conv_i_src_c087_2_04 conv_i_c087_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_04 (conv_q_src_c087_2_04 0 conv_bpf_c087_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_2_04 (conv_q_src_c087_2_04 conv_q_c087_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_05 (conv_i_src_c087_2_05 0 conv_bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_2_05 (conv_i_src_c087_2_05 conv_i_c087_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_05 (conv_q_src_c087_2_05 0 conv_bpf_c087_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_2_05 (conv_q_src_c087_2_05 conv_q_c087_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_06 (conv_i_src_c087_2_06 0 conv_bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_2_06 (conv_i_src_c087_2_06 conv_i_c087_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_06 (conv_q_src_c087_2_06 0 conv_bpf_c087_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_2_06 (conv_q_src_c087_2_06 conv_q_c087_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_07 (conv_i_src_c087_2_07 0 conv_bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_2_07 (conv_i_src_c087_2_07 conv_i_c087_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_07 (conv_q_src_c087_2_07 0 conv_bpf_c087_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_2_07 (conv_q_src_c087_2_07 conv_q_c087_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_08 (conv_i_src_c087_2_08 0 conv_bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_2_08 (conv_i_src_c087_2_08 conv_i_c087_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_08 (conv_q_src_c087_2_08 0 conv_bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_2_08 (conv_q_src_c087_2_08 conv_q_c087_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_09 (conv_i_src_c087_2_09 0 conv_bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_2_09 (conv_i_src_c087_2_09 conv_i_c087_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_09 (conv_q_src_c087_2_09 0 conv_bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_2_09 (conv_q_src_c087_2_09 conv_q_c087_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_10 (conv_i_src_c087_2_10 0 conv_bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_2_10 (conv_i_src_c087_2_10 conv_i_c087_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_10 (conv_q_src_c087_2_10 0 conv_bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_2_10 (conv_q_src_c087_2_10 conv_q_c087_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_11 (conv_i_src_c087_2_11 0 conv_bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_2_11 (conv_i_src_c087_2_11 conv_i_c087_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_11 (conv_q_src_c087_2_11 0 conv_bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_2_11 (conv_q_src_c087_2_11 conv_q_c087_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_12 (conv_i_src_c087_2_12 0 conv_bpf_c087_2 0) vcvs gain=1.950903220161e-01
SCONVI_c087_2_12 (conv_i_src_c087_2_12 conv_i_c087_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_12 (conv_q_src_c087_2_12 0 conv_bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_2_12 (conv_q_src_c087_2_12 conv_q_c087_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_13 (conv_i_src_c087_2_13 0 conv_bpf_c087_2 0) vcvs gain=5.555702330196e-01
SCONVI_c087_2_13 (conv_i_src_c087_2_13 conv_i_c087_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_13 (conv_q_src_c087_2_13 0 conv_bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_2_13 (conv_q_src_c087_2_13 conv_q_c087_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_14 (conv_i_src_c087_2_14 0 conv_bpf_c087_2 0) vcvs gain=8.314696123025e-01
SCONVI_c087_2_14 (conv_i_src_c087_2_14 conv_i_c087_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_14 (conv_q_src_c087_2_14 0 conv_bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_2_14 (conv_q_src_c087_2_14 conv_q_c087_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_2_15 (conv_i_src_c087_2_15 0 conv_bpf_c087_2 0) vcvs gain=9.807852804032e-01
SCONVI_c087_2_15 (conv_i_src_c087_2_15 conv_i_c087_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_2_15 (conv_q_src_c087_2_15 0 conv_bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_2_15 (conv_q_src_c087_2_15 conv_q_c087_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c087_2 (conv_i_c087_2 0) resistor r=1G
RCONVQ_c087_2 (conv_q_c087_2 0) resistor r=1G
RCONVINTI_c087_2 (conv_i_c087_2 ConvIcar_c087_2) resistor r=1k
CCONVINTI_c087_2 (ConvIcar_c087_2 0) capacitor c=80p
RCONVINTQ_c087_2 (conv_q_c087_2 ConvQcar_c087_2) resistor r=1k
CCONVINTQ_c087_2 (ConvQcar_c087_2 0) capacitor c=80p
save conv_bpf_c087_2 ConvIcar_c087_2 ConvQcar_c087_2

// conventional mixed baseline bl087, carrier_3: 1000000000 Hz
CCONVBPF_c087_3 (bl087 n_conv_cbpf_c087_3) capacitor c=2.533029591058e-14
LCONVBPF_c087_3 (n_conv_cbpf_c087_3 conv_bpf_c087_3) inductor l=1.000000000000e-06
RCONVBPF_c087_3 (conv_bpf_c087_3 0) resistor r=3.141592653590e+02
ECONVI_c087_3_00 (conv_i_src_c087_3_00 0 conv_bpf_c087_3 0) vcvs gain=9.807852804032e-01
SCONVI_c087_3_00 (conv_i_src_c087_3_00 conv_i_c087_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_00 (conv_q_src_c087_3_00 0 conv_bpf_c087_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_3_00 (conv_q_src_c087_3_00 conv_q_c087_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_01 (conv_i_src_c087_3_01 0 conv_bpf_c087_3 0) vcvs gain=8.314696123025e-01
SCONVI_c087_3_01 (conv_i_src_c087_3_01 conv_i_c087_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_01 (conv_q_src_c087_3_01 0 conv_bpf_c087_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_3_01 (conv_q_src_c087_3_01 conv_q_c087_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_02 (conv_i_src_c087_3_02 0 conv_bpf_c087_3 0) vcvs gain=5.555702330196e-01
SCONVI_c087_3_02 (conv_i_src_c087_3_02 conv_i_c087_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_02 (conv_q_src_c087_3_02 0 conv_bpf_c087_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_3_02 (conv_q_src_c087_3_02 conv_q_c087_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_03 (conv_i_src_c087_3_03 0 conv_bpf_c087_3 0) vcvs gain=1.950903220161e-01
SCONVI_c087_3_03 (conv_i_src_c087_3_03 conv_i_c087_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_03 (conv_q_src_c087_3_03 0 conv_bpf_c087_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_3_03 (conv_q_src_c087_3_03 conv_q_c087_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_04 (conv_i_src_c087_3_04 0 conv_bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_3_04 (conv_i_src_c087_3_04 conv_i_c087_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_04 (conv_q_src_c087_3_04 0 conv_bpf_c087_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c087_3_04 (conv_q_src_c087_3_04 conv_q_c087_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_05 (conv_i_src_c087_3_05 0 conv_bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_3_05 (conv_i_src_c087_3_05 conv_i_c087_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_05 (conv_q_src_c087_3_05 0 conv_bpf_c087_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c087_3_05 (conv_q_src_c087_3_05 conv_q_c087_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_06 (conv_i_src_c087_3_06 0 conv_bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_3_06 (conv_i_src_c087_3_06 conv_i_c087_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_06 (conv_q_src_c087_3_06 0 conv_bpf_c087_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c087_3_06 (conv_q_src_c087_3_06 conv_q_c087_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_07 (conv_i_src_c087_3_07 0 conv_bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_3_07 (conv_i_src_c087_3_07 conv_i_c087_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_07 (conv_q_src_c087_3_07 0 conv_bpf_c087_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c087_3_07 (conv_q_src_c087_3_07 conv_q_c087_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_08 (conv_i_src_c087_3_08 0 conv_bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c087_3_08 (conv_i_src_c087_3_08 conv_i_c087_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_08 (conv_q_src_c087_3_08 0 conv_bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_3_08 (conv_q_src_c087_3_08 conv_q_c087_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_09 (conv_i_src_c087_3_09 0 conv_bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c087_3_09 (conv_i_src_c087_3_09 conv_i_c087_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_09 (conv_q_src_c087_3_09 0 conv_bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_3_09 (conv_q_src_c087_3_09 conv_q_c087_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_10 (conv_i_src_c087_3_10 0 conv_bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c087_3_10 (conv_i_src_c087_3_10 conv_i_c087_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_10 (conv_q_src_c087_3_10 0 conv_bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_3_10 (conv_q_src_c087_3_10 conv_q_c087_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_11 (conv_i_src_c087_3_11 0 conv_bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c087_3_11 (conv_i_src_c087_3_11 conv_i_c087_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_11 (conv_q_src_c087_3_11 0 conv_bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_3_11 (conv_q_src_c087_3_11 conv_q_c087_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_12 (conv_i_src_c087_3_12 0 conv_bpf_c087_3 0) vcvs gain=1.950903220161e-01
SCONVI_c087_3_12 (conv_i_src_c087_3_12 conv_i_c087_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_12 (conv_q_src_c087_3_12 0 conv_bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c087_3_12 (conv_q_src_c087_3_12 conv_q_c087_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_13 (conv_i_src_c087_3_13 0 conv_bpf_c087_3 0) vcvs gain=5.555702330196e-01
SCONVI_c087_3_13 (conv_i_src_c087_3_13 conv_i_c087_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_13 (conv_q_src_c087_3_13 0 conv_bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c087_3_13 (conv_q_src_c087_3_13 conv_q_c087_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_14 (conv_i_src_c087_3_14 0 conv_bpf_c087_3 0) vcvs gain=8.314696123025e-01
SCONVI_c087_3_14 (conv_i_src_c087_3_14 conv_i_c087_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_14 (conv_q_src_c087_3_14 0 conv_bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c087_3_14 (conv_q_src_c087_3_14 conv_q_c087_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c087_3_15 (conv_i_src_c087_3_15 0 conv_bpf_c087_3 0) vcvs gain=9.807852804032e-01
SCONVI_c087_3_15 (conv_i_src_c087_3_15 conv_i_c087_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c087_3_15 (conv_q_src_c087_3_15 0 conv_bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c087_3_15 (conv_q_src_c087_3_15 conv_q_c087_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c087_3 (conv_i_c087_3 0) resistor r=1G
RCONVQ_c087_3 (conv_q_c087_3 0) resistor r=1G
RCONVINTI_c087_3 (conv_i_c087_3 ConvIcar_c087_3) resistor r=1k
CCONVINTI_c087_3 (ConvIcar_c087_3 0) capacitor c=80p
RCONVINTQ_c087_3 (conv_q_c087_3 ConvQcar_c087_3) resistor r=1k
CCONVINTQ_c087_3 (ConvQcar_c087_3 0) capacitor c=80p
save conv_bpf_c087_3 ConvIcar_c087_3 ConvQcar_c087_3

// conventional mixed baseline bl088, carrier_0: 250000000 Hz
CCONVBPF_c088_0 (bl088 n_conv_cbpf_c088_0) capacitor c=4.052847345694e-13
LCONVBPF_c088_0 (n_conv_cbpf_c088_0 conv_bpf_c088_0) inductor l=1.000000000000e-06
RCONVBPF_c088_0 (conv_bpf_c088_0 0) resistor r=7.853981633974e+01
ECONVI_c088_0_00 (conv_i_src_c088_0_00 0 conv_bpf_c088_0 0) vcvs gain=9.807852804032e-01
SCONVI_c088_0_00 (conv_i_src_c088_0_00 conv_i_c088_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_00 (conv_q_src_c088_0_00 0 conv_bpf_c088_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_0_00 (conv_q_src_c088_0_00 conv_q_c088_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_01 (conv_i_src_c088_0_01 0 conv_bpf_c088_0 0) vcvs gain=8.314696123025e-01
SCONVI_c088_0_01 (conv_i_src_c088_0_01 conv_i_c088_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_01 (conv_q_src_c088_0_01 0 conv_bpf_c088_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_0_01 (conv_q_src_c088_0_01 conv_q_c088_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_02 (conv_i_src_c088_0_02 0 conv_bpf_c088_0 0) vcvs gain=5.555702330196e-01
SCONVI_c088_0_02 (conv_i_src_c088_0_02 conv_i_c088_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_02 (conv_q_src_c088_0_02 0 conv_bpf_c088_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_0_02 (conv_q_src_c088_0_02 conv_q_c088_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_03 (conv_i_src_c088_0_03 0 conv_bpf_c088_0 0) vcvs gain=1.950903220161e-01
SCONVI_c088_0_03 (conv_i_src_c088_0_03 conv_i_c088_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_03 (conv_q_src_c088_0_03 0 conv_bpf_c088_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_0_03 (conv_q_src_c088_0_03 conv_q_c088_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_04 (conv_i_src_c088_0_04 0 conv_bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_0_04 (conv_i_src_c088_0_04 conv_i_c088_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_04 (conv_q_src_c088_0_04 0 conv_bpf_c088_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_0_04 (conv_q_src_c088_0_04 conv_q_c088_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_05 (conv_i_src_c088_0_05 0 conv_bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_0_05 (conv_i_src_c088_0_05 conv_i_c088_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_05 (conv_q_src_c088_0_05 0 conv_bpf_c088_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_0_05 (conv_q_src_c088_0_05 conv_q_c088_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_06 (conv_i_src_c088_0_06 0 conv_bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_0_06 (conv_i_src_c088_0_06 conv_i_c088_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_06 (conv_q_src_c088_0_06 0 conv_bpf_c088_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_0_06 (conv_q_src_c088_0_06 conv_q_c088_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_07 (conv_i_src_c088_0_07 0 conv_bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_0_07 (conv_i_src_c088_0_07 conv_i_c088_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_07 (conv_q_src_c088_0_07 0 conv_bpf_c088_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_0_07 (conv_q_src_c088_0_07 conv_q_c088_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_08 (conv_i_src_c088_0_08 0 conv_bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_0_08 (conv_i_src_c088_0_08 conv_i_c088_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_08 (conv_q_src_c088_0_08 0 conv_bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_0_08 (conv_q_src_c088_0_08 conv_q_c088_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_09 (conv_i_src_c088_0_09 0 conv_bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_0_09 (conv_i_src_c088_0_09 conv_i_c088_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_09 (conv_q_src_c088_0_09 0 conv_bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_0_09 (conv_q_src_c088_0_09 conv_q_c088_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_10 (conv_i_src_c088_0_10 0 conv_bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_0_10 (conv_i_src_c088_0_10 conv_i_c088_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_10 (conv_q_src_c088_0_10 0 conv_bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_0_10 (conv_q_src_c088_0_10 conv_q_c088_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_11 (conv_i_src_c088_0_11 0 conv_bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_0_11 (conv_i_src_c088_0_11 conv_i_c088_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_11 (conv_q_src_c088_0_11 0 conv_bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_0_11 (conv_q_src_c088_0_11 conv_q_c088_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_12 (conv_i_src_c088_0_12 0 conv_bpf_c088_0 0) vcvs gain=1.950903220161e-01
SCONVI_c088_0_12 (conv_i_src_c088_0_12 conv_i_c088_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_12 (conv_q_src_c088_0_12 0 conv_bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_0_12 (conv_q_src_c088_0_12 conv_q_c088_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_13 (conv_i_src_c088_0_13 0 conv_bpf_c088_0 0) vcvs gain=5.555702330196e-01
SCONVI_c088_0_13 (conv_i_src_c088_0_13 conv_i_c088_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_13 (conv_q_src_c088_0_13 0 conv_bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_0_13 (conv_q_src_c088_0_13 conv_q_c088_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_14 (conv_i_src_c088_0_14 0 conv_bpf_c088_0 0) vcvs gain=8.314696123025e-01
SCONVI_c088_0_14 (conv_i_src_c088_0_14 conv_i_c088_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_14 (conv_q_src_c088_0_14 0 conv_bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_0_14 (conv_q_src_c088_0_14 conv_q_c088_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_0_15 (conv_i_src_c088_0_15 0 conv_bpf_c088_0 0) vcvs gain=9.807852804032e-01
SCONVI_c088_0_15 (conv_i_src_c088_0_15 conv_i_c088_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_0_15 (conv_q_src_c088_0_15 0 conv_bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_0_15 (conv_q_src_c088_0_15 conv_q_c088_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c088_0 (conv_i_c088_0 0) resistor r=1G
RCONVQ_c088_0 (conv_q_c088_0 0) resistor r=1G
RCONVINTI_c088_0 (conv_i_c088_0 ConvIcar_c088_0) resistor r=1k
CCONVINTI_c088_0 (ConvIcar_c088_0 0) capacitor c=80p
RCONVINTQ_c088_0 (conv_q_c088_0 ConvQcar_c088_0) resistor r=1k
CCONVINTQ_c088_0 (ConvQcar_c088_0 0) capacitor c=80p
save conv_bpf_c088_0 ConvIcar_c088_0 ConvQcar_c088_0

// conventional mixed baseline bl088, carrier_1: 500000000 Hz
CCONVBPF_c088_1 (bl088 n_conv_cbpf_c088_1) capacitor c=1.013211836423e-13
LCONVBPF_c088_1 (n_conv_cbpf_c088_1 conv_bpf_c088_1) inductor l=1.000000000000e-06
RCONVBPF_c088_1 (conv_bpf_c088_1 0) resistor r=1.570796326795e+02
ECONVI_c088_1_00 (conv_i_src_c088_1_00 0 conv_bpf_c088_1 0) vcvs gain=9.807852804032e-01
SCONVI_c088_1_00 (conv_i_src_c088_1_00 conv_i_c088_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_00 (conv_q_src_c088_1_00 0 conv_bpf_c088_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_1_00 (conv_q_src_c088_1_00 conv_q_c088_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_01 (conv_i_src_c088_1_01 0 conv_bpf_c088_1 0) vcvs gain=8.314696123025e-01
SCONVI_c088_1_01 (conv_i_src_c088_1_01 conv_i_c088_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_01 (conv_q_src_c088_1_01 0 conv_bpf_c088_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_1_01 (conv_q_src_c088_1_01 conv_q_c088_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_02 (conv_i_src_c088_1_02 0 conv_bpf_c088_1 0) vcvs gain=5.555702330196e-01
SCONVI_c088_1_02 (conv_i_src_c088_1_02 conv_i_c088_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_02 (conv_q_src_c088_1_02 0 conv_bpf_c088_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_1_02 (conv_q_src_c088_1_02 conv_q_c088_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_03 (conv_i_src_c088_1_03 0 conv_bpf_c088_1 0) vcvs gain=1.950903220161e-01
SCONVI_c088_1_03 (conv_i_src_c088_1_03 conv_i_c088_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_03 (conv_q_src_c088_1_03 0 conv_bpf_c088_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_1_03 (conv_q_src_c088_1_03 conv_q_c088_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_04 (conv_i_src_c088_1_04 0 conv_bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_1_04 (conv_i_src_c088_1_04 conv_i_c088_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_04 (conv_q_src_c088_1_04 0 conv_bpf_c088_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_1_04 (conv_q_src_c088_1_04 conv_q_c088_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_05 (conv_i_src_c088_1_05 0 conv_bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_1_05 (conv_i_src_c088_1_05 conv_i_c088_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_05 (conv_q_src_c088_1_05 0 conv_bpf_c088_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_1_05 (conv_q_src_c088_1_05 conv_q_c088_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_06 (conv_i_src_c088_1_06 0 conv_bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_1_06 (conv_i_src_c088_1_06 conv_i_c088_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_06 (conv_q_src_c088_1_06 0 conv_bpf_c088_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_1_06 (conv_q_src_c088_1_06 conv_q_c088_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_07 (conv_i_src_c088_1_07 0 conv_bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_1_07 (conv_i_src_c088_1_07 conv_i_c088_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_07 (conv_q_src_c088_1_07 0 conv_bpf_c088_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_1_07 (conv_q_src_c088_1_07 conv_q_c088_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_08 (conv_i_src_c088_1_08 0 conv_bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_1_08 (conv_i_src_c088_1_08 conv_i_c088_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_08 (conv_q_src_c088_1_08 0 conv_bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_1_08 (conv_q_src_c088_1_08 conv_q_c088_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_09 (conv_i_src_c088_1_09 0 conv_bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_1_09 (conv_i_src_c088_1_09 conv_i_c088_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_09 (conv_q_src_c088_1_09 0 conv_bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_1_09 (conv_q_src_c088_1_09 conv_q_c088_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_10 (conv_i_src_c088_1_10 0 conv_bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_1_10 (conv_i_src_c088_1_10 conv_i_c088_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_10 (conv_q_src_c088_1_10 0 conv_bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_1_10 (conv_q_src_c088_1_10 conv_q_c088_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_11 (conv_i_src_c088_1_11 0 conv_bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_1_11 (conv_i_src_c088_1_11 conv_i_c088_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_11 (conv_q_src_c088_1_11 0 conv_bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_1_11 (conv_q_src_c088_1_11 conv_q_c088_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_12 (conv_i_src_c088_1_12 0 conv_bpf_c088_1 0) vcvs gain=1.950903220161e-01
SCONVI_c088_1_12 (conv_i_src_c088_1_12 conv_i_c088_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_12 (conv_q_src_c088_1_12 0 conv_bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_1_12 (conv_q_src_c088_1_12 conv_q_c088_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_13 (conv_i_src_c088_1_13 0 conv_bpf_c088_1 0) vcvs gain=5.555702330196e-01
SCONVI_c088_1_13 (conv_i_src_c088_1_13 conv_i_c088_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_13 (conv_q_src_c088_1_13 0 conv_bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_1_13 (conv_q_src_c088_1_13 conv_q_c088_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_14 (conv_i_src_c088_1_14 0 conv_bpf_c088_1 0) vcvs gain=8.314696123025e-01
SCONVI_c088_1_14 (conv_i_src_c088_1_14 conv_i_c088_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_14 (conv_q_src_c088_1_14 0 conv_bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_1_14 (conv_q_src_c088_1_14 conv_q_c088_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_1_15 (conv_i_src_c088_1_15 0 conv_bpf_c088_1 0) vcvs gain=9.807852804032e-01
SCONVI_c088_1_15 (conv_i_src_c088_1_15 conv_i_c088_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_1_15 (conv_q_src_c088_1_15 0 conv_bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_1_15 (conv_q_src_c088_1_15 conv_q_c088_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c088_1 (conv_i_c088_1 0) resistor r=1G
RCONVQ_c088_1 (conv_q_c088_1 0) resistor r=1G
RCONVINTI_c088_1 (conv_i_c088_1 ConvIcar_c088_1) resistor r=1k
CCONVINTI_c088_1 (ConvIcar_c088_1 0) capacitor c=80p
RCONVINTQ_c088_1 (conv_q_c088_1 ConvQcar_c088_1) resistor r=1k
CCONVINTQ_c088_1 (ConvQcar_c088_1 0) capacitor c=80p
save conv_bpf_c088_1 ConvIcar_c088_1 ConvQcar_c088_1

// conventional mixed baseline bl088, carrier_2: 750000000 Hz
CCONVBPF_c088_2 (bl088 n_conv_cbpf_c088_2) capacitor c=4.503163717437e-14
LCONVBPF_c088_2 (n_conv_cbpf_c088_2 conv_bpf_c088_2) inductor l=1.000000000000e-06
RCONVBPF_c088_2 (conv_bpf_c088_2 0) resistor r=2.356194490192e+02
ECONVI_c088_2_00 (conv_i_src_c088_2_00 0 conv_bpf_c088_2 0) vcvs gain=9.807852804032e-01
SCONVI_c088_2_00 (conv_i_src_c088_2_00 conv_i_c088_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_00 (conv_q_src_c088_2_00 0 conv_bpf_c088_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_2_00 (conv_q_src_c088_2_00 conv_q_c088_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_01 (conv_i_src_c088_2_01 0 conv_bpf_c088_2 0) vcvs gain=8.314696123025e-01
SCONVI_c088_2_01 (conv_i_src_c088_2_01 conv_i_c088_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_01 (conv_q_src_c088_2_01 0 conv_bpf_c088_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_2_01 (conv_q_src_c088_2_01 conv_q_c088_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_02 (conv_i_src_c088_2_02 0 conv_bpf_c088_2 0) vcvs gain=5.555702330196e-01
SCONVI_c088_2_02 (conv_i_src_c088_2_02 conv_i_c088_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_02 (conv_q_src_c088_2_02 0 conv_bpf_c088_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_2_02 (conv_q_src_c088_2_02 conv_q_c088_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_03 (conv_i_src_c088_2_03 0 conv_bpf_c088_2 0) vcvs gain=1.950903220161e-01
SCONVI_c088_2_03 (conv_i_src_c088_2_03 conv_i_c088_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_03 (conv_q_src_c088_2_03 0 conv_bpf_c088_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_2_03 (conv_q_src_c088_2_03 conv_q_c088_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_04 (conv_i_src_c088_2_04 0 conv_bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_2_04 (conv_i_src_c088_2_04 conv_i_c088_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_04 (conv_q_src_c088_2_04 0 conv_bpf_c088_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_2_04 (conv_q_src_c088_2_04 conv_q_c088_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_05 (conv_i_src_c088_2_05 0 conv_bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_2_05 (conv_i_src_c088_2_05 conv_i_c088_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_05 (conv_q_src_c088_2_05 0 conv_bpf_c088_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_2_05 (conv_q_src_c088_2_05 conv_q_c088_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_06 (conv_i_src_c088_2_06 0 conv_bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_2_06 (conv_i_src_c088_2_06 conv_i_c088_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_06 (conv_q_src_c088_2_06 0 conv_bpf_c088_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_2_06 (conv_q_src_c088_2_06 conv_q_c088_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_07 (conv_i_src_c088_2_07 0 conv_bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_2_07 (conv_i_src_c088_2_07 conv_i_c088_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_07 (conv_q_src_c088_2_07 0 conv_bpf_c088_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_2_07 (conv_q_src_c088_2_07 conv_q_c088_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_08 (conv_i_src_c088_2_08 0 conv_bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_2_08 (conv_i_src_c088_2_08 conv_i_c088_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_08 (conv_q_src_c088_2_08 0 conv_bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_2_08 (conv_q_src_c088_2_08 conv_q_c088_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_09 (conv_i_src_c088_2_09 0 conv_bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_2_09 (conv_i_src_c088_2_09 conv_i_c088_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_09 (conv_q_src_c088_2_09 0 conv_bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_2_09 (conv_q_src_c088_2_09 conv_q_c088_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_10 (conv_i_src_c088_2_10 0 conv_bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_2_10 (conv_i_src_c088_2_10 conv_i_c088_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_10 (conv_q_src_c088_2_10 0 conv_bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_2_10 (conv_q_src_c088_2_10 conv_q_c088_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_11 (conv_i_src_c088_2_11 0 conv_bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_2_11 (conv_i_src_c088_2_11 conv_i_c088_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_11 (conv_q_src_c088_2_11 0 conv_bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_2_11 (conv_q_src_c088_2_11 conv_q_c088_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_12 (conv_i_src_c088_2_12 0 conv_bpf_c088_2 0) vcvs gain=1.950903220161e-01
SCONVI_c088_2_12 (conv_i_src_c088_2_12 conv_i_c088_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_12 (conv_q_src_c088_2_12 0 conv_bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_2_12 (conv_q_src_c088_2_12 conv_q_c088_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_13 (conv_i_src_c088_2_13 0 conv_bpf_c088_2 0) vcvs gain=5.555702330196e-01
SCONVI_c088_2_13 (conv_i_src_c088_2_13 conv_i_c088_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_13 (conv_q_src_c088_2_13 0 conv_bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_2_13 (conv_q_src_c088_2_13 conv_q_c088_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_14 (conv_i_src_c088_2_14 0 conv_bpf_c088_2 0) vcvs gain=8.314696123025e-01
SCONVI_c088_2_14 (conv_i_src_c088_2_14 conv_i_c088_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_14 (conv_q_src_c088_2_14 0 conv_bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_2_14 (conv_q_src_c088_2_14 conv_q_c088_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_2_15 (conv_i_src_c088_2_15 0 conv_bpf_c088_2 0) vcvs gain=9.807852804032e-01
SCONVI_c088_2_15 (conv_i_src_c088_2_15 conv_i_c088_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_2_15 (conv_q_src_c088_2_15 0 conv_bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_2_15 (conv_q_src_c088_2_15 conv_q_c088_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c088_2 (conv_i_c088_2 0) resistor r=1G
RCONVQ_c088_2 (conv_q_c088_2 0) resistor r=1G
RCONVINTI_c088_2 (conv_i_c088_2 ConvIcar_c088_2) resistor r=1k
CCONVINTI_c088_2 (ConvIcar_c088_2 0) capacitor c=80p
RCONVINTQ_c088_2 (conv_q_c088_2 ConvQcar_c088_2) resistor r=1k
CCONVINTQ_c088_2 (ConvQcar_c088_2 0) capacitor c=80p
save conv_bpf_c088_2 ConvIcar_c088_2 ConvQcar_c088_2

// conventional mixed baseline bl088, carrier_3: 1000000000 Hz
CCONVBPF_c088_3 (bl088 n_conv_cbpf_c088_3) capacitor c=2.533029591058e-14
LCONVBPF_c088_3 (n_conv_cbpf_c088_3 conv_bpf_c088_3) inductor l=1.000000000000e-06
RCONVBPF_c088_3 (conv_bpf_c088_3 0) resistor r=3.141592653590e+02
ECONVI_c088_3_00 (conv_i_src_c088_3_00 0 conv_bpf_c088_3 0) vcvs gain=9.807852804032e-01
SCONVI_c088_3_00 (conv_i_src_c088_3_00 conv_i_c088_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_00 (conv_q_src_c088_3_00 0 conv_bpf_c088_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_3_00 (conv_q_src_c088_3_00 conv_q_c088_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_01 (conv_i_src_c088_3_01 0 conv_bpf_c088_3 0) vcvs gain=8.314696123025e-01
SCONVI_c088_3_01 (conv_i_src_c088_3_01 conv_i_c088_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_01 (conv_q_src_c088_3_01 0 conv_bpf_c088_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_3_01 (conv_q_src_c088_3_01 conv_q_c088_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_02 (conv_i_src_c088_3_02 0 conv_bpf_c088_3 0) vcvs gain=5.555702330196e-01
SCONVI_c088_3_02 (conv_i_src_c088_3_02 conv_i_c088_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_02 (conv_q_src_c088_3_02 0 conv_bpf_c088_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_3_02 (conv_q_src_c088_3_02 conv_q_c088_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_03 (conv_i_src_c088_3_03 0 conv_bpf_c088_3 0) vcvs gain=1.950903220161e-01
SCONVI_c088_3_03 (conv_i_src_c088_3_03 conv_i_c088_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_03 (conv_q_src_c088_3_03 0 conv_bpf_c088_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_3_03 (conv_q_src_c088_3_03 conv_q_c088_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_04 (conv_i_src_c088_3_04 0 conv_bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_3_04 (conv_i_src_c088_3_04 conv_i_c088_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_04 (conv_q_src_c088_3_04 0 conv_bpf_c088_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c088_3_04 (conv_q_src_c088_3_04 conv_q_c088_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_05 (conv_i_src_c088_3_05 0 conv_bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_3_05 (conv_i_src_c088_3_05 conv_i_c088_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_05 (conv_q_src_c088_3_05 0 conv_bpf_c088_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c088_3_05 (conv_q_src_c088_3_05 conv_q_c088_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_06 (conv_i_src_c088_3_06 0 conv_bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_3_06 (conv_i_src_c088_3_06 conv_i_c088_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_06 (conv_q_src_c088_3_06 0 conv_bpf_c088_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c088_3_06 (conv_q_src_c088_3_06 conv_q_c088_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_07 (conv_i_src_c088_3_07 0 conv_bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_3_07 (conv_i_src_c088_3_07 conv_i_c088_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_07 (conv_q_src_c088_3_07 0 conv_bpf_c088_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c088_3_07 (conv_q_src_c088_3_07 conv_q_c088_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_08 (conv_i_src_c088_3_08 0 conv_bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c088_3_08 (conv_i_src_c088_3_08 conv_i_c088_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_08 (conv_q_src_c088_3_08 0 conv_bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_3_08 (conv_q_src_c088_3_08 conv_q_c088_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_09 (conv_i_src_c088_3_09 0 conv_bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c088_3_09 (conv_i_src_c088_3_09 conv_i_c088_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_09 (conv_q_src_c088_3_09 0 conv_bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_3_09 (conv_q_src_c088_3_09 conv_q_c088_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_10 (conv_i_src_c088_3_10 0 conv_bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c088_3_10 (conv_i_src_c088_3_10 conv_i_c088_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_10 (conv_q_src_c088_3_10 0 conv_bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_3_10 (conv_q_src_c088_3_10 conv_q_c088_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_11 (conv_i_src_c088_3_11 0 conv_bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c088_3_11 (conv_i_src_c088_3_11 conv_i_c088_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_11 (conv_q_src_c088_3_11 0 conv_bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_3_11 (conv_q_src_c088_3_11 conv_q_c088_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_12 (conv_i_src_c088_3_12 0 conv_bpf_c088_3 0) vcvs gain=1.950903220161e-01
SCONVI_c088_3_12 (conv_i_src_c088_3_12 conv_i_c088_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_12 (conv_q_src_c088_3_12 0 conv_bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c088_3_12 (conv_q_src_c088_3_12 conv_q_c088_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_13 (conv_i_src_c088_3_13 0 conv_bpf_c088_3 0) vcvs gain=5.555702330196e-01
SCONVI_c088_3_13 (conv_i_src_c088_3_13 conv_i_c088_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_13 (conv_q_src_c088_3_13 0 conv_bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c088_3_13 (conv_q_src_c088_3_13 conv_q_c088_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_14 (conv_i_src_c088_3_14 0 conv_bpf_c088_3 0) vcvs gain=8.314696123025e-01
SCONVI_c088_3_14 (conv_i_src_c088_3_14 conv_i_c088_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_14 (conv_q_src_c088_3_14 0 conv_bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c088_3_14 (conv_q_src_c088_3_14 conv_q_c088_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c088_3_15 (conv_i_src_c088_3_15 0 conv_bpf_c088_3 0) vcvs gain=9.807852804032e-01
SCONVI_c088_3_15 (conv_i_src_c088_3_15 conv_i_c088_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c088_3_15 (conv_q_src_c088_3_15 0 conv_bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c088_3_15 (conv_q_src_c088_3_15 conv_q_c088_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c088_3 (conv_i_c088_3 0) resistor r=1G
RCONVQ_c088_3 (conv_q_c088_3 0) resistor r=1G
RCONVINTI_c088_3 (conv_i_c088_3 ConvIcar_c088_3) resistor r=1k
CCONVINTI_c088_3 (ConvIcar_c088_3 0) capacitor c=80p
RCONVINTQ_c088_3 (conv_q_c088_3 ConvQcar_c088_3) resistor r=1k
CCONVINTQ_c088_3 (ConvQcar_c088_3 0) capacitor c=80p
save conv_bpf_c088_3 ConvIcar_c088_3 ConvQcar_c088_3

// conventional mixed baseline bl089, carrier_0: 250000000 Hz
CCONVBPF_c089_0 (bl089 n_conv_cbpf_c089_0) capacitor c=4.052847345694e-13
LCONVBPF_c089_0 (n_conv_cbpf_c089_0 conv_bpf_c089_0) inductor l=1.000000000000e-06
RCONVBPF_c089_0 (conv_bpf_c089_0 0) resistor r=7.853981633974e+01
ECONVI_c089_0_00 (conv_i_src_c089_0_00 0 conv_bpf_c089_0 0) vcvs gain=9.807852804032e-01
SCONVI_c089_0_00 (conv_i_src_c089_0_00 conv_i_c089_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_00 (conv_q_src_c089_0_00 0 conv_bpf_c089_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_0_00 (conv_q_src_c089_0_00 conv_q_c089_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_01 (conv_i_src_c089_0_01 0 conv_bpf_c089_0 0) vcvs gain=8.314696123025e-01
SCONVI_c089_0_01 (conv_i_src_c089_0_01 conv_i_c089_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_01 (conv_q_src_c089_0_01 0 conv_bpf_c089_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_0_01 (conv_q_src_c089_0_01 conv_q_c089_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_02 (conv_i_src_c089_0_02 0 conv_bpf_c089_0 0) vcvs gain=5.555702330196e-01
SCONVI_c089_0_02 (conv_i_src_c089_0_02 conv_i_c089_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_02 (conv_q_src_c089_0_02 0 conv_bpf_c089_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_0_02 (conv_q_src_c089_0_02 conv_q_c089_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_03 (conv_i_src_c089_0_03 0 conv_bpf_c089_0 0) vcvs gain=1.950903220161e-01
SCONVI_c089_0_03 (conv_i_src_c089_0_03 conv_i_c089_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_03 (conv_q_src_c089_0_03 0 conv_bpf_c089_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_0_03 (conv_q_src_c089_0_03 conv_q_c089_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_04 (conv_i_src_c089_0_04 0 conv_bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_0_04 (conv_i_src_c089_0_04 conv_i_c089_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_04 (conv_q_src_c089_0_04 0 conv_bpf_c089_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_0_04 (conv_q_src_c089_0_04 conv_q_c089_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_05 (conv_i_src_c089_0_05 0 conv_bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_0_05 (conv_i_src_c089_0_05 conv_i_c089_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_05 (conv_q_src_c089_0_05 0 conv_bpf_c089_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_0_05 (conv_q_src_c089_0_05 conv_q_c089_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_06 (conv_i_src_c089_0_06 0 conv_bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_0_06 (conv_i_src_c089_0_06 conv_i_c089_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_06 (conv_q_src_c089_0_06 0 conv_bpf_c089_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_0_06 (conv_q_src_c089_0_06 conv_q_c089_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_07 (conv_i_src_c089_0_07 0 conv_bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_0_07 (conv_i_src_c089_0_07 conv_i_c089_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_07 (conv_q_src_c089_0_07 0 conv_bpf_c089_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_0_07 (conv_q_src_c089_0_07 conv_q_c089_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_08 (conv_i_src_c089_0_08 0 conv_bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_0_08 (conv_i_src_c089_0_08 conv_i_c089_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_08 (conv_q_src_c089_0_08 0 conv_bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_0_08 (conv_q_src_c089_0_08 conv_q_c089_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_09 (conv_i_src_c089_0_09 0 conv_bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_0_09 (conv_i_src_c089_0_09 conv_i_c089_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_09 (conv_q_src_c089_0_09 0 conv_bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_0_09 (conv_q_src_c089_0_09 conv_q_c089_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_10 (conv_i_src_c089_0_10 0 conv_bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_0_10 (conv_i_src_c089_0_10 conv_i_c089_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_10 (conv_q_src_c089_0_10 0 conv_bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_0_10 (conv_q_src_c089_0_10 conv_q_c089_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_11 (conv_i_src_c089_0_11 0 conv_bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_0_11 (conv_i_src_c089_0_11 conv_i_c089_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_11 (conv_q_src_c089_0_11 0 conv_bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_0_11 (conv_q_src_c089_0_11 conv_q_c089_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_12 (conv_i_src_c089_0_12 0 conv_bpf_c089_0 0) vcvs gain=1.950903220161e-01
SCONVI_c089_0_12 (conv_i_src_c089_0_12 conv_i_c089_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_12 (conv_q_src_c089_0_12 0 conv_bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_0_12 (conv_q_src_c089_0_12 conv_q_c089_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_13 (conv_i_src_c089_0_13 0 conv_bpf_c089_0 0) vcvs gain=5.555702330196e-01
SCONVI_c089_0_13 (conv_i_src_c089_0_13 conv_i_c089_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_13 (conv_q_src_c089_0_13 0 conv_bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_0_13 (conv_q_src_c089_0_13 conv_q_c089_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_14 (conv_i_src_c089_0_14 0 conv_bpf_c089_0 0) vcvs gain=8.314696123025e-01
SCONVI_c089_0_14 (conv_i_src_c089_0_14 conv_i_c089_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_14 (conv_q_src_c089_0_14 0 conv_bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_0_14 (conv_q_src_c089_0_14 conv_q_c089_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_0_15 (conv_i_src_c089_0_15 0 conv_bpf_c089_0 0) vcvs gain=9.807852804032e-01
SCONVI_c089_0_15 (conv_i_src_c089_0_15 conv_i_c089_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_0_15 (conv_q_src_c089_0_15 0 conv_bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_0_15 (conv_q_src_c089_0_15 conv_q_c089_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c089_0 (conv_i_c089_0 0) resistor r=1G
RCONVQ_c089_0 (conv_q_c089_0 0) resistor r=1G
RCONVINTI_c089_0 (conv_i_c089_0 ConvIcar_c089_0) resistor r=1k
CCONVINTI_c089_0 (ConvIcar_c089_0 0) capacitor c=80p
RCONVINTQ_c089_0 (conv_q_c089_0 ConvQcar_c089_0) resistor r=1k
CCONVINTQ_c089_0 (ConvQcar_c089_0 0) capacitor c=80p
save conv_bpf_c089_0 ConvIcar_c089_0 ConvQcar_c089_0

// conventional mixed baseline bl089, carrier_1: 500000000 Hz
CCONVBPF_c089_1 (bl089 n_conv_cbpf_c089_1) capacitor c=1.013211836423e-13
LCONVBPF_c089_1 (n_conv_cbpf_c089_1 conv_bpf_c089_1) inductor l=1.000000000000e-06
RCONVBPF_c089_1 (conv_bpf_c089_1 0) resistor r=1.570796326795e+02
ECONVI_c089_1_00 (conv_i_src_c089_1_00 0 conv_bpf_c089_1 0) vcvs gain=9.807852804032e-01
SCONVI_c089_1_00 (conv_i_src_c089_1_00 conv_i_c089_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_00 (conv_q_src_c089_1_00 0 conv_bpf_c089_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_1_00 (conv_q_src_c089_1_00 conv_q_c089_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_01 (conv_i_src_c089_1_01 0 conv_bpf_c089_1 0) vcvs gain=8.314696123025e-01
SCONVI_c089_1_01 (conv_i_src_c089_1_01 conv_i_c089_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_01 (conv_q_src_c089_1_01 0 conv_bpf_c089_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_1_01 (conv_q_src_c089_1_01 conv_q_c089_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_02 (conv_i_src_c089_1_02 0 conv_bpf_c089_1 0) vcvs gain=5.555702330196e-01
SCONVI_c089_1_02 (conv_i_src_c089_1_02 conv_i_c089_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_02 (conv_q_src_c089_1_02 0 conv_bpf_c089_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_1_02 (conv_q_src_c089_1_02 conv_q_c089_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_03 (conv_i_src_c089_1_03 0 conv_bpf_c089_1 0) vcvs gain=1.950903220161e-01
SCONVI_c089_1_03 (conv_i_src_c089_1_03 conv_i_c089_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_03 (conv_q_src_c089_1_03 0 conv_bpf_c089_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_1_03 (conv_q_src_c089_1_03 conv_q_c089_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_04 (conv_i_src_c089_1_04 0 conv_bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_1_04 (conv_i_src_c089_1_04 conv_i_c089_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_04 (conv_q_src_c089_1_04 0 conv_bpf_c089_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_1_04 (conv_q_src_c089_1_04 conv_q_c089_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_05 (conv_i_src_c089_1_05 0 conv_bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_1_05 (conv_i_src_c089_1_05 conv_i_c089_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_05 (conv_q_src_c089_1_05 0 conv_bpf_c089_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_1_05 (conv_q_src_c089_1_05 conv_q_c089_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_06 (conv_i_src_c089_1_06 0 conv_bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_1_06 (conv_i_src_c089_1_06 conv_i_c089_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_06 (conv_q_src_c089_1_06 0 conv_bpf_c089_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_1_06 (conv_q_src_c089_1_06 conv_q_c089_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_07 (conv_i_src_c089_1_07 0 conv_bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_1_07 (conv_i_src_c089_1_07 conv_i_c089_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_07 (conv_q_src_c089_1_07 0 conv_bpf_c089_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_1_07 (conv_q_src_c089_1_07 conv_q_c089_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_08 (conv_i_src_c089_1_08 0 conv_bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_1_08 (conv_i_src_c089_1_08 conv_i_c089_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_08 (conv_q_src_c089_1_08 0 conv_bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_1_08 (conv_q_src_c089_1_08 conv_q_c089_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_09 (conv_i_src_c089_1_09 0 conv_bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_1_09 (conv_i_src_c089_1_09 conv_i_c089_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_09 (conv_q_src_c089_1_09 0 conv_bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_1_09 (conv_q_src_c089_1_09 conv_q_c089_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_10 (conv_i_src_c089_1_10 0 conv_bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_1_10 (conv_i_src_c089_1_10 conv_i_c089_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_10 (conv_q_src_c089_1_10 0 conv_bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_1_10 (conv_q_src_c089_1_10 conv_q_c089_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_11 (conv_i_src_c089_1_11 0 conv_bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_1_11 (conv_i_src_c089_1_11 conv_i_c089_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_11 (conv_q_src_c089_1_11 0 conv_bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_1_11 (conv_q_src_c089_1_11 conv_q_c089_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_12 (conv_i_src_c089_1_12 0 conv_bpf_c089_1 0) vcvs gain=1.950903220161e-01
SCONVI_c089_1_12 (conv_i_src_c089_1_12 conv_i_c089_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_12 (conv_q_src_c089_1_12 0 conv_bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_1_12 (conv_q_src_c089_1_12 conv_q_c089_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_13 (conv_i_src_c089_1_13 0 conv_bpf_c089_1 0) vcvs gain=5.555702330196e-01
SCONVI_c089_1_13 (conv_i_src_c089_1_13 conv_i_c089_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_13 (conv_q_src_c089_1_13 0 conv_bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_1_13 (conv_q_src_c089_1_13 conv_q_c089_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_14 (conv_i_src_c089_1_14 0 conv_bpf_c089_1 0) vcvs gain=8.314696123025e-01
SCONVI_c089_1_14 (conv_i_src_c089_1_14 conv_i_c089_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_14 (conv_q_src_c089_1_14 0 conv_bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_1_14 (conv_q_src_c089_1_14 conv_q_c089_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_1_15 (conv_i_src_c089_1_15 0 conv_bpf_c089_1 0) vcvs gain=9.807852804032e-01
SCONVI_c089_1_15 (conv_i_src_c089_1_15 conv_i_c089_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_1_15 (conv_q_src_c089_1_15 0 conv_bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_1_15 (conv_q_src_c089_1_15 conv_q_c089_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c089_1 (conv_i_c089_1 0) resistor r=1G
RCONVQ_c089_1 (conv_q_c089_1 0) resistor r=1G
RCONVINTI_c089_1 (conv_i_c089_1 ConvIcar_c089_1) resistor r=1k
CCONVINTI_c089_1 (ConvIcar_c089_1 0) capacitor c=80p
RCONVINTQ_c089_1 (conv_q_c089_1 ConvQcar_c089_1) resistor r=1k
CCONVINTQ_c089_1 (ConvQcar_c089_1 0) capacitor c=80p
save conv_bpf_c089_1 ConvIcar_c089_1 ConvQcar_c089_1

// conventional mixed baseline bl089, carrier_2: 750000000 Hz
CCONVBPF_c089_2 (bl089 n_conv_cbpf_c089_2) capacitor c=4.503163717437e-14
LCONVBPF_c089_2 (n_conv_cbpf_c089_2 conv_bpf_c089_2) inductor l=1.000000000000e-06
RCONVBPF_c089_2 (conv_bpf_c089_2 0) resistor r=2.356194490192e+02
ECONVI_c089_2_00 (conv_i_src_c089_2_00 0 conv_bpf_c089_2 0) vcvs gain=9.807852804032e-01
SCONVI_c089_2_00 (conv_i_src_c089_2_00 conv_i_c089_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_00 (conv_q_src_c089_2_00 0 conv_bpf_c089_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_2_00 (conv_q_src_c089_2_00 conv_q_c089_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_01 (conv_i_src_c089_2_01 0 conv_bpf_c089_2 0) vcvs gain=8.314696123025e-01
SCONVI_c089_2_01 (conv_i_src_c089_2_01 conv_i_c089_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_01 (conv_q_src_c089_2_01 0 conv_bpf_c089_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_2_01 (conv_q_src_c089_2_01 conv_q_c089_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_02 (conv_i_src_c089_2_02 0 conv_bpf_c089_2 0) vcvs gain=5.555702330196e-01
SCONVI_c089_2_02 (conv_i_src_c089_2_02 conv_i_c089_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_02 (conv_q_src_c089_2_02 0 conv_bpf_c089_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_2_02 (conv_q_src_c089_2_02 conv_q_c089_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_03 (conv_i_src_c089_2_03 0 conv_bpf_c089_2 0) vcvs gain=1.950903220161e-01
SCONVI_c089_2_03 (conv_i_src_c089_2_03 conv_i_c089_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_03 (conv_q_src_c089_2_03 0 conv_bpf_c089_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_2_03 (conv_q_src_c089_2_03 conv_q_c089_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_04 (conv_i_src_c089_2_04 0 conv_bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_2_04 (conv_i_src_c089_2_04 conv_i_c089_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_04 (conv_q_src_c089_2_04 0 conv_bpf_c089_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_2_04 (conv_q_src_c089_2_04 conv_q_c089_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_05 (conv_i_src_c089_2_05 0 conv_bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_2_05 (conv_i_src_c089_2_05 conv_i_c089_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_05 (conv_q_src_c089_2_05 0 conv_bpf_c089_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_2_05 (conv_q_src_c089_2_05 conv_q_c089_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_06 (conv_i_src_c089_2_06 0 conv_bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_2_06 (conv_i_src_c089_2_06 conv_i_c089_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_06 (conv_q_src_c089_2_06 0 conv_bpf_c089_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_2_06 (conv_q_src_c089_2_06 conv_q_c089_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_07 (conv_i_src_c089_2_07 0 conv_bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_2_07 (conv_i_src_c089_2_07 conv_i_c089_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_07 (conv_q_src_c089_2_07 0 conv_bpf_c089_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_2_07 (conv_q_src_c089_2_07 conv_q_c089_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_08 (conv_i_src_c089_2_08 0 conv_bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_2_08 (conv_i_src_c089_2_08 conv_i_c089_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_08 (conv_q_src_c089_2_08 0 conv_bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_2_08 (conv_q_src_c089_2_08 conv_q_c089_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_09 (conv_i_src_c089_2_09 0 conv_bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_2_09 (conv_i_src_c089_2_09 conv_i_c089_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_09 (conv_q_src_c089_2_09 0 conv_bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_2_09 (conv_q_src_c089_2_09 conv_q_c089_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_10 (conv_i_src_c089_2_10 0 conv_bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_2_10 (conv_i_src_c089_2_10 conv_i_c089_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_10 (conv_q_src_c089_2_10 0 conv_bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_2_10 (conv_q_src_c089_2_10 conv_q_c089_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_11 (conv_i_src_c089_2_11 0 conv_bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_2_11 (conv_i_src_c089_2_11 conv_i_c089_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_11 (conv_q_src_c089_2_11 0 conv_bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_2_11 (conv_q_src_c089_2_11 conv_q_c089_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_12 (conv_i_src_c089_2_12 0 conv_bpf_c089_2 0) vcvs gain=1.950903220161e-01
SCONVI_c089_2_12 (conv_i_src_c089_2_12 conv_i_c089_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_12 (conv_q_src_c089_2_12 0 conv_bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_2_12 (conv_q_src_c089_2_12 conv_q_c089_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_13 (conv_i_src_c089_2_13 0 conv_bpf_c089_2 0) vcvs gain=5.555702330196e-01
SCONVI_c089_2_13 (conv_i_src_c089_2_13 conv_i_c089_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_13 (conv_q_src_c089_2_13 0 conv_bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_2_13 (conv_q_src_c089_2_13 conv_q_c089_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_14 (conv_i_src_c089_2_14 0 conv_bpf_c089_2 0) vcvs gain=8.314696123025e-01
SCONVI_c089_2_14 (conv_i_src_c089_2_14 conv_i_c089_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_14 (conv_q_src_c089_2_14 0 conv_bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_2_14 (conv_q_src_c089_2_14 conv_q_c089_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_2_15 (conv_i_src_c089_2_15 0 conv_bpf_c089_2 0) vcvs gain=9.807852804032e-01
SCONVI_c089_2_15 (conv_i_src_c089_2_15 conv_i_c089_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_2_15 (conv_q_src_c089_2_15 0 conv_bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_2_15 (conv_q_src_c089_2_15 conv_q_c089_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c089_2 (conv_i_c089_2 0) resistor r=1G
RCONVQ_c089_2 (conv_q_c089_2 0) resistor r=1G
RCONVINTI_c089_2 (conv_i_c089_2 ConvIcar_c089_2) resistor r=1k
CCONVINTI_c089_2 (ConvIcar_c089_2 0) capacitor c=80p
RCONVINTQ_c089_2 (conv_q_c089_2 ConvQcar_c089_2) resistor r=1k
CCONVINTQ_c089_2 (ConvQcar_c089_2 0) capacitor c=80p
save conv_bpf_c089_2 ConvIcar_c089_2 ConvQcar_c089_2

// conventional mixed baseline bl089, carrier_3: 1000000000 Hz
CCONVBPF_c089_3 (bl089 n_conv_cbpf_c089_3) capacitor c=2.533029591058e-14
LCONVBPF_c089_3 (n_conv_cbpf_c089_3 conv_bpf_c089_3) inductor l=1.000000000000e-06
RCONVBPF_c089_3 (conv_bpf_c089_3 0) resistor r=3.141592653590e+02
ECONVI_c089_3_00 (conv_i_src_c089_3_00 0 conv_bpf_c089_3 0) vcvs gain=9.807852804032e-01
SCONVI_c089_3_00 (conv_i_src_c089_3_00 conv_i_c089_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_00 (conv_q_src_c089_3_00 0 conv_bpf_c089_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_3_00 (conv_q_src_c089_3_00 conv_q_c089_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_01 (conv_i_src_c089_3_01 0 conv_bpf_c089_3 0) vcvs gain=8.314696123025e-01
SCONVI_c089_3_01 (conv_i_src_c089_3_01 conv_i_c089_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_01 (conv_q_src_c089_3_01 0 conv_bpf_c089_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_3_01 (conv_q_src_c089_3_01 conv_q_c089_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_02 (conv_i_src_c089_3_02 0 conv_bpf_c089_3 0) vcvs gain=5.555702330196e-01
SCONVI_c089_3_02 (conv_i_src_c089_3_02 conv_i_c089_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_02 (conv_q_src_c089_3_02 0 conv_bpf_c089_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_3_02 (conv_q_src_c089_3_02 conv_q_c089_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_03 (conv_i_src_c089_3_03 0 conv_bpf_c089_3 0) vcvs gain=1.950903220161e-01
SCONVI_c089_3_03 (conv_i_src_c089_3_03 conv_i_c089_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_03 (conv_q_src_c089_3_03 0 conv_bpf_c089_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_3_03 (conv_q_src_c089_3_03 conv_q_c089_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_04 (conv_i_src_c089_3_04 0 conv_bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_3_04 (conv_i_src_c089_3_04 conv_i_c089_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_04 (conv_q_src_c089_3_04 0 conv_bpf_c089_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c089_3_04 (conv_q_src_c089_3_04 conv_q_c089_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_05 (conv_i_src_c089_3_05 0 conv_bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_3_05 (conv_i_src_c089_3_05 conv_i_c089_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_05 (conv_q_src_c089_3_05 0 conv_bpf_c089_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c089_3_05 (conv_q_src_c089_3_05 conv_q_c089_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_06 (conv_i_src_c089_3_06 0 conv_bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_3_06 (conv_i_src_c089_3_06 conv_i_c089_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_06 (conv_q_src_c089_3_06 0 conv_bpf_c089_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c089_3_06 (conv_q_src_c089_3_06 conv_q_c089_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_07 (conv_i_src_c089_3_07 0 conv_bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_3_07 (conv_i_src_c089_3_07 conv_i_c089_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_07 (conv_q_src_c089_3_07 0 conv_bpf_c089_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c089_3_07 (conv_q_src_c089_3_07 conv_q_c089_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_08 (conv_i_src_c089_3_08 0 conv_bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c089_3_08 (conv_i_src_c089_3_08 conv_i_c089_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_08 (conv_q_src_c089_3_08 0 conv_bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_3_08 (conv_q_src_c089_3_08 conv_q_c089_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_09 (conv_i_src_c089_3_09 0 conv_bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c089_3_09 (conv_i_src_c089_3_09 conv_i_c089_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_09 (conv_q_src_c089_3_09 0 conv_bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_3_09 (conv_q_src_c089_3_09 conv_q_c089_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_10 (conv_i_src_c089_3_10 0 conv_bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c089_3_10 (conv_i_src_c089_3_10 conv_i_c089_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_10 (conv_q_src_c089_3_10 0 conv_bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_3_10 (conv_q_src_c089_3_10 conv_q_c089_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_11 (conv_i_src_c089_3_11 0 conv_bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c089_3_11 (conv_i_src_c089_3_11 conv_i_c089_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_11 (conv_q_src_c089_3_11 0 conv_bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_3_11 (conv_q_src_c089_3_11 conv_q_c089_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_12 (conv_i_src_c089_3_12 0 conv_bpf_c089_3 0) vcvs gain=1.950903220161e-01
SCONVI_c089_3_12 (conv_i_src_c089_3_12 conv_i_c089_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_12 (conv_q_src_c089_3_12 0 conv_bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c089_3_12 (conv_q_src_c089_3_12 conv_q_c089_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_13 (conv_i_src_c089_3_13 0 conv_bpf_c089_3 0) vcvs gain=5.555702330196e-01
SCONVI_c089_3_13 (conv_i_src_c089_3_13 conv_i_c089_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_13 (conv_q_src_c089_3_13 0 conv_bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c089_3_13 (conv_q_src_c089_3_13 conv_q_c089_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_14 (conv_i_src_c089_3_14 0 conv_bpf_c089_3 0) vcvs gain=8.314696123025e-01
SCONVI_c089_3_14 (conv_i_src_c089_3_14 conv_i_c089_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_14 (conv_q_src_c089_3_14 0 conv_bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c089_3_14 (conv_q_src_c089_3_14 conv_q_c089_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c089_3_15 (conv_i_src_c089_3_15 0 conv_bpf_c089_3 0) vcvs gain=9.807852804032e-01
SCONVI_c089_3_15 (conv_i_src_c089_3_15 conv_i_c089_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c089_3_15 (conv_q_src_c089_3_15 0 conv_bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c089_3_15 (conv_q_src_c089_3_15 conv_q_c089_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c089_3 (conv_i_c089_3 0) resistor r=1G
RCONVQ_c089_3 (conv_q_c089_3 0) resistor r=1G
RCONVINTI_c089_3 (conv_i_c089_3 ConvIcar_c089_3) resistor r=1k
CCONVINTI_c089_3 (ConvIcar_c089_3 0) capacitor c=80p
RCONVINTQ_c089_3 (conv_q_c089_3 ConvQcar_c089_3) resistor r=1k
CCONVINTQ_c089_3 (ConvQcar_c089_3 0) capacitor c=80p
save conv_bpf_c089_3 ConvIcar_c089_3 ConvQcar_c089_3

// conventional mixed baseline bl090, carrier_0: 250000000 Hz
CCONVBPF_c090_0 (bl090 n_conv_cbpf_c090_0) capacitor c=4.052847345694e-13
LCONVBPF_c090_0 (n_conv_cbpf_c090_0 conv_bpf_c090_0) inductor l=1.000000000000e-06
RCONVBPF_c090_0 (conv_bpf_c090_0 0) resistor r=7.853981633974e+01
ECONVI_c090_0_00 (conv_i_src_c090_0_00 0 conv_bpf_c090_0 0) vcvs gain=9.807852804032e-01
SCONVI_c090_0_00 (conv_i_src_c090_0_00 conv_i_c090_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_00 (conv_q_src_c090_0_00 0 conv_bpf_c090_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_0_00 (conv_q_src_c090_0_00 conv_q_c090_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_01 (conv_i_src_c090_0_01 0 conv_bpf_c090_0 0) vcvs gain=8.314696123025e-01
SCONVI_c090_0_01 (conv_i_src_c090_0_01 conv_i_c090_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_01 (conv_q_src_c090_0_01 0 conv_bpf_c090_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_0_01 (conv_q_src_c090_0_01 conv_q_c090_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_02 (conv_i_src_c090_0_02 0 conv_bpf_c090_0 0) vcvs gain=5.555702330196e-01
SCONVI_c090_0_02 (conv_i_src_c090_0_02 conv_i_c090_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_02 (conv_q_src_c090_0_02 0 conv_bpf_c090_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_0_02 (conv_q_src_c090_0_02 conv_q_c090_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_03 (conv_i_src_c090_0_03 0 conv_bpf_c090_0 0) vcvs gain=1.950903220161e-01
SCONVI_c090_0_03 (conv_i_src_c090_0_03 conv_i_c090_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_03 (conv_q_src_c090_0_03 0 conv_bpf_c090_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_0_03 (conv_q_src_c090_0_03 conv_q_c090_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_04 (conv_i_src_c090_0_04 0 conv_bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_0_04 (conv_i_src_c090_0_04 conv_i_c090_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_04 (conv_q_src_c090_0_04 0 conv_bpf_c090_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_0_04 (conv_q_src_c090_0_04 conv_q_c090_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_05 (conv_i_src_c090_0_05 0 conv_bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_0_05 (conv_i_src_c090_0_05 conv_i_c090_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_05 (conv_q_src_c090_0_05 0 conv_bpf_c090_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_0_05 (conv_q_src_c090_0_05 conv_q_c090_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_06 (conv_i_src_c090_0_06 0 conv_bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_0_06 (conv_i_src_c090_0_06 conv_i_c090_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_06 (conv_q_src_c090_0_06 0 conv_bpf_c090_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_0_06 (conv_q_src_c090_0_06 conv_q_c090_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_07 (conv_i_src_c090_0_07 0 conv_bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_0_07 (conv_i_src_c090_0_07 conv_i_c090_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_07 (conv_q_src_c090_0_07 0 conv_bpf_c090_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_0_07 (conv_q_src_c090_0_07 conv_q_c090_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_08 (conv_i_src_c090_0_08 0 conv_bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_0_08 (conv_i_src_c090_0_08 conv_i_c090_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_08 (conv_q_src_c090_0_08 0 conv_bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_0_08 (conv_q_src_c090_0_08 conv_q_c090_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_09 (conv_i_src_c090_0_09 0 conv_bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_0_09 (conv_i_src_c090_0_09 conv_i_c090_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_09 (conv_q_src_c090_0_09 0 conv_bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_0_09 (conv_q_src_c090_0_09 conv_q_c090_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_10 (conv_i_src_c090_0_10 0 conv_bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_0_10 (conv_i_src_c090_0_10 conv_i_c090_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_10 (conv_q_src_c090_0_10 0 conv_bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_0_10 (conv_q_src_c090_0_10 conv_q_c090_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_11 (conv_i_src_c090_0_11 0 conv_bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_0_11 (conv_i_src_c090_0_11 conv_i_c090_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_11 (conv_q_src_c090_0_11 0 conv_bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_0_11 (conv_q_src_c090_0_11 conv_q_c090_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_12 (conv_i_src_c090_0_12 0 conv_bpf_c090_0 0) vcvs gain=1.950903220161e-01
SCONVI_c090_0_12 (conv_i_src_c090_0_12 conv_i_c090_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_12 (conv_q_src_c090_0_12 0 conv_bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_0_12 (conv_q_src_c090_0_12 conv_q_c090_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_13 (conv_i_src_c090_0_13 0 conv_bpf_c090_0 0) vcvs gain=5.555702330196e-01
SCONVI_c090_0_13 (conv_i_src_c090_0_13 conv_i_c090_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_13 (conv_q_src_c090_0_13 0 conv_bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_0_13 (conv_q_src_c090_0_13 conv_q_c090_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_14 (conv_i_src_c090_0_14 0 conv_bpf_c090_0 0) vcvs gain=8.314696123025e-01
SCONVI_c090_0_14 (conv_i_src_c090_0_14 conv_i_c090_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_14 (conv_q_src_c090_0_14 0 conv_bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_0_14 (conv_q_src_c090_0_14 conv_q_c090_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_0_15 (conv_i_src_c090_0_15 0 conv_bpf_c090_0 0) vcvs gain=9.807852804032e-01
SCONVI_c090_0_15 (conv_i_src_c090_0_15 conv_i_c090_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_0_15 (conv_q_src_c090_0_15 0 conv_bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_0_15 (conv_q_src_c090_0_15 conv_q_c090_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c090_0 (conv_i_c090_0 0) resistor r=1G
RCONVQ_c090_0 (conv_q_c090_0 0) resistor r=1G
RCONVINTI_c090_0 (conv_i_c090_0 ConvIcar_c090_0) resistor r=1k
CCONVINTI_c090_0 (ConvIcar_c090_0 0) capacitor c=80p
RCONVINTQ_c090_0 (conv_q_c090_0 ConvQcar_c090_0) resistor r=1k
CCONVINTQ_c090_0 (ConvQcar_c090_0 0) capacitor c=80p
save conv_bpf_c090_0 ConvIcar_c090_0 ConvQcar_c090_0

// conventional mixed baseline bl090, carrier_1: 500000000 Hz
CCONVBPF_c090_1 (bl090 n_conv_cbpf_c090_1) capacitor c=1.013211836423e-13
LCONVBPF_c090_1 (n_conv_cbpf_c090_1 conv_bpf_c090_1) inductor l=1.000000000000e-06
RCONVBPF_c090_1 (conv_bpf_c090_1 0) resistor r=1.570796326795e+02
ECONVI_c090_1_00 (conv_i_src_c090_1_00 0 conv_bpf_c090_1 0) vcvs gain=9.807852804032e-01
SCONVI_c090_1_00 (conv_i_src_c090_1_00 conv_i_c090_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_00 (conv_q_src_c090_1_00 0 conv_bpf_c090_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_1_00 (conv_q_src_c090_1_00 conv_q_c090_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_01 (conv_i_src_c090_1_01 0 conv_bpf_c090_1 0) vcvs gain=8.314696123025e-01
SCONVI_c090_1_01 (conv_i_src_c090_1_01 conv_i_c090_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_01 (conv_q_src_c090_1_01 0 conv_bpf_c090_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_1_01 (conv_q_src_c090_1_01 conv_q_c090_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_02 (conv_i_src_c090_1_02 0 conv_bpf_c090_1 0) vcvs gain=5.555702330196e-01
SCONVI_c090_1_02 (conv_i_src_c090_1_02 conv_i_c090_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_02 (conv_q_src_c090_1_02 0 conv_bpf_c090_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_1_02 (conv_q_src_c090_1_02 conv_q_c090_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_03 (conv_i_src_c090_1_03 0 conv_bpf_c090_1 0) vcvs gain=1.950903220161e-01
SCONVI_c090_1_03 (conv_i_src_c090_1_03 conv_i_c090_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_03 (conv_q_src_c090_1_03 0 conv_bpf_c090_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_1_03 (conv_q_src_c090_1_03 conv_q_c090_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_04 (conv_i_src_c090_1_04 0 conv_bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_1_04 (conv_i_src_c090_1_04 conv_i_c090_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_04 (conv_q_src_c090_1_04 0 conv_bpf_c090_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_1_04 (conv_q_src_c090_1_04 conv_q_c090_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_05 (conv_i_src_c090_1_05 0 conv_bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_1_05 (conv_i_src_c090_1_05 conv_i_c090_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_05 (conv_q_src_c090_1_05 0 conv_bpf_c090_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_1_05 (conv_q_src_c090_1_05 conv_q_c090_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_06 (conv_i_src_c090_1_06 0 conv_bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_1_06 (conv_i_src_c090_1_06 conv_i_c090_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_06 (conv_q_src_c090_1_06 0 conv_bpf_c090_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_1_06 (conv_q_src_c090_1_06 conv_q_c090_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_07 (conv_i_src_c090_1_07 0 conv_bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_1_07 (conv_i_src_c090_1_07 conv_i_c090_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_07 (conv_q_src_c090_1_07 0 conv_bpf_c090_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_1_07 (conv_q_src_c090_1_07 conv_q_c090_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_08 (conv_i_src_c090_1_08 0 conv_bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_1_08 (conv_i_src_c090_1_08 conv_i_c090_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_08 (conv_q_src_c090_1_08 0 conv_bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_1_08 (conv_q_src_c090_1_08 conv_q_c090_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_09 (conv_i_src_c090_1_09 0 conv_bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_1_09 (conv_i_src_c090_1_09 conv_i_c090_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_09 (conv_q_src_c090_1_09 0 conv_bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_1_09 (conv_q_src_c090_1_09 conv_q_c090_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_10 (conv_i_src_c090_1_10 0 conv_bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_1_10 (conv_i_src_c090_1_10 conv_i_c090_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_10 (conv_q_src_c090_1_10 0 conv_bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_1_10 (conv_q_src_c090_1_10 conv_q_c090_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_11 (conv_i_src_c090_1_11 0 conv_bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_1_11 (conv_i_src_c090_1_11 conv_i_c090_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_11 (conv_q_src_c090_1_11 0 conv_bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_1_11 (conv_q_src_c090_1_11 conv_q_c090_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_12 (conv_i_src_c090_1_12 0 conv_bpf_c090_1 0) vcvs gain=1.950903220161e-01
SCONVI_c090_1_12 (conv_i_src_c090_1_12 conv_i_c090_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_12 (conv_q_src_c090_1_12 0 conv_bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_1_12 (conv_q_src_c090_1_12 conv_q_c090_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_13 (conv_i_src_c090_1_13 0 conv_bpf_c090_1 0) vcvs gain=5.555702330196e-01
SCONVI_c090_1_13 (conv_i_src_c090_1_13 conv_i_c090_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_13 (conv_q_src_c090_1_13 0 conv_bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_1_13 (conv_q_src_c090_1_13 conv_q_c090_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_14 (conv_i_src_c090_1_14 0 conv_bpf_c090_1 0) vcvs gain=8.314696123025e-01
SCONVI_c090_1_14 (conv_i_src_c090_1_14 conv_i_c090_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_14 (conv_q_src_c090_1_14 0 conv_bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_1_14 (conv_q_src_c090_1_14 conv_q_c090_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_1_15 (conv_i_src_c090_1_15 0 conv_bpf_c090_1 0) vcvs gain=9.807852804032e-01
SCONVI_c090_1_15 (conv_i_src_c090_1_15 conv_i_c090_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_1_15 (conv_q_src_c090_1_15 0 conv_bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_1_15 (conv_q_src_c090_1_15 conv_q_c090_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c090_1 (conv_i_c090_1 0) resistor r=1G
RCONVQ_c090_1 (conv_q_c090_1 0) resistor r=1G
RCONVINTI_c090_1 (conv_i_c090_1 ConvIcar_c090_1) resistor r=1k
CCONVINTI_c090_1 (ConvIcar_c090_1 0) capacitor c=80p
RCONVINTQ_c090_1 (conv_q_c090_1 ConvQcar_c090_1) resistor r=1k
CCONVINTQ_c090_1 (ConvQcar_c090_1 0) capacitor c=80p
save conv_bpf_c090_1 ConvIcar_c090_1 ConvQcar_c090_1

// conventional mixed baseline bl090, carrier_2: 750000000 Hz
CCONVBPF_c090_2 (bl090 n_conv_cbpf_c090_2) capacitor c=4.503163717437e-14
LCONVBPF_c090_2 (n_conv_cbpf_c090_2 conv_bpf_c090_2) inductor l=1.000000000000e-06
RCONVBPF_c090_2 (conv_bpf_c090_2 0) resistor r=2.356194490192e+02
ECONVI_c090_2_00 (conv_i_src_c090_2_00 0 conv_bpf_c090_2 0) vcvs gain=9.807852804032e-01
SCONVI_c090_2_00 (conv_i_src_c090_2_00 conv_i_c090_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_00 (conv_q_src_c090_2_00 0 conv_bpf_c090_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_2_00 (conv_q_src_c090_2_00 conv_q_c090_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_01 (conv_i_src_c090_2_01 0 conv_bpf_c090_2 0) vcvs gain=8.314696123025e-01
SCONVI_c090_2_01 (conv_i_src_c090_2_01 conv_i_c090_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_01 (conv_q_src_c090_2_01 0 conv_bpf_c090_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_2_01 (conv_q_src_c090_2_01 conv_q_c090_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_02 (conv_i_src_c090_2_02 0 conv_bpf_c090_2 0) vcvs gain=5.555702330196e-01
SCONVI_c090_2_02 (conv_i_src_c090_2_02 conv_i_c090_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_02 (conv_q_src_c090_2_02 0 conv_bpf_c090_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_2_02 (conv_q_src_c090_2_02 conv_q_c090_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_03 (conv_i_src_c090_2_03 0 conv_bpf_c090_2 0) vcvs gain=1.950903220161e-01
SCONVI_c090_2_03 (conv_i_src_c090_2_03 conv_i_c090_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_03 (conv_q_src_c090_2_03 0 conv_bpf_c090_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_2_03 (conv_q_src_c090_2_03 conv_q_c090_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_04 (conv_i_src_c090_2_04 0 conv_bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_2_04 (conv_i_src_c090_2_04 conv_i_c090_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_04 (conv_q_src_c090_2_04 0 conv_bpf_c090_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_2_04 (conv_q_src_c090_2_04 conv_q_c090_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_05 (conv_i_src_c090_2_05 0 conv_bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_2_05 (conv_i_src_c090_2_05 conv_i_c090_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_05 (conv_q_src_c090_2_05 0 conv_bpf_c090_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_2_05 (conv_q_src_c090_2_05 conv_q_c090_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_06 (conv_i_src_c090_2_06 0 conv_bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_2_06 (conv_i_src_c090_2_06 conv_i_c090_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_06 (conv_q_src_c090_2_06 0 conv_bpf_c090_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_2_06 (conv_q_src_c090_2_06 conv_q_c090_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_07 (conv_i_src_c090_2_07 0 conv_bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_2_07 (conv_i_src_c090_2_07 conv_i_c090_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_07 (conv_q_src_c090_2_07 0 conv_bpf_c090_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_2_07 (conv_q_src_c090_2_07 conv_q_c090_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_08 (conv_i_src_c090_2_08 0 conv_bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_2_08 (conv_i_src_c090_2_08 conv_i_c090_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_08 (conv_q_src_c090_2_08 0 conv_bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_2_08 (conv_q_src_c090_2_08 conv_q_c090_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_09 (conv_i_src_c090_2_09 0 conv_bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_2_09 (conv_i_src_c090_2_09 conv_i_c090_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_09 (conv_q_src_c090_2_09 0 conv_bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_2_09 (conv_q_src_c090_2_09 conv_q_c090_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_10 (conv_i_src_c090_2_10 0 conv_bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_2_10 (conv_i_src_c090_2_10 conv_i_c090_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_10 (conv_q_src_c090_2_10 0 conv_bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_2_10 (conv_q_src_c090_2_10 conv_q_c090_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_11 (conv_i_src_c090_2_11 0 conv_bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_2_11 (conv_i_src_c090_2_11 conv_i_c090_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_11 (conv_q_src_c090_2_11 0 conv_bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_2_11 (conv_q_src_c090_2_11 conv_q_c090_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_12 (conv_i_src_c090_2_12 0 conv_bpf_c090_2 0) vcvs gain=1.950903220161e-01
SCONVI_c090_2_12 (conv_i_src_c090_2_12 conv_i_c090_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_12 (conv_q_src_c090_2_12 0 conv_bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_2_12 (conv_q_src_c090_2_12 conv_q_c090_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_13 (conv_i_src_c090_2_13 0 conv_bpf_c090_2 0) vcvs gain=5.555702330196e-01
SCONVI_c090_2_13 (conv_i_src_c090_2_13 conv_i_c090_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_13 (conv_q_src_c090_2_13 0 conv_bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_2_13 (conv_q_src_c090_2_13 conv_q_c090_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_14 (conv_i_src_c090_2_14 0 conv_bpf_c090_2 0) vcvs gain=8.314696123025e-01
SCONVI_c090_2_14 (conv_i_src_c090_2_14 conv_i_c090_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_14 (conv_q_src_c090_2_14 0 conv_bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_2_14 (conv_q_src_c090_2_14 conv_q_c090_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_2_15 (conv_i_src_c090_2_15 0 conv_bpf_c090_2 0) vcvs gain=9.807852804032e-01
SCONVI_c090_2_15 (conv_i_src_c090_2_15 conv_i_c090_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_2_15 (conv_q_src_c090_2_15 0 conv_bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_2_15 (conv_q_src_c090_2_15 conv_q_c090_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c090_2 (conv_i_c090_2 0) resistor r=1G
RCONVQ_c090_2 (conv_q_c090_2 0) resistor r=1G
RCONVINTI_c090_2 (conv_i_c090_2 ConvIcar_c090_2) resistor r=1k
CCONVINTI_c090_2 (ConvIcar_c090_2 0) capacitor c=80p
RCONVINTQ_c090_2 (conv_q_c090_2 ConvQcar_c090_2) resistor r=1k
CCONVINTQ_c090_2 (ConvQcar_c090_2 0) capacitor c=80p
save conv_bpf_c090_2 ConvIcar_c090_2 ConvQcar_c090_2

// conventional mixed baseline bl090, carrier_3: 1000000000 Hz
CCONVBPF_c090_3 (bl090 n_conv_cbpf_c090_3) capacitor c=2.533029591058e-14
LCONVBPF_c090_3 (n_conv_cbpf_c090_3 conv_bpf_c090_3) inductor l=1.000000000000e-06
RCONVBPF_c090_3 (conv_bpf_c090_3 0) resistor r=3.141592653590e+02
ECONVI_c090_3_00 (conv_i_src_c090_3_00 0 conv_bpf_c090_3 0) vcvs gain=9.807852804032e-01
SCONVI_c090_3_00 (conv_i_src_c090_3_00 conv_i_c090_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_00 (conv_q_src_c090_3_00 0 conv_bpf_c090_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_3_00 (conv_q_src_c090_3_00 conv_q_c090_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_01 (conv_i_src_c090_3_01 0 conv_bpf_c090_3 0) vcvs gain=8.314696123025e-01
SCONVI_c090_3_01 (conv_i_src_c090_3_01 conv_i_c090_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_01 (conv_q_src_c090_3_01 0 conv_bpf_c090_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_3_01 (conv_q_src_c090_3_01 conv_q_c090_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_02 (conv_i_src_c090_3_02 0 conv_bpf_c090_3 0) vcvs gain=5.555702330196e-01
SCONVI_c090_3_02 (conv_i_src_c090_3_02 conv_i_c090_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_02 (conv_q_src_c090_3_02 0 conv_bpf_c090_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_3_02 (conv_q_src_c090_3_02 conv_q_c090_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_03 (conv_i_src_c090_3_03 0 conv_bpf_c090_3 0) vcvs gain=1.950903220161e-01
SCONVI_c090_3_03 (conv_i_src_c090_3_03 conv_i_c090_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_03 (conv_q_src_c090_3_03 0 conv_bpf_c090_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_3_03 (conv_q_src_c090_3_03 conv_q_c090_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_04 (conv_i_src_c090_3_04 0 conv_bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_3_04 (conv_i_src_c090_3_04 conv_i_c090_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_04 (conv_q_src_c090_3_04 0 conv_bpf_c090_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c090_3_04 (conv_q_src_c090_3_04 conv_q_c090_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_05 (conv_i_src_c090_3_05 0 conv_bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_3_05 (conv_i_src_c090_3_05 conv_i_c090_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_05 (conv_q_src_c090_3_05 0 conv_bpf_c090_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c090_3_05 (conv_q_src_c090_3_05 conv_q_c090_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_06 (conv_i_src_c090_3_06 0 conv_bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_3_06 (conv_i_src_c090_3_06 conv_i_c090_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_06 (conv_q_src_c090_3_06 0 conv_bpf_c090_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c090_3_06 (conv_q_src_c090_3_06 conv_q_c090_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_07 (conv_i_src_c090_3_07 0 conv_bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_3_07 (conv_i_src_c090_3_07 conv_i_c090_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_07 (conv_q_src_c090_3_07 0 conv_bpf_c090_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c090_3_07 (conv_q_src_c090_3_07 conv_q_c090_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_08 (conv_i_src_c090_3_08 0 conv_bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c090_3_08 (conv_i_src_c090_3_08 conv_i_c090_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_08 (conv_q_src_c090_3_08 0 conv_bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_3_08 (conv_q_src_c090_3_08 conv_q_c090_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_09 (conv_i_src_c090_3_09 0 conv_bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c090_3_09 (conv_i_src_c090_3_09 conv_i_c090_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_09 (conv_q_src_c090_3_09 0 conv_bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_3_09 (conv_q_src_c090_3_09 conv_q_c090_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_10 (conv_i_src_c090_3_10 0 conv_bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c090_3_10 (conv_i_src_c090_3_10 conv_i_c090_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_10 (conv_q_src_c090_3_10 0 conv_bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_3_10 (conv_q_src_c090_3_10 conv_q_c090_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_11 (conv_i_src_c090_3_11 0 conv_bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c090_3_11 (conv_i_src_c090_3_11 conv_i_c090_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_11 (conv_q_src_c090_3_11 0 conv_bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_3_11 (conv_q_src_c090_3_11 conv_q_c090_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_12 (conv_i_src_c090_3_12 0 conv_bpf_c090_3 0) vcvs gain=1.950903220161e-01
SCONVI_c090_3_12 (conv_i_src_c090_3_12 conv_i_c090_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_12 (conv_q_src_c090_3_12 0 conv_bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c090_3_12 (conv_q_src_c090_3_12 conv_q_c090_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_13 (conv_i_src_c090_3_13 0 conv_bpf_c090_3 0) vcvs gain=5.555702330196e-01
SCONVI_c090_3_13 (conv_i_src_c090_3_13 conv_i_c090_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_13 (conv_q_src_c090_3_13 0 conv_bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c090_3_13 (conv_q_src_c090_3_13 conv_q_c090_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_14 (conv_i_src_c090_3_14 0 conv_bpf_c090_3 0) vcvs gain=8.314696123025e-01
SCONVI_c090_3_14 (conv_i_src_c090_3_14 conv_i_c090_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_14 (conv_q_src_c090_3_14 0 conv_bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c090_3_14 (conv_q_src_c090_3_14 conv_q_c090_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c090_3_15 (conv_i_src_c090_3_15 0 conv_bpf_c090_3 0) vcvs gain=9.807852804032e-01
SCONVI_c090_3_15 (conv_i_src_c090_3_15 conv_i_c090_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c090_3_15 (conv_q_src_c090_3_15 0 conv_bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c090_3_15 (conv_q_src_c090_3_15 conv_q_c090_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c090_3 (conv_i_c090_3 0) resistor r=1G
RCONVQ_c090_3 (conv_q_c090_3 0) resistor r=1G
RCONVINTI_c090_3 (conv_i_c090_3 ConvIcar_c090_3) resistor r=1k
CCONVINTI_c090_3 (ConvIcar_c090_3 0) capacitor c=80p
RCONVINTQ_c090_3 (conv_q_c090_3 ConvQcar_c090_3) resistor r=1k
CCONVINTQ_c090_3 (ConvQcar_c090_3 0) capacitor c=80p
save conv_bpf_c090_3 ConvIcar_c090_3 ConvQcar_c090_3

// conventional mixed baseline bl091, carrier_0: 250000000 Hz
CCONVBPF_c091_0 (bl091 n_conv_cbpf_c091_0) capacitor c=4.052847345694e-13
LCONVBPF_c091_0 (n_conv_cbpf_c091_0 conv_bpf_c091_0) inductor l=1.000000000000e-06
RCONVBPF_c091_0 (conv_bpf_c091_0 0) resistor r=7.853981633974e+01
ECONVI_c091_0_00 (conv_i_src_c091_0_00 0 conv_bpf_c091_0 0) vcvs gain=9.807852804032e-01
SCONVI_c091_0_00 (conv_i_src_c091_0_00 conv_i_c091_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_00 (conv_q_src_c091_0_00 0 conv_bpf_c091_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_0_00 (conv_q_src_c091_0_00 conv_q_c091_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_01 (conv_i_src_c091_0_01 0 conv_bpf_c091_0 0) vcvs gain=8.314696123025e-01
SCONVI_c091_0_01 (conv_i_src_c091_0_01 conv_i_c091_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_01 (conv_q_src_c091_0_01 0 conv_bpf_c091_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_0_01 (conv_q_src_c091_0_01 conv_q_c091_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_02 (conv_i_src_c091_0_02 0 conv_bpf_c091_0 0) vcvs gain=5.555702330196e-01
SCONVI_c091_0_02 (conv_i_src_c091_0_02 conv_i_c091_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_02 (conv_q_src_c091_0_02 0 conv_bpf_c091_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_0_02 (conv_q_src_c091_0_02 conv_q_c091_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_03 (conv_i_src_c091_0_03 0 conv_bpf_c091_0 0) vcvs gain=1.950903220161e-01
SCONVI_c091_0_03 (conv_i_src_c091_0_03 conv_i_c091_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_03 (conv_q_src_c091_0_03 0 conv_bpf_c091_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c091_0_03 (conv_q_src_c091_0_03 conv_q_c091_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_04 (conv_i_src_c091_0_04 0 conv_bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_0_04 (conv_i_src_c091_0_04 conv_i_c091_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_04 (conv_q_src_c091_0_04 0 conv_bpf_c091_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c091_0_04 (conv_q_src_c091_0_04 conv_q_c091_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_05 (conv_i_src_c091_0_05 0 conv_bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_0_05 (conv_i_src_c091_0_05 conv_i_c091_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_05 (conv_q_src_c091_0_05 0 conv_bpf_c091_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_0_05 (conv_q_src_c091_0_05 conv_q_c091_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_06 (conv_i_src_c091_0_06 0 conv_bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_0_06 (conv_i_src_c091_0_06 conv_i_c091_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_06 (conv_q_src_c091_0_06 0 conv_bpf_c091_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_0_06 (conv_q_src_c091_0_06 conv_q_c091_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_07 (conv_i_src_c091_0_07 0 conv_bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_0_07 (conv_i_src_c091_0_07 conv_i_c091_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_07 (conv_q_src_c091_0_07 0 conv_bpf_c091_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_0_07 (conv_q_src_c091_0_07 conv_q_c091_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_08 (conv_i_src_c091_0_08 0 conv_bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_0_08 (conv_i_src_c091_0_08 conv_i_c091_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_08 (conv_q_src_c091_0_08 0 conv_bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_0_08 (conv_q_src_c091_0_08 conv_q_c091_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_09 (conv_i_src_c091_0_09 0 conv_bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_0_09 (conv_i_src_c091_0_09 conv_i_c091_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_09 (conv_q_src_c091_0_09 0 conv_bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_0_09 (conv_q_src_c091_0_09 conv_q_c091_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_10 (conv_i_src_c091_0_10 0 conv_bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_0_10 (conv_i_src_c091_0_10 conv_i_c091_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_10 (conv_q_src_c091_0_10 0 conv_bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_0_10 (conv_q_src_c091_0_10 conv_q_c091_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_11 (conv_i_src_c091_0_11 0 conv_bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_0_11 (conv_i_src_c091_0_11 conv_i_c091_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_11 (conv_q_src_c091_0_11 0 conv_bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_0_11 (conv_q_src_c091_0_11 conv_q_c091_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_12 (conv_i_src_c091_0_12 0 conv_bpf_c091_0 0) vcvs gain=1.950903220161e-01
SCONVI_c091_0_12 (conv_i_src_c091_0_12 conv_i_c091_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_12 (conv_q_src_c091_0_12 0 conv_bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_0_12 (conv_q_src_c091_0_12 conv_q_c091_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_13 (conv_i_src_c091_0_13 0 conv_bpf_c091_0 0) vcvs gain=5.555702330196e-01
SCONVI_c091_0_13 (conv_i_src_c091_0_13 conv_i_c091_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_13 (conv_q_src_c091_0_13 0 conv_bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_0_13 (conv_q_src_c091_0_13 conv_q_c091_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_14 (conv_i_src_c091_0_14 0 conv_bpf_c091_0 0) vcvs gain=8.314696123025e-01
SCONVI_c091_0_14 (conv_i_src_c091_0_14 conv_i_c091_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_14 (conv_q_src_c091_0_14 0 conv_bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_0_14 (conv_q_src_c091_0_14 conv_q_c091_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_0_15 (conv_i_src_c091_0_15 0 conv_bpf_c091_0 0) vcvs gain=9.807852804032e-01
SCONVI_c091_0_15 (conv_i_src_c091_0_15 conv_i_c091_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_0_15 (conv_q_src_c091_0_15 0 conv_bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_0_15 (conv_q_src_c091_0_15 conv_q_c091_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c091_0 (conv_i_c091_0 0) resistor r=1G
RCONVQ_c091_0 (conv_q_c091_0 0) resistor r=1G
RCONVINTI_c091_0 (conv_i_c091_0 ConvIcar_c091_0) resistor r=1k
CCONVINTI_c091_0 (ConvIcar_c091_0 0) capacitor c=80p
RCONVINTQ_c091_0 (conv_q_c091_0 ConvQcar_c091_0) resistor r=1k
CCONVINTQ_c091_0 (ConvQcar_c091_0 0) capacitor c=80p
save conv_bpf_c091_0 ConvIcar_c091_0 ConvQcar_c091_0

// conventional mixed baseline bl091, carrier_1: 500000000 Hz
CCONVBPF_c091_1 (bl091 n_conv_cbpf_c091_1) capacitor c=1.013211836423e-13
LCONVBPF_c091_1 (n_conv_cbpf_c091_1 conv_bpf_c091_1) inductor l=1.000000000000e-06
RCONVBPF_c091_1 (conv_bpf_c091_1 0) resistor r=1.570796326795e+02
ECONVI_c091_1_00 (conv_i_src_c091_1_00 0 conv_bpf_c091_1 0) vcvs gain=9.807852804032e-01
SCONVI_c091_1_00 (conv_i_src_c091_1_00 conv_i_c091_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_00 (conv_q_src_c091_1_00 0 conv_bpf_c091_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_1_00 (conv_q_src_c091_1_00 conv_q_c091_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_01 (conv_i_src_c091_1_01 0 conv_bpf_c091_1 0) vcvs gain=8.314696123025e-01
SCONVI_c091_1_01 (conv_i_src_c091_1_01 conv_i_c091_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_01 (conv_q_src_c091_1_01 0 conv_bpf_c091_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_1_01 (conv_q_src_c091_1_01 conv_q_c091_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_02 (conv_i_src_c091_1_02 0 conv_bpf_c091_1 0) vcvs gain=5.555702330196e-01
SCONVI_c091_1_02 (conv_i_src_c091_1_02 conv_i_c091_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_02 (conv_q_src_c091_1_02 0 conv_bpf_c091_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_1_02 (conv_q_src_c091_1_02 conv_q_c091_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_03 (conv_i_src_c091_1_03 0 conv_bpf_c091_1 0) vcvs gain=1.950903220161e-01
SCONVI_c091_1_03 (conv_i_src_c091_1_03 conv_i_c091_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_03 (conv_q_src_c091_1_03 0 conv_bpf_c091_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c091_1_03 (conv_q_src_c091_1_03 conv_q_c091_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_04 (conv_i_src_c091_1_04 0 conv_bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_1_04 (conv_i_src_c091_1_04 conv_i_c091_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_04 (conv_q_src_c091_1_04 0 conv_bpf_c091_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c091_1_04 (conv_q_src_c091_1_04 conv_q_c091_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_05 (conv_i_src_c091_1_05 0 conv_bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_1_05 (conv_i_src_c091_1_05 conv_i_c091_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_05 (conv_q_src_c091_1_05 0 conv_bpf_c091_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_1_05 (conv_q_src_c091_1_05 conv_q_c091_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_06 (conv_i_src_c091_1_06 0 conv_bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_1_06 (conv_i_src_c091_1_06 conv_i_c091_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_06 (conv_q_src_c091_1_06 0 conv_bpf_c091_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_1_06 (conv_q_src_c091_1_06 conv_q_c091_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_07 (conv_i_src_c091_1_07 0 conv_bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_1_07 (conv_i_src_c091_1_07 conv_i_c091_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_07 (conv_q_src_c091_1_07 0 conv_bpf_c091_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_1_07 (conv_q_src_c091_1_07 conv_q_c091_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_08 (conv_i_src_c091_1_08 0 conv_bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_1_08 (conv_i_src_c091_1_08 conv_i_c091_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_08 (conv_q_src_c091_1_08 0 conv_bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_1_08 (conv_q_src_c091_1_08 conv_q_c091_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_09 (conv_i_src_c091_1_09 0 conv_bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_1_09 (conv_i_src_c091_1_09 conv_i_c091_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_09 (conv_q_src_c091_1_09 0 conv_bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_1_09 (conv_q_src_c091_1_09 conv_q_c091_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_10 (conv_i_src_c091_1_10 0 conv_bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_1_10 (conv_i_src_c091_1_10 conv_i_c091_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_10 (conv_q_src_c091_1_10 0 conv_bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_1_10 (conv_q_src_c091_1_10 conv_q_c091_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_11 (conv_i_src_c091_1_11 0 conv_bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_1_11 (conv_i_src_c091_1_11 conv_i_c091_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_11 (conv_q_src_c091_1_11 0 conv_bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_1_11 (conv_q_src_c091_1_11 conv_q_c091_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_12 (conv_i_src_c091_1_12 0 conv_bpf_c091_1 0) vcvs gain=1.950903220161e-01
SCONVI_c091_1_12 (conv_i_src_c091_1_12 conv_i_c091_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_12 (conv_q_src_c091_1_12 0 conv_bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_1_12 (conv_q_src_c091_1_12 conv_q_c091_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_13 (conv_i_src_c091_1_13 0 conv_bpf_c091_1 0) vcvs gain=5.555702330196e-01
SCONVI_c091_1_13 (conv_i_src_c091_1_13 conv_i_c091_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_13 (conv_q_src_c091_1_13 0 conv_bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_1_13 (conv_q_src_c091_1_13 conv_q_c091_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_14 (conv_i_src_c091_1_14 0 conv_bpf_c091_1 0) vcvs gain=8.314696123025e-01
SCONVI_c091_1_14 (conv_i_src_c091_1_14 conv_i_c091_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_14 (conv_q_src_c091_1_14 0 conv_bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_1_14 (conv_q_src_c091_1_14 conv_q_c091_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_1_15 (conv_i_src_c091_1_15 0 conv_bpf_c091_1 0) vcvs gain=9.807852804032e-01
SCONVI_c091_1_15 (conv_i_src_c091_1_15 conv_i_c091_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_1_15 (conv_q_src_c091_1_15 0 conv_bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_1_15 (conv_q_src_c091_1_15 conv_q_c091_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c091_1 (conv_i_c091_1 0) resistor r=1G
RCONVQ_c091_1 (conv_q_c091_1 0) resistor r=1G
RCONVINTI_c091_1 (conv_i_c091_1 ConvIcar_c091_1) resistor r=1k
CCONVINTI_c091_1 (ConvIcar_c091_1 0) capacitor c=80p
RCONVINTQ_c091_1 (conv_q_c091_1 ConvQcar_c091_1) resistor r=1k
CCONVINTQ_c091_1 (ConvQcar_c091_1 0) capacitor c=80p
save conv_bpf_c091_1 ConvIcar_c091_1 ConvQcar_c091_1

// conventional mixed baseline bl091, carrier_2: 750000000 Hz
CCONVBPF_c091_2 (bl091 n_conv_cbpf_c091_2) capacitor c=4.503163717437e-14
LCONVBPF_c091_2 (n_conv_cbpf_c091_2 conv_bpf_c091_2) inductor l=1.000000000000e-06
RCONVBPF_c091_2 (conv_bpf_c091_2 0) resistor r=2.356194490192e+02
ECONVI_c091_2_00 (conv_i_src_c091_2_00 0 conv_bpf_c091_2 0) vcvs gain=9.807852804032e-01
SCONVI_c091_2_00 (conv_i_src_c091_2_00 conv_i_c091_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_00 (conv_q_src_c091_2_00 0 conv_bpf_c091_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_2_00 (conv_q_src_c091_2_00 conv_q_c091_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_01 (conv_i_src_c091_2_01 0 conv_bpf_c091_2 0) vcvs gain=8.314696123025e-01
SCONVI_c091_2_01 (conv_i_src_c091_2_01 conv_i_c091_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_01 (conv_q_src_c091_2_01 0 conv_bpf_c091_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_2_01 (conv_q_src_c091_2_01 conv_q_c091_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_02 (conv_i_src_c091_2_02 0 conv_bpf_c091_2 0) vcvs gain=5.555702330196e-01
SCONVI_c091_2_02 (conv_i_src_c091_2_02 conv_i_c091_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_02 (conv_q_src_c091_2_02 0 conv_bpf_c091_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_2_02 (conv_q_src_c091_2_02 conv_q_c091_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_03 (conv_i_src_c091_2_03 0 conv_bpf_c091_2 0) vcvs gain=1.950903220161e-01
SCONVI_c091_2_03 (conv_i_src_c091_2_03 conv_i_c091_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_03 (conv_q_src_c091_2_03 0 conv_bpf_c091_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c091_2_03 (conv_q_src_c091_2_03 conv_q_c091_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_04 (conv_i_src_c091_2_04 0 conv_bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_2_04 (conv_i_src_c091_2_04 conv_i_c091_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_04 (conv_q_src_c091_2_04 0 conv_bpf_c091_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c091_2_04 (conv_q_src_c091_2_04 conv_q_c091_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_05 (conv_i_src_c091_2_05 0 conv_bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_2_05 (conv_i_src_c091_2_05 conv_i_c091_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_05 (conv_q_src_c091_2_05 0 conv_bpf_c091_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_2_05 (conv_q_src_c091_2_05 conv_q_c091_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_06 (conv_i_src_c091_2_06 0 conv_bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_2_06 (conv_i_src_c091_2_06 conv_i_c091_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_06 (conv_q_src_c091_2_06 0 conv_bpf_c091_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_2_06 (conv_q_src_c091_2_06 conv_q_c091_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_07 (conv_i_src_c091_2_07 0 conv_bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_2_07 (conv_i_src_c091_2_07 conv_i_c091_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_07 (conv_q_src_c091_2_07 0 conv_bpf_c091_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_2_07 (conv_q_src_c091_2_07 conv_q_c091_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_08 (conv_i_src_c091_2_08 0 conv_bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c091_2_08 (conv_i_src_c091_2_08 conv_i_c091_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_08 (conv_q_src_c091_2_08 0 conv_bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_2_08 (conv_q_src_c091_2_08 conv_q_c091_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_09 (conv_i_src_c091_2_09 0 conv_bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c091_2_09 (conv_i_src_c091_2_09 conv_i_c091_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_09 (conv_q_src_c091_2_09 0 conv_bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_2_09 (conv_q_src_c091_2_09 conv_q_c091_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_10 (conv_i_src_c091_2_10 0 conv_bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c091_2_10 (conv_i_src_c091_2_10 conv_i_c091_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_10 (conv_q_src_c091_2_10 0 conv_bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_2_10 (conv_q_src_c091_2_10 conv_q_c091_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_11 (conv_i_src_c091_2_11 0 conv_bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_2_11 (conv_i_src_c091_2_11 conv_i_c091_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_11 (conv_q_src_c091_2_11 0 conv_bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_2_11 (conv_q_src_c091_2_11 conv_q_c091_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_12 (conv_i_src_c091_2_12 0 conv_bpf_c091_2 0) vcvs gain=1.950903220161e-01
SCONVI_c091_2_12 (conv_i_src_c091_2_12 conv_i_c091_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_12 (conv_q_src_c091_2_12 0 conv_bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c091_2_12 (conv_q_src_c091_2_12 conv_q_c091_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_13 (conv_i_src_c091_2_13 0 conv_bpf_c091_2 0) vcvs gain=5.555702330196e-01
SCONVI_c091_2_13 (conv_i_src_c091_2_13 conv_i_c091_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_13 (conv_q_src_c091_2_13 0 conv_bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c091_2_13 (conv_q_src_c091_2_13 conv_q_c091_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_14 (conv_i_src_c091_2_14 0 conv_bpf_c091_2 0) vcvs gain=8.314696123025e-01
SCONVI_c091_2_14 (conv_i_src_c091_2_14 conv_i_c091_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_14 (conv_q_src_c091_2_14 0 conv_bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c091_2_14 (conv_q_src_c091_2_14 conv_q_c091_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_2_15 (conv_i_src_c091_2_15 0 conv_bpf_c091_2 0) vcvs gain=9.807852804032e-01
SCONVI_c091_2_15 (conv_i_src_c091_2_15 conv_i_c091_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_2_15 (conv_q_src_c091_2_15 0 conv_bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c091_2_15 (conv_q_src_c091_2_15 conv_q_c091_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c091_2 (conv_i_c091_2 0) resistor r=1G
RCONVQ_c091_2 (conv_q_c091_2 0) resistor r=1G
RCONVINTI_c091_2 (conv_i_c091_2 ConvIcar_c091_2) resistor r=1k
CCONVINTI_c091_2 (ConvIcar_c091_2 0) capacitor c=80p
RCONVINTQ_c091_2 (conv_q_c091_2 ConvQcar_c091_2) resistor r=1k
CCONVINTQ_c091_2 (ConvQcar_c091_2 0) capacitor c=80p
save conv_bpf_c091_2 ConvIcar_c091_2 ConvQcar_c091_2

// conventional mixed baseline bl091, carrier_3: 1000000000 Hz
CCONVBPF_c091_3 (bl091 n_conv_cbpf_c091_3) capacitor c=2.533029591058e-14
LCONVBPF_c091_3 (n_conv_cbpf_c091_3 conv_bpf_c091_3) inductor l=1.000000000000e-06
RCONVBPF_c091_3 (conv_bpf_c091_3 0) resistor r=3.141592653590e+02
ECONVI_c091_3_00 (conv_i_src_c091_3_00 0 conv_bpf_c091_3 0) vcvs gain=9.807852804032e-01
SCONVI_c091_3_00 (conv_i_src_c091_3_00 conv_i_c091_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_00 (conv_q_src_c091_3_00 0 conv_bpf_c091_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c091_3_00 (conv_q_src_c091_3_00 conv_q_c091_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_01 (conv_i_src_c091_3_01 0 conv_bpf_c091_3 0) vcvs gain=8.314696123025e-01
SCONVI_c091_3_01 (conv_i_src_c091_3_01 conv_i_c091_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_01 (conv_q_src_c091_3_01 0 conv_bpf_c091_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c091_3_01 (conv_q_src_c091_3_01 conv_q_c091_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_02 (conv_i_src_c091_3_02 0 conv_bpf_c091_3 0) vcvs gain=5.555702330196e-01
SCONVI_c091_3_02 (conv_i_src_c091_3_02 conv_i_c091_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_02 (conv_q_src_c091_3_02 0 conv_bpf_c091_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c091_3_02 (conv_q_src_c091_3_02 conv_q_c091_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_03 (conv_i_src_c091_3_03 0 conv_bpf_c091_3 0) vcvs gain=1.950903220161e-01
SCONVI_c091_3_03 (conv_i_src_c091_3_03 conv_i_c091_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_03 (conv_q_src_c091_3_03 0 conv_bpf_c091_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c091_3_03 (conv_q_src_c091_3_03 conv_q_c091_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c091_3_04 (conv_i_src_c091_3_04 0 conv_bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c091_3_04 (conv_i_src_c091_3_04 conv_i_c091_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c091_3_04 (conv_q_src_c091_3_04 0 conv_bpf_c091_3 0) vcvs gain=9.807852804032e-01
