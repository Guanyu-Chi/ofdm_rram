SCONVQ_c012_3_02 (conv_q_src_c012_3_02 conv_q_c012_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_03 (conv_i_src_c012_3_03 0 conv_bpf_c012_3 0) vcvs gain=1.950903220161e-01
SCONVI_c012_3_03 (conv_i_src_c012_3_03 conv_i_c012_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_03 (conv_q_src_c012_3_03 0 conv_bpf_c012_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_3_03 (conv_q_src_c012_3_03 conv_q_c012_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_04 (conv_i_src_c012_3_04 0 conv_bpf_c012_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_3_04 (conv_i_src_c012_3_04 conv_i_c012_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_04 (conv_q_src_c012_3_04 0 conv_bpf_c012_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c012_3_04 (conv_q_src_c012_3_04 conv_q_c012_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_05 (conv_i_src_c012_3_05 0 conv_bpf_c012_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_3_05 (conv_i_src_c012_3_05 conv_i_c012_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_05 (conv_q_src_c012_3_05 0 conv_bpf_c012_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c012_3_05 (conv_q_src_c012_3_05 conv_q_c012_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_06 (conv_i_src_c012_3_06 0 conv_bpf_c012_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_3_06 (conv_i_src_c012_3_06 conv_i_c012_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_06 (conv_q_src_c012_3_06 0 conv_bpf_c012_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c012_3_06 (conv_q_src_c012_3_06 conv_q_c012_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_07 (conv_i_src_c012_3_07 0 conv_bpf_c012_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_3_07 (conv_i_src_c012_3_07 conv_i_c012_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_07 (conv_q_src_c012_3_07 0 conv_bpf_c012_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c012_3_07 (conv_q_src_c012_3_07 conv_q_c012_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_08 (conv_i_src_c012_3_08 0 conv_bpf_c012_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c012_3_08 (conv_i_src_c012_3_08 conv_i_c012_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_08 (conv_q_src_c012_3_08 0 conv_bpf_c012_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_3_08 (conv_q_src_c012_3_08 conv_q_c012_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_09 (conv_i_src_c012_3_09 0 conv_bpf_c012_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c012_3_09 (conv_i_src_c012_3_09 conv_i_c012_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_09 (conv_q_src_c012_3_09 0 conv_bpf_c012_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_3_09 (conv_q_src_c012_3_09 conv_q_c012_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_10 (conv_i_src_c012_3_10 0 conv_bpf_c012_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c012_3_10 (conv_i_src_c012_3_10 conv_i_c012_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_10 (conv_q_src_c012_3_10 0 conv_bpf_c012_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_3_10 (conv_q_src_c012_3_10 conv_q_c012_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_11 (conv_i_src_c012_3_11 0 conv_bpf_c012_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c012_3_11 (conv_i_src_c012_3_11 conv_i_c012_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_11 (conv_q_src_c012_3_11 0 conv_bpf_c012_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_3_11 (conv_q_src_c012_3_11 conv_q_c012_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_12 (conv_i_src_c012_3_12 0 conv_bpf_c012_3 0) vcvs gain=1.950903220161e-01
SCONVI_c012_3_12 (conv_i_src_c012_3_12 conv_i_c012_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_12 (conv_q_src_c012_3_12 0 conv_bpf_c012_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c012_3_12 (conv_q_src_c012_3_12 conv_q_c012_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_13 (conv_i_src_c012_3_13 0 conv_bpf_c012_3 0) vcvs gain=5.555702330196e-01
SCONVI_c012_3_13 (conv_i_src_c012_3_13 conv_i_c012_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_13 (conv_q_src_c012_3_13 0 conv_bpf_c012_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c012_3_13 (conv_q_src_c012_3_13 conv_q_c012_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_14 (conv_i_src_c012_3_14 0 conv_bpf_c012_3 0) vcvs gain=8.314696123025e-01
SCONVI_c012_3_14 (conv_i_src_c012_3_14 conv_i_c012_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_14 (conv_q_src_c012_3_14 0 conv_bpf_c012_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c012_3_14 (conv_q_src_c012_3_14 conv_q_c012_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c012_3_15 (conv_i_src_c012_3_15 0 conv_bpf_c012_3 0) vcvs gain=9.807852804032e-01
SCONVI_c012_3_15 (conv_i_src_c012_3_15 conv_i_c012_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c012_3_15 (conv_q_src_c012_3_15 0 conv_bpf_c012_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c012_3_15 (conv_q_src_c012_3_15 conv_q_c012_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c012_3 (conv_i_c012_3 0) resistor r=1G
RCONVQ_c012_3 (conv_q_c012_3 0) resistor r=1G
RCONVINTI_c012_3 (conv_i_c012_3 ConvIcar_c012_3) resistor r=1k
CCONVINTI_c012_3 (ConvIcar_c012_3 0) capacitor c=80p
RCONVINTQ_c012_3 (conv_q_c012_3 ConvQcar_c012_3) resistor r=1k
CCONVINTQ_c012_3 (ConvQcar_c012_3 0) capacitor c=80p
save conv_bpf_c012_3 ConvIcar_c012_3 ConvQcar_c012_3

// conventional mixed baseline bl013, carrier_0: 250000000 Hz
CCONVBPF_c013_0 (bl013 n_conv_cbpf_c013_0) capacitor c=4.052847345694e-13
LCONVBPF_c013_0 (n_conv_cbpf_c013_0 conv_bpf_c013_0) inductor l=1.000000000000e-06
RCONVBPF_c013_0 (conv_bpf_c013_0 0) resistor r=7.853981633974e+01
ECONVI_c013_0_00 (conv_i_src_c013_0_00 0 conv_bpf_c013_0 0) vcvs gain=9.807852804032e-01
SCONVI_c013_0_00 (conv_i_src_c013_0_00 conv_i_c013_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_00 (conv_q_src_c013_0_00 0 conv_bpf_c013_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_0_00 (conv_q_src_c013_0_00 conv_q_c013_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_01 (conv_i_src_c013_0_01 0 conv_bpf_c013_0 0) vcvs gain=8.314696123025e-01
SCONVI_c013_0_01 (conv_i_src_c013_0_01 conv_i_c013_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_01 (conv_q_src_c013_0_01 0 conv_bpf_c013_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_0_01 (conv_q_src_c013_0_01 conv_q_c013_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_02 (conv_i_src_c013_0_02 0 conv_bpf_c013_0 0) vcvs gain=5.555702330196e-01
SCONVI_c013_0_02 (conv_i_src_c013_0_02 conv_i_c013_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_02 (conv_q_src_c013_0_02 0 conv_bpf_c013_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_0_02 (conv_q_src_c013_0_02 conv_q_c013_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_03 (conv_i_src_c013_0_03 0 conv_bpf_c013_0 0) vcvs gain=1.950903220161e-01
SCONVI_c013_0_03 (conv_i_src_c013_0_03 conv_i_c013_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_03 (conv_q_src_c013_0_03 0 conv_bpf_c013_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_0_03 (conv_q_src_c013_0_03 conv_q_c013_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_04 (conv_i_src_c013_0_04 0 conv_bpf_c013_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_0_04 (conv_i_src_c013_0_04 conv_i_c013_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_04 (conv_q_src_c013_0_04 0 conv_bpf_c013_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_0_04 (conv_q_src_c013_0_04 conv_q_c013_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_05 (conv_i_src_c013_0_05 0 conv_bpf_c013_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_0_05 (conv_i_src_c013_0_05 conv_i_c013_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_05 (conv_q_src_c013_0_05 0 conv_bpf_c013_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_0_05 (conv_q_src_c013_0_05 conv_q_c013_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_06 (conv_i_src_c013_0_06 0 conv_bpf_c013_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_0_06 (conv_i_src_c013_0_06 conv_i_c013_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_06 (conv_q_src_c013_0_06 0 conv_bpf_c013_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_0_06 (conv_q_src_c013_0_06 conv_q_c013_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_07 (conv_i_src_c013_0_07 0 conv_bpf_c013_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_0_07 (conv_i_src_c013_0_07 conv_i_c013_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_07 (conv_q_src_c013_0_07 0 conv_bpf_c013_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_0_07 (conv_q_src_c013_0_07 conv_q_c013_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_08 (conv_i_src_c013_0_08 0 conv_bpf_c013_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_0_08 (conv_i_src_c013_0_08 conv_i_c013_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_08 (conv_q_src_c013_0_08 0 conv_bpf_c013_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_0_08 (conv_q_src_c013_0_08 conv_q_c013_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_09 (conv_i_src_c013_0_09 0 conv_bpf_c013_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_0_09 (conv_i_src_c013_0_09 conv_i_c013_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_09 (conv_q_src_c013_0_09 0 conv_bpf_c013_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_0_09 (conv_q_src_c013_0_09 conv_q_c013_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_10 (conv_i_src_c013_0_10 0 conv_bpf_c013_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_0_10 (conv_i_src_c013_0_10 conv_i_c013_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_10 (conv_q_src_c013_0_10 0 conv_bpf_c013_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_0_10 (conv_q_src_c013_0_10 conv_q_c013_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_11 (conv_i_src_c013_0_11 0 conv_bpf_c013_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_0_11 (conv_i_src_c013_0_11 conv_i_c013_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_11 (conv_q_src_c013_0_11 0 conv_bpf_c013_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_0_11 (conv_q_src_c013_0_11 conv_q_c013_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_12 (conv_i_src_c013_0_12 0 conv_bpf_c013_0 0) vcvs gain=1.950903220161e-01
SCONVI_c013_0_12 (conv_i_src_c013_0_12 conv_i_c013_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_12 (conv_q_src_c013_0_12 0 conv_bpf_c013_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_0_12 (conv_q_src_c013_0_12 conv_q_c013_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_13 (conv_i_src_c013_0_13 0 conv_bpf_c013_0 0) vcvs gain=5.555702330196e-01
SCONVI_c013_0_13 (conv_i_src_c013_0_13 conv_i_c013_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_13 (conv_q_src_c013_0_13 0 conv_bpf_c013_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_0_13 (conv_q_src_c013_0_13 conv_q_c013_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_14 (conv_i_src_c013_0_14 0 conv_bpf_c013_0 0) vcvs gain=8.314696123025e-01
SCONVI_c013_0_14 (conv_i_src_c013_0_14 conv_i_c013_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_14 (conv_q_src_c013_0_14 0 conv_bpf_c013_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_0_14 (conv_q_src_c013_0_14 conv_q_c013_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_0_15 (conv_i_src_c013_0_15 0 conv_bpf_c013_0 0) vcvs gain=9.807852804032e-01
SCONVI_c013_0_15 (conv_i_src_c013_0_15 conv_i_c013_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_0_15 (conv_q_src_c013_0_15 0 conv_bpf_c013_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_0_15 (conv_q_src_c013_0_15 conv_q_c013_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c013_0 (conv_i_c013_0 0) resistor r=1G
RCONVQ_c013_0 (conv_q_c013_0 0) resistor r=1G
RCONVINTI_c013_0 (conv_i_c013_0 ConvIcar_c013_0) resistor r=1k
CCONVINTI_c013_0 (ConvIcar_c013_0 0) capacitor c=80p
RCONVINTQ_c013_0 (conv_q_c013_0 ConvQcar_c013_0) resistor r=1k
CCONVINTQ_c013_0 (ConvQcar_c013_0 0) capacitor c=80p
save conv_bpf_c013_0 ConvIcar_c013_0 ConvQcar_c013_0

// conventional mixed baseline bl013, carrier_1: 500000000 Hz
CCONVBPF_c013_1 (bl013 n_conv_cbpf_c013_1) capacitor c=1.013211836423e-13
LCONVBPF_c013_1 (n_conv_cbpf_c013_1 conv_bpf_c013_1) inductor l=1.000000000000e-06
RCONVBPF_c013_1 (conv_bpf_c013_1 0) resistor r=1.570796326795e+02
ECONVI_c013_1_00 (conv_i_src_c013_1_00 0 conv_bpf_c013_1 0) vcvs gain=9.807852804032e-01
SCONVI_c013_1_00 (conv_i_src_c013_1_00 conv_i_c013_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_00 (conv_q_src_c013_1_00 0 conv_bpf_c013_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_1_00 (conv_q_src_c013_1_00 conv_q_c013_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_01 (conv_i_src_c013_1_01 0 conv_bpf_c013_1 0) vcvs gain=8.314696123025e-01
SCONVI_c013_1_01 (conv_i_src_c013_1_01 conv_i_c013_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_01 (conv_q_src_c013_1_01 0 conv_bpf_c013_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_1_01 (conv_q_src_c013_1_01 conv_q_c013_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_02 (conv_i_src_c013_1_02 0 conv_bpf_c013_1 0) vcvs gain=5.555702330196e-01
SCONVI_c013_1_02 (conv_i_src_c013_1_02 conv_i_c013_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_02 (conv_q_src_c013_1_02 0 conv_bpf_c013_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_1_02 (conv_q_src_c013_1_02 conv_q_c013_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_03 (conv_i_src_c013_1_03 0 conv_bpf_c013_1 0) vcvs gain=1.950903220161e-01
SCONVI_c013_1_03 (conv_i_src_c013_1_03 conv_i_c013_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_03 (conv_q_src_c013_1_03 0 conv_bpf_c013_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_1_03 (conv_q_src_c013_1_03 conv_q_c013_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_04 (conv_i_src_c013_1_04 0 conv_bpf_c013_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_1_04 (conv_i_src_c013_1_04 conv_i_c013_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_04 (conv_q_src_c013_1_04 0 conv_bpf_c013_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_1_04 (conv_q_src_c013_1_04 conv_q_c013_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_05 (conv_i_src_c013_1_05 0 conv_bpf_c013_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_1_05 (conv_i_src_c013_1_05 conv_i_c013_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_05 (conv_q_src_c013_1_05 0 conv_bpf_c013_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_1_05 (conv_q_src_c013_1_05 conv_q_c013_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_06 (conv_i_src_c013_1_06 0 conv_bpf_c013_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_1_06 (conv_i_src_c013_1_06 conv_i_c013_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_06 (conv_q_src_c013_1_06 0 conv_bpf_c013_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_1_06 (conv_q_src_c013_1_06 conv_q_c013_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_07 (conv_i_src_c013_1_07 0 conv_bpf_c013_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_1_07 (conv_i_src_c013_1_07 conv_i_c013_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_07 (conv_q_src_c013_1_07 0 conv_bpf_c013_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_1_07 (conv_q_src_c013_1_07 conv_q_c013_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_08 (conv_i_src_c013_1_08 0 conv_bpf_c013_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_1_08 (conv_i_src_c013_1_08 conv_i_c013_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_08 (conv_q_src_c013_1_08 0 conv_bpf_c013_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_1_08 (conv_q_src_c013_1_08 conv_q_c013_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_09 (conv_i_src_c013_1_09 0 conv_bpf_c013_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_1_09 (conv_i_src_c013_1_09 conv_i_c013_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_09 (conv_q_src_c013_1_09 0 conv_bpf_c013_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_1_09 (conv_q_src_c013_1_09 conv_q_c013_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_10 (conv_i_src_c013_1_10 0 conv_bpf_c013_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_1_10 (conv_i_src_c013_1_10 conv_i_c013_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_10 (conv_q_src_c013_1_10 0 conv_bpf_c013_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_1_10 (conv_q_src_c013_1_10 conv_q_c013_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_11 (conv_i_src_c013_1_11 0 conv_bpf_c013_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_1_11 (conv_i_src_c013_1_11 conv_i_c013_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_11 (conv_q_src_c013_1_11 0 conv_bpf_c013_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_1_11 (conv_q_src_c013_1_11 conv_q_c013_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_12 (conv_i_src_c013_1_12 0 conv_bpf_c013_1 0) vcvs gain=1.950903220161e-01
SCONVI_c013_1_12 (conv_i_src_c013_1_12 conv_i_c013_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_12 (conv_q_src_c013_1_12 0 conv_bpf_c013_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_1_12 (conv_q_src_c013_1_12 conv_q_c013_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_13 (conv_i_src_c013_1_13 0 conv_bpf_c013_1 0) vcvs gain=5.555702330196e-01
SCONVI_c013_1_13 (conv_i_src_c013_1_13 conv_i_c013_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_13 (conv_q_src_c013_1_13 0 conv_bpf_c013_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_1_13 (conv_q_src_c013_1_13 conv_q_c013_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_14 (conv_i_src_c013_1_14 0 conv_bpf_c013_1 0) vcvs gain=8.314696123025e-01
SCONVI_c013_1_14 (conv_i_src_c013_1_14 conv_i_c013_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_14 (conv_q_src_c013_1_14 0 conv_bpf_c013_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_1_14 (conv_q_src_c013_1_14 conv_q_c013_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_1_15 (conv_i_src_c013_1_15 0 conv_bpf_c013_1 0) vcvs gain=9.807852804032e-01
SCONVI_c013_1_15 (conv_i_src_c013_1_15 conv_i_c013_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_1_15 (conv_q_src_c013_1_15 0 conv_bpf_c013_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_1_15 (conv_q_src_c013_1_15 conv_q_c013_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c013_1 (conv_i_c013_1 0) resistor r=1G
RCONVQ_c013_1 (conv_q_c013_1 0) resistor r=1G
RCONVINTI_c013_1 (conv_i_c013_1 ConvIcar_c013_1) resistor r=1k
CCONVINTI_c013_1 (ConvIcar_c013_1 0) capacitor c=80p
RCONVINTQ_c013_1 (conv_q_c013_1 ConvQcar_c013_1) resistor r=1k
CCONVINTQ_c013_1 (ConvQcar_c013_1 0) capacitor c=80p
save conv_bpf_c013_1 ConvIcar_c013_1 ConvQcar_c013_1

// conventional mixed baseline bl013, carrier_2: 750000000 Hz
CCONVBPF_c013_2 (bl013 n_conv_cbpf_c013_2) capacitor c=4.503163717437e-14
LCONVBPF_c013_2 (n_conv_cbpf_c013_2 conv_bpf_c013_2) inductor l=1.000000000000e-06
RCONVBPF_c013_2 (conv_bpf_c013_2 0) resistor r=2.356194490192e+02
ECONVI_c013_2_00 (conv_i_src_c013_2_00 0 conv_bpf_c013_2 0) vcvs gain=9.807852804032e-01
SCONVI_c013_2_00 (conv_i_src_c013_2_00 conv_i_c013_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_00 (conv_q_src_c013_2_00 0 conv_bpf_c013_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_2_00 (conv_q_src_c013_2_00 conv_q_c013_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_01 (conv_i_src_c013_2_01 0 conv_bpf_c013_2 0) vcvs gain=8.314696123025e-01
SCONVI_c013_2_01 (conv_i_src_c013_2_01 conv_i_c013_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_01 (conv_q_src_c013_2_01 0 conv_bpf_c013_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_2_01 (conv_q_src_c013_2_01 conv_q_c013_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_02 (conv_i_src_c013_2_02 0 conv_bpf_c013_2 0) vcvs gain=5.555702330196e-01
SCONVI_c013_2_02 (conv_i_src_c013_2_02 conv_i_c013_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_02 (conv_q_src_c013_2_02 0 conv_bpf_c013_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_2_02 (conv_q_src_c013_2_02 conv_q_c013_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_03 (conv_i_src_c013_2_03 0 conv_bpf_c013_2 0) vcvs gain=1.950903220161e-01
SCONVI_c013_2_03 (conv_i_src_c013_2_03 conv_i_c013_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_03 (conv_q_src_c013_2_03 0 conv_bpf_c013_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_2_03 (conv_q_src_c013_2_03 conv_q_c013_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_04 (conv_i_src_c013_2_04 0 conv_bpf_c013_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_2_04 (conv_i_src_c013_2_04 conv_i_c013_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_04 (conv_q_src_c013_2_04 0 conv_bpf_c013_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_2_04 (conv_q_src_c013_2_04 conv_q_c013_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_05 (conv_i_src_c013_2_05 0 conv_bpf_c013_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_2_05 (conv_i_src_c013_2_05 conv_i_c013_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_05 (conv_q_src_c013_2_05 0 conv_bpf_c013_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_2_05 (conv_q_src_c013_2_05 conv_q_c013_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_06 (conv_i_src_c013_2_06 0 conv_bpf_c013_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_2_06 (conv_i_src_c013_2_06 conv_i_c013_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_06 (conv_q_src_c013_2_06 0 conv_bpf_c013_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_2_06 (conv_q_src_c013_2_06 conv_q_c013_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_07 (conv_i_src_c013_2_07 0 conv_bpf_c013_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_2_07 (conv_i_src_c013_2_07 conv_i_c013_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_07 (conv_q_src_c013_2_07 0 conv_bpf_c013_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_2_07 (conv_q_src_c013_2_07 conv_q_c013_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_08 (conv_i_src_c013_2_08 0 conv_bpf_c013_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_2_08 (conv_i_src_c013_2_08 conv_i_c013_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_08 (conv_q_src_c013_2_08 0 conv_bpf_c013_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_2_08 (conv_q_src_c013_2_08 conv_q_c013_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_09 (conv_i_src_c013_2_09 0 conv_bpf_c013_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_2_09 (conv_i_src_c013_2_09 conv_i_c013_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_09 (conv_q_src_c013_2_09 0 conv_bpf_c013_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_2_09 (conv_q_src_c013_2_09 conv_q_c013_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_10 (conv_i_src_c013_2_10 0 conv_bpf_c013_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_2_10 (conv_i_src_c013_2_10 conv_i_c013_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_10 (conv_q_src_c013_2_10 0 conv_bpf_c013_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_2_10 (conv_q_src_c013_2_10 conv_q_c013_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_11 (conv_i_src_c013_2_11 0 conv_bpf_c013_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_2_11 (conv_i_src_c013_2_11 conv_i_c013_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_11 (conv_q_src_c013_2_11 0 conv_bpf_c013_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_2_11 (conv_q_src_c013_2_11 conv_q_c013_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_12 (conv_i_src_c013_2_12 0 conv_bpf_c013_2 0) vcvs gain=1.950903220161e-01
SCONVI_c013_2_12 (conv_i_src_c013_2_12 conv_i_c013_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_12 (conv_q_src_c013_2_12 0 conv_bpf_c013_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_2_12 (conv_q_src_c013_2_12 conv_q_c013_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_13 (conv_i_src_c013_2_13 0 conv_bpf_c013_2 0) vcvs gain=5.555702330196e-01
SCONVI_c013_2_13 (conv_i_src_c013_2_13 conv_i_c013_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_13 (conv_q_src_c013_2_13 0 conv_bpf_c013_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_2_13 (conv_q_src_c013_2_13 conv_q_c013_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_14 (conv_i_src_c013_2_14 0 conv_bpf_c013_2 0) vcvs gain=8.314696123025e-01
SCONVI_c013_2_14 (conv_i_src_c013_2_14 conv_i_c013_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_14 (conv_q_src_c013_2_14 0 conv_bpf_c013_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_2_14 (conv_q_src_c013_2_14 conv_q_c013_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_2_15 (conv_i_src_c013_2_15 0 conv_bpf_c013_2 0) vcvs gain=9.807852804032e-01
SCONVI_c013_2_15 (conv_i_src_c013_2_15 conv_i_c013_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_2_15 (conv_q_src_c013_2_15 0 conv_bpf_c013_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_2_15 (conv_q_src_c013_2_15 conv_q_c013_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c013_2 (conv_i_c013_2 0) resistor r=1G
RCONVQ_c013_2 (conv_q_c013_2 0) resistor r=1G
RCONVINTI_c013_2 (conv_i_c013_2 ConvIcar_c013_2) resistor r=1k
CCONVINTI_c013_2 (ConvIcar_c013_2 0) capacitor c=80p
RCONVINTQ_c013_2 (conv_q_c013_2 ConvQcar_c013_2) resistor r=1k
CCONVINTQ_c013_2 (ConvQcar_c013_2 0) capacitor c=80p
save conv_bpf_c013_2 ConvIcar_c013_2 ConvQcar_c013_2

// conventional mixed baseline bl013, carrier_3: 1000000000 Hz
CCONVBPF_c013_3 (bl013 n_conv_cbpf_c013_3) capacitor c=2.533029591058e-14
LCONVBPF_c013_3 (n_conv_cbpf_c013_3 conv_bpf_c013_3) inductor l=1.000000000000e-06
RCONVBPF_c013_3 (conv_bpf_c013_3 0) resistor r=3.141592653590e+02
ECONVI_c013_3_00 (conv_i_src_c013_3_00 0 conv_bpf_c013_3 0) vcvs gain=9.807852804032e-01
SCONVI_c013_3_00 (conv_i_src_c013_3_00 conv_i_c013_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_00 (conv_q_src_c013_3_00 0 conv_bpf_c013_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_3_00 (conv_q_src_c013_3_00 conv_q_c013_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_01 (conv_i_src_c013_3_01 0 conv_bpf_c013_3 0) vcvs gain=8.314696123025e-01
SCONVI_c013_3_01 (conv_i_src_c013_3_01 conv_i_c013_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_01 (conv_q_src_c013_3_01 0 conv_bpf_c013_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_3_01 (conv_q_src_c013_3_01 conv_q_c013_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_02 (conv_i_src_c013_3_02 0 conv_bpf_c013_3 0) vcvs gain=5.555702330196e-01
SCONVI_c013_3_02 (conv_i_src_c013_3_02 conv_i_c013_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_02 (conv_q_src_c013_3_02 0 conv_bpf_c013_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_3_02 (conv_q_src_c013_3_02 conv_q_c013_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_03 (conv_i_src_c013_3_03 0 conv_bpf_c013_3 0) vcvs gain=1.950903220161e-01
SCONVI_c013_3_03 (conv_i_src_c013_3_03 conv_i_c013_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_03 (conv_q_src_c013_3_03 0 conv_bpf_c013_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_3_03 (conv_q_src_c013_3_03 conv_q_c013_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_04 (conv_i_src_c013_3_04 0 conv_bpf_c013_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_3_04 (conv_i_src_c013_3_04 conv_i_c013_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_04 (conv_q_src_c013_3_04 0 conv_bpf_c013_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c013_3_04 (conv_q_src_c013_3_04 conv_q_c013_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_05 (conv_i_src_c013_3_05 0 conv_bpf_c013_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_3_05 (conv_i_src_c013_3_05 conv_i_c013_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_05 (conv_q_src_c013_3_05 0 conv_bpf_c013_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c013_3_05 (conv_q_src_c013_3_05 conv_q_c013_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_06 (conv_i_src_c013_3_06 0 conv_bpf_c013_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_3_06 (conv_i_src_c013_3_06 conv_i_c013_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_06 (conv_q_src_c013_3_06 0 conv_bpf_c013_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c013_3_06 (conv_q_src_c013_3_06 conv_q_c013_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_07 (conv_i_src_c013_3_07 0 conv_bpf_c013_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_3_07 (conv_i_src_c013_3_07 conv_i_c013_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_07 (conv_q_src_c013_3_07 0 conv_bpf_c013_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c013_3_07 (conv_q_src_c013_3_07 conv_q_c013_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_08 (conv_i_src_c013_3_08 0 conv_bpf_c013_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c013_3_08 (conv_i_src_c013_3_08 conv_i_c013_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_08 (conv_q_src_c013_3_08 0 conv_bpf_c013_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_3_08 (conv_q_src_c013_3_08 conv_q_c013_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_09 (conv_i_src_c013_3_09 0 conv_bpf_c013_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c013_3_09 (conv_i_src_c013_3_09 conv_i_c013_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_09 (conv_q_src_c013_3_09 0 conv_bpf_c013_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_3_09 (conv_q_src_c013_3_09 conv_q_c013_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_10 (conv_i_src_c013_3_10 0 conv_bpf_c013_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c013_3_10 (conv_i_src_c013_3_10 conv_i_c013_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_10 (conv_q_src_c013_3_10 0 conv_bpf_c013_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_3_10 (conv_q_src_c013_3_10 conv_q_c013_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_11 (conv_i_src_c013_3_11 0 conv_bpf_c013_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c013_3_11 (conv_i_src_c013_3_11 conv_i_c013_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_11 (conv_q_src_c013_3_11 0 conv_bpf_c013_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_3_11 (conv_q_src_c013_3_11 conv_q_c013_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_12 (conv_i_src_c013_3_12 0 conv_bpf_c013_3 0) vcvs gain=1.950903220161e-01
SCONVI_c013_3_12 (conv_i_src_c013_3_12 conv_i_c013_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_12 (conv_q_src_c013_3_12 0 conv_bpf_c013_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c013_3_12 (conv_q_src_c013_3_12 conv_q_c013_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_13 (conv_i_src_c013_3_13 0 conv_bpf_c013_3 0) vcvs gain=5.555702330196e-01
SCONVI_c013_3_13 (conv_i_src_c013_3_13 conv_i_c013_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_13 (conv_q_src_c013_3_13 0 conv_bpf_c013_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c013_3_13 (conv_q_src_c013_3_13 conv_q_c013_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_14 (conv_i_src_c013_3_14 0 conv_bpf_c013_3 0) vcvs gain=8.314696123025e-01
SCONVI_c013_3_14 (conv_i_src_c013_3_14 conv_i_c013_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_14 (conv_q_src_c013_3_14 0 conv_bpf_c013_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c013_3_14 (conv_q_src_c013_3_14 conv_q_c013_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c013_3_15 (conv_i_src_c013_3_15 0 conv_bpf_c013_3 0) vcvs gain=9.807852804032e-01
SCONVI_c013_3_15 (conv_i_src_c013_3_15 conv_i_c013_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c013_3_15 (conv_q_src_c013_3_15 0 conv_bpf_c013_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c013_3_15 (conv_q_src_c013_3_15 conv_q_c013_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c013_3 (conv_i_c013_3 0) resistor r=1G
RCONVQ_c013_3 (conv_q_c013_3 0) resistor r=1G
RCONVINTI_c013_3 (conv_i_c013_3 ConvIcar_c013_3) resistor r=1k
CCONVINTI_c013_3 (ConvIcar_c013_3 0) capacitor c=80p
RCONVINTQ_c013_3 (conv_q_c013_3 ConvQcar_c013_3) resistor r=1k
CCONVINTQ_c013_3 (ConvQcar_c013_3 0) capacitor c=80p
save conv_bpf_c013_3 ConvIcar_c013_3 ConvQcar_c013_3

// conventional mixed baseline bl014, carrier_0: 250000000 Hz
CCONVBPF_c014_0 (bl014 n_conv_cbpf_c014_0) capacitor c=4.052847345694e-13
LCONVBPF_c014_0 (n_conv_cbpf_c014_0 conv_bpf_c014_0) inductor l=1.000000000000e-06
RCONVBPF_c014_0 (conv_bpf_c014_0 0) resistor r=7.853981633974e+01
ECONVI_c014_0_00 (conv_i_src_c014_0_00 0 conv_bpf_c014_0 0) vcvs gain=9.807852804032e-01
SCONVI_c014_0_00 (conv_i_src_c014_0_00 conv_i_c014_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_00 (conv_q_src_c014_0_00 0 conv_bpf_c014_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_0_00 (conv_q_src_c014_0_00 conv_q_c014_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_01 (conv_i_src_c014_0_01 0 conv_bpf_c014_0 0) vcvs gain=8.314696123025e-01
SCONVI_c014_0_01 (conv_i_src_c014_0_01 conv_i_c014_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_01 (conv_q_src_c014_0_01 0 conv_bpf_c014_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_0_01 (conv_q_src_c014_0_01 conv_q_c014_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_02 (conv_i_src_c014_0_02 0 conv_bpf_c014_0 0) vcvs gain=5.555702330196e-01
SCONVI_c014_0_02 (conv_i_src_c014_0_02 conv_i_c014_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_02 (conv_q_src_c014_0_02 0 conv_bpf_c014_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_0_02 (conv_q_src_c014_0_02 conv_q_c014_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_03 (conv_i_src_c014_0_03 0 conv_bpf_c014_0 0) vcvs gain=1.950903220161e-01
SCONVI_c014_0_03 (conv_i_src_c014_0_03 conv_i_c014_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_03 (conv_q_src_c014_0_03 0 conv_bpf_c014_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_0_03 (conv_q_src_c014_0_03 conv_q_c014_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_04 (conv_i_src_c014_0_04 0 conv_bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_0_04 (conv_i_src_c014_0_04 conv_i_c014_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_04 (conv_q_src_c014_0_04 0 conv_bpf_c014_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_0_04 (conv_q_src_c014_0_04 conv_q_c014_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_05 (conv_i_src_c014_0_05 0 conv_bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_0_05 (conv_i_src_c014_0_05 conv_i_c014_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_05 (conv_q_src_c014_0_05 0 conv_bpf_c014_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_0_05 (conv_q_src_c014_0_05 conv_q_c014_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_06 (conv_i_src_c014_0_06 0 conv_bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_0_06 (conv_i_src_c014_0_06 conv_i_c014_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_06 (conv_q_src_c014_0_06 0 conv_bpf_c014_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_0_06 (conv_q_src_c014_0_06 conv_q_c014_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_07 (conv_i_src_c014_0_07 0 conv_bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_0_07 (conv_i_src_c014_0_07 conv_i_c014_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_07 (conv_q_src_c014_0_07 0 conv_bpf_c014_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_0_07 (conv_q_src_c014_0_07 conv_q_c014_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_08 (conv_i_src_c014_0_08 0 conv_bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_0_08 (conv_i_src_c014_0_08 conv_i_c014_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_08 (conv_q_src_c014_0_08 0 conv_bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_0_08 (conv_q_src_c014_0_08 conv_q_c014_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_09 (conv_i_src_c014_0_09 0 conv_bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_0_09 (conv_i_src_c014_0_09 conv_i_c014_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_09 (conv_q_src_c014_0_09 0 conv_bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_0_09 (conv_q_src_c014_0_09 conv_q_c014_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_10 (conv_i_src_c014_0_10 0 conv_bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_0_10 (conv_i_src_c014_0_10 conv_i_c014_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_10 (conv_q_src_c014_0_10 0 conv_bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_0_10 (conv_q_src_c014_0_10 conv_q_c014_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_11 (conv_i_src_c014_0_11 0 conv_bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_0_11 (conv_i_src_c014_0_11 conv_i_c014_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_11 (conv_q_src_c014_0_11 0 conv_bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_0_11 (conv_q_src_c014_0_11 conv_q_c014_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_12 (conv_i_src_c014_0_12 0 conv_bpf_c014_0 0) vcvs gain=1.950903220161e-01
SCONVI_c014_0_12 (conv_i_src_c014_0_12 conv_i_c014_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_12 (conv_q_src_c014_0_12 0 conv_bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_0_12 (conv_q_src_c014_0_12 conv_q_c014_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_13 (conv_i_src_c014_0_13 0 conv_bpf_c014_0 0) vcvs gain=5.555702330196e-01
SCONVI_c014_0_13 (conv_i_src_c014_0_13 conv_i_c014_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_13 (conv_q_src_c014_0_13 0 conv_bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_0_13 (conv_q_src_c014_0_13 conv_q_c014_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_14 (conv_i_src_c014_0_14 0 conv_bpf_c014_0 0) vcvs gain=8.314696123025e-01
SCONVI_c014_0_14 (conv_i_src_c014_0_14 conv_i_c014_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_14 (conv_q_src_c014_0_14 0 conv_bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_0_14 (conv_q_src_c014_0_14 conv_q_c014_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_0_15 (conv_i_src_c014_0_15 0 conv_bpf_c014_0 0) vcvs gain=9.807852804032e-01
SCONVI_c014_0_15 (conv_i_src_c014_0_15 conv_i_c014_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_0_15 (conv_q_src_c014_0_15 0 conv_bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_0_15 (conv_q_src_c014_0_15 conv_q_c014_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c014_0 (conv_i_c014_0 0) resistor r=1G
RCONVQ_c014_0 (conv_q_c014_0 0) resistor r=1G
RCONVINTI_c014_0 (conv_i_c014_0 ConvIcar_c014_0) resistor r=1k
CCONVINTI_c014_0 (ConvIcar_c014_0 0) capacitor c=80p
RCONVINTQ_c014_0 (conv_q_c014_0 ConvQcar_c014_0) resistor r=1k
CCONVINTQ_c014_0 (ConvQcar_c014_0 0) capacitor c=80p
save conv_bpf_c014_0 ConvIcar_c014_0 ConvQcar_c014_0

// conventional mixed baseline bl014, carrier_1: 500000000 Hz
CCONVBPF_c014_1 (bl014 n_conv_cbpf_c014_1) capacitor c=1.013211836423e-13
LCONVBPF_c014_1 (n_conv_cbpf_c014_1 conv_bpf_c014_1) inductor l=1.000000000000e-06
RCONVBPF_c014_1 (conv_bpf_c014_1 0) resistor r=1.570796326795e+02
ECONVI_c014_1_00 (conv_i_src_c014_1_00 0 conv_bpf_c014_1 0) vcvs gain=9.807852804032e-01
SCONVI_c014_1_00 (conv_i_src_c014_1_00 conv_i_c014_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_00 (conv_q_src_c014_1_00 0 conv_bpf_c014_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_1_00 (conv_q_src_c014_1_00 conv_q_c014_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_01 (conv_i_src_c014_1_01 0 conv_bpf_c014_1 0) vcvs gain=8.314696123025e-01
SCONVI_c014_1_01 (conv_i_src_c014_1_01 conv_i_c014_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_01 (conv_q_src_c014_1_01 0 conv_bpf_c014_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_1_01 (conv_q_src_c014_1_01 conv_q_c014_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_02 (conv_i_src_c014_1_02 0 conv_bpf_c014_1 0) vcvs gain=5.555702330196e-01
SCONVI_c014_1_02 (conv_i_src_c014_1_02 conv_i_c014_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_02 (conv_q_src_c014_1_02 0 conv_bpf_c014_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_1_02 (conv_q_src_c014_1_02 conv_q_c014_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_03 (conv_i_src_c014_1_03 0 conv_bpf_c014_1 0) vcvs gain=1.950903220161e-01
SCONVI_c014_1_03 (conv_i_src_c014_1_03 conv_i_c014_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_03 (conv_q_src_c014_1_03 0 conv_bpf_c014_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_1_03 (conv_q_src_c014_1_03 conv_q_c014_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_04 (conv_i_src_c014_1_04 0 conv_bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_1_04 (conv_i_src_c014_1_04 conv_i_c014_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_04 (conv_q_src_c014_1_04 0 conv_bpf_c014_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_1_04 (conv_q_src_c014_1_04 conv_q_c014_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_05 (conv_i_src_c014_1_05 0 conv_bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_1_05 (conv_i_src_c014_1_05 conv_i_c014_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_05 (conv_q_src_c014_1_05 0 conv_bpf_c014_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_1_05 (conv_q_src_c014_1_05 conv_q_c014_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_06 (conv_i_src_c014_1_06 0 conv_bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_1_06 (conv_i_src_c014_1_06 conv_i_c014_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_06 (conv_q_src_c014_1_06 0 conv_bpf_c014_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_1_06 (conv_q_src_c014_1_06 conv_q_c014_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_07 (conv_i_src_c014_1_07 0 conv_bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_1_07 (conv_i_src_c014_1_07 conv_i_c014_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_07 (conv_q_src_c014_1_07 0 conv_bpf_c014_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_1_07 (conv_q_src_c014_1_07 conv_q_c014_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_08 (conv_i_src_c014_1_08 0 conv_bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_1_08 (conv_i_src_c014_1_08 conv_i_c014_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_08 (conv_q_src_c014_1_08 0 conv_bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_1_08 (conv_q_src_c014_1_08 conv_q_c014_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_09 (conv_i_src_c014_1_09 0 conv_bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_1_09 (conv_i_src_c014_1_09 conv_i_c014_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_09 (conv_q_src_c014_1_09 0 conv_bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_1_09 (conv_q_src_c014_1_09 conv_q_c014_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_10 (conv_i_src_c014_1_10 0 conv_bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_1_10 (conv_i_src_c014_1_10 conv_i_c014_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_10 (conv_q_src_c014_1_10 0 conv_bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_1_10 (conv_q_src_c014_1_10 conv_q_c014_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_11 (conv_i_src_c014_1_11 0 conv_bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_1_11 (conv_i_src_c014_1_11 conv_i_c014_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_11 (conv_q_src_c014_1_11 0 conv_bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_1_11 (conv_q_src_c014_1_11 conv_q_c014_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_12 (conv_i_src_c014_1_12 0 conv_bpf_c014_1 0) vcvs gain=1.950903220161e-01
SCONVI_c014_1_12 (conv_i_src_c014_1_12 conv_i_c014_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_12 (conv_q_src_c014_1_12 0 conv_bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_1_12 (conv_q_src_c014_1_12 conv_q_c014_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_13 (conv_i_src_c014_1_13 0 conv_bpf_c014_1 0) vcvs gain=5.555702330196e-01
SCONVI_c014_1_13 (conv_i_src_c014_1_13 conv_i_c014_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_13 (conv_q_src_c014_1_13 0 conv_bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_1_13 (conv_q_src_c014_1_13 conv_q_c014_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_14 (conv_i_src_c014_1_14 0 conv_bpf_c014_1 0) vcvs gain=8.314696123025e-01
SCONVI_c014_1_14 (conv_i_src_c014_1_14 conv_i_c014_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_14 (conv_q_src_c014_1_14 0 conv_bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_1_14 (conv_q_src_c014_1_14 conv_q_c014_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_1_15 (conv_i_src_c014_1_15 0 conv_bpf_c014_1 0) vcvs gain=9.807852804032e-01
SCONVI_c014_1_15 (conv_i_src_c014_1_15 conv_i_c014_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_1_15 (conv_q_src_c014_1_15 0 conv_bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_1_15 (conv_q_src_c014_1_15 conv_q_c014_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c014_1 (conv_i_c014_1 0) resistor r=1G
RCONVQ_c014_1 (conv_q_c014_1 0) resistor r=1G
RCONVINTI_c014_1 (conv_i_c014_1 ConvIcar_c014_1) resistor r=1k
CCONVINTI_c014_1 (ConvIcar_c014_1 0) capacitor c=80p
RCONVINTQ_c014_1 (conv_q_c014_1 ConvQcar_c014_1) resistor r=1k
CCONVINTQ_c014_1 (ConvQcar_c014_1 0) capacitor c=80p
save conv_bpf_c014_1 ConvIcar_c014_1 ConvQcar_c014_1

// conventional mixed baseline bl014, carrier_2: 750000000 Hz
CCONVBPF_c014_2 (bl014 n_conv_cbpf_c014_2) capacitor c=4.503163717437e-14
LCONVBPF_c014_2 (n_conv_cbpf_c014_2 conv_bpf_c014_2) inductor l=1.000000000000e-06
RCONVBPF_c014_2 (conv_bpf_c014_2 0) resistor r=2.356194490192e+02
ECONVI_c014_2_00 (conv_i_src_c014_2_00 0 conv_bpf_c014_2 0) vcvs gain=9.807852804032e-01
SCONVI_c014_2_00 (conv_i_src_c014_2_00 conv_i_c014_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_00 (conv_q_src_c014_2_00 0 conv_bpf_c014_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_2_00 (conv_q_src_c014_2_00 conv_q_c014_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_01 (conv_i_src_c014_2_01 0 conv_bpf_c014_2 0) vcvs gain=8.314696123025e-01
SCONVI_c014_2_01 (conv_i_src_c014_2_01 conv_i_c014_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_01 (conv_q_src_c014_2_01 0 conv_bpf_c014_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_2_01 (conv_q_src_c014_2_01 conv_q_c014_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_02 (conv_i_src_c014_2_02 0 conv_bpf_c014_2 0) vcvs gain=5.555702330196e-01
SCONVI_c014_2_02 (conv_i_src_c014_2_02 conv_i_c014_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_02 (conv_q_src_c014_2_02 0 conv_bpf_c014_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_2_02 (conv_q_src_c014_2_02 conv_q_c014_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_03 (conv_i_src_c014_2_03 0 conv_bpf_c014_2 0) vcvs gain=1.950903220161e-01
SCONVI_c014_2_03 (conv_i_src_c014_2_03 conv_i_c014_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_03 (conv_q_src_c014_2_03 0 conv_bpf_c014_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_2_03 (conv_q_src_c014_2_03 conv_q_c014_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_04 (conv_i_src_c014_2_04 0 conv_bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_2_04 (conv_i_src_c014_2_04 conv_i_c014_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_04 (conv_q_src_c014_2_04 0 conv_bpf_c014_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_2_04 (conv_q_src_c014_2_04 conv_q_c014_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_05 (conv_i_src_c014_2_05 0 conv_bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_2_05 (conv_i_src_c014_2_05 conv_i_c014_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_05 (conv_q_src_c014_2_05 0 conv_bpf_c014_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_2_05 (conv_q_src_c014_2_05 conv_q_c014_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_06 (conv_i_src_c014_2_06 0 conv_bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_2_06 (conv_i_src_c014_2_06 conv_i_c014_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_06 (conv_q_src_c014_2_06 0 conv_bpf_c014_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_2_06 (conv_q_src_c014_2_06 conv_q_c014_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_07 (conv_i_src_c014_2_07 0 conv_bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_2_07 (conv_i_src_c014_2_07 conv_i_c014_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_07 (conv_q_src_c014_2_07 0 conv_bpf_c014_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_2_07 (conv_q_src_c014_2_07 conv_q_c014_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_08 (conv_i_src_c014_2_08 0 conv_bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_2_08 (conv_i_src_c014_2_08 conv_i_c014_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_08 (conv_q_src_c014_2_08 0 conv_bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_2_08 (conv_q_src_c014_2_08 conv_q_c014_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_09 (conv_i_src_c014_2_09 0 conv_bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_2_09 (conv_i_src_c014_2_09 conv_i_c014_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_09 (conv_q_src_c014_2_09 0 conv_bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_2_09 (conv_q_src_c014_2_09 conv_q_c014_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_10 (conv_i_src_c014_2_10 0 conv_bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_2_10 (conv_i_src_c014_2_10 conv_i_c014_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_10 (conv_q_src_c014_2_10 0 conv_bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_2_10 (conv_q_src_c014_2_10 conv_q_c014_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_11 (conv_i_src_c014_2_11 0 conv_bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_2_11 (conv_i_src_c014_2_11 conv_i_c014_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_11 (conv_q_src_c014_2_11 0 conv_bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_2_11 (conv_q_src_c014_2_11 conv_q_c014_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_12 (conv_i_src_c014_2_12 0 conv_bpf_c014_2 0) vcvs gain=1.950903220161e-01
SCONVI_c014_2_12 (conv_i_src_c014_2_12 conv_i_c014_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_12 (conv_q_src_c014_2_12 0 conv_bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_2_12 (conv_q_src_c014_2_12 conv_q_c014_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_13 (conv_i_src_c014_2_13 0 conv_bpf_c014_2 0) vcvs gain=5.555702330196e-01
SCONVI_c014_2_13 (conv_i_src_c014_2_13 conv_i_c014_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_13 (conv_q_src_c014_2_13 0 conv_bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_2_13 (conv_q_src_c014_2_13 conv_q_c014_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_14 (conv_i_src_c014_2_14 0 conv_bpf_c014_2 0) vcvs gain=8.314696123025e-01
SCONVI_c014_2_14 (conv_i_src_c014_2_14 conv_i_c014_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_14 (conv_q_src_c014_2_14 0 conv_bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_2_14 (conv_q_src_c014_2_14 conv_q_c014_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_2_15 (conv_i_src_c014_2_15 0 conv_bpf_c014_2 0) vcvs gain=9.807852804032e-01
SCONVI_c014_2_15 (conv_i_src_c014_2_15 conv_i_c014_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_2_15 (conv_q_src_c014_2_15 0 conv_bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_2_15 (conv_q_src_c014_2_15 conv_q_c014_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c014_2 (conv_i_c014_2 0) resistor r=1G
RCONVQ_c014_2 (conv_q_c014_2 0) resistor r=1G
RCONVINTI_c014_2 (conv_i_c014_2 ConvIcar_c014_2) resistor r=1k
CCONVINTI_c014_2 (ConvIcar_c014_2 0) capacitor c=80p
RCONVINTQ_c014_2 (conv_q_c014_2 ConvQcar_c014_2) resistor r=1k
CCONVINTQ_c014_2 (ConvQcar_c014_2 0) capacitor c=80p
save conv_bpf_c014_2 ConvIcar_c014_2 ConvQcar_c014_2

// conventional mixed baseline bl014, carrier_3: 1000000000 Hz
CCONVBPF_c014_3 (bl014 n_conv_cbpf_c014_3) capacitor c=2.533029591058e-14
LCONVBPF_c014_3 (n_conv_cbpf_c014_3 conv_bpf_c014_3) inductor l=1.000000000000e-06
RCONVBPF_c014_3 (conv_bpf_c014_3 0) resistor r=3.141592653590e+02
ECONVI_c014_3_00 (conv_i_src_c014_3_00 0 conv_bpf_c014_3 0) vcvs gain=9.807852804032e-01
SCONVI_c014_3_00 (conv_i_src_c014_3_00 conv_i_c014_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_00 (conv_q_src_c014_3_00 0 conv_bpf_c014_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_3_00 (conv_q_src_c014_3_00 conv_q_c014_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_01 (conv_i_src_c014_3_01 0 conv_bpf_c014_3 0) vcvs gain=8.314696123025e-01
SCONVI_c014_3_01 (conv_i_src_c014_3_01 conv_i_c014_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_01 (conv_q_src_c014_3_01 0 conv_bpf_c014_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_3_01 (conv_q_src_c014_3_01 conv_q_c014_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_02 (conv_i_src_c014_3_02 0 conv_bpf_c014_3 0) vcvs gain=5.555702330196e-01
SCONVI_c014_3_02 (conv_i_src_c014_3_02 conv_i_c014_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_02 (conv_q_src_c014_3_02 0 conv_bpf_c014_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_3_02 (conv_q_src_c014_3_02 conv_q_c014_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_03 (conv_i_src_c014_3_03 0 conv_bpf_c014_3 0) vcvs gain=1.950903220161e-01
SCONVI_c014_3_03 (conv_i_src_c014_3_03 conv_i_c014_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_03 (conv_q_src_c014_3_03 0 conv_bpf_c014_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_3_03 (conv_q_src_c014_3_03 conv_q_c014_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_04 (conv_i_src_c014_3_04 0 conv_bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_3_04 (conv_i_src_c014_3_04 conv_i_c014_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_04 (conv_q_src_c014_3_04 0 conv_bpf_c014_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c014_3_04 (conv_q_src_c014_3_04 conv_q_c014_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_05 (conv_i_src_c014_3_05 0 conv_bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_3_05 (conv_i_src_c014_3_05 conv_i_c014_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_05 (conv_q_src_c014_3_05 0 conv_bpf_c014_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c014_3_05 (conv_q_src_c014_3_05 conv_q_c014_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_06 (conv_i_src_c014_3_06 0 conv_bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_3_06 (conv_i_src_c014_3_06 conv_i_c014_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_06 (conv_q_src_c014_3_06 0 conv_bpf_c014_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c014_3_06 (conv_q_src_c014_3_06 conv_q_c014_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_07 (conv_i_src_c014_3_07 0 conv_bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_3_07 (conv_i_src_c014_3_07 conv_i_c014_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_07 (conv_q_src_c014_3_07 0 conv_bpf_c014_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c014_3_07 (conv_q_src_c014_3_07 conv_q_c014_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_08 (conv_i_src_c014_3_08 0 conv_bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c014_3_08 (conv_i_src_c014_3_08 conv_i_c014_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_08 (conv_q_src_c014_3_08 0 conv_bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_3_08 (conv_q_src_c014_3_08 conv_q_c014_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_09 (conv_i_src_c014_3_09 0 conv_bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c014_3_09 (conv_i_src_c014_3_09 conv_i_c014_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_09 (conv_q_src_c014_3_09 0 conv_bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_3_09 (conv_q_src_c014_3_09 conv_q_c014_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_10 (conv_i_src_c014_3_10 0 conv_bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c014_3_10 (conv_i_src_c014_3_10 conv_i_c014_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_10 (conv_q_src_c014_3_10 0 conv_bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_3_10 (conv_q_src_c014_3_10 conv_q_c014_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_11 (conv_i_src_c014_3_11 0 conv_bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c014_3_11 (conv_i_src_c014_3_11 conv_i_c014_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_11 (conv_q_src_c014_3_11 0 conv_bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_3_11 (conv_q_src_c014_3_11 conv_q_c014_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_12 (conv_i_src_c014_3_12 0 conv_bpf_c014_3 0) vcvs gain=1.950903220161e-01
SCONVI_c014_3_12 (conv_i_src_c014_3_12 conv_i_c014_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_12 (conv_q_src_c014_3_12 0 conv_bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c014_3_12 (conv_q_src_c014_3_12 conv_q_c014_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_13 (conv_i_src_c014_3_13 0 conv_bpf_c014_3 0) vcvs gain=5.555702330196e-01
SCONVI_c014_3_13 (conv_i_src_c014_3_13 conv_i_c014_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_13 (conv_q_src_c014_3_13 0 conv_bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c014_3_13 (conv_q_src_c014_3_13 conv_q_c014_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_14 (conv_i_src_c014_3_14 0 conv_bpf_c014_3 0) vcvs gain=8.314696123025e-01
SCONVI_c014_3_14 (conv_i_src_c014_3_14 conv_i_c014_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_14 (conv_q_src_c014_3_14 0 conv_bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c014_3_14 (conv_q_src_c014_3_14 conv_q_c014_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c014_3_15 (conv_i_src_c014_3_15 0 conv_bpf_c014_3 0) vcvs gain=9.807852804032e-01
SCONVI_c014_3_15 (conv_i_src_c014_3_15 conv_i_c014_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c014_3_15 (conv_q_src_c014_3_15 0 conv_bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c014_3_15 (conv_q_src_c014_3_15 conv_q_c014_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c014_3 (conv_i_c014_3 0) resistor r=1G
RCONVQ_c014_3 (conv_q_c014_3 0) resistor r=1G
RCONVINTI_c014_3 (conv_i_c014_3 ConvIcar_c014_3) resistor r=1k
CCONVINTI_c014_3 (ConvIcar_c014_3 0) capacitor c=80p
RCONVINTQ_c014_3 (conv_q_c014_3 ConvQcar_c014_3) resistor r=1k
CCONVINTQ_c014_3 (ConvQcar_c014_3 0) capacitor c=80p
save conv_bpf_c014_3 ConvIcar_c014_3 ConvQcar_c014_3

// conventional mixed baseline bl015, carrier_0: 250000000 Hz
CCONVBPF_c015_0 (bl015 n_conv_cbpf_c015_0) capacitor c=4.052847345694e-13
LCONVBPF_c015_0 (n_conv_cbpf_c015_0 conv_bpf_c015_0) inductor l=1.000000000000e-06
RCONVBPF_c015_0 (conv_bpf_c015_0 0) resistor r=7.853981633974e+01
ECONVI_c015_0_00 (conv_i_src_c015_0_00 0 conv_bpf_c015_0 0) vcvs gain=9.807852804032e-01
SCONVI_c015_0_00 (conv_i_src_c015_0_00 conv_i_c015_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_00 (conv_q_src_c015_0_00 0 conv_bpf_c015_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_0_00 (conv_q_src_c015_0_00 conv_q_c015_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_01 (conv_i_src_c015_0_01 0 conv_bpf_c015_0 0) vcvs gain=8.314696123025e-01
SCONVI_c015_0_01 (conv_i_src_c015_0_01 conv_i_c015_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_01 (conv_q_src_c015_0_01 0 conv_bpf_c015_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_0_01 (conv_q_src_c015_0_01 conv_q_c015_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_02 (conv_i_src_c015_0_02 0 conv_bpf_c015_0 0) vcvs gain=5.555702330196e-01
SCONVI_c015_0_02 (conv_i_src_c015_0_02 conv_i_c015_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_02 (conv_q_src_c015_0_02 0 conv_bpf_c015_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_0_02 (conv_q_src_c015_0_02 conv_q_c015_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_03 (conv_i_src_c015_0_03 0 conv_bpf_c015_0 0) vcvs gain=1.950903220161e-01
SCONVI_c015_0_03 (conv_i_src_c015_0_03 conv_i_c015_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_03 (conv_q_src_c015_0_03 0 conv_bpf_c015_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_0_03 (conv_q_src_c015_0_03 conv_q_c015_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_04 (conv_i_src_c015_0_04 0 conv_bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_0_04 (conv_i_src_c015_0_04 conv_i_c015_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_04 (conv_q_src_c015_0_04 0 conv_bpf_c015_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_0_04 (conv_q_src_c015_0_04 conv_q_c015_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_05 (conv_i_src_c015_0_05 0 conv_bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_0_05 (conv_i_src_c015_0_05 conv_i_c015_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_05 (conv_q_src_c015_0_05 0 conv_bpf_c015_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_0_05 (conv_q_src_c015_0_05 conv_q_c015_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_06 (conv_i_src_c015_0_06 0 conv_bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_0_06 (conv_i_src_c015_0_06 conv_i_c015_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_06 (conv_q_src_c015_0_06 0 conv_bpf_c015_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_0_06 (conv_q_src_c015_0_06 conv_q_c015_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_07 (conv_i_src_c015_0_07 0 conv_bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_0_07 (conv_i_src_c015_0_07 conv_i_c015_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_07 (conv_q_src_c015_0_07 0 conv_bpf_c015_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_0_07 (conv_q_src_c015_0_07 conv_q_c015_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_08 (conv_i_src_c015_0_08 0 conv_bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_0_08 (conv_i_src_c015_0_08 conv_i_c015_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_08 (conv_q_src_c015_0_08 0 conv_bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_0_08 (conv_q_src_c015_0_08 conv_q_c015_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_09 (conv_i_src_c015_0_09 0 conv_bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_0_09 (conv_i_src_c015_0_09 conv_i_c015_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_09 (conv_q_src_c015_0_09 0 conv_bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_0_09 (conv_q_src_c015_0_09 conv_q_c015_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_10 (conv_i_src_c015_0_10 0 conv_bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_0_10 (conv_i_src_c015_0_10 conv_i_c015_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_10 (conv_q_src_c015_0_10 0 conv_bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_0_10 (conv_q_src_c015_0_10 conv_q_c015_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_11 (conv_i_src_c015_0_11 0 conv_bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_0_11 (conv_i_src_c015_0_11 conv_i_c015_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_11 (conv_q_src_c015_0_11 0 conv_bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_0_11 (conv_q_src_c015_0_11 conv_q_c015_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_12 (conv_i_src_c015_0_12 0 conv_bpf_c015_0 0) vcvs gain=1.950903220161e-01
SCONVI_c015_0_12 (conv_i_src_c015_0_12 conv_i_c015_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_12 (conv_q_src_c015_0_12 0 conv_bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_0_12 (conv_q_src_c015_0_12 conv_q_c015_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_13 (conv_i_src_c015_0_13 0 conv_bpf_c015_0 0) vcvs gain=5.555702330196e-01
SCONVI_c015_0_13 (conv_i_src_c015_0_13 conv_i_c015_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_13 (conv_q_src_c015_0_13 0 conv_bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_0_13 (conv_q_src_c015_0_13 conv_q_c015_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_14 (conv_i_src_c015_0_14 0 conv_bpf_c015_0 0) vcvs gain=8.314696123025e-01
SCONVI_c015_0_14 (conv_i_src_c015_0_14 conv_i_c015_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_14 (conv_q_src_c015_0_14 0 conv_bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_0_14 (conv_q_src_c015_0_14 conv_q_c015_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_0_15 (conv_i_src_c015_0_15 0 conv_bpf_c015_0 0) vcvs gain=9.807852804032e-01
SCONVI_c015_0_15 (conv_i_src_c015_0_15 conv_i_c015_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_0_15 (conv_q_src_c015_0_15 0 conv_bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_0_15 (conv_q_src_c015_0_15 conv_q_c015_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c015_0 (conv_i_c015_0 0) resistor r=1G
RCONVQ_c015_0 (conv_q_c015_0 0) resistor r=1G
RCONVINTI_c015_0 (conv_i_c015_0 ConvIcar_c015_0) resistor r=1k
CCONVINTI_c015_0 (ConvIcar_c015_0 0) capacitor c=80p
RCONVINTQ_c015_0 (conv_q_c015_0 ConvQcar_c015_0) resistor r=1k
CCONVINTQ_c015_0 (ConvQcar_c015_0 0) capacitor c=80p
save conv_bpf_c015_0 ConvIcar_c015_0 ConvQcar_c015_0

// conventional mixed baseline bl015, carrier_1: 500000000 Hz
CCONVBPF_c015_1 (bl015 n_conv_cbpf_c015_1) capacitor c=1.013211836423e-13
LCONVBPF_c015_1 (n_conv_cbpf_c015_1 conv_bpf_c015_1) inductor l=1.000000000000e-06
RCONVBPF_c015_1 (conv_bpf_c015_1 0) resistor r=1.570796326795e+02
ECONVI_c015_1_00 (conv_i_src_c015_1_00 0 conv_bpf_c015_1 0) vcvs gain=9.807852804032e-01
SCONVI_c015_1_00 (conv_i_src_c015_1_00 conv_i_c015_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_00 (conv_q_src_c015_1_00 0 conv_bpf_c015_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_1_00 (conv_q_src_c015_1_00 conv_q_c015_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_01 (conv_i_src_c015_1_01 0 conv_bpf_c015_1 0) vcvs gain=8.314696123025e-01
SCONVI_c015_1_01 (conv_i_src_c015_1_01 conv_i_c015_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_01 (conv_q_src_c015_1_01 0 conv_bpf_c015_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_1_01 (conv_q_src_c015_1_01 conv_q_c015_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_02 (conv_i_src_c015_1_02 0 conv_bpf_c015_1 0) vcvs gain=5.555702330196e-01
SCONVI_c015_1_02 (conv_i_src_c015_1_02 conv_i_c015_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_02 (conv_q_src_c015_1_02 0 conv_bpf_c015_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_1_02 (conv_q_src_c015_1_02 conv_q_c015_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_03 (conv_i_src_c015_1_03 0 conv_bpf_c015_1 0) vcvs gain=1.950903220161e-01
SCONVI_c015_1_03 (conv_i_src_c015_1_03 conv_i_c015_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_03 (conv_q_src_c015_1_03 0 conv_bpf_c015_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_1_03 (conv_q_src_c015_1_03 conv_q_c015_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_04 (conv_i_src_c015_1_04 0 conv_bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_1_04 (conv_i_src_c015_1_04 conv_i_c015_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_04 (conv_q_src_c015_1_04 0 conv_bpf_c015_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_1_04 (conv_q_src_c015_1_04 conv_q_c015_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_05 (conv_i_src_c015_1_05 0 conv_bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_1_05 (conv_i_src_c015_1_05 conv_i_c015_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_05 (conv_q_src_c015_1_05 0 conv_bpf_c015_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_1_05 (conv_q_src_c015_1_05 conv_q_c015_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_06 (conv_i_src_c015_1_06 0 conv_bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_1_06 (conv_i_src_c015_1_06 conv_i_c015_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_06 (conv_q_src_c015_1_06 0 conv_bpf_c015_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_1_06 (conv_q_src_c015_1_06 conv_q_c015_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_07 (conv_i_src_c015_1_07 0 conv_bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_1_07 (conv_i_src_c015_1_07 conv_i_c015_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_07 (conv_q_src_c015_1_07 0 conv_bpf_c015_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_1_07 (conv_q_src_c015_1_07 conv_q_c015_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_08 (conv_i_src_c015_1_08 0 conv_bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_1_08 (conv_i_src_c015_1_08 conv_i_c015_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_08 (conv_q_src_c015_1_08 0 conv_bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_1_08 (conv_q_src_c015_1_08 conv_q_c015_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_09 (conv_i_src_c015_1_09 0 conv_bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_1_09 (conv_i_src_c015_1_09 conv_i_c015_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_09 (conv_q_src_c015_1_09 0 conv_bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_1_09 (conv_q_src_c015_1_09 conv_q_c015_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_10 (conv_i_src_c015_1_10 0 conv_bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_1_10 (conv_i_src_c015_1_10 conv_i_c015_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_10 (conv_q_src_c015_1_10 0 conv_bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_1_10 (conv_q_src_c015_1_10 conv_q_c015_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_11 (conv_i_src_c015_1_11 0 conv_bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_1_11 (conv_i_src_c015_1_11 conv_i_c015_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_11 (conv_q_src_c015_1_11 0 conv_bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_1_11 (conv_q_src_c015_1_11 conv_q_c015_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_12 (conv_i_src_c015_1_12 0 conv_bpf_c015_1 0) vcvs gain=1.950903220161e-01
SCONVI_c015_1_12 (conv_i_src_c015_1_12 conv_i_c015_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_12 (conv_q_src_c015_1_12 0 conv_bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_1_12 (conv_q_src_c015_1_12 conv_q_c015_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_13 (conv_i_src_c015_1_13 0 conv_bpf_c015_1 0) vcvs gain=5.555702330196e-01
SCONVI_c015_1_13 (conv_i_src_c015_1_13 conv_i_c015_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_13 (conv_q_src_c015_1_13 0 conv_bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_1_13 (conv_q_src_c015_1_13 conv_q_c015_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_14 (conv_i_src_c015_1_14 0 conv_bpf_c015_1 0) vcvs gain=8.314696123025e-01
SCONVI_c015_1_14 (conv_i_src_c015_1_14 conv_i_c015_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_14 (conv_q_src_c015_1_14 0 conv_bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_1_14 (conv_q_src_c015_1_14 conv_q_c015_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_1_15 (conv_i_src_c015_1_15 0 conv_bpf_c015_1 0) vcvs gain=9.807852804032e-01
SCONVI_c015_1_15 (conv_i_src_c015_1_15 conv_i_c015_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_1_15 (conv_q_src_c015_1_15 0 conv_bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_1_15 (conv_q_src_c015_1_15 conv_q_c015_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c015_1 (conv_i_c015_1 0) resistor r=1G
RCONVQ_c015_1 (conv_q_c015_1 0) resistor r=1G
RCONVINTI_c015_1 (conv_i_c015_1 ConvIcar_c015_1) resistor r=1k
CCONVINTI_c015_1 (ConvIcar_c015_1 0) capacitor c=80p
RCONVINTQ_c015_1 (conv_q_c015_1 ConvQcar_c015_1) resistor r=1k
CCONVINTQ_c015_1 (ConvQcar_c015_1 0) capacitor c=80p
save conv_bpf_c015_1 ConvIcar_c015_1 ConvQcar_c015_1

// conventional mixed baseline bl015, carrier_2: 750000000 Hz
CCONVBPF_c015_2 (bl015 n_conv_cbpf_c015_2) capacitor c=4.503163717437e-14
LCONVBPF_c015_2 (n_conv_cbpf_c015_2 conv_bpf_c015_2) inductor l=1.000000000000e-06
RCONVBPF_c015_2 (conv_bpf_c015_2 0) resistor r=2.356194490192e+02
ECONVI_c015_2_00 (conv_i_src_c015_2_00 0 conv_bpf_c015_2 0) vcvs gain=9.807852804032e-01
SCONVI_c015_2_00 (conv_i_src_c015_2_00 conv_i_c015_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_00 (conv_q_src_c015_2_00 0 conv_bpf_c015_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_2_00 (conv_q_src_c015_2_00 conv_q_c015_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_01 (conv_i_src_c015_2_01 0 conv_bpf_c015_2 0) vcvs gain=8.314696123025e-01
SCONVI_c015_2_01 (conv_i_src_c015_2_01 conv_i_c015_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_01 (conv_q_src_c015_2_01 0 conv_bpf_c015_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_2_01 (conv_q_src_c015_2_01 conv_q_c015_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_02 (conv_i_src_c015_2_02 0 conv_bpf_c015_2 0) vcvs gain=5.555702330196e-01
SCONVI_c015_2_02 (conv_i_src_c015_2_02 conv_i_c015_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_02 (conv_q_src_c015_2_02 0 conv_bpf_c015_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_2_02 (conv_q_src_c015_2_02 conv_q_c015_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_03 (conv_i_src_c015_2_03 0 conv_bpf_c015_2 0) vcvs gain=1.950903220161e-01
SCONVI_c015_2_03 (conv_i_src_c015_2_03 conv_i_c015_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_03 (conv_q_src_c015_2_03 0 conv_bpf_c015_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_2_03 (conv_q_src_c015_2_03 conv_q_c015_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_04 (conv_i_src_c015_2_04 0 conv_bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_2_04 (conv_i_src_c015_2_04 conv_i_c015_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_04 (conv_q_src_c015_2_04 0 conv_bpf_c015_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_2_04 (conv_q_src_c015_2_04 conv_q_c015_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_05 (conv_i_src_c015_2_05 0 conv_bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_2_05 (conv_i_src_c015_2_05 conv_i_c015_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_05 (conv_q_src_c015_2_05 0 conv_bpf_c015_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_2_05 (conv_q_src_c015_2_05 conv_q_c015_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_06 (conv_i_src_c015_2_06 0 conv_bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_2_06 (conv_i_src_c015_2_06 conv_i_c015_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_06 (conv_q_src_c015_2_06 0 conv_bpf_c015_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_2_06 (conv_q_src_c015_2_06 conv_q_c015_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_07 (conv_i_src_c015_2_07 0 conv_bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_2_07 (conv_i_src_c015_2_07 conv_i_c015_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_07 (conv_q_src_c015_2_07 0 conv_bpf_c015_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_2_07 (conv_q_src_c015_2_07 conv_q_c015_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_08 (conv_i_src_c015_2_08 0 conv_bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_2_08 (conv_i_src_c015_2_08 conv_i_c015_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_08 (conv_q_src_c015_2_08 0 conv_bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_2_08 (conv_q_src_c015_2_08 conv_q_c015_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_09 (conv_i_src_c015_2_09 0 conv_bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_2_09 (conv_i_src_c015_2_09 conv_i_c015_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_09 (conv_q_src_c015_2_09 0 conv_bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_2_09 (conv_q_src_c015_2_09 conv_q_c015_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_10 (conv_i_src_c015_2_10 0 conv_bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_2_10 (conv_i_src_c015_2_10 conv_i_c015_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_10 (conv_q_src_c015_2_10 0 conv_bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_2_10 (conv_q_src_c015_2_10 conv_q_c015_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_11 (conv_i_src_c015_2_11 0 conv_bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_2_11 (conv_i_src_c015_2_11 conv_i_c015_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_11 (conv_q_src_c015_2_11 0 conv_bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_2_11 (conv_q_src_c015_2_11 conv_q_c015_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_12 (conv_i_src_c015_2_12 0 conv_bpf_c015_2 0) vcvs gain=1.950903220161e-01
SCONVI_c015_2_12 (conv_i_src_c015_2_12 conv_i_c015_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_12 (conv_q_src_c015_2_12 0 conv_bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_2_12 (conv_q_src_c015_2_12 conv_q_c015_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_13 (conv_i_src_c015_2_13 0 conv_bpf_c015_2 0) vcvs gain=5.555702330196e-01
SCONVI_c015_2_13 (conv_i_src_c015_2_13 conv_i_c015_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_13 (conv_q_src_c015_2_13 0 conv_bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_2_13 (conv_q_src_c015_2_13 conv_q_c015_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_14 (conv_i_src_c015_2_14 0 conv_bpf_c015_2 0) vcvs gain=8.314696123025e-01
SCONVI_c015_2_14 (conv_i_src_c015_2_14 conv_i_c015_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_14 (conv_q_src_c015_2_14 0 conv_bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_2_14 (conv_q_src_c015_2_14 conv_q_c015_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_2_15 (conv_i_src_c015_2_15 0 conv_bpf_c015_2 0) vcvs gain=9.807852804032e-01
SCONVI_c015_2_15 (conv_i_src_c015_2_15 conv_i_c015_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_2_15 (conv_q_src_c015_2_15 0 conv_bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_2_15 (conv_q_src_c015_2_15 conv_q_c015_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c015_2 (conv_i_c015_2 0) resistor r=1G
RCONVQ_c015_2 (conv_q_c015_2 0) resistor r=1G
RCONVINTI_c015_2 (conv_i_c015_2 ConvIcar_c015_2) resistor r=1k
CCONVINTI_c015_2 (ConvIcar_c015_2 0) capacitor c=80p
RCONVINTQ_c015_2 (conv_q_c015_2 ConvQcar_c015_2) resistor r=1k
CCONVINTQ_c015_2 (ConvQcar_c015_2 0) capacitor c=80p
save conv_bpf_c015_2 ConvIcar_c015_2 ConvQcar_c015_2

// conventional mixed baseline bl015, carrier_3: 1000000000 Hz
CCONVBPF_c015_3 (bl015 n_conv_cbpf_c015_3) capacitor c=2.533029591058e-14
LCONVBPF_c015_3 (n_conv_cbpf_c015_3 conv_bpf_c015_3) inductor l=1.000000000000e-06
RCONVBPF_c015_3 (conv_bpf_c015_3 0) resistor r=3.141592653590e+02
ECONVI_c015_3_00 (conv_i_src_c015_3_00 0 conv_bpf_c015_3 0) vcvs gain=9.807852804032e-01
SCONVI_c015_3_00 (conv_i_src_c015_3_00 conv_i_c015_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_00 (conv_q_src_c015_3_00 0 conv_bpf_c015_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_3_00 (conv_q_src_c015_3_00 conv_q_c015_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_01 (conv_i_src_c015_3_01 0 conv_bpf_c015_3 0) vcvs gain=8.314696123025e-01
SCONVI_c015_3_01 (conv_i_src_c015_3_01 conv_i_c015_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_01 (conv_q_src_c015_3_01 0 conv_bpf_c015_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_3_01 (conv_q_src_c015_3_01 conv_q_c015_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_02 (conv_i_src_c015_3_02 0 conv_bpf_c015_3 0) vcvs gain=5.555702330196e-01
SCONVI_c015_3_02 (conv_i_src_c015_3_02 conv_i_c015_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_02 (conv_q_src_c015_3_02 0 conv_bpf_c015_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_3_02 (conv_q_src_c015_3_02 conv_q_c015_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_03 (conv_i_src_c015_3_03 0 conv_bpf_c015_3 0) vcvs gain=1.950903220161e-01
SCONVI_c015_3_03 (conv_i_src_c015_3_03 conv_i_c015_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_03 (conv_q_src_c015_3_03 0 conv_bpf_c015_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_3_03 (conv_q_src_c015_3_03 conv_q_c015_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_04 (conv_i_src_c015_3_04 0 conv_bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_3_04 (conv_i_src_c015_3_04 conv_i_c015_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_04 (conv_q_src_c015_3_04 0 conv_bpf_c015_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c015_3_04 (conv_q_src_c015_3_04 conv_q_c015_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_05 (conv_i_src_c015_3_05 0 conv_bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_3_05 (conv_i_src_c015_3_05 conv_i_c015_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_05 (conv_q_src_c015_3_05 0 conv_bpf_c015_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c015_3_05 (conv_q_src_c015_3_05 conv_q_c015_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_06 (conv_i_src_c015_3_06 0 conv_bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_3_06 (conv_i_src_c015_3_06 conv_i_c015_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_06 (conv_q_src_c015_3_06 0 conv_bpf_c015_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c015_3_06 (conv_q_src_c015_3_06 conv_q_c015_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_07 (conv_i_src_c015_3_07 0 conv_bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_3_07 (conv_i_src_c015_3_07 conv_i_c015_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_07 (conv_q_src_c015_3_07 0 conv_bpf_c015_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c015_3_07 (conv_q_src_c015_3_07 conv_q_c015_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_08 (conv_i_src_c015_3_08 0 conv_bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c015_3_08 (conv_i_src_c015_3_08 conv_i_c015_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_08 (conv_q_src_c015_3_08 0 conv_bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_3_08 (conv_q_src_c015_3_08 conv_q_c015_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_09 (conv_i_src_c015_3_09 0 conv_bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c015_3_09 (conv_i_src_c015_3_09 conv_i_c015_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_09 (conv_q_src_c015_3_09 0 conv_bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_3_09 (conv_q_src_c015_3_09 conv_q_c015_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_10 (conv_i_src_c015_3_10 0 conv_bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c015_3_10 (conv_i_src_c015_3_10 conv_i_c015_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_10 (conv_q_src_c015_3_10 0 conv_bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_3_10 (conv_q_src_c015_3_10 conv_q_c015_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_11 (conv_i_src_c015_3_11 0 conv_bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c015_3_11 (conv_i_src_c015_3_11 conv_i_c015_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_11 (conv_q_src_c015_3_11 0 conv_bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_3_11 (conv_q_src_c015_3_11 conv_q_c015_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_12 (conv_i_src_c015_3_12 0 conv_bpf_c015_3 0) vcvs gain=1.950903220161e-01
SCONVI_c015_3_12 (conv_i_src_c015_3_12 conv_i_c015_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_12 (conv_q_src_c015_3_12 0 conv_bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c015_3_12 (conv_q_src_c015_3_12 conv_q_c015_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_13 (conv_i_src_c015_3_13 0 conv_bpf_c015_3 0) vcvs gain=5.555702330196e-01
SCONVI_c015_3_13 (conv_i_src_c015_3_13 conv_i_c015_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_13 (conv_q_src_c015_3_13 0 conv_bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c015_3_13 (conv_q_src_c015_3_13 conv_q_c015_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_14 (conv_i_src_c015_3_14 0 conv_bpf_c015_3 0) vcvs gain=8.314696123025e-01
SCONVI_c015_3_14 (conv_i_src_c015_3_14 conv_i_c015_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_14 (conv_q_src_c015_3_14 0 conv_bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c015_3_14 (conv_q_src_c015_3_14 conv_q_c015_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c015_3_15 (conv_i_src_c015_3_15 0 conv_bpf_c015_3 0) vcvs gain=9.807852804032e-01
SCONVI_c015_3_15 (conv_i_src_c015_3_15 conv_i_c015_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c015_3_15 (conv_q_src_c015_3_15 0 conv_bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c015_3_15 (conv_q_src_c015_3_15 conv_q_c015_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c015_3 (conv_i_c015_3 0) resistor r=1G
RCONVQ_c015_3 (conv_q_c015_3 0) resistor r=1G
RCONVINTI_c015_3 (conv_i_c015_3 ConvIcar_c015_3) resistor r=1k
CCONVINTI_c015_3 (ConvIcar_c015_3 0) capacitor c=80p
RCONVINTQ_c015_3 (conv_q_c015_3 ConvQcar_c015_3) resistor r=1k
CCONVINTQ_c015_3 (ConvQcar_c015_3 0) capacitor c=80p
save conv_bpf_c015_3 ConvIcar_c015_3 ConvQcar_c015_3

// conventional mixed baseline bl016, carrier_0: 250000000 Hz
CCONVBPF_c016_0 (bl016 n_conv_cbpf_c016_0) capacitor c=4.052847345694e-13
LCONVBPF_c016_0 (n_conv_cbpf_c016_0 conv_bpf_c016_0) inductor l=1.000000000000e-06
RCONVBPF_c016_0 (conv_bpf_c016_0 0) resistor r=7.853981633974e+01
ECONVI_c016_0_00 (conv_i_src_c016_0_00 0 conv_bpf_c016_0 0) vcvs gain=9.807852804032e-01
SCONVI_c016_0_00 (conv_i_src_c016_0_00 conv_i_c016_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_00 (conv_q_src_c016_0_00 0 conv_bpf_c016_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_0_00 (conv_q_src_c016_0_00 conv_q_c016_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_01 (conv_i_src_c016_0_01 0 conv_bpf_c016_0 0) vcvs gain=8.314696123025e-01
SCONVI_c016_0_01 (conv_i_src_c016_0_01 conv_i_c016_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_01 (conv_q_src_c016_0_01 0 conv_bpf_c016_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_0_01 (conv_q_src_c016_0_01 conv_q_c016_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_02 (conv_i_src_c016_0_02 0 conv_bpf_c016_0 0) vcvs gain=5.555702330196e-01
SCONVI_c016_0_02 (conv_i_src_c016_0_02 conv_i_c016_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_02 (conv_q_src_c016_0_02 0 conv_bpf_c016_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_0_02 (conv_q_src_c016_0_02 conv_q_c016_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_03 (conv_i_src_c016_0_03 0 conv_bpf_c016_0 0) vcvs gain=1.950903220161e-01
SCONVI_c016_0_03 (conv_i_src_c016_0_03 conv_i_c016_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_03 (conv_q_src_c016_0_03 0 conv_bpf_c016_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_0_03 (conv_q_src_c016_0_03 conv_q_c016_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_04 (conv_i_src_c016_0_04 0 conv_bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_0_04 (conv_i_src_c016_0_04 conv_i_c016_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_04 (conv_q_src_c016_0_04 0 conv_bpf_c016_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_0_04 (conv_q_src_c016_0_04 conv_q_c016_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_05 (conv_i_src_c016_0_05 0 conv_bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_0_05 (conv_i_src_c016_0_05 conv_i_c016_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_05 (conv_q_src_c016_0_05 0 conv_bpf_c016_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_0_05 (conv_q_src_c016_0_05 conv_q_c016_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_06 (conv_i_src_c016_0_06 0 conv_bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_0_06 (conv_i_src_c016_0_06 conv_i_c016_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_06 (conv_q_src_c016_0_06 0 conv_bpf_c016_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_0_06 (conv_q_src_c016_0_06 conv_q_c016_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_07 (conv_i_src_c016_0_07 0 conv_bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_0_07 (conv_i_src_c016_0_07 conv_i_c016_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_07 (conv_q_src_c016_0_07 0 conv_bpf_c016_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_0_07 (conv_q_src_c016_0_07 conv_q_c016_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_08 (conv_i_src_c016_0_08 0 conv_bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_0_08 (conv_i_src_c016_0_08 conv_i_c016_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_08 (conv_q_src_c016_0_08 0 conv_bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_0_08 (conv_q_src_c016_0_08 conv_q_c016_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_09 (conv_i_src_c016_0_09 0 conv_bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_0_09 (conv_i_src_c016_0_09 conv_i_c016_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_09 (conv_q_src_c016_0_09 0 conv_bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_0_09 (conv_q_src_c016_0_09 conv_q_c016_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_10 (conv_i_src_c016_0_10 0 conv_bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_0_10 (conv_i_src_c016_0_10 conv_i_c016_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_10 (conv_q_src_c016_0_10 0 conv_bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_0_10 (conv_q_src_c016_0_10 conv_q_c016_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_11 (conv_i_src_c016_0_11 0 conv_bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_0_11 (conv_i_src_c016_0_11 conv_i_c016_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_11 (conv_q_src_c016_0_11 0 conv_bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_0_11 (conv_q_src_c016_0_11 conv_q_c016_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_12 (conv_i_src_c016_0_12 0 conv_bpf_c016_0 0) vcvs gain=1.950903220161e-01
SCONVI_c016_0_12 (conv_i_src_c016_0_12 conv_i_c016_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_12 (conv_q_src_c016_0_12 0 conv_bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_0_12 (conv_q_src_c016_0_12 conv_q_c016_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_13 (conv_i_src_c016_0_13 0 conv_bpf_c016_0 0) vcvs gain=5.555702330196e-01
SCONVI_c016_0_13 (conv_i_src_c016_0_13 conv_i_c016_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_13 (conv_q_src_c016_0_13 0 conv_bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_0_13 (conv_q_src_c016_0_13 conv_q_c016_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_14 (conv_i_src_c016_0_14 0 conv_bpf_c016_0 0) vcvs gain=8.314696123025e-01
SCONVI_c016_0_14 (conv_i_src_c016_0_14 conv_i_c016_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_14 (conv_q_src_c016_0_14 0 conv_bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_0_14 (conv_q_src_c016_0_14 conv_q_c016_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_0_15 (conv_i_src_c016_0_15 0 conv_bpf_c016_0 0) vcvs gain=9.807852804032e-01
SCONVI_c016_0_15 (conv_i_src_c016_0_15 conv_i_c016_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_0_15 (conv_q_src_c016_0_15 0 conv_bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_0_15 (conv_q_src_c016_0_15 conv_q_c016_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c016_0 (conv_i_c016_0 0) resistor r=1G
RCONVQ_c016_0 (conv_q_c016_0 0) resistor r=1G
RCONVINTI_c016_0 (conv_i_c016_0 ConvIcar_c016_0) resistor r=1k
CCONVINTI_c016_0 (ConvIcar_c016_0 0) capacitor c=80p
RCONVINTQ_c016_0 (conv_q_c016_0 ConvQcar_c016_0) resistor r=1k
CCONVINTQ_c016_0 (ConvQcar_c016_0 0) capacitor c=80p
save conv_bpf_c016_0 ConvIcar_c016_0 ConvQcar_c016_0

// conventional mixed baseline bl016, carrier_1: 500000000 Hz
CCONVBPF_c016_1 (bl016 n_conv_cbpf_c016_1) capacitor c=1.013211836423e-13
LCONVBPF_c016_1 (n_conv_cbpf_c016_1 conv_bpf_c016_1) inductor l=1.000000000000e-06
RCONVBPF_c016_1 (conv_bpf_c016_1 0) resistor r=1.570796326795e+02
ECONVI_c016_1_00 (conv_i_src_c016_1_00 0 conv_bpf_c016_1 0) vcvs gain=9.807852804032e-01
SCONVI_c016_1_00 (conv_i_src_c016_1_00 conv_i_c016_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_00 (conv_q_src_c016_1_00 0 conv_bpf_c016_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_1_00 (conv_q_src_c016_1_00 conv_q_c016_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_01 (conv_i_src_c016_1_01 0 conv_bpf_c016_1 0) vcvs gain=8.314696123025e-01
SCONVI_c016_1_01 (conv_i_src_c016_1_01 conv_i_c016_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_01 (conv_q_src_c016_1_01 0 conv_bpf_c016_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_1_01 (conv_q_src_c016_1_01 conv_q_c016_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_02 (conv_i_src_c016_1_02 0 conv_bpf_c016_1 0) vcvs gain=5.555702330196e-01
SCONVI_c016_1_02 (conv_i_src_c016_1_02 conv_i_c016_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_02 (conv_q_src_c016_1_02 0 conv_bpf_c016_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_1_02 (conv_q_src_c016_1_02 conv_q_c016_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_03 (conv_i_src_c016_1_03 0 conv_bpf_c016_1 0) vcvs gain=1.950903220161e-01
SCONVI_c016_1_03 (conv_i_src_c016_1_03 conv_i_c016_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_03 (conv_q_src_c016_1_03 0 conv_bpf_c016_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_1_03 (conv_q_src_c016_1_03 conv_q_c016_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_04 (conv_i_src_c016_1_04 0 conv_bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_1_04 (conv_i_src_c016_1_04 conv_i_c016_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_04 (conv_q_src_c016_1_04 0 conv_bpf_c016_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_1_04 (conv_q_src_c016_1_04 conv_q_c016_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_05 (conv_i_src_c016_1_05 0 conv_bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_1_05 (conv_i_src_c016_1_05 conv_i_c016_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_05 (conv_q_src_c016_1_05 0 conv_bpf_c016_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_1_05 (conv_q_src_c016_1_05 conv_q_c016_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_06 (conv_i_src_c016_1_06 0 conv_bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_1_06 (conv_i_src_c016_1_06 conv_i_c016_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_06 (conv_q_src_c016_1_06 0 conv_bpf_c016_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_1_06 (conv_q_src_c016_1_06 conv_q_c016_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_07 (conv_i_src_c016_1_07 0 conv_bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_1_07 (conv_i_src_c016_1_07 conv_i_c016_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_07 (conv_q_src_c016_1_07 0 conv_bpf_c016_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_1_07 (conv_q_src_c016_1_07 conv_q_c016_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_08 (conv_i_src_c016_1_08 0 conv_bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_1_08 (conv_i_src_c016_1_08 conv_i_c016_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_08 (conv_q_src_c016_1_08 0 conv_bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_1_08 (conv_q_src_c016_1_08 conv_q_c016_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_09 (conv_i_src_c016_1_09 0 conv_bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_1_09 (conv_i_src_c016_1_09 conv_i_c016_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_09 (conv_q_src_c016_1_09 0 conv_bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_1_09 (conv_q_src_c016_1_09 conv_q_c016_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_10 (conv_i_src_c016_1_10 0 conv_bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_1_10 (conv_i_src_c016_1_10 conv_i_c016_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_10 (conv_q_src_c016_1_10 0 conv_bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_1_10 (conv_q_src_c016_1_10 conv_q_c016_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_11 (conv_i_src_c016_1_11 0 conv_bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_1_11 (conv_i_src_c016_1_11 conv_i_c016_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_11 (conv_q_src_c016_1_11 0 conv_bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_1_11 (conv_q_src_c016_1_11 conv_q_c016_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_12 (conv_i_src_c016_1_12 0 conv_bpf_c016_1 0) vcvs gain=1.950903220161e-01
SCONVI_c016_1_12 (conv_i_src_c016_1_12 conv_i_c016_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_12 (conv_q_src_c016_1_12 0 conv_bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_1_12 (conv_q_src_c016_1_12 conv_q_c016_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_13 (conv_i_src_c016_1_13 0 conv_bpf_c016_1 0) vcvs gain=5.555702330196e-01
SCONVI_c016_1_13 (conv_i_src_c016_1_13 conv_i_c016_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_13 (conv_q_src_c016_1_13 0 conv_bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_1_13 (conv_q_src_c016_1_13 conv_q_c016_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_14 (conv_i_src_c016_1_14 0 conv_bpf_c016_1 0) vcvs gain=8.314696123025e-01
SCONVI_c016_1_14 (conv_i_src_c016_1_14 conv_i_c016_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_14 (conv_q_src_c016_1_14 0 conv_bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_1_14 (conv_q_src_c016_1_14 conv_q_c016_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_1_15 (conv_i_src_c016_1_15 0 conv_bpf_c016_1 0) vcvs gain=9.807852804032e-01
SCONVI_c016_1_15 (conv_i_src_c016_1_15 conv_i_c016_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_1_15 (conv_q_src_c016_1_15 0 conv_bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_1_15 (conv_q_src_c016_1_15 conv_q_c016_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c016_1 (conv_i_c016_1 0) resistor r=1G
RCONVQ_c016_1 (conv_q_c016_1 0) resistor r=1G
RCONVINTI_c016_1 (conv_i_c016_1 ConvIcar_c016_1) resistor r=1k
CCONVINTI_c016_1 (ConvIcar_c016_1 0) capacitor c=80p
RCONVINTQ_c016_1 (conv_q_c016_1 ConvQcar_c016_1) resistor r=1k
CCONVINTQ_c016_1 (ConvQcar_c016_1 0) capacitor c=80p
save conv_bpf_c016_1 ConvIcar_c016_1 ConvQcar_c016_1

// conventional mixed baseline bl016, carrier_2: 750000000 Hz
CCONVBPF_c016_2 (bl016 n_conv_cbpf_c016_2) capacitor c=4.503163717437e-14
LCONVBPF_c016_2 (n_conv_cbpf_c016_2 conv_bpf_c016_2) inductor l=1.000000000000e-06
RCONVBPF_c016_2 (conv_bpf_c016_2 0) resistor r=2.356194490192e+02
ECONVI_c016_2_00 (conv_i_src_c016_2_00 0 conv_bpf_c016_2 0) vcvs gain=9.807852804032e-01
SCONVI_c016_2_00 (conv_i_src_c016_2_00 conv_i_c016_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_00 (conv_q_src_c016_2_00 0 conv_bpf_c016_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_2_00 (conv_q_src_c016_2_00 conv_q_c016_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_01 (conv_i_src_c016_2_01 0 conv_bpf_c016_2 0) vcvs gain=8.314696123025e-01
SCONVI_c016_2_01 (conv_i_src_c016_2_01 conv_i_c016_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_01 (conv_q_src_c016_2_01 0 conv_bpf_c016_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_2_01 (conv_q_src_c016_2_01 conv_q_c016_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_02 (conv_i_src_c016_2_02 0 conv_bpf_c016_2 0) vcvs gain=5.555702330196e-01
SCONVI_c016_2_02 (conv_i_src_c016_2_02 conv_i_c016_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_02 (conv_q_src_c016_2_02 0 conv_bpf_c016_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_2_02 (conv_q_src_c016_2_02 conv_q_c016_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_03 (conv_i_src_c016_2_03 0 conv_bpf_c016_2 0) vcvs gain=1.950903220161e-01
SCONVI_c016_2_03 (conv_i_src_c016_2_03 conv_i_c016_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_03 (conv_q_src_c016_2_03 0 conv_bpf_c016_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_2_03 (conv_q_src_c016_2_03 conv_q_c016_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_04 (conv_i_src_c016_2_04 0 conv_bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_2_04 (conv_i_src_c016_2_04 conv_i_c016_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_04 (conv_q_src_c016_2_04 0 conv_bpf_c016_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_2_04 (conv_q_src_c016_2_04 conv_q_c016_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_05 (conv_i_src_c016_2_05 0 conv_bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_2_05 (conv_i_src_c016_2_05 conv_i_c016_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_05 (conv_q_src_c016_2_05 0 conv_bpf_c016_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_2_05 (conv_q_src_c016_2_05 conv_q_c016_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_06 (conv_i_src_c016_2_06 0 conv_bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_2_06 (conv_i_src_c016_2_06 conv_i_c016_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_06 (conv_q_src_c016_2_06 0 conv_bpf_c016_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_2_06 (conv_q_src_c016_2_06 conv_q_c016_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_07 (conv_i_src_c016_2_07 0 conv_bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_2_07 (conv_i_src_c016_2_07 conv_i_c016_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_07 (conv_q_src_c016_2_07 0 conv_bpf_c016_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_2_07 (conv_q_src_c016_2_07 conv_q_c016_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_08 (conv_i_src_c016_2_08 0 conv_bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_2_08 (conv_i_src_c016_2_08 conv_i_c016_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_08 (conv_q_src_c016_2_08 0 conv_bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_2_08 (conv_q_src_c016_2_08 conv_q_c016_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_09 (conv_i_src_c016_2_09 0 conv_bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_2_09 (conv_i_src_c016_2_09 conv_i_c016_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_09 (conv_q_src_c016_2_09 0 conv_bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_2_09 (conv_q_src_c016_2_09 conv_q_c016_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_10 (conv_i_src_c016_2_10 0 conv_bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_2_10 (conv_i_src_c016_2_10 conv_i_c016_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_10 (conv_q_src_c016_2_10 0 conv_bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_2_10 (conv_q_src_c016_2_10 conv_q_c016_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_11 (conv_i_src_c016_2_11 0 conv_bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_2_11 (conv_i_src_c016_2_11 conv_i_c016_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_11 (conv_q_src_c016_2_11 0 conv_bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_2_11 (conv_q_src_c016_2_11 conv_q_c016_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_12 (conv_i_src_c016_2_12 0 conv_bpf_c016_2 0) vcvs gain=1.950903220161e-01
SCONVI_c016_2_12 (conv_i_src_c016_2_12 conv_i_c016_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_12 (conv_q_src_c016_2_12 0 conv_bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_2_12 (conv_q_src_c016_2_12 conv_q_c016_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_13 (conv_i_src_c016_2_13 0 conv_bpf_c016_2 0) vcvs gain=5.555702330196e-01
SCONVI_c016_2_13 (conv_i_src_c016_2_13 conv_i_c016_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_13 (conv_q_src_c016_2_13 0 conv_bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_2_13 (conv_q_src_c016_2_13 conv_q_c016_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_14 (conv_i_src_c016_2_14 0 conv_bpf_c016_2 0) vcvs gain=8.314696123025e-01
SCONVI_c016_2_14 (conv_i_src_c016_2_14 conv_i_c016_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_14 (conv_q_src_c016_2_14 0 conv_bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_2_14 (conv_q_src_c016_2_14 conv_q_c016_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_2_15 (conv_i_src_c016_2_15 0 conv_bpf_c016_2 0) vcvs gain=9.807852804032e-01
SCONVI_c016_2_15 (conv_i_src_c016_2_15 conv_i_c016_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_2_15 (conv_q_src_c016_2_15 0 conv_bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_2_15 (conv_q_src_c016_2_15 conv_q_c016_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c016_2 (conv_i_c016_2 0) resistor r=1G
RCONVQ_c016_2 (conv_q_c016_2 0) resistor r=1G
RCONVINTI_c016_2 (conv_i_c016_2 ConvIcar_c016_2) resistor r=1k
CCONVINTI_c016_2 (ConvIcar_c016_2 0) capacitor c=80p
RCONVINTQ_c016_2 (conv_q_c016_2 ConvQcar_c016_2) resistor r=1k
CCONVINTQ_c016_2 (ConvQcar_c016_2 0) capacitor c=80p
save conv_bpf_c016_2 ConvIcar_c016_2 ConvQcar_c016_2

// conventional mixed baseline bl016, carrier_3: 1000000000 Hz
CCONVBPF_c016_3 (bl016 n_conv_cbpf_c016_3) capacitor c=2.533029591058e-14
LCONVBPF_c016_3 (n_conv_cbpf_c016_3 conv_bpf_c016_3) inductor l=1.000000000000e-06
RCONVBPF_c016_3 (conv_bpf_c016_3 0) resistor r=3.141592653590e+02
ECONVI_c016_3_00 (conv_i_src_c016_3_00 0 conv_bpf_c016_3 0) vcvs gain=9.807852804032e-01
SCONVI_c016_3_00 (conv_i_src_c016_3_00 conv_i_c016_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_00 (conv_q_src_c016_3_00 0 conv_bpf_c016_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_3_00 (conv_q_src_c016_3_00 conv_q_c016_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_01 (conv_i_src_c016_3_01 0 conv_bpf_c016_3 0) vcvs gain=8.314696123025e-01
SCONVI_c016_3_01 (conv_i_src_c016_3_01 conv_i_c016_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_01 (conv_q_src_c016_3_01 0 conv_bpf_c016_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_3_01 (conv_q_src_c016_3_01 conv_q_c016_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_02 (conv_i_src_c016_3_02 0 conv_bpf_c016_3 0) vcvs gain=5.555702330196e-01
SCONVI_c016_3_02 (conv_i_src_c016_3_02 conv_i_c016_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_02 (conv_q_src_c016_3_02 0 conv_bpf_c016_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_3_02 (conv_q_src_c016_3_02 conv_q_c016_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_03 (conv_i_src_c016_3_03 0 conv_bpf_c016_3 0) vcvs gain=1.950903220161e-01
SCONVI_c016_3_03 (conv_i_src_c016_3_03 conv_i_c016_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_03 (conv_q_src_c016_3_03 0 conv_bpf_c016_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_3_03 (conv_q_src_c016_3_03 conv_q_c016_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_04 (conv_i_src_c016_3_04 0 conv_bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_3_04 (conv_i_src_c016_3_04 conv_i_c016_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_04 (conv_q_src_c016_3_04 0 conv_bpf_c016_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c016_3_04 (conv_q_src_c016_3_04 conv_q_c016_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_05 (conv_i_src_c016_3_05 0 conv_bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_3_05 (conv_i_src_c016_3_05 conv_i_c016_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_05 (conv_q_src_c016_3_05 0 conv_bpf_c016_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c016_3_05 (conv_q_src_c016_3_05 conv_q_c016_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_06 (conv_i_src_c016_3_06 0 conv_bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_3_06 (conv_i_src_c016_3_06 conv_i_c016_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_06 (conv_q_src_c016_3_06 0 conv_bpf_c016_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c016_3_06 (conv_q_src_c016_3_06 conv_q_c016_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_07 (conv_i_src_c016_3_07 0 conv_bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_3_07 (conv_i_src_c016_3_07 conv_i_c016_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_07 (conv_q_src_c016_3_07 0 conv_bpf_c016_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c016_3_07 (conv_q_src_c016_3_07 conv_q_c016_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_08 (conv_i_src_c016_3_08 0 conv_bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c016_3_08 (conv_i_src_c016_3_08 conv_i_c016_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_08 (conv_q_src_c016_3_08 0 conv_bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_3_08 (conv_q_src_c016_3_08 conv_q_c016_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_09 (conv_i_src_c016_3_09 0 conv_bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c016_3_09 (conv_i_src_c016_3_09 conv_i_c016_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_09 (conv_q_src_c016_3_09 0 conv_bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_3_09 (conv_q_src_c016_3_09 conv_q_c016_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_10 (conv_i_src_c016_3_10 0 conv_bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c016_3_10 (conv_i_src_c016_3_10 conv_i_c016_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_10 (conv_q_src_c016_3_10 0 conv_bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_3_10 (conv_q_src_c016_3_10 conv_q_c016_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_11 (conv_i_src_c016_3_11 0 conv_bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c016_3_11 (conv_i_src_c016_3_11 conv_i_c016_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_11 (conv_q_src_c016_3_11 0 conv_bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_3_11 (conv_q_src_c016_3_11 conv_q_c016_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_12 (conv_i_src_c016_3_12 0 conv_bpf_c016_3 0) vcvs gain=1.950903220161e-01
SCONVI_c016_3_12 (conv_i_src_c016_3_12 conv_i_c016_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_12 (conv_q_src_c016_3_12 0 conv_bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c016_3_12 (conv_q_src_c016_3_12 conv_q_c016_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_13 (conv_i_src_c016_3_13 0 conv_bpf_c016_3 0) vcvs gain=5.555702330196e-01
SCONVI_c016_3_13 (conv_i_src_c016_3_13 conv_i_c016_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_13 (conv_q_src_c016_3_13 0 conv_bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c016_3_13 (conv_q_src_c016_3_13 conv_q_c016_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_14 (conv_i_src_c016_3_14 0 conv_bpf_c016_3 0) vcvs gain=8.314696123025e-01
SCONVI_c016_3_14 (conv_i_src_c016_3_14 conv_i_c016_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_14 (conv_q_src_c016_3_14 0 conv_bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c016_3_14 (conv_q_src_c016_3_14 conv_q_c016_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c016_3_15 (conv_i_src_c016_3_15 0 conv_bpf_c016_3 0) vcvs gain=9.807852804032e-01
SCONVI_c016_3_15 (conv_i_src_c016_3_15 conv_i_c016_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c016_3_15 (conv_q_src_c016_3_15 0 conv_bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c016_3_15 (conv_q_src_c016_3_15 conv_q_c016_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c016_3 (conv_i_c016_3 0) resistor r=1G
RCONVQ_c016_3 (conv_q_c016_3 0) resistor r=1G
RCONVINTI_c016_3 (conv_i_c016_3 ConvIcar_c016_3) resistor r=1k
CCONVINTI_c016_3 (ConvIcar_c016_3 0) capacitor c=80p
RCONVINTQ_c016_3 (conv_q_c016_3 ConvQcar_c016_3) resistor r=1k
CCONVINTQ_c016_3 (ConvQcar_c016_3 0) capacitor c=80p
save conv_bpf_c016_3 ConvIcar_c016_3 ConvQcar_c016_3

// conventional mixed baseline bl017, carrier_0: 250000000 Hz
CCONVBPF_c017_0 (bl017 n_conv_cbpf_c017_0) capacitor c=4.052847345694e-13
LCONVBPF_c017_0 (n_conv_cbpf_c017_0 conv_bpf_c017_0) inductor l=1.000000000000e-06
RCONVBPF_c017_0 (conv_bpf_c017_0 0) resistor r=7.853981633974e+01
ECONVI_c017_0_00 (conv_i_src_c017_0_00 0 conv_bpf_c017_0 0) vcvs gain=9.807852804032e-01
SCONVI_c017_0_00 (conv_i_src_c017_0_00 conv_i_c017_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_00 (conv_q_src_c017_0_00 0 conv_bpf_c017_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_0_00 (conv_q_src_c017_0_00 conv_q_c017_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_01 (conv_i_src_c017_0_01 0 conv_bpf_c017_0 0) vcvs gain=8.314696123025e-01
SCONVI_c017_0_01 (conv_i_src_c017_0_01 conv_i_c017_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_01 (conv_q_src_c017_0_01 0 conv_bpf_c017_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_0_01 (conv_q_src_c017_0_01 conv_q_c017_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_02 (conv_i_src_c017_0_02 0 conv_bpf_c017_0 0) vcvs gain=5.555702330196e-01
SCONVI_c017_0_02 (conv_i_src_c017_0_02 conv_i_c017_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_02 (conv_q_src_c017_0_02 0 conv_bpf_c017_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_0_02 (conv_q_src_c017_0_02 conv_q_c017_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_03 (conv_i_src_c017_0_03 0 conv_bpf_c017_0 0) vcvs gain=1.950903220161e-01
SCONVI_c017_0_03 (conv_i_src_c017_0_03 conv_i_c017_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_03 (conv_q_src_c017_0_03 0 conv_bpf_c017_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_0_03 (conv_q_src_c017_0_03 conv_q_c017_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_04 (conv_i_src_c017_0_04 0 conv_bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_0_04 (conv_i_src_c017_0_04 conv_i_c017_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_04 (conv_q_src_c017_0_04 0 conv_bpf_c017_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_0_04 (conv_q_src_c017_0_04 conv_q_c017_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_05 (conv_i_src_c017_0_05 0 conv_bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_0_05 (conv_i_src_c017_0_05 conv_i_c017_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_05 (conv_q_src_c017_0_05 0 conv_bpf_c017_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_0_05 (conv_q_src_c017_0_05 conv_q_c017_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_06 (conv_i_src_c017_0_06 0 conv_bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_0_06 (conv_i_src_c017_0_06 conv_i_c017_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_06 (conv_q_src_c017_0_06 0 conv_bpf_c017_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_0_06 (conv_q_src_c017_0_06 conv_q_c017_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_07 (conv_i_src_c017_0_07 0 conv_bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_0_07 (conv_i_src_c017_0_07 conv_i_c017_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_07 (conv_q_src_c017_0_07 0 conv_bpf_c017_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_0_07 (conv_q_src_c017_0_07 conv_q_c017_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_08 (conv_i_src_c017_0_08 0 conv_bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_0_08 (conv_i_src_c017_0_08 conv_i_c017_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_08 (conv_q_src_c017_0_08 0 conv_bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_0_08 (conv_q_src_c017_0_08 conv_q_c017_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_09 (conv_i_src_c017_0_09 0 conv_bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_0_09 (conv_i_src_c017_0_09 conv_i_c017_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_09 (conv_q_src_c017_0_09 0 conv_bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_0_09 (conv_q_src_c017_0_09 conv_q_c017_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_10 (conv_i_src_c017_0_10 0 conv_bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_0_10 (conv_i_src_c017_0_10 conv_i_c017_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_10 (conv_q_src_c017_0_10 0 conv_bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_0_10 (conv_q_src_c017_0_10 conv_q_c017_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_11 (conv_i_src_c017_0_11 0 conv_bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_0_11 (conv_i_src_c017_0_11 conv_i_c017_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_11 (conv_q_src_c017_0_11 0 conv_bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_0_11 (conv_q_src_c017_0_11 conv_q_c017_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_12 (conv_i_src_c017_0_12 0 conv_bpf_c017_0 0) vcvs gain=1.950903220161e-01
SCONVI_c017_0_12 (conv_i_src_c017_0_12 conv_i_c017_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_12 (conv_q_src_c017_0_12 0 conv_bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_0_12 (conv_q_src_c017_0_12 conv_q_c017_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_13 (conv_i_src_c017_0_13 0 conv_bpf_c017_0 0) vcvs gain=5.555702330196e-01
SCONVI_c017_0_13 (conv_i_src_c017_0_13 conv_i_c017_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_13 (conv_q_src_c017_0_13 0 conv_bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_0_13 (conv_q_src_c017_0_13 conv_q_c017_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_14 (conv_i_src_c017_0_14 0 conv_bpf_c017_0 0) vcvs gain=8.314696123025e-01
SCONVI_c017_0_14 (conv_i_src_c017_0_14 conv_i_c017_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_14 (conv_q_src_c017_0_14 0 conv_bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_0_14 (conv_q_src_c017_0_14 conv_q_c017_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_0_15 (conv_i_src_c017_0_15 0 conv_bpf_c017_0 0) vcvs gain=9.807852804032e-01
SCONVI_c017_0_15 (conv_i_src_c017_0_15 conv_i_c017_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_0_15 (conv_q_src_c017_0_15 0 conv_bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_0_15 (conv_q_src_c017_0_15 conv_q_c017_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c017_0 (conv_i_c017_0 0) resistor r=1G
RCONVQ_c017_0 (conv_q_c017_0 0) resistor r=1G
RCONVINTI_c017_0 (conv_i_c017_0 ConvIcar_c017_0) resistor r=1k
CCONVINTI_c017_0 (ConvIcar_c017_0 0) capacitor c=80p
RCONVINTQ_c017_0 (conv_q_c017_0 ConvQcar_c017_0) resistor r=1k
CCONVINTQ_c017_0 (ConvQcar_c017_0 0) capacitor c=80p
save conv_bpf_c017_0 ConvIcar_c017_0 ConvQcar_c017_0

// conventional mixed baseline bl017, carrier_1: 500000000 Hz
CCONVBPF_c017_1 (bl017 n_conv_cbpf_c017_1) capacitor c=1.013211836423e-13
LCONVBPF_c017_1 (n_conv_cbpf_c017_1 conv_bpf_c017_1) inductor l=1.000000000000e-06
RCONVBPF_c017_1 (conv_bpf_c017_1 0) resistor r=1.570796326795e+02
ECONVI_c017_1_00 (conv_i_src_c017_1_00 0 conv_bpf_c017_1 0) vcvs gain=9.807852804032e-01
SCONVI_c017_1_00 (conv_i_src_c017_1_00 conv_i_c017_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_00 (conv_q_src_c017_1_00 0 conv_bpf_c017_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_1_00 (conv_q_src_c017_1_00 conv_q_c017_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_01 (conv_i_src_c017_1_01 0 conv_bpf_c017_1 0) vcvs gain=8.314696123025e-01
SCONVI_c017_1_01 (conv_i_src_c017_1_01 conv_i_c017_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_01 (conv_q_src_c017_1_01 0 conv_bpf_c017_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_1_01 (conv_q_src_c017_1_01 conv_q_c017_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_02 (conv_i_src_c017_1_02 0 conv_bpf_c017_1 0) vcvs gain=5.555702330196e-01
SCONVI_c017_1_02 (conv_i_src_c017_1_02 conv_i_c017_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_02 (conv_q_src_c017_1_02 0 conv_bpf_c017_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_1_02 (conv_q_src_c017_1_02 conv_q_c017_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_03 (conv_i_src_c017_1_03 0 conv_bpf_c017_1 0) vcvs gain=1.950903220161e-01
SCONVI_c017_1_03 (conv_i_src_c017_1_03 conv_i_c017_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_03 (conv_q_src_c017_1_03 0 conv_bpf_c017_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_1_03 (conv_q_src_c017_1_03 conv_q_c017_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_04 (conv_i_src_c017_1_04 0 conv_bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_1_04 (conv_i_src_c017_1_04 conv_i_c017_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_04 (conv_q_src_c017_1_04 0 conv_bpf_c017_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_1_04 (conv_q_src_c017_1_04 conv_q_c017_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_05 (conv_i_src_c017_1_05 0 conv_bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_1_05 (conv_i_src_c017_1_05 conv_i_c017_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_05 (conv_q_src_c017_1_05 0 conv_bpf_c017_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_1_05 (conv_q_src_c017_1_05 conv_q_c017_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_06 (conv_i_src_c017_1_06 0 conv_bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_1_06 (conv_i_src_c017_1_06 conv_i_c017_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_06 (conv_q_src_c017_1_06 0 conv_bpf_c017_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_1_06 (conv_q_src_c017_1_06 conv_q_c017_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_07 (conv_i_src_c017_1_07 0 conv_bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_1_07 (conv_i_src_c017_1_07 conv_i_c017_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_07 (conv_q_src_c017_1_07 0 conv_bpf_c017_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_1_07 (conv_q_src_c017_1_07 conv_q_c017_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_08 (conv_i_src_c017_1_08 0 conv_bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_1_08 (conv_i_src_c017_1_08 conv_i_c017_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_08 (conv_q_src_c017_1_08 0 conv_bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_1_08 (conv_q_src_c017_1_08 conv_q_c017_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_09 (conv_i_src_c017_1_09 0 conv_bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_1_09 (conv_i_src_c017_1_09 conv_i_c017_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_09 (conv_q_src_c017_1_09 0 conv_bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_1_09 (conv_q_src_c017_1_09 conv_q_c017_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_10 (conv_i_src_c017_1_10 0 conv_bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_1_10 (conv_i_src_c017_1_10 conv_i_c017_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_10 (conv_q_src_c017_1_10 0 conv_bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_1_10 (conv_q_src_c017_1_10 conv_q_c017_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_11 (conv_i_src_c017_1_11 0 conv_bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_1_11 (conv_i_src_c017_1_11 conv_i_c017_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_11 (conv_q_src_c017_1_11 0 conv_bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_1_11 (conv_q_src_c017_1_11 conv_q_c017_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_12 (conv_i_src_c017_1_12 0 conv_bpf_c017_1 0) vcvs gain=1.950903220161e-01
SCONVI_c017_1_12 (conv_i_src_c017_1_12 conv_i_c017_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_12 (conv_q_src_c017_1_12 0 conv_bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_1_12 (conv_q_src_c017_1_12 conv_q_c017_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_13 (conv_i_src_c017_1_13 0 conv_bpf_c017_1 0) vcvs gain=5.555702330196e-01
SCONVI_c017_1_13 (conv_i_src_c017_1_13 conv_i_c017_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_13 (conv_q_src_c017_1_13 0 conv_bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_1_13 (conv_q_src_c017_1_13 conv_q_c017_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_14 (conv_i_src_c017_1_14 0 conv_bpf_c017_1 0) vcvs gain=8.314696123025e-01
SCONVI_c017_1_14 (conv_i_src_c017_1_14 conv_i_c017_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_14 (conv_q_src_c017_1_14 0 conv_bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_1_14 (conv_q_src_c017_1_14 conv_q_c017_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_1_15 (conv_i_src_c017_1_15 0 conv_bpf_c017_1 0) vcvs gain=9.807852804032e-01
SCONVI_c017_1_15 (conv_i_src_c017_1_15 conv_i_c017_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_1_15 (conv_q_src_c017_1_15 0 conv_bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_1_15 (conv_q_src_c017_1_15 conv_q_c017_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c017_1 (conv_i_c017_1 0) resistor r=1G
RCONVQ_c017_1 (conv_q_c017_1 0) resistor r=1G
RCONVINTI_c017_1 (conv_i_c017_1 ConvIcar_c017_1) resistor r=1k
CCONVINTI_c017_1 (ConvIcar_c017_1 0) capacitor c=80p
RCONVINTQ_c017_1 (conv_q_c017_1 ConvQcar_c017_1) resistor r=1k
CCONVINTQ_c017_1 (ConvQcar_c017_1 0) capacitor c=80p
save conv_bpf_c017_1 ConvIcar_c017_1 ConvQcar_c017_1

// conventional mixed baseline bl017, carrier_2: 750000000 Hz
CCONVBPF_c017_2 (bl017 n_conv_cbpf_c017_2) capacitor c=4.503163717437e-14
LCONVBPF_c017_2 (n_conv_cbpf_c017_2 conv_bpf_c017_2) inductor l=1.000000000000e-06
RCONVBPF_c017_2 (conv_bpf_c017_2 0) resistor r=2.356194490192e+02
ECONVI_c017_2_00 (conv_i_src_c017_2_00 0 conv_bpf_c017_2 0) vcvs gain=9.807852804032e-01
SCONVI_c017_2_00 (conv_i_src_c017_2_00 conv_i_c017_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_00 (conv_q_src_c017_2_00 0 conv_bpf_c017_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_2_00 (conv_q_src_c017_2_00 conv_q_c017_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_01 (conv_i_src_c017_2_01 0 conv_bpf_c017_2 0) vcvs gain=8.314696123025e-01
SCONVI_c017_2_01 (conv_i_src_c017_2_01 conv_i_c017_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_01 (conv_q_src_c017_2_01 0 conv_bpf_c017_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_2_01 (conv_q_src_c017_2_01 conv_q_c017_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_02 (conv_i_src_c017_2_02 0 conv_bpf_c017_2 0) vcvs gain=5.555702330196e-01
SCONVI_c017_2_02 (conv_i_src_c017_2_02 conv_i_c017_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_02 (conv_q_src_c017_2_02 0 conv_bpf_c017_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_2_02 (conv_q_src_c017_2_02 conv_q_c017_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_03 (conv_i_src_c017_2_03 0 conv_bpf_c017_2 0) vcvs gain=1.950903220161e-01
SCONVI_c017_2_03 (conv_i_src_c017_2_03 conv_i_c017_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_03 (conv_q_src_c017_2_03 0 conv_bpf_c017_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_2_03 (conv_q_src_c017_2_03 conv_q_c017_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_04 (conv_i_src_c017_2_04 0 conv_bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_2_04 (conv_i_src_c017_2_04 conv_i_c017_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_04 (conv_q_src_c017_2_04 0 conv_bpf_c017_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_2_04 (conv_q_src_c017_2_04 conv_q_c017_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_05 (conv_i_src_c017_2_05 0 conv_bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_2_05 (conv_i_src_c017_2_05 conv_i_c017_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_05 (conv_q_src_c017_2_05 0 conv_bpf_c017_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_2_05 (conv_q_src_c017_2_05 conv_q_c017_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_06 (conv_i_src_c017_2_06 0 conv_bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_2_06 (conv_i_src_c017_2_06 conv_i_c017_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_06 (conv_q_src_c017_2_06 0 conv_bpf_c017_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_2_06 (conv_q_src_c017_2_06 conv_q_c017_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_07 (conv_i_src_c017_2_07 0 conv_bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_2_07 (conv_i_src_c017_2_07 conv_i_c017_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_07 (conv_q_src_c017_2_07 0 conv_bpf_c017_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_2_07 (conv_q_src_c017_2_07 conv_q_c017_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_08 (conv_i_src_c017_2_08 0 conv_bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_2_08 (conv_i_src_c017_2_08 conv_i_c017_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_08 (conv_q_src_c017_2_08 0 conv_bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_2_08 (conv_q_src_c017_2_08 conv_q_c017_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_09 (conv_i_src_c017_2_09 0 conv_bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_2_09 (conv_i_src_c017_2_09 conv_i_c017_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_09 (conv_q_src_c017_2_09 0 conv_bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_2_09 (conv_q_src_c017_2_09 conv_q_c017_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_10 (conv_i_src_c017_2_10 0 conv_bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_2_10 (conv_i_src_c017_2_10 conv_i_c017_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_10 (conv_q_src_c017_2_10 0 conv_bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_2_10 (conv_q_src_c017_2_10 conv_q_c017_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_11 (conv_i_src_c017_2_11 0 conv_bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_2_11 (conv_i_src_c017_2_11 conv_i_c017_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_11 (conv_q_src_c017_2_11 0 conv_bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_2_11 (conv_q_src_c017_2_11 conv_q_c017_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_12 (conv_i_src_c017_2_12 0 conv_bpf_c017_2 0) vcvs gain=1.950903220161e-01
SCONVI_c017_2_12 (conv_i_src_c017_2_12 conv_i_c017_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_12 (conv_q_src_c017_2_12 0 conv_bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_2_12 (conv_q_src_c017_2_12 conv_q_c017_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_13 (conv_i_src_c017_2_13 0 conv_bpf_c017_2 0) vcvs gain=5.555702330196e-01
SCONVI_c017_2_13 (conv_i_src_c017_2_13 conv_i_c017_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_13 (conv_q_src_c017_2_13 0 conv_bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_2_13 (conv_q_src_c017_2_13 conv_q_c017_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_14 (conv_i_src_c017_2_14 0 conv_bpf_c017_2 0) vcvs gain=8.314696123025e-01
SCONVI_c017_2_14 (conv_i_src_c017_2_14 conv_i_c017_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_14 (conv_q_src_c017_2_14 0 conv_bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_2_14 (conv_q_src_c017_2_14 conv_q_c017_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_2_15 (conv_i_src_c017_2_15 0 conv_bpf_c017_2 0) vcvs gain=9.807852804032e-01
SCONVI_c017_2_15 (conv_i_src_c017_2_15 conv_i_c017_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_2_15 (conv_q_src_c017_2_15 0 conv_bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_2_15 (conv_q_src_c017_2_15 conv_q_c017_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c017_2 (conv_i_c017_2 0) resistor r=1G
RCONVQ_c017_2 (conv_q_c017_2 0) resistor r=1G
RCONVINTI_c017_2 (conv_i_c017_2 ConvIcar_c017_2) resistor r=1k
CCONVINTI_c017_2 (ConvIcar_c017_2 0) capacitor c=80p
RCONVINTQ_c017_2 (conv_q_c017_2 ConvQcar_c017_2) resistor r=1k
CCONVINTQ_c017_2 (ConvQcar_c017_2 0) capacitor c=80p
save conv_bpf_c017_2 ConvIcar_c017_2 ConvQcar_c017_2

// conventional mixed baseline bl017, carrier_3: 1000000000 Hz
CCONVBPF_c017_3 (bl017 n_conv_cbpf_c017_3) capacitor c=2.533029591058e-14
LCONVBPF_c017_3 (n_conv_cbpf_c017_3 conv_bpf_c017_3) inductor l=1.000000000000e-06
RCONVBPF_c017_3 (conv_bpf_c017_3 0) resistor r=3.141592653590e+02
ECONVI_c017_3_00 (conv_i_src_c017_3_00 0 conv_bpf_c017_3 0) vcvs gain=9.807852804032e-01
SCONVI_c017_3_00 (conv_i_src_c017_3_00 conv_i_c017_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_00 (conv_q_src_c017_3_00 0 conv_bpf_c017_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_3_00 (conv_q_src_c017_3_00 conv_q_c017_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_01 (conv_i_src_c017_3_01 0 conv_bpf_c017_3 0) vcvs gain=8.314696123025e-01
SCONVI_c017_3_01 (conv_i_src_c017_3_01 conv_i_c017_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_01 (conv_q_src_c017_3_01 0 conv_bpf_c017_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_3_01 (conv_q_src_c017_3_01 conv_q_c017_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_02 (conv_i_src_c017_3_02 0 conv_bpf_c017_3 0) vcvs gain=5.555702330196e-01
SCONVI_c017_3_02 (conv_i_src_c017_3_02 conv_i_c017_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_02 (conv_q_src_c017_3_02 0 conv_bpf_c017_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_3_02 (conv_q_src_c017_3_02 conv_q_c017_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_03 (conv_i_src_c017_3_03 0 conv_bpf_c017_3 0) vcvs gain=1.950903220161e-01
SCONVI_c017_3_03 (conv_i_src_c017_3_03 conv_i_c017_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_03 (conv_q_src_c017_3_03 0 conv_bpf_c017_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_3_03 (conv_q_src_c017_3_03 conv_q_c017_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_04 (conv_i_src_c017_3_04 0 conv_bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_3_04 (conv_i_src_c017_3_04 conv_i_c017_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_04 (conv_q_src_c017_3_04 0 conv_bpf_c017_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c017_3_04 (conv_q_src_c017_3_04 conv_q_c017_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_05 (conv_i_src_c017_3_05 0 conv_bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_3_05 (conv_i_src_c017_3_05 conv_i_c017_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_05 (conv_q_src_c017_3_05 0 conv_bpf_c017_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c017_3_05 (conv_q_src_c017_3_05 conv_q_c017_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_06 (conv_i_src_c017_3_06 0 conv_bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_3_06 (conv_i_src_c017_3_06 conv_i_c017_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_06 (conv_q_src_c017_3_06 0 conv_bpf_c017_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c017_3_06 (conv_q_src_c017_3_06 conv_q_c017_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_07 (conv_i_src_c017_3_07 0 conv_bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_3_07 (conv_i_src_c017_3_07 conv_i_c017_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_07 (conv_q_src_c017_3_07 0 conv_bpf_c017_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c017_3_07 (conv_q_src_c017_3_07 conv_q_c017_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_08 (conv_i_src_c017_3_08 0 conv_bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c017_3_08 (conv_i_src_c017_3_08 conv_i_c017_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_08 (conv_q_src_c017_3_08 0 conv_bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_3_08 (conv_q_src_c017_3_08 conv_q_c017_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_09 (conv_i_src_c017_3_09 0 conv_bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c017_3_09 (conv_i_src_c017_3_09 conv_i_c017_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_09 (conv_q_src_c017_3_09 0 conv_bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_3_09 (conv_q_src_c017_3_09 conv_q_c017_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_10 (conv_i_src_c017_3_10 0 conv_bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c017_3_10 (conv_i_src_c017_3_10 conv_i_c017_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_10 (conv_q_src_c017_3_10 0 conv_bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_3_10 (conv_q_src_c017_3_10 conv_q_c017_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_11 (conv_i_src_c017_3_11 0 conv_bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c017_3_11 (conv_i_src_c017_3_11 conv_i_c017_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_11 (conv_q_src_c017_3_11 0 conv_bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_3_11 (conv_q_src_c017_3_11 conv_q_c017_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_12 (conv_i_src_c017_3_12 0 conv_bpf_c017_3 0) vcvs gain=1.950903220161e-01
SCONVI_c017_3_12 (conv_i_src_c017_3_12 conv_i_c017_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_12 (conv_q_src_c017_3_12 0 conv_bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c017_3_12 (conv_q_src_c017_3_12 conv_q_c017_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_13 (conv_i_src_c017_3_13 0 conv_bpf_c017_3 0) vcvs gain=5.555702330196e-01
SCONVI_c017_3_13 (conv_i_src_c017_3_13 conv_i_c017_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_13 (conv_q_src_c017_3_13 0 conv_bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c017_3_13 (conv_q_src_c017_3_13 conv_q_c017_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_14 (conv_i_src_c017_3_14 0 conv_bpf_c017_3 0) vcvs gain=8.314696123025e-01
SCONVI_c017_3_14 (conv_i_src_c017_3_14 conv_i_c017_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_14 (conv_q_src_c017_3_14 0 conv_bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c017_3_14 (conv_q_src_c017_3_14 conv_q_c017_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c017_3_15 (conv_i_src_c017_3_15 0 conv_bpf_c017_3 0) vcvs gain=9.807852804032e-01
SCONVI_c017_3_15 (conv_i_src_c017_3_15 conv_i_c017_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c017_3_15 (conv_q_src_c017_3_15 0 conv_bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c017_3_15 (conv_q_src_c017_3_15 conv_q_c017_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c017_3 (conv_i_c017_3 0) resistor r=1G
RCONVQ_c017_3 (conv_q_c017_3 0) resistor r=1G
RCONVINTI_c017_3 (conv_i_c017_3 ConvIcar_c017_3) resistor r=1k
CCONVINTI_c017_3 (ConvIcar_c017_3 0) capacitor c=80p
RCONVINTQ_c017_3 (conv_q_c017_3 ConvQcar_c017_3) resistor r=1k
CCONVINTQ_c017_3 (ConvQcar_c017_3 0) capacitor c=80p
save conv_bpf_c017_3 ConvIcar_c017_3 ConvQcar_c017_3

// conventional mixed baseline bl018, carrier_0: 250000000 Hz
CCONVBPF_c018_0 (bl018 n_conv_cbpf_c018_0) capacitor c=4.052847345694e-13
LCONVBPF_c018_0 (n_conv_cbpf_c018_0 conv_bpf_c018_0) inductor l=1.000000000000e-06
RCONVBPF_c018_0 (conv_bpf_c018_0 0) resistor r=7.853981633974e+01
ECONVI_c018_0_00 (conv_i_src_c018_0_00 0 conv_bpf_c018_0 0) vcvs gain=9.807852804032e-01
SCONVI_c018_0_00 (conv_i_src_c018_0_00 conv_i_c018_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_00 (conv_q_src_c018_0_00 0 conv_bpf_c018_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_0_00 (conv_q_src_c018_0_00 conv_q_c018_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_01 (conv_i_src_c018_0_01 0 conv_bpf_c018_0 0) vcvs gain=8.314696123025e-01
SCONVI_c018_0_01 (conv_i_src_c018_0_01 conv_i_c018_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_01 (conv_q_src_c018_0_01 0 conv_bpf_c018_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_0_01 (conv_q_src_c018_0_01 conv_q_c018_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_02 (conv_i_src_c018_0_02 0 conv_bpf_c018_0 0) vcvs gain=5.555702330196e-01
SCONVI_c018_0_02 (conv_i_src_c018_0_02 conv_i_c018_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_02 (conv_q_src_c018_0_02 0 conv_bpf_c018_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_0_02 (conv_q_src_c018_0_02 conv_q_c018_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_03 (conv_i_src_c018_0_03 0 conv_bpf_c018_0 0) vcvs gain=1.950903220161e-01
SCONVI_c018_0_03 (conv_i_src_c018_0_03 conv_i_c018_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_03 (conv_q_src_c018_0_03 0 conv_bpf_c018_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_0_03 (conv_q_src_c018_0_03 conv_q_c018_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_04 (conv_i_src_c018_0_04 0 conv_bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_0_04 (conv_i_src_c018_0_04 conv_i_c018_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_04 (conv_q_src_c018_0_04 0 conv_bpf_c018_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_0_04 (conv_q_src_c018_0_04 conv_q_c018_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_05 (conv_i_src_c018_0_05 0 conv_bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_0_05 (conv_i_src_c018_0_05 conv_i_c018_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_05 (conv_q_src_c018_0_05 0 conv_bpf_c018_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_0_05 (conv_q_src_c018_0_05 conv_q_c018_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_06 (conv_i_src_c018_0_06 0 conv_bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_0_06 (conv_i_src_c018_0_06 conv_i_c018_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_06 (conv_q_src_c018_0_06 0 conv_bpf_c018_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_0_06 (conv_q_src_c018_0_06 conv_q_c018_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_07 (conv_i_src_c018_0_07 0 conv_bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_0_07 (conv_i_src_c018_0_07 conv_i_c018_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_07 (conv_q_src_c018_0_07 0 conv_bpf_c018_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_0_07 (conv_q_src_c018_0_07 conv_q_c018_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_08 (conv_i_src_c018_0_08 0 conv_bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_0_08 (conv_i_src_c018_0_08 conv_i_c018_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_08 (conv_q_src_c018_0_08 0 conv_bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_0_08 (conv_q_src_c018_0_08 conv_q_c018_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_09 (conv_i_src_c018_0_09 0 conv_bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_0_09 (conv_i_src_c018_0_09 conv_i_c018_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_09 (conv_q_src_c018_0_09 0 conv_bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_0_09 (conv_q_src_c018_0_09 conv_q_c018_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_10 (conv_i_src_c018_0_10 0 conv_bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_0_10 (conv_i_src_c018_0_10 conv_i_c018_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_10 (conv_q_src_c018_0_10 0 conv_bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_0_10 (conv_q_src_c018_0_10 conv_q_c018_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_11 (conv_i_src_c018_0_11 0 conv_bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_0_11 (conv_i_src_c018_0_11 conv_i_c018_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_11 (conv_q_src_c018_0_11 0 conv_bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_0_11 (conv_q_src_c018_0_11 conv_q_c018_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_12 (conv_i_src_c018_0_12 0 conv_bpf_c018_0 0) vcvs gain=1.950903220161e-01
SCONVI_c018_0_12 (conv_i_src_c018_0_12 conv_i_c018_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_12 (conv_q_src_c018_0_12 0 conv_bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_0_12 (conv_q_src_c018_0_12 conv_q_c018_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_13 (conv_i_src_c018_0_13 0 conv_bpf_c018_0 0) vcvs gain=5.555702330196e-01
SCONVI_c018_0_13 (conv_i_src_c018_0_13 conv_i_c018_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_13 (conv_q_src_c018_0_13 0 conv_bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_0_13 (conv_q_src_c018_0_13 conv_q_c018_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_14 (conv_i_src_c018_0_14 0 conv_bpf_c018_0 0) vcvs gain=8.314696123025e-01
SCONVI_c018_0_14 (conv_i_src_c018_0_14 conv_i_c018_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_14 (conv_q_src_c018_0_14 0 conv_bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_0_14 (conv_q_src_c018_0_14 conv_q_c018_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_0_15 (conv_i_src_c018_0_15 0 conv_bpf_c018_0 0) vcvs gain=9.807852804032e-01
SCONVI_c018_0_15 (conv_i_src_c018_0_15 conv_i_c018_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_0_15 (conv_q_src_c018_0_15 0 conv_bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_0_15 (conv_q_src_c018_0_15 conv_q_c018_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c018_0 (conv_i_c018_0 0) resistor r=1G
RCONVQ_c018_0 (conv_q_c018_0 0) resistor r=1G
RCONVINTI_c018_0 (conv_i_c018_0 ConvIcar_c018_0) resistor r=1k
CCONVINTI_c018_0 (ConvIcar_c018_0 0) capacitor c=80p
RCONVINTQ_c018_0 (conv_q_c018_0 ConvQcar_c018_0) resistor r=1k
CCONVINTQ_c018_0 (ConvQcar_c018_0 0) capacitor c=80p
save conv_bpf_c018_0 ConvIcar_c018_0 ConvQcar_c018_0

// conventional mixed baseline bl018, carrier_1: 500000000 Hz
CCONVBPF_c018_1 (bl018 n_conv_cbpf_c018_1) capacitor c=1.013211836423e-13
LCONVBPF_c018_1 (n_conv_cbpf_c018_1 conv_bpf_c018_1) inductor l=1.000000000000e-06
RCONVBPF_c018_1 (conv_bpf_c018_1 0) resistor r=1.570796326795e+02
ECONVI_c018_1_00 (conv_i_src_c018_1_00 0 conv_bpf_c018_1 0) vcvs gain=9.807852804032e-01
SCONVI_c018_1_00 (conv_i_src_c018_1_00 conv_i_c018_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_00 (conv_q_src_c018_1_00 0 conv_bpf_c018_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_1_00 (conv_q_src_c018_1_00 conv_q_c018_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_01 (conv_i_src_c018_1_01 0 conv_bpf_c018_1 0) vcvs gain=8.314696123025e-01
SCONVI_c018_1_01 (conv_i_src_c018_1_01 conv_i_c018_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_01 (conv_q_src_c018_1_01 0 conv_bpf_c018_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_1_01 (conv_q_src_c018_1_01 conv_q_c018_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_02 (conv_i_src_c018_1_02 0 conv_bpf_c018_1 0) vcvs gain=5.555702330196e-01
SCONVI_c018_1_02 (conv_i_src_c018_1_02 conv_i_c018_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_02 (conv_q_src_c018_1_02 0 conv_bpf_c018_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_1_02 (conv_q_src_c018_1_02 conv_q_c018_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_03 (conv_i_src_c018_1_03 0 conv_bpf_c018_1 0) vcvs gain=1.950903220161e-01
SCONVI_c018_1_03 (conv_i_src_c018_1_03 conv_i_c018_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_03 (conv_q_src_c018_1_03 0 conv_bpf_c018_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_1_03 (conv_q_src_c018_1_03 conv_q_c018_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_04 (conv_i_src_c018_1_04 0 conv_bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_1_04 (conv_i_src_c018_1_04 conv_i_c018_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_04 (conv_q_src_c018_1_04 0 conv_bpf_c018_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_1_04 (conv_q_src_c018_1_04 conv_q_c018_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_05 (conv_i_src_c018_1_05 0 conv_bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_1_05 (conv_i_src_c018_1_05 conv_i_c018_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_05 (conv_q_src_c018_1_05 0 conv_bpf_c018_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_1_05 (conv_q_src_c018_1_05 conv_q_c018_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_06 (conv_i_src_c018_1_06 0 conv_bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_1_06 (conv_i_src_c018_1_06 conv_i_c018_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_06 (conv_q_src_c018_1_06 0 conv_bpf_c018_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_1_06 (conv_q_src_c018_1_06 conv_q_c018_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_07 (conv_i_src_c018_1_07 0 conv_bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_1_07 (conv_i_src_c018_1_07 conv_i_c018_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_07 (conv_q_src_c018_1_07 0 conv_bpf_c018_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_1_07 (conv_q_src_c018_1_07 conv_q_c018_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_08 (conv_i_src_c018_1_08 0 conv_bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_1_08 (conv_i_src_c018_1_08 conv_i_c018_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_08 (conv_q_src_c018_1_08 0 conv_bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_1_08 (conv_q_src_c018_1_08 conv_q_c018_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_09 (conv_i_src_c018_1_09 0 conv_bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_1_09 (conv_i_src_c018_1_09 conv_i_c018_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_09 (conv_q_src_c018_1_09 0 conv_bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_1_09 (conv_q_src_c018_1_09 conv_q_c018_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_10 (conv_i_src_c018_1_10 0 conv_bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_1_10 (conv_i_src_c018_1_10 conv_i_c018_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_10 (conv_q_src_c018_1_10 0 conv_bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_1_10 (conv_q_src_c018_1_10 conv_q_c018_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_11 (conv_i_src_c018_1_11 0 conv_bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_1_11 (conv_i_src_c018_1_11 conv_i_c018_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_11 (conv_q_src_c018_1_11 0 conv_bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_1_11 (conv_q_src_c018_1_11 conv_q_c018_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_12 (conv_i_src_c018_1_12 0 conv_bpf_c018_1 0) vcvs gain=1.950903220161e-01
SCONVI_c018_1_12 (conv_i_src_c018_1_12 conv_i_c018_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_12 (conv_q_src_c018_1_12 0 conv_bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_1_12 (conv_q_src_c018_1_12 conv_q_c018_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_13 (conv_i_src_c018_1_13 0 conv_bpf_c018_1 0) vcvs gain=5.555702330196e-01
SCONVI_c018_1_13 (conv_i_src_c018_1_13 conv_i_c018_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_13 (conv_q_src_c018_1_13 0 conv_bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_1_13 (conv_q_src_c018_1_13 conv_q_c018_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_14 (conv_i_src_c018_1_14 0 conv_bpf_c018_1 0) vcvs gain=8.314696123025e-01
SCONVI_c018_1_14 (conv_i_src_c018_1_14 conv_i_c018_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_14 (conv_q_src_c018_1_14 0 conv_bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_1_14 (conv_q_src_c018_1_14 conv_q_c018_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_1_15 (conv_i_src_c018_1_15 0 conv_bpf_c018_1 0) vcvs gain=9.807852804032e-01
SCONVI_c018_1_15 (conv_i_src_c018_1_15 conv_i_c018_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_1_15 (conv_q_src_c018_1_15 0 conv_bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_1_15 (conv_q_src_c018_1_15 conv_q_c018_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c018_1 (conv_i_c018_1 0) resistor r=1G
RCONVQ_c018_1 (conv_q_c018_1 0) resistor r=1G
RCONVINTI_c018_1 (conv_i_c018_1 ConvIcar_c018_1) resistor r=1k
CCONVINTI_c018_1 (ConvIcar_c018_1 0) capacitor c=80p
RCONVINTQ_c018_1 (conv_q_c018_1 ConvQcar_c018_1) resistor r=1k
CCONVINTQ_c018_1 (ConvQcar_c018_1 0) capacitor c=80p
save conv_bpf_c018_1 ConvIcar_c018_1 ConvQcar_c018_1

// conventional mixed baseline bl018, carrier_2: 750000000 Hz
CCONVBPF_c018_2 (bl018 n_conv_cbpf_c018_2) capacitor c=4.503163717437e-14
LCONVBPF_c018_2 (n_conv_cbpf_c018_2 conv_bpf_c018_2) inductor l=1.000000000000e-06
RCONVBPF_c018_2 (conv_bpf_c018_2 0) resistor r=2.356194490192e+02
ECONVI_c018_2_00 (conv_i_src_c018_2_00 0 conv_bpf_c018_2 0) vcvs gain=9.807852804032e-01
SCONVI_c018_2_00 (conv_i_src_c018_2_00 conv_i_c018_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_00 (conv_q_src_c018_2_00 0 conv_bpf_c018_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_2_00 (conv_q_src_c018_2_00 conv_q_c018_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_01 (conv_i_src_c018_2_01 0 conv_bpf_c018_2 0) vcvs gain=8.314696123025e-01
SCONVI_c018_2_01 (conv_i_src_c018_2_01 conv_i_c018_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_01 (conv_q_src_c018_2_01 0 conv_bpf_c018_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_2_01 (conv_q_src_c018_2_01 conv_q_c018_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_02 (conv_i_src_c018_2_02 0 conv_bpf_c018_2 0) vcvs gain=5.555702330196e-01
SCONVI_c018_2_02 (conv_i_src_c018_2_02 conv_i_c018_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_02 (conv_q_src_c018_2_02 0 conv_bpf_c018_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_2_02 (conv_q_src_c018_2_02 conv_q_c018_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_03 (conv_i_src_c018_2_03 0 conv_bpf_c018_2 0) vcvs gain=1.950903220161e-01
SCONVI_c018_2_03 (conv_i_src_c018_2_03 conv_i_c018_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_03 (conv_q_src_c018_2_03 0 conv_bpf_c018_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_2_03 (conv_q_src_c018_2_03 conv_q_c018_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_04 (conv_i_src_c018_2_04 0 conv_bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_2_04 (conv_i_src_c018_2_04 conv_i_c018_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_04 (conv_q_src_c018_2_04 0 conv_bpf_c018_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_2_04 (conv_q_src_c018_2_04 conv_q_c018_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_05 (conv_i_src_c018_2_05 0 conv_bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_2_05 (conv_i_src_c018_2_05 conv_i_c018_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_05 (conv_q_src_c018_2_05 0 conv_bpf_c018_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_2_05 (conv_q_src_c018_2_05 conv_q_c018_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_06 (conv_i_src_c018_2_06 0 conv_bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_2_06 (conv_i_src_c018_2_06 conv_i_c018_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_06 (conv_q_src_c018_2_06 0 conv_bpf_c018_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_2_06 (conv_q_src_c018_2_06 conv_q_c018_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_07 (conv_i_src_c018_2_07 0 conv_bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_2_07 (conv_i_src_c018_2_07 conv_i_c018_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_07 (conv_q_src_c018_2_07 0 conv_bpf_c018_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_2_07 (conv_q_src_c018_2_07 conv_q_c018_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_08 (conv_i_src_c018_2_08 0 conv_bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_2_08 (conv_i_src_c018_2_08 conv_i_c018_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_08 (conv_q_src_c018_2_08 0 conv_bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_2_08 (conv_q_src_c018_2_08 conv_q_c018_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_09 (conv_i_src_c018_2_09 0 conv_bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_2_09 (conv_i_src_c018_2_09 conv_i_c018_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_09 (conv_q_src_c018_2_09 0 conv_bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_2_09 (conv_q_src_c018_2_09 conv_q_c018_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_10 (conv_i_src_c018_2_10 0 conv_bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_2_10 (conv_i_src_c018_2_10 conv_i_c018_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_10 (conv_q_src_c018_2_10 0 conv_bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_2_10 (conv_q_src_c018_2_10 conv_q_c018_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_11 (conv_i_src_c018_2_11 0 conv_bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_2_11 (conv_i_src_c018_2_11 conv_i_c018_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_11 (conv_q_src_c018_2_11 0 conv_bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_2_11 (conv_q_src_c018_2_11 conv_q_c018_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_12 (conv_i_src_c018_2_12 0 conv_bpf_c018_2 0) vcvs gain=1.950903220161e-01
SCONVI_c018_2_12 (conv_i_src_c018_2_12 conv_i_c018_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_12 (conv_q_src_c018_2_12 0 conv_bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_2_12 (conv_q_src_c018_2_12 conv_q_c018_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_13 (conv_i_src_c018_2_13 0 conv_bpf_c018_2 0) vcvs gain=5.555702330196e-01
SCONVI_c018_2_13 (conv_i_src_c018_2_13 conv_i_c018_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_13 (conv_q_src_c018_2_13 0 conv_bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_2_13 (conv_q_src_c018_2_13 conv_q_c018_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_14 (conv_i_src_c018_2_14 0 conv_bpf_c018_2 0) vcvs gain=8.314696123025e-01
SCONVI_c018_2_14 (conv_i_src_c018_2_14 conv_i_c018_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_14 (conv_q_src_c018_2_14 0 conv_bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_2_14 (conv_q_src_c018_2_14 conv_q_c018_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_2_15 (conv_i_src_c018_2_15 0 conv_bpf_c018_2 0) vcvs gain=9.807852804032e-01
SCONVI_c018_2_15 (conv_i_src_c018_2_15 conv_i_c018_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_2_15 (conv_q_src_c018_2_15 0 conv_bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_2_15 (conv_q_src_c018_2_15 conv_q_c018_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c018_2 (conv_i_c018_2 0) resistor r=1G
RCONVQ_c018_2 (conv_q_c018_2 0) resistor r=1G
RCONVINTI_c018_2 (conv_i_c018_2 ConvIcar_c018_2) resistor r=1k
CCONVINTI_c018_2 (ConvIcar_c018_2 0) capacitor c=80p
RCONVINTQ_c018_2 (conv_q_c018_2 ConvQcar_c018_2) resistor r=1k
CCONVINTQ_c018_2 (ConvQcar_c018_2 0) capacitor c=80p
save conv_bpf_c018_2 ConvIcar_c018_2 ConvQcar_c018_2

// conventional mixed baseline bl018, carrier_3: 1000000000 Hz
CCONVBPF_c018_3 (bl018 n_conv_cbpf_c018_3) capacitor c=2.533029591058e-14
LCONVBPF_c018_3 (n_conv_cbpf_c018_3 conv_bpf_c018_3) inductor l=1.000000000000e-06
RCONVBPF_c018_3 (conv_bpf_c018_3 0) resistor r=3.141592653590e+02
ECONVI_c018_3_00 (conv_i_src_c018_3_00 0 conv_bpf_c018_3 0) vcvs gain=9.807852804032e-01
SCONVI_c018_3_00 (conv_i_src_c018_3_00 conv_i_c018_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_00 (conv_q_src_c018_3_00 0 conv_bpf_c018_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_3_00 (conv_q_src_c018_3_00 conv_q_c018_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_01 (conv_i_src_c018_3_01 0 conv_bpf_c018_3 0) vcvs gain=8.314696123025e-01
SCONVI_c018_3_01 (conv_i_src_c018_3_01 conv_i_c018_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_01 (conv_q_src_c018_3_01 0 conv_bpf_c018_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_3_01 (conv_q_src_c018_3_01 conv_q_c018_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_02 (conv_i_src_c018_3_02 0 conv_bpf_c018_3 0) vcvs gain=5.555702330196e-01
SCONVI_c018_3_02 (conv_i_src_c018_3_02 conv_i_c018_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_02 (conv_q_src_c018_3_02 0 conv_bpf_c018_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_3_02 (conv_q_src_c018_3_02 conv_q_c018_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_03 (conv_i_src_c018_3_03 0 conv_bpf_c018_3 0) vcvs gain=1.950903220161e-01
SCONVI_c018_3_03 (conv_i_src_c018_3_03 conv_i_c018_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_03 (conv_q_src_c018_3_03 0 conv_bpf_c018_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_3_03 (conv_q_src_c018_3_03 conv_q_c018_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_04 (conv_i_src_c018_3_04 0 conv_bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_3_04 (conv_i_src_c018_3_04 conv_i_c018_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_04 (conv_q_src_c018_3_04 0 conv_bpf_c018_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c018_3_04 (conv_q_src_c018_3_04 conv_q_c018_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_05 (conv_i_src_c018_3_05 0 conv_bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_3_05 (conv_i_src_c018_3_05 conv_i_c018_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_05 (conv_q_src_c018_3_05 0 conv_bpf_c018_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c018_3_05 (conv_q_src_c018_3_05 conv_q_c018_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_06 (conv_i_src_c018_3_06 0 conv_bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_3_06 (conv_i_src_c018_3_06 conv_i_c018_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_06 (conv_q_src_c018_3_06 0 conv_bpf_c018_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c018_3_06 (conv_q_src_c018_3_06 conv_q_c018_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_07 (conv_i_src_c018_3_07 0 conv_bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_3_07 (conv_i_src_c018_3_07 conv_i_c018_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_07 (conv_q_src_c018_3_07 0 conv_bpf_c018_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c018_3_07 (conv_q_src_c018_3_07 conv_q_c018_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_08 (conv_i_src_c018_3_08 0 conv_bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c018_3_08 (conv_i_src_c018_3_08 conv_i_c018_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_08 (conv_q_src_c018_3_08 0 conv_bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_3_08 (conv_q_src_c018_3_08 conv_q_c018_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_09 (conv_i_src_c018_3_09 0 conv_bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c018_3_09 (conv_i_src_c018_3_09 conv_i_c018_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_09 (conv_q_src_c018_3_09 0 conv_bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_3_09 (conv_q_src_c018_3_09 conv_q_c018_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_10 (conv_i_src_c018_3_10 0 conv_bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c018_3_10 (conv_i_src_c018_3_10 conv_i_c018_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_10 (conv_q_src_c018_3_10 0 conv_bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_3_10 (conv_q_src_c018_3_10 conv_q_c018_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_11 (conv_i_src_c018_3_11 0 conv_bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c018_3_11 (conv_i_src_c018_3_11 conv_i_c018_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_11 (conv_q_src_c018_3_11 0 conv_bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_3_11 (conv_q_src_c018_3_11 conv_q_c018_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_12 (conv_i_src_c018_3_12 0 conv_bpf_c018_3 0) vcvs gain=1.950903220161e-01
SCONVI_c018_3_12 (conv_i_src_c018_3_12 conv_i_c018_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_12 (conv_q_src_c018_3_12 0 conv_bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c018_3_12 (conv_q_src_c018_3_12 conv_q_c018_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_13 (conv_i_src_c018_3_13 0 conv_bpf_c018_3 0) vcvs gain=5.555702330196e-01
SCONVI_c018_3_13 (conv_i_src_c018_3_13 conv_i_c018_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_13 (conv_q_src_c018_3_13 0 conv_bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c018_3_13 (conv_q_src_c018_3_13 conv_q_c018_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_14 (conv_i_src_c018_3_14 0 conv_bpf_c018_3 0) vcvs gain=8.314696123025e-01
SCONVI_c018_3_14 (conv_i_src_c018_3_14 conv_i_c018_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_14 (conv_q_src_c018_3_14 0 conv_bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c018_3_14 (conv_q_src_c018_3_14 conv_q_c018_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c018_3_15 (conv_i_src_c018_3_15 0 conv_bpf_c018_3 0) vcvs gain=9.807852804032e-01
SCONVI_c018_3_15 (conv_i_src_c018_3_15 conv_i_c018_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c018_3_15 (conv_q_src_c018_3_15 0 conv_bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c018_3_15 (conv_q_src_c018_3_15 conv_q_c018_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c018_3 (conv_i_c018_3 0) resistor r=1G
RCONVQ_c018_3 (conv_q_c018_3 0) resistor r=1G
RCONVINTI_c018_3 (conv_i_c018_3 ConvIcar_c018_3) resistor r=1k
CCONVINTI_c018_3 (ConvIcar_c018_3 0) capacitor c=80p
RCONVINTQ_c018_3 (conv_q_c018_3 ConvQcar_c018_3) resistor r=1k
CCONVINTQ_c018_3 (ConvQcar_c018_3 0) capacitor c=80p
save conv_bpf_c018_3 ConvIcar_c018_3 ConvQcar_c018_3

// conventional mixed baseline bl019, carrier_0: 250000000 Hz
CCONVBPF_c019_0 (bl019 n_conv_cbpf_c019_0) capacitor c=4.052847345694e-13
LCONVBPF_c019_0 (n_conv_cbpf_c019_0 conv_bpf_c019_0) inductor l=1.000000000000e-06
RCONVBPF_c019_0 (conv_bpf_c019_0 0) resistor r=7.853981633974e+01
ECONVI_c019_0_00 (conv_i_src_c019_0_00 0 conv_bpf_c019_0 0) vcvs gain=9.807852804032e-01
SCONVI_c019_0_00 (conv_i_src_c019_0_00 conv_i_c019_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_00 (conv_q_src_c019_0_00 0 conv_bpf_c019_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_0_00 (conv_q_src_c019_0_00 conv_q_c019_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_01 (conv_i_src_c019_0_01 0 conv_bpf_c019_0 0) vcvs gain=8.314696123025e-01
SCONVI_c019_0_01 (conv_i_src_c019_0_01 conv_i_c019_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_01 (conv_q_src_c019_0_01 0 conv_bpf_c019_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_0_01 (conv_q_src_c019_0_01 conv_q_c019_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_02 (conv_i_src_c019_0_02 0 conv_bpf_c019_0 0) vcvs gain=5.555702330196e-01
SCONVI_c019_0_02 (conv_i_src_c019_0_02 conv_i_c019_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_02 (conv_q_src_c019_0_02 0 conv_bpf_c019_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_0_02 (conv_q_src_c019_0_02 conv_q_c019_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_03 (conv_i_src_c019_0_03 0 conv_bpf_c019_0 0) vcvs gain=1.950903220161e-01
SCONVI_c019_0_03 (conv_i_src_c019_0_03 conv_i_c019_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_03 (conv_q_src_c019_0_03 0 conv_bpf_c019_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_0_03 (conv_q_src_c019_0_03 conv_q_c019_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_04 (conv_i_src_c019_0_04 0 conv_bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_0_04 (conv_i_src_c019_0_04 conv_i_c019_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_04 (conv_q_src_c019_0_04 0 conv_bpf_c019_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_0_04 (conv_q_src_c019_0_04 conv_q_c019_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_05 (conv_i_src_c019_0_05 0 conv_bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_0_05 (conv_i_src_c019_0_05 conv_i_c019_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_05 (conv_q_src_c019_0_05 0 conv_bpf_c019_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_0_05 (conv_q_src_c019_0_05 conv_q_c019_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_06 (conv_i_src_c019_0_06 0 conv_bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_0_06 (conv_i_src_c019_0_06 conv_i_c019_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_06 (conv_q_src_c019_0_06 0 conv_bpf_c019_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_0_06 (conv_q_src_c019_0_06 conv_q_c019_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_07 (conv_i_src_c019_0_07 0 conv_bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_0_07 (conv_i_src_c019_0_07 conv_i_c019_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_07 (conv_q_src_c019_0_07 0 conv_bpf_c019_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_0_07 (conv_q_src_c019_0_07 conv_q_c019_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_08 (conv_i_src_c019_0_08 0 conv_bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_0_08 (conv_i_src_c019_0_08 conv_i_c019_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_08 (conv_q_src_c019_0_08 0 conv_bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_0_08 (conv_q_src_c019_0_08 conv_q_c019_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_09 (conv_i_src_c019_0_09 0 conv_bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_0_09 (conv_i_src_c019_0_09 conv_i_c019_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_09 (conv_q_src_c019_0_09 0 conv_bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_0_09 (conv_q_src_c019_0_09 conv_q_c019_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_10 (conv_i_src_c019_0_10 0 conv_bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_0_10 (conv_i_src_c019_0_10 conv_i_c019_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_10 (conv_q_src_c019_0_10 0 conv_bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_0_10 (conv_q_src_c019_0_10 conv_q_c019_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_11 (conv_i_src_c019_0_11 0 conv_bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_0_11 (conv_i_src_c019_0_11 conv_i_c019_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_11 (conv_q_src_c019_0_11 0 conv_bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_0_11 (conv_q_src_c019_0_11 conv_q_c019_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_12 (conv_i_src_c019_0_12 0 conv_bpf_c019_0 0) vcvs gain=1.950903220161e-01
SCONVI_c019_0_12 (conv_i_src_c019_0_12 conv_i_c019_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_12 (conv_q_src_c019_0_12 0 conv_bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_0_12 (conv_q_src_c019_0_12 conv_q_c019_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_13 (conv_i_src_c019_0_13 0 conv_bpf_c019_0 0) vcvs gain=5.555702330196e-01
SCONVI_c019_0_13 (conv_i_src_c019_0_13 conv_i_c019_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_13 (conv_q_src_c019_0_13 0 conv_bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_0_13 (conv_q_src_c019_0_13 conv_q_c019_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_14 (conv_i_src_c019_0_14 0 conv_bpf_c019_0 0) vcvs gain=8.314696123025e-01
SCONVI_c019_0_14 (conv_i_src_c019_0_14 conv_i_c019_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_14 (conv_q_src_c019_0_14 0 conv_bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_0_14 (conv_q_src_c019_0_14 conv_q_c019_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_0_15 (conv_i_src_c019_0_15 0 conv_bpf_c019_0 0) vcvs gain=9.807852804032e-01
SCONVI_c019_0_15 (conv_i_src_c019_0_15 conv_i_c019_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_0_15 (conv_q_src_c019_0_15 0 conv_bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_0_15 (conv_q_src_c019_0_15 conv_q_c019_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c019_0 (conv_i_c019_0 0) resistor r=1G
RCONVQ_c019_0 (conv_q_c019_0 0) resistor r=1G
RCONVINTI_c019_0 (conv_i_c019_0 ConvIcar_c019_0) resistor r=1k
CCONVINTI_c019_0 (ConvIcar_c019_0 0) capacitor c=80p
RCONVINTQ_c019_0 (conv_q_c019_0 ConvQcar_c019_0) resistor r=1k
CCONVINTQ_c019_0 (ConvQcar_c019_0 0) capacitor c=80p
save conv_bpf_c019_0 ConvIcar_c019_0 ConvQcar_c019_0

// conventional mixed baseline bl019, carrier_1: 500000000 Hz
CCONVBPF_c019_1 (bl019 n_conv_cbpf_c019_1) capacitor c=1.013211836423e-13
LCONVBPF_c019_1 (n_conv_cbpf_c019_1 conv_bpf_c019_1) inductor l=1.000000000000e-06
RCONVBPF_c019_1 (conv_bpf_c019_1 0) resistor r=1.570796326795e+02
ECONVI_c019_1_00 (conv_i_src_c019_1_00 0 conv_bpf_c019_1 0) vcvs gain=9.807852804032e-01
SCONVI_c019_1_00 (conv_i_src_c019_1_00 conv_i_c019_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_00 (conv_q_src_c019_1_00 0 conv_bpf_c019_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_1_00 (conv_q_src_c019_1_00 conv_q_c019_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_01 (conv_i_src_c019_1_01 0 conv_bpf_c019_1 0) vcvs gain=8.314696123025e-01
SCONVI_c019_1_01 (conv_i_src_c019_1_01 conv_i_c019_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_01 (conv_q_src_c019_1_01 0 conv_bpf_c019_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_1_01 (conv_q_src_c019_1_01 conv_q_c019_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_02 (conv_i_src_c019_1_02 0 conv_bpf_c019_1 0) vcvs gain=5.555702330196e-01
SCONVI_c019_1_02 (conv_i_src_c019_1_02 conv_i_c019_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_02 (conv_q_src_c019_1_02 0 conv_bpf_c019_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_1_02 (conv_q_src_c019_1_02 conv_q_c019_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_03 (conv_i_src_c019_1_03 0 conv_bpf_c019_1 0) vcvs gain=1.950903220161e-01
SCONVI_c019_1_03 (conv_i_src_c019_1_03 conv_i_c019_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_03 (conv_q_src_c019_1_03 0 conv_bpf_c019_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_1_03 (conv_q_src_c019_1_03 conv_q_c019_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_04 (conv_i_src_c019_1_04 0 conv_bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_1_04 (conv_i_src_c019_1_04 conv_i_c019_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_04 (conv_q_src_c019_1_04 0 conv_bpf_c019_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_1_04 (conv_q_src_c019_1_04 conv_q_c019_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_05 (conv_i_src_c019_1_05 0 conv_bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_1_05 (conv_i_src_c019_1_05 conv_i_c019_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_05 (conv_q_src_c019_1_05 0 conv_bpf_c019_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_1_05 (conv_q_src_c019_1_05 conv_q_c019_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_06 (conv_i_src_c019_1_06 0 conv_bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_1_06 (conv_i_src_c019_1_06 conv_i_c019_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_06 (conv_q_src_c019_1_06 0 conv_bpf_c019_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_1_06 (conv_q_src_c019_1_06 conv_q_c019_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_07 (conv_i_src_c019_1_07 0 conv_bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_1_07 (conv_i_src_c019_1_07 conv_i_c019_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_07 (conv_q_src_c019_1_07 0 conv_bpf_c019_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_1_07 (conv_q_src_c019_1_07 conv_q_c019_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_08 (conv_i_src_c019_1_08 0 conv_bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_1_08 (conv_i_src_c019_1_08 conv_i_c019_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_08 (conv_q_src_c019_1_08 0 conv_bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_1_08 (conv_q_src_c019_1_08 conv_q_c019_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_09 (conv_i_src_c019_1_09 0 conv_bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_1_09 (conv_i_src_c019_1_09 conv_i_c019_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_09 (conv_q_src_c019_1_09 0 conv_bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_1_09 (conv_q_src_c019_1_09 conv_q_c019_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_10 (conv_i_src_c019_1_10 0 conv_bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_1_10 (conv_i_src_c019_1_10 conv_i_c019_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_10 (conv_q_src_c019_1_10 0 conv_bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_1_10 (conv_q_src_c019_1_10 conv_q_c019_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_11 (conv_i_src_c019_1_11 0 conv_bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_1_11 (conv_i_src_c019_1_11 conv_i_c019_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_11 (conv_q_src_c019_1_11 0 conv_bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_1_11 (conv_q_src_c019_1_11 conv_q_c019_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_12 (conv_i_src_c019_1_12 0 conv_bpf_c019_1 0) vcvs gain=1.950903220161e-01
SCONVI_c019_1_12 (conv_i_src_c019_1_12 conv_i_c019_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_12 (conv_q_src_c019_1_12 0 conv_bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_1_12 (conv_q_src_c019_1_12 conv_q_c019_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_13 (conv_i_src_c019_1_13 0 conv_bpf_c019_1 0) vcvs gain=5.555702330196e-01
SCONVI_c019_1_13 (conv_i_src_c019_1_13 conv_i_c019_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_13 (conv_q_src_c019_1_13 0 conv_bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_1_13 (conv_q_src_c019_1_13 conv_q_c019_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_14 (conv_i_src_c019_1_14 0 conv_bpf_c019_1 0) vcvs gain=8.314696123025e-01
SCONVI_c019_1_14 (conv_i_src_c019_1_14 conv_i_c019_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_14 (conv_q_src_c019_1_14 0 conv_bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_1_14 (conv_q_src_c019_1_14 conv_q_c019_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_1_15 (conv_i_src_c019_1_15 0 conv_bpf_c019_1 0) vcvs gain=9.807852804032e-01
SCONVI_c019_1_15 (conv_i_src_c019_1_15 conv_i_c019_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_1_15 (conv_q_src_c019_1_15 0 conv_bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_1_15 (conv_q_src_c019_1_15 conv_q_c019_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c019_1 (conv_i_c019_1 0) resistor r=1G
RCONVQ_c019_1 (conv_q_c019_1 0) resistor r=1G
RCONVINTI_c019_1 (conv_i_c019_1 ConvIcar_c019_1) resistor r=1k
CCONVINTI_c019_1 (ConvIcar_c019_1 0) capacitor c=80p
RCONVINTQ_c019_1 (conv_q_c019_1 ConvQcar_c019_1) resistor r=1k
CCONVINTQ_c019_1 (ConvQcar_c019_1 0) capacitor c=80p
save conv_bpf_c019_1 ConvIcar_c019_1 ConvQcar_c019_1

// conventional mixed baseline bl019, carrier_2: 750000000 Hz
CCONVBPF_c019_2 (bl019 n_conv_cbpf_c019_2) capacitor c=4.503163717437e-14
LCONVBPF_c019_2 (n_conv_cbpf_c019_2 conv_bpf_c019_2) inductor l=1.000000000000e-06
RCONVBPF_c019_2 (conv_bpf_c019_2 0) resistor r=2.356194490192e+02
ECONVI_c019_2_00 (conv_i_src_c019_2_00 0 conv_bpf_c019_2 0) vcvs gain=9.807852804032e-01
SCONVI_c019_2_00 (conv_i_src_c019_2_00 conv_i_c019_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_00 (conv_q_src_c019_2_00 0 conv_bpf_c019_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_2_00 (conv_q_src_c019_2_00 conv_q_c019_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_01 (conv_i_src_c019_2_01 0 conv_bpf_c019_2 0) vcvs gain=8.314696123025e-01
SCONVI_c019_2_01 (conv_i_src_c019_2_01 conv_i_c019_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_01 (conv_q_src_c019_2_01 0 conv_bpf_c019_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_2_01 (conv_q_src_c019_2_01 conv_q_c019_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_02 (conv_i_src_c019_2_02 0 conv_bpf_c019_2 0) vcvs gain=5.555702330196e-01
SCONVI_c019_2_02 (conv_i_src_c019_2_02 conv_i_c019_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_02 (conv_q_src_c019_2_02 0 conv_bpf_c019_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_2_02 (conv_q_src_c019_2_02 conv_q_c019_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_03 (conv_i_src_c019_2_03 0 conv_bpf_c019_2 0) vcvs gain=1.950903220161e-01
SCONVI_c019_2_03 (conv_i_src_c019_2_03 conv_i_c019_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_03 (conv_q_src_c019_2_03 0 conv_bpf_c019_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_2_03 (conv_q_src_c019_2_03 conv_q_c019_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_04 (conv_i_src_c019_2_04 0 conv_bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_2_04 (conv_i_src_c019_2_04 conv_i_c019_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_04 (conv_q_src_c019_2_04 0 conv_bpf_c019_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_2_04 (conv_q_src_c019_2_04 conv_q_c019_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_05 (conv_i_src_c019_2_05 0 conv_bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_2_05 (conv_i_src_c019_2_05 conv_i_c019_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_05 (conv_q_src_c019_2_05 0 conv_bpf_c019_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_2_05 (conv_q_src_c019_2_05 conv_q_c019_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_06 (conv_i_src_c019_2_06 0 conv_bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_2_06 (conv_i_src_c019_2_06 conv_i_c019_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_06 (conv_q_src_c019_2_06 0 conv_bpf_c019_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_2_06 (conv_q_src_c019_2_06 conv_q_c019_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_07 (conv_i_src_c019_2_07 0 conv_bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_2_07 (conv_i_src_c019_2_07 conv_i_c019_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_07 (conv_q_src_c019_2_07 0 conv_bpf_c019_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_2_07 (conv_q_src_c019_2_07 conv_q_c019_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_08 (conv_i_src_c019_2_08 0 conv_bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_2_08 (conv_i_src_c019_2_08 conv_i_c019_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_08 (conv_q_src_c019_2_08 0 conv_bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_2_08 (conv_q_src_c019_2_08 conv_q_c019_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_09 (conv_i_src_c019_2_09 0 conv_bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_2_09 (conv_i_src_c019_2_09 conv_i_c019_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_09 (conv_q_src_c019_2_09 0 conv_bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_2_09 (conv_q_src_c019_2_09 conv_q_c019_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_10 (conv_i_src_c019_2_10 0 conv_bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_2_10 (conv_i_src_c019_2_10 conv_i_c019_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_10 (conv_q_src_c019_2_10 0 conv_bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_2_10 (conv_q_src_c019_2_10 conv_q_c019_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_11 (conv_i_src_c019_2_11 0 conv_bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_2_11 (conv_i_src_c019_2_11 conv_i_c019_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_11 (conv_q_src_c019_2_11 0 conv_bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_2_11 (conv_q_src_c019_2_11 conv_q_c019_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_12 (conv_i_src_c019_2_12 0 conv_bpf_c019_2 0) vcvs gain=1.950903220161e-01
SCONVI_c019_2_12 (conv_i_src_c019_2_12 conv_i_c019_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_12 (conv_q_src_c019_2_12 0 conv_bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_2_12 (conv_q_src_c019_2_12 conv_q_c019_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_13 (conv_i_src_c019_2_13 0 conv_bpf_c019_2 0) vcvs gain=5.555702330196e-01
SCONVI_c019_2_13 (conv_i_src_c019_2_13 conv_i_c019_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_13 (conv_q_src_c019_2_13 0 conv_bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_2_13 (conv_q_src_c019_2_13 conv_q_c019_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_14 (conv_i_src_c019_2_14 0 conv_bpf_c019_2 0) vcvs gain=8.314696123025e-01
SCONVI_c019_2_14 (conv_i_src_c019_2_14 conv_i_c019_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_14 (conv_q_src_c019_2_14 0 conv_bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_2_14 (conv_q_src_c019_2_14 conv_q_c019_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_2_15 (conv_i_src_c019_2_15 0 conv_bpf_c019_2 0) vcvs gain=9.807852804032e-01
SCONVI_c019_2_15 (conv_i_src_c019_2_15 conv_i_c019_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_2_15 (conv_q_src_c019_2_15 0 conv_bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_2_15 (conv_q_src_c019_2_15 conv_q_c019_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c019_2 (conv_i_c019_2 0) resistor r=1G
RCONVQ_c019_2 (conv_q_c019_2 0) resistor r=1G
RCONVINTI_c019_2 (conv_i_c019_2 ConvIcar_c019_2) resistor r=1k
CCONVINTI_c019_2 (ConvIcar_c019_2 0) capacitor c=80p
RCONVINTQ_c019_2 (conv_q_c019_2 ConvQcar_c019_2) resistor r=1k
CCONVINTQ_c019_2 (ConvQcar_c019_2 0) capacitor c=80p
save conv_bpf_c019_2 ConvIcar_c019_2 ConvQcar_c019_2

// conventional mixed baseline bl019, carrier_3: 1000000000 Hz
CCONVBPF_c019_3 (bl019 n_conv_cbpf_c019_3) capacitor c=2.533029591058e-14
LCONVBPF_c019_3 (n_conv_cbpf_c019_3 conv_bpf_c019_3) inductor l=1.000000000000e-06
RCONVBPF_c019_3 (conv_bpf_c019_3 0) resistor r=3.141592653590e+02
ECONVI_c019_3_00 (conv_i_src_c019_3_00 0 conv_bpf_c019_3 0) vcvs gain=9.807852804032e-01
SCONVI_c019_3_00 (conv_i_src_c019_3_00 conv_i_c019_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_00 (conv_q_src_c019_3_00 0 conv_bpf_c019_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_3_00 (conv_q_src_c019_3_00 conv_q_c019_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_01 (conv_i_src_c019_3_01 0 conv_bpf_c019_3 0) vcvs gain=8.314696123025e-01
SCONVI_c019_3_01 (conv_i_src_c019_3_01 conv_i_c019_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_01 (conv_q_src_c019_3_01 0 conv_bpf_c019_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_3_01 (conv_q_src_c019_3_01 conv_q_c019_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_02 (conv_i_src_c019_3_02 0 conv_bpf_c019_3 0) vcvs gain=5.555702330196e-01
SCONVI_c019_3_02 (conv_i_src_c019_3_02 conv_i_c019_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_02 (conv_q_src_c019_3_02 0 conv_bpf_c019_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_3_02 (conv_q_src_c019_3_02 conv_q_c019_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_03 (conv_i_src_c019_3_03 0 conv_bpf_c019_3 0) vcvs gain=1.950903220161e-01
SCONVI_c019_3_03 (conv_i_src_c019_3_03 conv_i_c019_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_03 (conv_q_src_c019_3_03 0 conv_bpf_c019_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_3_03 (conv_q_src_c019_3_03 conv_q_c019_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_04 (conv_i_src_c019_3_04 0 conv_bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_3_04 (conv_i_src_c019_3_04 conv_i_c019_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_04 (conv_q_src_c019_3_04 0 conv_bpf_c019_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c019_3_04 (conv_q_src_c019_3_04 conv_q_c019_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_05 (conv_i_src_c019_3_05 0 conv_bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_3_05 (conv_i_src_c019_3_05 conv_i_c019_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_05 (conv_q_src_c019_3_05 0 conv_bpf_c019_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c019_3_05 (conv_q_src_c019_3_05 conv_q_c019_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_06 (conv_i_src_c019_3_06 0 conv_bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_3_06 (conv_i_src_c019_3_06 conv_i_c019_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_06 (conv_q_src_c019_3_06 0 conv_bpf_c019_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c019_3_06 (conv_q_src_c019_3_06 conv_q_c019_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_07 (conv_i_src_c019_3_07 0 conv_bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_3_07 (conv_i_src_c019_3_07 conv_i_c019_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_07 (conv_q_src_c019_3_07 0 conv_bpf_c019_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c019_3_07 (conv_q_src_c019_3_07 conv_q_c019_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_08 (conv_i_src_c019_3_08 0 conv_bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c019_3_08 (conv_i_src_c019_3_08 conv_i_c019_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_08 (conv_q_src_c019_3_08 0 conv_bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_3_08 (conv_q_src_c019_3_08 conv_q_c019_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_09 (conv_i_src_c019_3_09 0 conv_bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c019_3_09 (conv_i_src_c019_3_09 conv_i_c019_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_09 (conv_q_src_c019_3_09 0 conv_bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_3_09 (conv_q_src_c019_3_09 conv_q_c019_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_10 (conv_i_src_c019_3_10 0 conv_bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c019_3_10 (conv_i_src_c019_3_10 conv_i_c019_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_10 (conv_q_src_c019_3_10 0 conv_bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_3_10 (conv_q_src_c019_3_10 conv_q_c019_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_11 (conv_i_src_c019_3_11 0 conv_bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c019_3_11 (conv_i_src_c019_3_11 conv_i_c019_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_11 (conv_q_src_c019_3_11 0 conv_bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_3_11 (conv_q_src_c019_3_11 conv_q_c019_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_12 (conv_i_src_c019_3_12 0 conv_bpf_c019_3 0) vcvs gain=1.950903220161e-01
SCONVI_c019_3_12 (conv_i_src_c019_3_12 conv_i_c019_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_12 (conv_q_src_c019_3_12 0 conv_bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c019_3_12 (conv_q_src_c019_3_12 conv_q_c019_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_13 (conv_i_src_c019_3_13 0 conv_bpf_c019_3 0) vcvs gain=5.555702330196e-01
SCONVI_c019_3_13 (conv_i_src_c019_3_13 conv_i_c019_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_13 (conv_q_src_c019_3_13 0 conv_bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c019_3_13 (conv_q_src_c019_3_13 conv_q_c019_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_14 (conv_i_src_c019_3_14 0 conv_bpf_c019_3 0) vcvs gain=8.314696123025e-01
SCONVI_c019_3_14 (conv_i_src_c019_3_14 conv_i_c019_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_14 (conv_q_src_c019_3_14 0 conv_bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c019_3_14 (conv_q_src_c019_3_14 conv_q_c019_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c019_3_15 (conv_i_src_c019_3_15 0 conv_bpf_c019_3 0) vcvs gain=9.807852804032e-01
SCONVI_c019_3_15 (conv_i_src_c019_3_15 conv_i_c019_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c019_3_15 (conv_q_src_c019_3_15 0 conv_bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c019_3_15 (conv_q_src_c019_3_15 conv_q_c019_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c019_3 (conv_i_c019_3 0) resistor r=1G
RCONVQ_c019_3 (conv_q_c019_3 0) resistor r=1G
RCONVINTI_c019_3 (conv_i_c019_3 ConvIcar_c019_3) resistor r=1k
CCONVINTI_c019_3 (ConvIcar_c019_3 0) capacitor c=80p
RCONVINTQ_c019_3 (conv_q_c019_3 ConvQcar_c019_3) resistor r=1k
CCONVINTQ_c019_3 (ConvQcar_c019_3 0) capacitor c=80p
save conv_bpf_c019_3 ConvIcar_c019_3 ConvQcar_c019_3

// conventional mixed baseline bl020, carrier_0: 250000000 Hz
CCONVBPF_c020_0 (bl020 n_conv_cbpf_c020_0) capacitor c=4.052847345694e-13
LCONVBPF_c020_0 (n_conv_cbpf_c020_0 conv_bpf_c020_0) inductor l=1.000000000000e-06
RCONVBPF_c020_0 (conv_bpf_c020_0 0) resistor r=7.853981633974e+01
ECONVI_c020_0_00 (conv_i_src_c020_0_00 0 conv_bpf_c020_0 0) vcvs gain=9.807852804032e-01
SCONVI_c020_0_00 (conv_i_src_c020_0_00 conv_i_c020_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_00 (conv_q_src_c020_0_00 0 conv_bpf_c020_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_0_00 (conv_q_src_c020_0_00 conv_q_c020_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_01 (conv_i_src_c020_0_01 0 conv_bpf_c020_0 0) vcvs gain=8.314696123025e-01
SCONVI_c020_0_01 (conv_i_src_c020_0_01 conv_i_c020_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_01 (conv_q_src_c020_0_01 0 conv_bpf_c020_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_0_01 (conv_q_src_c020_0_01 conv_q_c020_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_02 (conv_i_src_c020_0_02 0 conv_bpf_c020_0 0) vcvs gain=5.555702330196e-01
SCONVI_c020_0_02 (conv_i_src_c020_0_02 conv_i_c020_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_02 (conv_q_src_c020_0_02 0 conv_bpf_c020_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_0_02 (conv_q_src_c020_0_02 conv_q_c020_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_03 (conv_i_src_c020_0_03 0 conv_bpf_c020_0 0) vcvs gain=1.950903220161e-01
SCONVI_c020_0_03 (conv_i_src_c020_0_03 conv_i_c020_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_03 (conv_q_src_c020_0_03 0 conv_bpf_c020_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_0_03 (conv_q_src_c020_0_03 conv_q_c020_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_04 (conv_i_src_c020_0_04 0 conv_bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_0_04 (conv_i_src_c020_0_04 conv_i_c020_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_04 (conv_q_src_c020_0_04 0 conv_bpf_c020_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_0_04 (conv_q_src_c020_0_04 conv_q_c020_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_05 (conv_i_src_c020_0_05 0 conv_bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_0_05 (conv_i_src_c020_0_05 conv_i_c020_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_05 (conv_q_src_c020_0_05 0 conv_bpf_c020_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_0_05 (conv_q_src_c020_0_05 conv_q_c020_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_06 (conv_i_src_c020_0_06 0 conv_bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_0_06 (conv_i_src_c020_0_06 conv_i_c020_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_06 (conv_q_src_c020_0_06 0 conv_bpf_c020_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_0_06 (conv_q_src_c020_0_06 conv_q_c020_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_07 (conv_i_src_c020_0_07 0 conv_bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_0_07 (conv_i_src_c020_0_07 conv_i_c020_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_07 (conv_q_src_c020_0_07 0 conv_bpf_c020_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_0_07 (conv_q_src_c020_0_07 conv_q_c020_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_08 (conv_i_src_c020_0_08 0 conv_bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_0_08 (conv_i_src_c020_0_08 conv_i_c020_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_08 (conv_q_src_c020_0_08 0 conv_bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_0_08 (conv_q_src_c020_0_08 conv_q_c020_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_09 (conv_i_src_c020_0_09 0 conv_bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_0_09 (conv_i_src_c020_0_09 conv_i_c020_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_09 (conv_q_src_c020_0_09 0 conv_bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_0_09 (conv_q_src_c020_0_09 conv_q_c020_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_10 (conv_i_src_c020_0_10 0 conv_bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_0_10 (conv_i_src_c020_0_10 conv_i_c020_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_10 (conv_q_src_c020_0_10 0 conv_bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_0_10 (conv_q_src_c020_0_10 conv_q_c020_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_11 (conv_i_src_c020_0_11 0 conv_bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_0_11 (conv_i_src_c020_0_11 conv_i_c020_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_11 (conv_q_src_c020_0_11 0 conv_bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_0_11 (conv_q_src_c020_0_11 conv_q_c020_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_12 (conv_i_src_c020_0_12 0 conv_bpf_c020_0 0) vcvs gain=1.950903220161e-01
SCONVI_c020_0_12 (conv_i_src_c020_0_12 conv_i_c020_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_12 (conv_q_src_c020_0_12 0 conv_bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_0_12 (conv_q_src_c020_0_12 conv_q_c020_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_13 (conv_i_src_c020_0_13 0 conv_bpf_c020_0 0) vcvs gain=5.555702330196e-01
SCONVI_c020_0_13 (conv_i_src_c020_0_13 conv_i_c020_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_13 (conv_q_src_c020_0_13 0 conv_bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_0_13 (conv_q_src_c020_0_13 conv_q_c020_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_14 (conv_i_src_c020_0_14 0 conv_bpf_c020_0 0) vcvs gain=8.314696123025e-01
SCONVI_c020_0_14 (conv_i_src_c020_0_14 conv_i_c020_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_14 (conv_q_src_c020_0_14 0 conv_bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_0_14 (conv_q_src_c020_0_14 conv_q_c020_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_0_15 (conv_i_src_c020_0_15 0 conv_bpf_c020_0 0) vcvs gain=9.807852804032e-01
SCONVI_c020_0_15 (conv_i_src_c020_0_15 conv_i_c020_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_0_15 (conv_q_src_c020_0_15 0 conv_bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_0_15 (conv_q_src_c020_0_15 conv_q_c020_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c020_0 (conv_i_c020_0 0) resistor r=1G
RCONVQ_c020_0 (conv_q_c020_0 0) resistor r=1G
RCONVINTI_c020_0 (conv_i_c020_0 ConvIcar_c020_0) resistor r=1k
CCONVINTI_c020_0 (ConvIcar_c020_0 0) capacitor c=80p
RCONVINTQ_c020_0 (conv_q_c020_0 ConvQcar_c020_0) resistor r=1k
CCONVINTQ_c020_0 (ConvQcar_c020_0 0) capacitor c=80p
save conv_bpf_c020_0 ConvIcar_c020_0 ConvQcar_c020_0

// conventional mixed baseline bl020, carrier_1: 500000000 Hz
CCONVBPF_c020_1 (bl020 n_conv_cbpf_c020_1) capacitor c=1.013211836423e-13
LCONVBPF_c020_1 (n_conv_cbpf_c020_1 conv_bpf_c020_1) inductor l=1.000000000000e-06
RCONVBPF_c020_1 (conv_bpf_c020_1 0) resistor r=1.570796326795e+02
ECONVI_c020_1_00 (conv_i_src_c020_1_00 0 conv_bpf_c020_1 0) vcvs gain=9.807852804032e-01
SCONVI_c020_1_00 (conv_i_src_c020_1_00 conv_i_c020_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_00 (conv_q_src_c020_1_00 0 conv_bpf_c020_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_1_00 (conv_q_src_c020_1_00 conv_q_c020_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_01 (conv_i_src_c020_1_01 0 conv_bpf_c020_1 0) vcvs gain=8.314696123025e-01
SCONVI_c020_1_01 (conv_i_src_c020_1_01 conv_i_c020_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_01 (conv_q_src_c020_1_01 0 conv_bpf_c020_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_1_01 (conv_q_src_c020_1_01 conv_q_c020_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_02 (conv_i_src_c020_1_02 0 conv_bpf_c020_1 0) vcvs gain=5.555702330196e-01
SCONVI_c020_1_02 (conv_i_src_c020_1_02 conv_i_c020_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_02 (conv_q_src_c020_1_02 0 conv_bpf_c020_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_1_02 (conv_q_src_c020_1_02 conv_q_c020_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_03 (conv_i_src_c020_1_03 0 conv_bpf_c020_1 0) vcvs gain=1.950903220161e-01
SCONVI_c020_1_03 (conv_i_src_c020_1_03 conv_i_c020_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_03 (conv_q_src_c020_1_03 0 conv_bpf_c020_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_1_03 (conv_q_src_c020_1_03 conv_q_c020_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_04 (conv_i_src_c020_1_04 0 conv_bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_1_04 (conv_i_src_c020_1_04 conv_i_c020_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_04 (conv_q_src_c020_1_04 0 conv_bpf_c020_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_1_04 (conv_q_src_c020_1_04 conv_q_c020_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_05 (conv_i_src_c020_1_05 0 conv_bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_1_05 (conv_i_src_c020_1_05 conv_i_c020_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_05 (conv_q_src_c020_1_05 0 conv_bpf_c020_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_1_05 (conv_q_src_c020_1_05 conv_q_c020_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_06 (conv_i_src_c020_1_06 0 conv_bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_1_06 (conv_i_src_c020_1_06 conv_i_c020_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_06 (conv_q_src_c020_1_06 0 conv_bpf_c020_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_1_06 (conv_q_src_c020_1_06 conv_q_c020_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_07 (conv_i_src_c020_1_07 0 conv_bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_1_07 (conv_i_src_c020_1_07 conv_i_c020_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_07 (conv_q_src_c020_1_07 0 conv_bpf_c020_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_1_07 (conv_q_src_c020_1_07 conv_q_c020_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_08 (conv_i_src_c020_1_08 0 conv_bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_1_08 (conv_i_src_c020_1_08 conv_i_c020_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_08 (conv_q_src_c020_1_08 0 conv_bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_1_08 (conv_q_src_c020_1_08 conv_q_c020_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_09 (conv_i_src_c020_1_09 0 conv_bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_1_09 (conv_i_src_c020_1_09 conv_i_c020_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_09 (conv_q_src_c020_1_09 0 conv_bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_1_09 (conv_q_src_c020_1_09 conv_q_c020_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_10 (conv_i_src_c020_1_10 0 conv_bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_1_10 (conv_i_src_c020_1_10 conv_i_c020_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_10 (conv_q_src_c020_1_10 0 conv_bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_1_10 (conv_q_src_c020_1_10 conv_q_c020_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_11 (conv_i_src_c020_1_11 0 conv_bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_1_11 (conv_i_src_c020_1_11 conv_i_c020_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_11 (conv_q_src_c020_1_11 0 conv_bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_1_11 (conv_q_src_c020_1_11 conv_q_c020_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_12 (conv_i_src_c020_1_12 0 conv_bpf_c020_1 0) vcvs gain=1.950903220161e-01
SCONVI_c020_1_12 (conv_i_src_c020_1_12 conv_i_c020_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_12 (conv_q_src_c020_1_12 0 conv_bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_1_12 (conv_q_src_c020_1_12 conv_q_c020_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_13 (conv_i_src_c020_1_13 0 conv_bpf_c020_1 0) vcvs gain=5.555702330196e-01
SCONVI_c020_1_13 (conv_i_src_c020_1_13 conv_i_c020_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_13 (conv_q_src_c020_1_13 0 conv_bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_1_13 (conv_q_src_c020_1_13 conv_q_c020_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_14 (conv_i_src_c020_1_14 0 conv_bpf_c020_1 0) vcvs gain=8.314696123025e-01
SCONVI_c020_1_14 (conv_i_src_c020_1_14 conv_i_c020_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_14 (conv_q_src_c020_1_14 0 conv_bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_1_14 (conv_q_src_c020_1_14 conv_q_c020_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_1_15 (conv_i_src_c020_1_15 0 conv_bpf_c020_1 0) vcvs gain=9.807852804032e-01
SCONVI_c020_1_15 (conv_i_src_c020_1_15 conv_i_c020_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_1_15 (conv_q_src_c020_1_15 0 conv_bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_1_15 (conv_q_src_c020_1_15 conv_q_c020_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c020_1 (conv_i_c020_1 0) resistor r=1G
RCONVQ_c020_1 (conv_q_c020_1 0) resistor r=1G
RCONVINTI_c020_1 (conv_i_c020_1 ConvIcar_c020_1) resistor r=1k
CCONVINTI_c020_1 (ConvIcar_c020_1 0) capacitor c=80p
RCONVINTQ_c020_1 (conv_q_c020_1 ConvQcar_c020_1) resistor r=1k
CCONVINTQ_c020_1 (ConvQcar_c020_1 0) capacitor c=80p
save conv_bpf_c020_1 ConvIcar_c020_1 ConvQcar_c020_1

// conventional mixed baseline bl020, carrier_2: 750000000 Hz
CCONVBPF_c020_2 (bl020 n_conv_cbpf_c020_2) capacitor c=4.503163717437e-14
LCONVBPF_c020_2 (n_conv_cbpf_c020_2 conv_bpf_c020_2) inductor l=1.000000000000e-06
RCONVBPF_c020_2 (conv_bpf_c020_2 0) resistor r=2.356194490192e+02
ECONVI_c020_2_00 (conv_i_src_c020_2_00 0 conv_bpf_c020_2 0) vcvs gain=9.807852804032e-01
SCONVI_c020_2_00 (conv_i_src_c020_2_00 conv_i_c020_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_00 (conv_q_src_c020_2_00 0 conv_bpf_c020_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_2_00 (conv_q_src_c020_2_00 conv_q_c020_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_01 (conv_i_src_c020_2_01 0 conv_bpf_c020_2 0) vcvs gain=8.314696123025e-01
SCONVI_c020_2_01 (conv_i_src_c020_2_01 conv_i_c020_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_01 (conv_q_src_c020_2_01 0 conv_bpf_c020_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_2_01 (conv_q_src_c020_2_01 conv_q_c020_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_02 (conv_i_src_c020_2_02 0 conv_bpf_c020_2 0) vcvs gain=5.555702330196e-01
SCONVI_c020_2_02 (conv_i_src_c020_2_02 conv_i_c020_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_02 (conv_q_src_c020_2_02 0 conv_bpf_c020_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_2_02 (conv_q_src_c020_2_02 conv_q_c020_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_03 (conv_i_src_c020_2_03 0 conv_bpf_c020_2 0) vcvs gain=1.950903220161e-01
SCONVI_c020_2_03 (conv_i_src_c020_2_03 conv_i_c020_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_03 (conv_q_src_c020_2_03 0 conv_bpf_c020_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_2_03 (conv_q_src_c020_2_03 conv_q_c020_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_04 (conv_i_src_c020_2_04 0 conv_bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_2_04 (conv_i_src_c020_2_04 conv_i_c020_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_04 (conv_q_src_c020_2_04 0 conv_bpf_c020_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_2_04 (conv_q_src_c020_2_04 conv_q_c020_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_05 (conv_i_src_c020_2_05 0 conv_bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_2_05 (conv_i_src_c020_2_05 conv_i_c020_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_05 (conv_q_src_c020_2_05 0 conv_bpf_c020_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_2_05 (conv_q_src_c020_2_05 conv_q_c020_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_06 (conv_i_src_c020_2_06 0 conv_bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_2_06 (conv_i_src_c020_2_06 conv_i_c020_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_06 (conv_q_src_c020_2_06 0 conv_bpf_c020_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_2_06 (conv_q_src_c020_2_06 conv_q_c020_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_07 (conv_i_src_c020_2_07 0 conv_bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_2_07 (conv_i_src_c020_2_07 conv_i_c020_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_07 (conv_q_src_c020_2_07 0 conv_bpf_c020_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_2_07 (conv_q_src_c020_2_07 conv_q_c020_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_08 (conv_i_src_c020_2_08 0 conv_bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_2_08 (conv_i_src_c020_2_08 conv_i_c020_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_08 (conv_q_src_c020_2_08 0 conv_bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_2_08 (conv_q_src_c020_2_08 conv_q_c020_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_09 (conv_i_src_c020_2_09 0 conv_bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_2_09 (conv_i_src_c020_2_09 conv_i_c020_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_09 (conv_q_src_c020_2_09 0 conv_bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_2_09 (conv_q_src_c020_2_09 conv_q_c020_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_10 (conv_i_src_c020_2_10 0 conv_bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_2_10 (conv_i_src_c020_2_10 conv_i_c020_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_10 (conv_q_src_c020_2_10 0 conv_bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_2_10 (conv_q_src_c020_2_10 conv_q_c020_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_11 (conv_i_src_c020_2_11 0 conv_bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_2_11 (conv_i_src_c020_2_11 conv_i_c020_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_11 (conv_q_src_c020_2_11 0 conv_bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_2_11 (conv_q_src_c020_2_11 conv_q_c020_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_12 (conv_i_src_c020_2_12 0 conv_bpf_c020_2 0) vcvs gain=1.950903220161e-01
SCONVI_c020_2_12 (conv_i_src_c020_2_12 conv_i_c020_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_12 (conv_q_src_c020_2_12 0 conv_bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_2_12 (conv_q_src_c020_2_12 conv_q_c020_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_13 (conv_i_src_c020_2_13 0 conv_bpf_c020_2 0) vcvs gain=5.555702330196e-01
SCONVI_c020_2_13 (conv_i_src_c020_2_13 conv_i_c020_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_13 (conv_q_src_c020_2_13 0 conv_bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_2_13 (conv_q_src_c020_2_13 conv_q_c020_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_14 (conv_i_src_c020_2_14 0 conv_bpf_c020_2 0) vcvs gain=8.314696123025e-01
SCONVI_c020_2_14 (conv_i_src_c020_2_14 conv_i_c020_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_14 (conv_q_src_c020_2_14 0 conv_bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_2_14 (conv_q_src_c020_2_14 conv_q_c020_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_2_15 (conv_i_src_c020_2_15 0 conv_bpf_c020_2 0) vcvs gain=9.807852804032e-01
SCONVI_c020_2_15 (conv_i_src_c020_2_15 conv_i_c020_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_2_15 (conv_q_src_c020_2_15 0 conv_bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_2_15 (conv_q_src_c020_2_15 conv_q_c020_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c020_2 (conv_i_c020_2 0) resistor r=1G
RCONVQ_c020_2 (conv_q_c020_2 0) resistor r=1G
RCONVINTI_c020_2 (conv_i_c020_2 ConvIcar_c020_2) resistor r=1k
CCONVINTI_c020_2 (ConvIcar_c020_2 0) capacitor c=80p
RCONVINTQ_c020_2 (conv_q_c020_2 ConvQcar_c020_2) resistor r=1k
CCONVINTQ_c020_2 (ConvQcar_c020_2 0) capacitor c=80p
save conv_bpf_c020_2 ConvIcar_c020_2 ConvQcar_c020_2

// conventional mixed baseline bl020, carrier_3: 1000000000 Hz
CCONVBPF_c020_3 (bl020 n_conv_cbpf_c020_3) capacitor c=2.533029591058e-14
LCONVBPF_c020_3 (n_conv_cbpf_c020_3 conv_bpf_c020_3) inductor l=1.000000000000e-06
RCONVBPF_c020_3 (conv_bpf_c020_3 0) resistor r=3.141592653590e+02
ECONVI_c020_3_00 (conv_i_src_c020_3_00 0 conv_bpf_c020_3 0) vcvs gain=9.807852804032e-01
SCONVI_c020_3_00 (conv_i_src_c020_3_00 conv_i_c020_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_00 (conv_q_src_c020_3_00 0 conv_bpf_c020_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_3_00 (conv_q_src_c020_3_00 conv_q_c020_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_01 (conv_i_src_c020_3_01 0 conv_bpf_c020_3 0) vcvs gain=8.314696123025e-01
SCONVI_c020_3_01 (conv_i_src_c020_3_01 conv_i_c020_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_01 (conv_q_src_c020_3_01 0 conv_bpf_c020_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_3_01 (conv_q_src_c020_3_01 conv_q_c020_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_02 (conv_i_src_c020_3_02 0 conv_bpf_c020_3 0) vcvs gain=5.555702330196e-01
SCONVI_c020_3_02 (conv_i_src_c020_3_02 conv_i_c020_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_02 (conv_q_src_c020_3_02 0 conv_bpf_c020_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_3_02 (conv_q_src_c020_3_02 conv_q_c020_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_03 (conv_i_src_c020_3_03 0 conv_bpf_c020_3 0) vcvs gain=1.950903220161e-01
SCONVI_c020_3_03 (conv_i_src_c020_3_03 conv_i_c020_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_03 (conv_q_src_c020_3_03 0 conv_bpf_c020_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_3_03 (conv_q_src_c020_3_03 conv_q_c020_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_04 (conv_i_src_c020_3_04 0 conv_bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_3_04 (conv_i_src_c020_3_04 conv_i_c020_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_04 (conv_q_src_c020_3_04 0 conv_bpf_c020_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c020_3_04 (conv_q_src_c020_3_04 conv_q_c020_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_05 (conv_i_src_c020_3_05 0 conv_bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_3_05 (conv_i_src_c020_3_05 conv_i_c020_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_05 (conv_q_src_c020_3_05 0 conv_bpf_c020_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c020_3_05 (conv_q_src_c020_3_05 conv_q_c020_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_06 (conv_i_src_c020_3_06 0 conv_bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_3_06 (conv_i_src_c020_3_06 conv_i_c020_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_06 (conv_q_src_c020_3_06 0 conv_bpf_c020_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c020_3_06 (conv_q_src_c020_3_06 conv_q_c020_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_07 (conv_i_src_c020_3_07 0 conv_bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_3_07 (conv_i_src_c020_3_07 conv_i_c020_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_07 (conv_q_src_c020_3_07 0 conv_bpf_c020_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c020_3_07 (conv_q_src_c020_3_07 conv_q_c020_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_08 (conv_i_src_c020_3_08 0 conv_bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c020_3_08 (conv_i_src_c020_3_08 conv_i_c020_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_08 (conv_q_src_c020_3_08 0 conv_bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_3_08 (conv_q_src_c020_3_08 conv_q_c020_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_09 (conv_i_src_c020_3_09 0 conv_bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c020_3_09 (conv_i_src_c020_3_09 conv_i_c020_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_09 (conv_q_src_c020_3_09 0 conv_bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_3_09 (conv_q_src_c020_3_09 conv_q_c020_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_10 (conv_i_src_c020_3_10 0 conv_bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c020_3_10 (conv_i_src_c020_3_10 conv_i_c020_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_10 (conv_q_src_c020_3_10 0 conv_bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_3_10 (conv_q_src_c020_3_10 conv_q_c020_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_11 (conv_i_src_c020_3_11 0 conv_bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c020_3_11 (conv_i_src_c020_3_11 conv_i_c020_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_11 (conv_q_src_c020_3_11 0 conv_bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_3_11 (conv_q_src_c020_3_11 conv_q_c020_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_12 (conv_i_src_c020_3_12 0 conv_bpf_c020_3 0) vcvs gain=1.950903220161e-01
SCONVI_c020_3_12 (conv_i_src_c020_3_12 conv_i_c020_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_12 (conv_q_src_c020_3_12 0 conv_bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c020_3_12 (conv_q_src_c020_3_12 conv_q_c020_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_13 (conv_i_src_c020_3_13 0 conv_bpf_c020_3 0) vcvs gain=5.555702330196e-01
SCONVI_c020_3_13 (conv_i_src_c020_3_13 conv_i_c020_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_13 (conv_q_src_c020_3_13 0 conv_bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c020_3_13 (conv_q_src_c020_3_13 conv_q_c020_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_14 (conv_i_src_c020_3_14 0 conv_bpf_c020_3 0) vcvs gain=8.314696123025e-01
SCONVI_c020_3_14 (conv_i_src_c020_3_14 conv_i_c020_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_14 (conv_q_src_c020_3_14 0 conv_bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c020_3_14 (conv_q_src_c020_3_14 conv_q_c020_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c020_3_15 (conv_i_src_c020_3_15 0 conv_bpf_c020_3 0) vcvs gain=9.807852804032e-01
SCONVI_c020_3_15 (conv_i_src_c020_3_15 conv_i_c020_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c020_3_15 (conv_q_src_c020_3_15 0 conv_bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c020_3_15 (conv_q_src_c020_3_15 conv_q_c020_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c020_3 (conv_i_c020_3 0) resistor r=1G
RCONVQ_c020_3 (conv_q_c020_3 0) resistor r=1G
RCONVINTI_c020_3 (conv_i_c020_3 ConvIcar_c020_3) resistor r=1k
CCONVINTI_c020_3 (ConvIcar_c020_3 0) capacitor c=80p
RCONVINTQ_c020_3 (conv_q_c020_3 ConvQcar_c020_3) resistor r=1k
CCONVINTQ_c020_3 (ConvQcar_c020_3 0) capacitor c=80p
save conv_bpf_c020_3 ConvIcar_c020_3 ConvQcar_c020_3

// conventional mixed baseline bl021, carrier_0: 250000000 Hz
CCONVBPF_c021_0 (bl021 n_conv_cbpf_c021_0) capacitor c=4.052847345694e-13
LCONVBPF_c021_0 (n_conv_cbpf_c021_0 conv_bpf_c021_0) inductor l=1.000000000000e-06
RCONVBPF_c021_0 (conv_bpf_c021_0 0) resistor r=7.853981633974e+01
ECONVI_c021_0_00 (conv_i_src_c021_0_00 0 conv_bpf_c021_0 0) vcvs gain=9.807852804032e-01
SCONVI_c021_0_00 (conv_i_src_c021_0_00 conv_i_c021_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_00 (conv_q_src_c021_0_00 0 conv_bpf_c021_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_0_00 (conv_q_src_c021_0_00 conv_q_c021_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_01 (conv_i_src_c021_0_01 0 conv_bpf_c021_0 0) vcvs gain=8.314696123025e-01
SCONVI_c021_0_01 (conv_i_src_c021_0_01 conv_i_c021_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_01 (conv_q_src_c021_0_01 0 conv_bpf_c021_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_0_01 (conv_q_src_c021_0_01 conv_q_c021_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_02 (conv_i_src_c021_0_02 0 conv_bpf_c021_0 0) vcvs gain=5.555702330196e-01
SCONVI_c021_0_02 (conv_i_src_c021_0_02 conv_i_c021_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_02 (conv_q_src_c021_0_02 0 conv_bpf_c021_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_0_02 (conv_q_src_c021_0_02 conv_q_c021_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_03 (conv_i_src_c021_0_03 0 conv_bpf_c021_0 0) vcvs gain=1.950903220161e-01
SCONVI_c021_0_03 (conv_i_src_c021_0_03 conv_i_c021_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_03 (conv_q_src_c021_0_03 0 conv_bpf_c021_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_0_03 (conv_q_src_c021_0_03 conv_q_c021_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_04 (conv_i_src_c021_0_04 0 conv_bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_0_04 (conv_i_src_c021_0_04 conv_i_c021_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_04 (conv_q_src_c021_0_04 0 conv_bpf_c021_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_0_04 (conv_q_src_c021_0_04 conv_q_c021_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_05 (conv_i_src_c021_0_05 0 conv_bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_0_05 (conv_i_src_c021_0_05 conv_i_c021_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_05 (conv_q_src_c021_0_05 0 conv_bpf_c021_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_0_05 (conv_q_src_c021_0_05 conv_q_c021_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_06 (conv_i_src_c021_0_06 0 conv_bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_0_06 (conv_i_src_c021_0_06 conv_i_c021_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_06 (conv_q_src_c021_0_06 0 conv_bpf_c021_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_0_06 (conv_q_src_c021_0_06 conv_q_c021_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_07 (conv_i_src_c021_0_07 0 conv_bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_0_07 (conv_i_src_c021_0_07 conv_i_c021_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_07 (conv_q_src_c021_0_07 0 conv_bpf_c021_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_0_07 (conv_q_src_c021_0_07 conv_q_c021_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_08 (conv_i_src_c021_0_08 0 conv_bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_0_08 (conv_i_src_c021_0_08 conv_i_c021_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_08 (conv_q_src_c021_0_08 0 conv_bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_0_08 (conv_q_src_c021_0_08 conv_q_c021_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_09 (conv_i_src_c021_0_09 0 conv_bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_0_09 (conv_i_src_c021_0_09 conv_i_c021_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_09 (conv_q_src_c021_0_09 0 conv_bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_0_09 (conv_q_src_c021_0_09 conv_q_c021_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_10 (conv_i_src_c021_0_10 0 conv_bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_0_10 (conv_i_src_c021_0_10 conv_i_c021_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_10 (conv_q_src_c021_0_10 0 conv_bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_0_10 (conv_q_src_c021_0_10 conv_q_c021_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_11 (conv_i_src_c021_0_11 0 conv_bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_0_11 (conv_i_src_c021_0_11 conv_i_c021_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_11 (conv_q_src_c021_0_11 0 conv_bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_0_11 (conv_q_src_c021_0_11 conv_q_c021_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_12 (conv_i_src_c021_0_12 0 conv_bpf_c021_0 0) vcvs gain=1.950903220161e-01
SCONVI_c021_0_12 (conv_i_src_c021_0_12 conv_i_c021_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_12 (conv_q_src_c021_0_12 0 conv_bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_0_12 (conv_q_src_c021_0_12 conv_q_c021_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_13 (conv_i_src_c021_0_13 0 conv_bpf_c021_0 0) vcvs gain=5.555702330196e-01
SCONVI_c021_0_13 (conv_i_src_c021_0_13 conv_i_c021_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_13 (conv_q_src_c021_0_13 0 conv_bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_0_13 (conv_q_src_c021_0_13 conv_q_c021_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_14 (conv_i_src_c021_0_14 0 conv_bpf_c021_0 0) vcvs gain=8.314696123025e-01
SCONVI_c021_0_14 (conv_i_src_c021_0_14 conv_i_c021_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_14 (conv_q_src_c021_0_14 0 conv_bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_0_14 (conv_q_src_c021_0_14 conv_q_c021_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_0_15 (conv_i_src_c021_0_15 0 conv_bpf_c021_0 0) vcvs gain=9.807852804032e-01
SCONVI_c021_0_15 (conv_i_src_c021_0_15 conv_i_c021_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_0_15 (conv_q_src_c021_0_15 0 conv_bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_0_15 (conv_q_src_c021_0_15 conv_q_c021_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c021_0 (conv_i_c021_0 0) resistor r=1G
RCONVQ_c021_0 (conv_q_c021_0 0) resistor r=1G
RCONVINTI_c021_0 (conv_i_c021_0 ConvIcar_c021_0) resistor r=1k
CCONVINTI_c021_0 (ConvIcar_c021_0 0) capacitor c=80p
RCONVINTQ_c021_0 (conv_q_c021_0 ConvQcar_c021_0) resistor r=1k
CCONVINTQ_c021_0 (ConvQcar_c021_0 0) capacitor c=80p
save conv_bpf_c021_0 ConvIcar_c021_0 ConvQcar_c021_0

// conventional mixed baseline bl021, carrier_1: 500000000 Hz
CCONVBPF_c021_1 (bl021 n_conv_cbpf_c021_1) capacitor c=1.013211836423e-13
LCONVBPF_c021_1 (n_conv_cbpf_c021_1 conv_bpf_c021_1) inductor l=1.000000000000e-06
RCONVBPF_c021_1 (conv_bpf_c021_1 0) resistor r=1.570796326795e+02
ECONVI_c021_1_00 (conv_i_src_c021_1_00 0 conv_bpf_c021_1 0) vcvs gain=9.807852804032e-01
SCONVI_c021_1_00 (conv_i_src_c021_1_00 conv_i_c021_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_00 (conv_q_src_c021_1_00 0 conv_bpf_c021_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_1_00 (conv_q_src_c021_1_00 conv_q_c021_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_01 (conv_i_src_c021_1_01 0 conv_bpf_c021_1 0) vcvs gain=8.314696123025e-01
SCONVI_c021_1_01 (conv_i_src_c021_1_01 conv_i_c021_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_01 (conv_q_src_c021_1_01 0 conv_bpf_c021_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_1_01 (conv_q_src_c021_1_01 conv_q_c021_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_02 (conv_i_src_c021_1_02 0 conv_bpf_c021_1 0) vcvs gain=5.555702330196e-01
SCONVI_c021_1_02 (conv_i_src_c021_1_02 conv_i_c021_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_02 (conv_q_src_c021_1_02 0 conv_bpf_c021_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_1_02 (conv_q_src_c021_1_02 conv_q_c021_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_03 (conv_i_src_c021_1_03 0 conv_bpf_c021_1 0) vcvs gain=1.950903220161e-01
SCONVI_c021_1_03 (conv_i_src_c021_1_03 conv_i_c021_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_03 (conv_q_src_c021_1_03 0 conv_bpf_c021_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_1_03 (conv_q_src_c021_1_03 conv_q_c021_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_04 (conv_i_src_c021_1_04 0 conv_bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_1_04 (conv_i_src_c021_1_04 conv_i_c021_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_04 (conv_q_src_c021_1_04 0 conv_bpf_c021_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_1_04 (conv_q_src_c021_1_04 conv_q_c021_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_05 (conv_i_src_c021_1_05 0 conv_bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_1_05 (conv_i_src_c021_1_05 conv_i_c021_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_05 (conv_q_src_c021_1_05 0 conv_bpf_c021_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_1_05 (conv_q_src_c021_1_05 conv_q_c021_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_06 (conv_i_src_c021_1_06 0 conv_bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_1_06 (conv_i_src_c021_1_06 conv_i_c021_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_06 (conv_q_src_c021_1_06 0 conv_bpf_c021_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_1_06 (conv_q_src_c021_1_06 conv_q_c021_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_07 (conv_i_src_c021_1_07 0 conv_bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_1_07 (conv_i_src_c021_1_07 conv_i_c021_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_07 (conv_q_src_c021_1_07 0 conv_bpf_c021_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_1_07 (conv_q_src_c021_1_07 conv_q_c021_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_08 (conv_i_src_c021_1_08 0 conv_bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_1_08 (conv_i_src_c021_1_08 conv_i_c021_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_08 (conv_q_src_c021_1_08 0 conv_bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_1_08 (conv_q_src_c021_1_08 conv_q_c021_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_09 (conv_i_src_c021_1_09 0 conv_bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_1_09 (conv_i_src_c021_1_09 conv_i_c021_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_09 (conv_q_src_c021_1_09 0 conv_bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_1_09 (conv_q_src_c021_1_09 conv_q_c021_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_10 (conv_i_src_c021_1_10 0 conv_bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_1_10 (conv_i_src_c021_1_10 conv_i_c021_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_10 (conv_q_src_c021_1_10 0 conv_bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_1_10 (conv_q_src_c021_1_10 conv_q_c021_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_11 (conv_i_src_c021_1_11 0 conv_bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_1_11 (conv_i_src_c021_1_11 conv_i_c021_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_11 (conv_q_src_c021_1_11 0 conv_bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_1_11 (conv_q_src_c021_1_11 conv_q_c021_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_12 (conv_i_src_c021_1_12 0 conv_bpf_c021_1 0) vcvs gain=1.950903220161e-01
SCONVI_c021_1_12 (conv_i_src_c021_1_12 conv_i_c021_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_12 (conv_q_src_c021_1_12 0 conv_bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_1_12 (conv_q_src_c021_1_12 conv_q_c021_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_13 (conv_i_src_c021_1_13 0 conv_bpf_c021_1 0) vcvs gain=5.555702330196e-01
SCONVI_c021_1_13 (conv_i_src_c021_1_13 conv_i_c021_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_13 (conv_q_src_c021_1_13 0 conv_bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_1_13 (conv_q_src_c021_1_13 conv_q_c021_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_14 (conv_i_src_c021_1_14 0 conv_bpf_c021_1 0) vcvs gain=8.314696123025e-01
SCONVI_c021_1_14 (conv_i_src_c021_1_14 conv_i_c021_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_14 (conv_q_src_c021_1_14 0 conv_bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_1_14 (conv_q_src_c021_1_14 conv_q_c021_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_1_15 (conv_i_src_c021_1_15 0 conv_bpf_c021_1 0) vcvs gain=9.807852804032e-01
SCONVI_c021_1_15 (conv_i_src_c021_1_15 conv_i_c021_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_1_15 (conv_q_src_c021_1_15 0 conv_bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_1_15 (conv_q_src_c021_1_15 conv_q_c021_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c021_1 (conv_i_c021_1 0) resistor r=1G
RCONVQ_c021_1 (conv_q_c021_1 0) resistor r=1G
RCONVINTI_c021_1 (conv_i_c021_1 ConvIcar_c021_1) resistor r=1k
CCONVINTI_c021_1 (ConvIcar_c021_1 0) capacitor c=80p
RCONVINTQ_c021_1 (conv_q_c021_1 ConvQcar_c021_1) resistor r=1k
CCONVINTQ_c021_1 (ConvQcar_c021_1 0) capacitor c=80p
save conv_bpf_c021_1 ConvIcar_c021_1 ConvQcar_c021_1

// conventional mixed baseline bl021, carrier_2: 750000000 Hz
CCONVBPF_c021_2 (bl021 n_conv_cbpf_c021_2) capacitor c=4.503163717437e-14
LCONVBPF_c021_2 (n_conv_cbpf_c021_2 conv_bpf_c021_2) inductor l=1.000000000000e-06
RCONVBPF_c021_2 (conv_bpf_c021_2 0) resistor r=2.356194490192e+02
ECONVI_c021_2_00 (conv_i_src_c021_2_00 0 conv_bpf_c021_2 0) vcvs gain=9.807852804032e-01
SCONVI_c021_2_00 (conv_i_src_c021_2_00 conv_i_c021_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_00 (conv_q_src_c021_2_00 0 conv_bpf_c021_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_2_00 (conv_q_src_c021_2_00 conv_q_c021_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_01 (conv_i_src_c021_2_01 0 conv_bpf_c021_2 0) vcvs gain=8.314696123025e-01
SCONVI_c021_2_01 (conv_i_src_c021_2_01 conv_i_c021_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_01 (conv_q_src_c021_2_01 0 conv_bpf_c021_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_2_01 (conv_q_src_c021_2_01 conv_q_c021_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_02 (conv_i_src_c021_2_02 0 conv_bpf_c021_2 0) vcvs gain=5.555702330196e-01
SCONVI_c021_2_02 (conv_i_src_c021_2_02 conv_i_c021_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_02 (conv_q_src_c021_2_02 0 conv_bpf_c021_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_2_02 (conv_q_src_c021_2_02 conv_q_c021_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_03 (conv_i_src_c021_2_03 0 conv_bpf_c021_2 0) vcvs gain=1.950903220161e-01
SCONVI_c021_2_03 (conv_i_src_c021_2_03 conv_i_c021_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_03 (conv_q_src_c021_2_03 0 conv_bpf_c021_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_2_03 (conv_q_src_c021_2_03 conv_q_c021_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_04 (conv_i_src_c021_2_04 0 conv_bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_2_04 (conv_i_src_c021_2_04 conv_i_c021_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_04 (conv_q_src_c021_2_04 0 conv_bpf_c021_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_2_04 (conv_q_src_c021_2_04 conv_q_c021_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_05 (conv_i_src_c021_2_05 0 conv_bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_2_05 (conv_i_src_c021_2_05 conv_i_c021_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_05 (conv_q_src_c021_2_05 0 conv_bpf_c021_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_2_05 (conv_q_src_c021_2_05 conv_q_c021_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_06 (conv_i_src_c021_2_06 0 conv_bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_2_06 (conv_i_src_c021_2_06 conv_i_c021_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_06 (conv_q_src_c021_2_06 0 conv_bpf_c021_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_2_06 (conv_q_src_c021_2_06 conv_q_c021_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_07 (conv_i_src_c021_2_07 0 conv_bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_2_07 (conv_i_src_c021_2_07 conv_i_c021_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_07 (conv_q_src_c021_2_07 0 conv_bpf_c021_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_2_07 (conv_q_src_c021_2_07 conv_q_c021_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_08 (conv_i_src_c021_2_08 0 conv_bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_2_08 (conv_i_src_c021_2_08 conv_i_c021_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_08 (conv_q_src_c021_2_08 0 conv_bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_2_08 (conv_q_src_c021_2_08 conv_q_c021_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_09 (conv_i_src_c021_2_09 0 conv_bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_2_09 (conv_i_src_c021_2_09 conv_i_c021_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_09 (conv_q_src_c021_2_09 0 conv_bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_2_09 (conv_q_src_c021_2_09 conv_q_c021_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_10 (conv_i_src_c021_2_10 0 conv_bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_2_10 (conv_i_src_c021_2_10 conv_i_c021_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_10 (conv_q_src_c021_2_10 0 conv_bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_2_10 (conv_q_src_c021_2_10 conv_q_c021_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_11 (conv_i_src_c021_2_11 0 conv_bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_2_11 (conv_i_src_c021_2_11 conv_i_c021_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_11 (conv_q_src_c021_2_11 0 conv_bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_2_11 (conv_q_src_c021_2_11 conv_q_c021_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_12 (conv_i_src_c021_2_12 0 conv_bpf_c021_2 0) vcvs gain=1.950903220161e-01
SCONVI_c021_2_12 (conv_i_src_c021_2_12 conv_i_c021_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_12 (conv_q_src_c021_2_12 0 conv_bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_2_12 (conv_q_src_c021_2_12 conv_q_c021_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_13 (conv_i_src_c021_2_13 0 conv_bpf_c021_2 0) vcvs gain=5.555702330196e-01
SCONVI_c021_2_13 (conv_i_src_c021_2_13 conv_i_c021_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_13 (conv_q_src_c021_2_13 0 conv_bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_2_13 (conv_q_src_c021_2_13 conv_q_c021_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_14 (conv_i_src_c021_2_14 0 conv_bpf_c021_2 0) vcvs gain=8.314696123025e-01
SCONVI_c021_2_14 (conv_i_src_c021_2_14 conv_i_c021_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_14 (conv_q_src_c021_2_14 0 conv_bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_2_14 (conv_q_src_c021_2_14 conv_q_c021_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_2_15 (conv_i_src_c021_2_15 0 conv_bpf_c021_2 0) vcvs gain=9.807852804032e-01
SCONVI_c021_2_15 (conv_i_src_c021_2_15 conv_i_c021_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_2_15 (conv_q_src_c021_2_15 0 conv_bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_2_15 (conv_q_src_c021_2_15 conv_q_c021_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c021_2 (conv_i_c021_2 0) resistor r=1G
RCONVQ_c021_2 (conv_q_c021_2 0) resistor r=1G
RCONVINTI_c021_2 (conv_i_c021_2 ConvIcar_c021_2) resistor r=1k
CCONVINTI_c021_2 (ConvIcar_c021_2 0) capacitor c=80p
RCONVINTQ_c021_2 (conv_q_c021_2 ConvQcar_c021_2) resistor r=1k
CCONVINTQ_c021_2 (ConvQcar_c021_2 0) capacitor c=80p
save conv_bpf_c021_2 ConvIcar_c021_2 ConvQcar_c021_2

// conventional mixed baseline bl021, carrier_3: 1000000000 Hz
CCONVBPF_c021_3 (bl021 n_conv_cbpf_c021_3) capacitor c=2.533029591058e-14
LCONVBPF_c021_3 (n_conv_cbpf_c021_3 conv_bpf_c021_3) inductor l=1.000000000000e-06
RCONVBPF_c021_3 (conv_bpf_c021_3 0) resistor r=3.141592653590e+02
ECONVI_c021_3_00 (conv_i_src_c021_3_00 0 conv_bpf_c021_3 0) vcvs gain=9.807852804032e-01
SCONVI_c021_3_00 (conv_i_src_c021_3_00 conv_i_c021_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_00 (conv_q_src_c021_3_00 0 conv_bpf_c021_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_3_00 (conv_q_src_c021_3_00 conv_q_c021_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_01 (conv_i_src_c021_3_01 0 conv_bpf_c021_3 0) vcvs gain=8.314696123025e-01
SCONVI_c021_3_01 (conv_i_src_c021_3_01 conv_i_c021_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_01 (conv_q_src_c021_3_01 0 conv_bpf_c021_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_3_01 (conv_q_src_c021_3_01 conv_q_c021_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_02 (conv_i_src_c021_3_02 0 conv_bpf_c021_3 0) vcvs gain=5.555702330196e-01
SCONVI_c021_3_02 (conv_i_src_c021_3_02 conv_i_c021_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_02 (conv_q_src_c021_3_02 0 conv_bpf_c021_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_3_02 (conv_q_src_c021_3_02 conv_q_c021_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_03 (conv_i_src_c021_3_03 0 conv_bpf_c021_3 0) vcvs gain=1.950903220161e-01
SCONVI_c021_3_03 (conv_i_src_c021_3_03 conv_i_c021_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_03 (conv_q_src_c021_3_03 0 conv_bpf_c021_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_3_03 (conv_q_src_c021_3_03 conv_q_c021_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_04 (conv_i_src_c021_3_04 0 conv_bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_3_04 (conv_i_src_c021_3_04 conv_i_c021_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_04 (conv_q_src_c021_3_04 0 conv_bpf_c021_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c021_3_04 (conv_q_src_c021_3_04 conv_q_c021_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_05 (conv_i_src_c021_3_05 0 conv_bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_3_05 (conv_i_src_c021_3_05 conv_i_c021_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_05 (conv_q_src_c021_3_05 0 conv_bpf_c021_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c021_3_05 (conv_q_src_c021_3_05 conv_q_c021_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_06 (conv_i_src_c021_3_06 0 conv_bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_3_06 (conv_i_src_c021_3_06 conv_i_c021_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_06 (conv_q_src_c021_3_06 0 conv_bpf_c021_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c021_3_06 (conv_q_src_c021_3_06 conv_q_c021_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_07 (conv_i_src_c021_3_07 0 conv_bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_3_07 (conv_i_src_c021_3_07 conv_i_c021_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_07 (conv_q_src_c021_3_07 0 conv_bpf_c021_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c021_3_07 (conv_q_src_c021_3_07 conv_q_c021_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_08 (conv_i_src_c021_3_08 0 conv_bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c021_3_08 (conv_i_src_c021_3_08 conv_i_c021_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_08 (conv_q_src_c021_3_08 0 conv_bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_3_08 (conv_q_src_c021_3_08 conv_q_c021_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_09 (conv_i_src_c021_3_09 0 conv_bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c021_3_09 (conv_i_src_c021_3_09 conv_i_c021_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_09 (conv_q_src_c021_3_09 0 conv_bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_3_09 (conv_q_src_c021_3_09 conv_q_c021_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_10 (conv_i_src_c021_3_10 0 conv_bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c021_3_10 (conv_i_src_c021_3_10 conv_i_c021_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_10 (conv_q_src_c021_3_10 0 conv_bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_3_10 (conv_q_src_c021_3_10 conv_q_c021_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_11 (conv_i_src_c021_3_11 0 conv_bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c021_3_11 (conv_i_src_c021_3_11 conv_i_c021_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_11 (conv_q_src_c021_3_11 0 conv_bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_3_11 (conv_q_src_c021_3_11 conv_q_c021_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_12 (conv_i_src_c021_3_12 0 conv_bpf_c021_3 0) vcvs gain=1.950903220161e-01
SCONVI_c021_3_12 (conv_i_src_c021_3_12 conv_i_c021_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_12 (conv_q_src_c021_3_12 0 conv_bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c021_3_12 (conv_q_src_c021_3_12 conv_q_c021_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_13 (conv_i_src_c021_3_13 0 conv_bpf_c021_3 0) vcvs gain=5.555702330196e-01
SCONVI_c021_3_13 (conv_i_src_c021_3_13 conv_i_c021_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_13 (conv_q_src_c021_3_13 0 conv_bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c021_3_13 (conv_q_src_c021_3_13 conv_q_c021_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_14 (conv_i_src_c021_3_14 0 conv_bpf_c021_3 0) vcvs gain=8.314696123025e-01
SCONVI_c021_3_14 (conv_i_src_c021_3_14 conv_i_c021_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_14 (conv_q_src_c021_3_14 0 conv_bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c021_3_14 (conv_q_src_c021_3_14 conv_q_c021_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c021_3_15 (conv_i_src_c021_3_15 0 conv_bpf_c021_3 0) vcvs gain=9.807852804032e-01
SCONVI_c021_3_15 (conv_i_src_c021_3_15 conv_i_c021_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c021_3_15 (conv_q_src_c021_3_15 0 conv_bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c021_3_15 (conv_q_src_c021_3_15 conv_q_c021_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c021_3 (conv_i_c021_3 0) resistor r=1G
RCONVQ_c021_3 (conv_q_c021_3 0) resistor r=1G
RCONVINTI_c021_3 (conv_i_c021_3 ConvIcar_c021_3) resistor r=1k
CCONVINTI_c021_3 (ConvIcar_c021_3 0) capacitor c=80p
RCONVINTQ_c021_3 (conv_q_c021_3 ConvQcar_c021_3) resistor r=1k
CCONVINTQ_c021_3 (ConvQcar_c021_3 0) capacitor c=80p
save conv_bpf_c021_3 ConvIcar_c021_3 ConvQcar_c021_3

// conventional mixed baseline bl022, carrier_0: 250000000 Hz
CCONVBPF_c022_0 (bl022 n_conv_cbpf_c022_0) capacitor c=4.052847345694e-13
LCONVBPF_c022_0 (n_conv_cbpf_c022_0 conv_bpf_c022_0) inductor l=1.000000000000e-06
RCONVBPF_c022_0 (conv_bpf_c022_0 0) resistor r=7.853981633974e+01
ECONVI_c022_0_00 (conv_i_src_c022_0_00 0 conv_bpf_c022_0 0) vcvs gain=9.807852804032e-01
SCONVI_c022_0_00 (conv_i_src_c022_0_00 conv_i_c022_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_00 (conv_q_src_c022_0_00 0 conv_bpf_c022_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_0_00 (conv_q_src_c022_0_00 conv_q_c022_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_01 (conv_i_src_c022_0_01 0 conv_bpf_c022_0 0) vcvs gain=8.314696123025e-01
SCONVI_c022_0_01 (conv_i_src_c022_0_01 conv_i_c022_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_01 (conv_q_src_c022_0_01 0 conv_bpf_c022_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_0_01 (conv_q_src_c022_0_01 conv_q_c022_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_02 (conv_i_src_c022_0_02 0 conv_bpf_c022_0 0) vcvs gain=5.555702330196e-01
SCONVI_c022_0_02 (conv_i_src_c022_0_02 conv_i_c022_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_02 (conv_q_src_c022_0_02 0 conv_bpf_c022_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_0_02 (conv_q_src_c022_0_02 conv_q_c022_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_03 (conv_i_src_c022_0_03 0 conv_bpf_c022_0 0) vcvs gain=1.950903220161e-01
SCONVI_c022_0_03 (conv_i_src_c022_0_03 conv_i_c022_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_03 (conv_q_src_c022_0_03 0 conv_bpf_c022_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_0_03 (conv_q_src_c022_0_03 conv_q_c022_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_04 (conv_i_src_c022_0_04 0 conv_bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_0_04 (conv_i_src_c022_0_04 conv_i_c022_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_04 (conv_q_src_c022_0_04 0 conv_bpf_c022_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_0_04 (conv_q_src_c022_0_04 conv_q_c022_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_05 (conv_i_src_c022_0_05 0 conv_bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_0_05 (conv_i_src_c022_0_05 conv_i_c022_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_05 (conv_q_src_c022_0_05 0 conv_bpf_c022_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_0_05 (conv_q_src_c022_0_05 conv_q_c022_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_06 (conv_i_src_c022_0_06 0 conv_bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_0_06 (conv_i_src_c022_0_06 conv_i_c022_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_06 (conv_q_src_c022_0_06 0 conv_bpf_c022_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_0_06 (conv_q_src_c022_0_06 conv_q_c022_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_07 (conv_i_src_c022_0_07 0 conv_bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_0_07 (conv_i_src_c022_0_07 conv_i_c022_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_07 (conv_q_src_c022_0_07 0 conv_bpf_c022_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_0_07 (conv_q_src_c022_0_07 conv_q_c022_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_08 (conv_i_src_c022_0_08 0 conv_bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_0_08 (conv_i_src_c022_0_08 conv_i_c022_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_08 (conv_q_src_c022_0_08 0 conv_bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_0_08 (conv_q_src_c022_0_08 conv_q_c022_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_09 (conv_i_src_c022_0_09 0 conv_bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_0_09 (conv_i_src_c022_0_09 conv_i_c022_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_09 (conv_q_src_c022_0_09 0 conv_bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_0_09 (conv_q_src_c022_0_09 conv_q_c022_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_10 (conv_i_src_c022_0_10 0 conv_bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_0_10 (conv_i_src_c022_0_10 conv_i_c022_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_10 (conv_q_src_c022_0_10 0 conv_bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_0_10 (conv_q_src_c022_0_10 conv_q_c022_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_11 (conv_i_src_c022_0_11 0 conv_bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_0_11 (conv_i_src_c022_0_11 conv_i_c022_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_11 (conv_q_src_c022_0_11 0 conv_bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_0_11 (conv_q_src_c022_0_11 conv_q_c022_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_12 (conv_i_src_c022_0_12 0 conv_bpf_c022_0 0) vcvs gain=1.950903220161e-01
SCONVI_c022_0_12 (conv_i_src_c022_0_12 conv_i_c022_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_12 (conv_q_src_c022_0_12 0 conv_bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_0_12 (conv_q_src_c022_0_12 conv_q_c022_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_13 (conv_i_src_c022_0_13 0 conv_bpf_c022_0 0) vcvs gain=5.555702330196e-01
SCONVI_c022_0_13 (conv_i_src_c022_0_13 conv_i_c022_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_13 (conv_q_src_c022_0_13 0 conv_bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_0_13 (conv_q_src_c022_0_13 conv_q_c022_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_14 (conv_i_src_c022_0_14 0 conv_bpf_c022_0 0) vcvs gain=8.314696123025e-01
SCONVI_c022_0_14 (conv_i_src_c022_0_14 conv_i_c022_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_14 (conv_q_src_c022_0_14 0 conv_bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_0_14 (conv_q_src_c022_0_14 conv_q_c022_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_0_15 (conv_i_src_c022_0_15 0 conv_bpf_c022_0 0) vcvs gain=9.807852804032e-01
SCONVI_c022_0_15 (conv_i_src_c022_0_15 conv_i_c022_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_0_15 (conv_q_src_c022_0_15 0 conv_bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_0_15 (conv_q_src_c022_0_15 conv_q_c022_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c022_0 (conv_i_c022_0 0) resistor r=1G
RCONVQ_c022_0 (conv_q_c022_0 0) resistor r=1G
RCONVINTI_c022_0 (conv_i_c022_0 ConvIcar_c022_0) resistor r=1k
CCONVINTI_c022_0 (ConvIcar_c022_0 0) capacitor c=80p
RCONVINTQ_c022_0 (conv_q_c022_0 ConvQcar_c022_0) resistor r=1k
CCONVINTQ_c022_0 (ConvQcar_c022_0 0) capacitor c=80p
save conv_bpf_c022_0 ConvIcar_c022_0 ConvQcar_c022_0

// conventional mixed baseline bl022, carrier_1: 500000000 Hz
CCONVBPF_c022_1 (bl022 n_conv_cbpf_c022_1) capacitor c=1.013211836423e-13
LCONVBPF_c022_1 (n_conv_cbpf_c022_1 conv_bpf_c022_1) inductor l=1.000000000000e-06
RCONVBPF_c022_1 (conv_bpf_c022_1 0) resistor r=1.570796326795e+02
ECONVI_c022_1_00 (conv_i_src_c022_1_00 0 conv_bpf_c022_1 0) vcvs gain=9.807852804032e-01
SCONVI_c022_1_00 (conv_i_src_c022_1_00 conv_i_c022_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_00 (conv_q_src_c022_1_00 0 conv_bpf_c022_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_1_00 (conv_q_src_c022_1_00 conv_q_c022_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_01 (conv_i_src_c022_1_01 0 conv_bpf_c022_1 0) vcvs gain=8.314696123025e-01
SCONVI_c022_1_01 (conv_i_src_c022_1_01 conv_i_c022_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_01 (conv_q_src_c022_1_01 0 conv_bpf_c022_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_1_01 (conv_q_src_c022_1_01 conv_q_c022_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_02 (conv_i_src_c022_1_02 0 conv_bpf_c022_1 0) vcvs gain=5.555702330196e-01
SCONVI_c022_1_02 (conv_i_src_c022_1_02 conv_i_c022_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_02 (conv_q_src_c022_1_02 0 conv_bpf_c022_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_1_02 (conv_q_src_c022_1_02 conv_q_c022_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_03 (conv_i_src_c022_1_03 0 conv_bpf_c022_1 0) vcvs gain=1.950903220161e-01
SCONVI_c022_1_03 (conv_i_src_c022_1_03 conv_i_c022_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_03 (conv_q_src_c022_1_03 0 conv_bpf_c022_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_1_03 (conv_q_src_c022_1_03 conv_q_c022_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_04 (conv_i_src_c022_1_04 0 conv_bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_1_04 (conv_i_src_c022_1_04 conv_i_c022_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_04 (conv_q_src_c022_1_04 0 conv_bpf_c022_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_1_04 (conv_q_src_c022_1_04 conv_q_c022_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_05 (conv_i_src_c022_1_05 0 conv_bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_1_05 (conv_i_src_c022_1_05 conv_i_c022_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_05 (conv_q_src_c022_1_05 0 conv_bpf_c022_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_1_05 (conv_q_src_c022_1_05 conv_q_c022_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_06 (conv_i_src_c022_1_06 0 conv_bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_1_06 (conv_i_src_c022_1_06 conv_i_c022_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_06 (conv_q_src_c022_1_06 0 conv_bpf_c022_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_1_06 (conv_q_src_c022_1_06 conv_q_c022_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_07 (conv_i_src_c022_1_07 0 conv_bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_1_07 (conv_i_src_c022_1_07 conv_i_c022_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_07 (conv_q_src_c022_1_07 0 conv_bpf_c022_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_1_07 (conv_q_src_c022_1_07 conv_q_c022_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_08 (conv_i_src_c022_1_08 0 conv_bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_1_08 (conv_i_src_c022_1_08 conv_i_c022_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_08 (conv_q_src_c022_1_08 0 conv_bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_1_08 (conv_q_src_c022_1_08 conv_q_c022_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_09 (conv_i_src_c022_1_09 0 conv_bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_1_09 (conv_i_src_c022_1_09 conv_i_c022_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_09 (conv_q_src_c022_1_09 0 conv_bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_1_09 (conv_q_src_c022_1_09 conv_q_c022_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_10 (conv_i_src_c022_1_10 0 conv_bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_1_10 (conv_i_src_c022_1_10 conv_i_c022_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_10 (conv_q_src_c022_1_10 0 conv_bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_1_10 (conv_q_src_c022_1_10 conv_q_c022_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_11 (conv_i_src_c022_1_11 0 conv_bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_1_11 (conv_i_src_c022_1_11 conv_i_c022_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_11 (conv_q_src_c022_1_11 0 conv_bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_1_11 (conv_q_src_c022_1_11 conv_q_c022_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_12 (conv_i_src_c022_1_12 0 conv_bpf_c022_1 0) vcvs gain=1.950903220161e-01
SCONVI_c022_1_12 (conv_i_src_c022_1_12 conv_i_c022_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_12 (conv_q_src_c022_1_12 0 conv_bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_1_12 (conv_q_src_c022_1_12 conv_q_c022_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_13 (conv_i_src_c022_1_13 0 conv_bpf_c022_1 0) vcvs gain=5.555702330196e-01
SCONVI_c022_1_13 (conv_i_src_c022_1_13 conv_i_c022_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_13 (conv_q_src_c022_1_13 0 conv_bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_1_13 (conv_q_src_c022_1_13 conv_q_c022_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_14 (conv_i_src_c022_1_14 0 conv_bpf_c022_1 0) vcvs gain=8.314696123025e-01
SCONVI_c022_1_14 (conv_i_src_c022_1_14 conv_i_c022_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_14 (conv_q_src_c022_1_14 0 conv_bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_1_14 (conv_q_src_c022_1_14 conv_q_c022_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_1_15 (conv_i_src_c022_1_15 0 conv_bpf_c022_1 0) vcvs gain=9.807852804032e-01
SCONVI_c022_1_15 (conv_i_src_c022_1_15 conv_i_c022_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_1_15 (conv_q_src_c022_1_15 0 conv_bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_1_15 (conv_q_src_c022_1_15 conv_q_c022_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c022_1 (conv_i_c022_1 0) resistor r=1G
RCONVQ_c022_1 (conv_q_c022_1 0) resistor r=1G
RCONVINTI_c022_1 (conv_i_c022_1 ConvIcar_c022_1) resistor r=1k
CCONVINTI_c022_1 (ConvIcar_c022_1 0) capacitor c=80p
RCONVINTQ_c022_1 (conv_q_c022_1 ConvQcar_c022_1) resistor r=1k
CCONVINTQ_c022_1 (ConvQcar_c022_1 0) capacitor c=80p
save conv_bpf_c022_1 ConvIcar_c022_1 ConvQcar_c022_1

// conventional mixed baseline bl022, carrier_2: 750000000 Hz
CCONVBPF_c022_2 (bl022 n_conv_cbpf_c022_2) capacitor c=4.503163717437e-14
LCONVBPF_c022_2 (n_conv_cbpf_c022_2 conv_bpf_c022_2) inductor l=1.000000000000e-06
RCONVBPF_c022_2 (conv_bpf_c022_2 0) resistor r=2.356194490192e+02
ECONVI_c022_2_00 (conv_i_src_c022_2_00 0 conv_bpf_c022_2 0) vcvs gain=9.807852804032e-01
SCONVI_c022_2_00 (conv_i_src_c022_2_00 conv_i_c022_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_00 (conv_q_src_c022_2_00 0 conv_bpf_c022_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_2_00 (conv_q_src_c022_2_00 conv_q_c022_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_01 (conv_i_src_c022_2_01 0 conv_bpf_c022_2 0) vcvs gain=8.314696123025e-01
SCONVI_c022_2_01 (conv_i_src_c022_2_01 conv_i_c022_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_01 (conv_q_src_c022_2_01 0 conv_bpf_c022_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_2_01 (conv_q_src_c022_2_01 conv_q_c022_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_02 (conv_i_src_c022_2_02 0 conv_bpf_c022_2 0) vcvs gain=5.555702330196e-01
SCONVI_c022_2_02 (conv_i_src_c022_2_02 conv_i_c022_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_02 (conv_q_src_c022_2_02 0 conv_bpf_c022_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_2_02 (conv_q_src_c022_2_02 conv_q_c022_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_03 (conv_i_src_c022_2_03 0 conv_bpf_c022_2 0) vcvs gain=1.950903220161e-01
SCONVI_c022_2_03 (conv_i_src_c022_2_03 conv_i_c022_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_03 (conv_q_src_c022_2_03 0 conv_bpf_c022_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_2_03 (conv_q_src_c022_2_03 conv_q_c022_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_04 (conv_i_src_c022_2_04 0 conv_bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_2_04 (conv_i_src_c022_2_04 conv_i_c022_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_04 (conv_q_src_c022_2_04 0 conv_bpf_c022_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_2_04 (conv_q_src_c022_2_04 conv_q_c022_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_05 (conv_i_src_c022_2_05 0 conv_bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_2_05 (conv_i_src_c022_2_05 conv_i_c022_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_05 (conv_q_src_c022_2_05 0 conv_bpf_c022_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_2_05 (conv_q_src_c022_2_05 conv_q_c022_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_06 (conv_i_src_c022_2_06 0 conv_bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_2_06 (conv_i_src_c022_2_06 conv_i_c022_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_06 (conv_q_src_c022_2_06 0 conv_bpf_c022_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_2_06 (conv_q_src_c022_2_06 conv_q_c022_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_07 (conv_i_src_c022_2_07 0 conv_bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_2_07 (conv_i_src_c022_2_07 conv_i_c022_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_07 (conv_q_src_c022_2_07 0 conv_bpf_c022_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_2_07 (conv_q_src_c022_2_07 conv_q_c022_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_08 (conv_i_src_c022_2_08 0 conv_bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_2_08 (conv_i_src_c022_2_08 conv_i_c022_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_08 (conv_q_src_c022_2_08 0 conv_bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_2_08 (conv_q_src_c022_2_08 conv_q_c022_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_09 (conv_i_src_c022_2_09 0 conv_bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_2_09 (conv_i_src_c022_2_09 conv_i_c022_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_09 (conv_q_src_c022_2_09 0 conv_bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_2_09 (conv_q_src_c022_2_09 conv_q_c022_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_10 (conv_i_src_c022_2_10 0 conv_bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_2_10 (conv_i_src_c022_2_10 conv_i_c022_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_10 (conv_q_src_c022_2_10 0 conv_bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_2_10 (conv_q_src_c022_2_10 conv_q_c022_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_11 (conv_i_src_c022_2_11 0 conv_bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_2_11 (conv_i_src_c022_2_11 conv_i_c022_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_11 (conv_q_src_c022_2_11 0 conv_bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_2_11 (conv_q_src_c022_2_11 conv_q_c022_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_12 (conv_i_src_c022_2_12 0 conv_bpf_c022_2 0) vcvs gain=1.950903220161e-01
SCONVI_c022_2_12 (conv_i_src_c022_2_12 conv_i_c022_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_12 (conv_q_src_c022_2_12 0 conv_bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_2_12 (conv_q_src_c022_2_12 conv_q_c022_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_13 (conv_i_src_c022_2_13 0 conv_bpf_c022_2 0) vcvs gain=5.555702330196e-01
SCONVI_c022_2_13 (conv_i_src_c022_2_13 conv_i_c022_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_13 (conv_q_src_c022_2_13 0 conv_bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_2_13 (conv_q_src_c022_2_13 conv_q_c022_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_14 (conv_i_src_c022_2_14 0 conv_bpf_c022_2 0) vcvs gain=8.314696123025e-01
SCONVI_c022_2_14 (conv_i_src_c022_2_14 conv_i_c022_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_14 (conv_q_src_c022_2_14 0 conv_bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_2_14 (conv_q_src_c022_2_14 conv_q_c022_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_2_15 (conv_i_src_c022_2_15 0 conv_bpf_c022_2 0) vcvs gain=9.807852804032e-01
SCONVI_c022_2_15 (conv_i_src_c022_2_15 conv_i_c022_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_2_15 (conv_q_src_c022_2_15 0 conv_bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_2_15 (conv_q_src_c022_2_15 conv_q_c022_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c022_2 (conv_i_c022_2 0) resistor r=1G
RCONVQ_c022_2 (conv_q_c022_2 0) resistor r=1G
RCONVINTI_c022_2 (conv_i_c022_2 ConvIcar_c022_2) resistor r=1k
CCONVINTI_c022_2 (ConvIcar_c022_2 0) capacitor c=80p
RCONVINTQ_c022_2 (conv_q_c022_2 ConvQcar_c022_2) resistor r=1k
CCONVINTQ_c022_2 (ConvQcar_c022_2 0) capacitor c=80p
save conv_bpf_c022_2 ConvIcar_c022_2 ConvQcar_c022_2

// conventional mixed baseline bl022, carrier_3: 1000000000 Hz
CCONVBPF_c022_3 (bl022 n_conv_cbpf_c022_3) capacitor c=2.533029591058e-14
LCONVBPF_c022_3 (n_conv_cbpf_c022_3 conv_bpf_c022_3) inductor l=1.000000000000e-06
RCONVBPF_c022_3 (conv_bpf_c022_3 0) resistor r=3.141592653590e+02
ECONVI_c022_3_00 (conv_i_src_c022_3_00 0 conv_bpf_c022_3 0) vcvs gain=9.807852804032e-01
SCONVI_c022_3_00 (conv_i_src_c022_3_00 conv_i_c022_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_00 (conv_q_src_c022_3_00 0 conv_bpf_c022_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_3_00 (conv_q_src_c022_3_00 conv_q_c022_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_01 (conv_i_src_c022_3_01 0 conv_bpf_c022_3 0) vcvs gain=8.314696123025e-01
SCONVI_c022_3_01 (conv_i_src_c022_3_01 conv_i_c022_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_01 (conv_q_src_c022_3_01 0 conv_bpf_c022_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_3_01 (conv_q_src_c022_3_01 conv_q_c022_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_02 (conv_i_src_c022_3_02 0 conv_bpf_c022_3 0) vcvs gain=5.555702330196e-01
SCONVI_c022_3_02 (conv_i_src_c022_3_02 conv_i_c022_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_02 (conv_q_src_c022_3_02 0 conv_bpf_c022_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_3_02 (conv_q_src_c022_3_02 conv_q_c022_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_03 (conv_i_src_c022_3_03 0 conv_bpf_c022_3 0) vcvs gain=1.950903220161e-01
SCONVI_c022_3_03 (conv_i_src_c022_3_03 conv_i_c022_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_03 (conv_q_src_c022_3_03 0 conv_bpf_c022_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_3_03 (conv_q_src_c022_3_03 conv_q_c022_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_04 (conv_i_src_c022_3_04 0 conv_bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_3_04 (conv_i_src_c022_3_04 conv_i_c022_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_04 (conv_q_src_c022_3_04 0 conv_bpf_c022_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c022_3_04 (conv_q_src_c022_3_04 conv_q_c022_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_05 (conv_i_src_c022_3_05 0 conv_bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_3_05 (conv_i_src_c022_3_05 conv_i_c022_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_05 (conv_q_src_c022_3_05 0 conv_bpf_c022_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c022_3_05 (conv_q_src_c022_3_05 conv_q_c022_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_06 (conv_i_src_c022_3_06 0 conv_bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_3_06 (conv_i_src_c022_3_06 conv_i_c022_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_06 (conv_q_src_c022_3_06 0 conv_bpf_c022_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c022_3_06 (conv_q_src_c022_3_06 conv_q_c022_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_07 (conv_i_src_c022_3_07 0 conv_bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_3_07 (conv_i_src_c022_3_07 conv_i_c022_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_07 (conv_q_src_c022_3_07 0 conv_bpf_c022_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c022_3_07 (conv_q_src_c022_3_07 conv_q_c022_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_08 (conv_i_src_c022_3_08 0 conv_bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c022_3_08 (conv_i_src_c022_3_08 conv_i_c022_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_08 (conv_q_src_c022_3_08 0 conv_bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_3_08 (conv_q_src_c022_3_08 conv_q_c022_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_09 (conv_i_src_c022_3_09 0 conv_bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c022_3_09 (conv_i_src_c022_3_09 conv_i_c022_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_09 (conv_q_src_c022_3_09 0 conv_bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_3_09 (conv_q_src_c022_3_09 conv_q_c022_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_10 (conv_i_src_c022_3_10 0 conv_bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c022_3_10 (conv_i_src_c022_3_10 conv_i_c022_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_10 (conv_q_src_c022_3_10 0 conv_bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_3_10 (conv_q_src_c022_3_10 conv_q_c022_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_11 (conv_i_src_c022_3_11 0 conv_bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c022_3_11 (conv_i_src_c022_3_11 conv_i_c022_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_11 (conv_q_src_c022_3_11 0 conv_bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_3_11 (conv_q_src_c022_3_11 conv_q_c022_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_12 (conv_i_src_c022_3_12 0 conv_bpf_c022_3 0) vcvs gain=1.950903220161e-01
SCONVI_c022_3_12 (conv_i_src_c022_3_12 conv_i_c022_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_12 (conv_q_src_c022_3_12 0 conv_bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c022_3_12 (conv_q_src_c022_3_12 conv_q_c022_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_13 (conv_i_src_c022_3_13 0 conv_bpf_c022_3 0) vcvs gain=5.555702330196e-01
SCONVI_c022_3_13 (conv_i_src_c022_3_13 conv_i_c022_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_13 (conv_q_src_c022_3_13 0 conv_bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c022_3_13 (conv_q_src_c022_3_13 conv_q_c022_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_14 (conv_i_src_c022_3_14 0 conv_bpf_c022_3 0) vcvs gain=8.314696123025e-01
SCONVI_c022_3_14 (conv_i_src_c022_3_14 conv_i_c022_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_14 (conv_q_src_c022_3_14 0 conv_bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c022_3_14 (conv_q_src_c022_3_14 conv_q_c022_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c022_3_15 (conv_i_src_c022_3_15 0 conv_bpf_c022_3 0) vcvs gain=9.807852804032e-01
SCONVI_c022_3_15 (conv_i_src_c022_3_15 conv_i_c022_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c022_3_15 (conv_q_src_c022_3_15 0 conv_bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c022_3_15 (conv_q_src_c022_3_15 conv_q_c022_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c022_3 (conv_i_c022_3 0) resistor r=1G
RCONVQ_c022_3 (conv_q_c022_3 0) resistor r=1G
RCONVINTI_c022_3 (conv_i_c022_3 ConvIcar_c022_3) resistor r=1k
CCONVINTI_c022_3 (ConvIcar_c022_3 0) capacitor c=80p
RCONVINTQ_c022_3 (conv_q_c022_3 ConvQcar_c022_3) resistor r=1k
CCONVINTQ_c022_3 (ConvQcar_c022_3 0) capacitor c=80p
save conv_bpf_c022_3 ConvIcar_c022_3 ConvQcar_c022_3

// conventional mixed baseline bl023, carrier_0: 250000000 Hz
CCONVBPF_c023_0 (bl023 n_conv_cbpf_c023_0) capacitor c=4.052847345694e-13
LCONVBPF_c023_0 (n_conv_cbpf_c023_0 conv_bpf_c023_0) inductor l=1.000000000000e-06
RCONVBPF_c023_0 (conv_bpf_c023_0 0) resistor r=7.853981633974e+01
ECONVI_c023_0_00 (conv_i_src_c023_0_00 0 conv_bpf_c023_0 0) vcvs gain=9.807852804032e-01
SCONVI_c023_0_00 (conv_i_src_c023_0_00 conv_i_c023_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_00 (conv_q_src_c023_0_00 0 conv_bpf_c023_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_0_00 (conv_q_src_c023_0_00 conv_q_c023_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_01 (conv_i_src_c023_0_01 0 conv_bpf_c023_0 0) vcvs gain=8.314696123025e-01
SCONVI_c023_0_01 (conv_i_src_c023_0_01 conv_i_c023_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_01 (conv_q_src_c023_0_01 0 conv_bpf_c023_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_0_01 (conv_q_src_c023_0_01 conv_q_c023_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_02 (conv_i_src_c023_0_02 0 conv_bpf_c023_0 0) vcvs gain=5.555702330196e-01
SCONVI_c023_0_02 (conv_i_src_c023_0_02 conv_i_c023_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_02 (conv_q_src_c023_0_02 0 conv_bpf_c023_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_0_02 (conv_q_src_c023_0_02 conv_q_c023_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_03 (conv_i_src_c023_0_03 0 conv_bpf_c023_0 0) vcvs gain=1.950903220161e-01
SCONVI_c023_0_03 (conv_i_src_c023_0_03 conv_i_c023_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_03 (conv_q_src_c023_0_03 0 conv_bpf_c023_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_0_03 (conv_q_src_c023_0_03 conv_q_c023_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_04 (conv_i_src_c023_0_04 0 conv_bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_0_04 (conv_i_src_c023_0_04 conv_i_c023_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_04 (conv_q_src_c023_0_04 0 conv_bpf_c023_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_0_04 (conv_q_src_c023_0_04 conv_q_c023_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_05 (conv_i_src_c023_0_05 0 conv_bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_0_05 (conv_i_src_c023_0_05 conv_i_c023_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_05 (conv_q_src_c023_0_05 0 conv_bpf_c023_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_0_05 (conv_q_src_c023_0_05 conv_q_c023_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_06 (conv_i_src_c023_0_06 0 conv_bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_0_06 (conv_i_src_c023_0_06 conv_i_c023_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_06 (conv_q_src_c023_0_06 0 conv_bpf_c023_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_0_06 (conv_q_src_c023_0_06 conv_q_c023_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_07 (conv_i_src_c023_0_07 0 conv_bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_0_07 (conv_i_src_c023_0_07 conv_i_c023_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_07 (conv_q_src_c023_0_07 0 conv_bpf_c023_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_0_07 (conv_q_src_c023_0_07 conv_q_c023_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_08 (conv_i_src_c023_0_08 0 conv_bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_0_08 (conv_i_src_c023_0_08 conv_i_c023_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_08 (conv_q_src_c023_0_08 0 conv_bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_0_08 (conv_q_src_c023_0_08 conv_q_c023_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_09 (conv_i_src_c023_0_09 0 conv_bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_0_09 (conv_i_src_c023_0_09 conv_i_c023_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_09 (conv_q_src_c023_0_09 0 conv_bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_0_09 (conv_q_src_c023_0_09 conv_q_c023_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_10 (conv_i_src_c023_0_10 0 conv_bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_0_10 (conv_i_src_c023_0_10 conv_i_c023_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_10 (conv_q_src_c023_0_10 0 conv_bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_0_10 (conv_q_src_c023_0_10 conv_q_c023_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_11 (conv_i_src_c023_0_11 0 conv_bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_0_11 (conv_i_src_c023_0_11 conv_i_c023_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_11 (conv_q_src_c023_0_11 0 conv_bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_0_11 (conv_q_src_c023_0_11 conv_q_c023_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_12 (conv_i_src_c023_0_12 0 conv_bpf_c023_0 0) vcvs gain=1.950903220161e-01
SCONVI_c023_0_12 (conv_i_src_c023_0_12 conv_i_c023_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_12 (conv_q_src_c023_0_12 0 conv_bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_0_12 (conv_q_src_c023_0_12 conv_q_c023_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_13 (conv_i_src_c023_0_13 0 conv_bpf_c023_0 0) vcvs gain=5.555702330196e-01
SCONVI_c023_0_13 (conv_i_src_c023_0_13 conv_i_c023_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_13 (conv_q_src_c023_0_13 0 conv_bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_0_13 (conv_q_src_c023_0_13 conv_q_c023_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_14 (conv_i_src_c023_0_14 0 conv_bpf_c023_0 0) vcvs gain=8.314696123025e-01
SCONVI_c023_0_14 (conv_i_src_c023_0_14 conv_i_c023_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_14 (conv_q_src_c023_0_14 0 conv_bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_0_14 (conv_q_src_c023_0_14 conv_q_c023_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_0_15 (conv_i_src_c023_0_15 0 conv_bpf_c023_0 0) vcvs gain=9.807852804032e-01
SCONVI_c023_0_15 (conv_i_src_c023_0_15 conv_i_c023_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_0_15 (conv_q_src_c023_0_15 0 conv_bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_0_15 (conv_q_src_c023_0_15 conv_q_c023_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c023_0 (conv_i_c023_0 0) resistor r=1G
RCONVQ_c023_0 (conv_q_c023_0 0) resistor r=1G
RCONVINTI_c023_0 (conv_i_c023_0 ConvIcar_c023_0) resistor r=1k
CCONVINTI_c023_0 (ConvIcar_c023_0 0) capacitor c=80p
RCONVINTQ_c023_0 (conv_q_c023_0 ConvQcar_c023_0) resistor r=1k
CCONVINTQ_c023_0 (ConvQcar_c023_0 0) capacitor c=80p
save conv_bpf_c023_0 ConvIcar_c023_0 ConvQcar_c023_0

// conventional mixed baseline bl023, carrier_1: 500000000 Hz
CCONVBPF_c023_1 (bl023 n_conv_cbpf_c023_1) capacitor c=1.013211836423e-13
LCONVBPF_c023_1 (n_conv_cbpf_c023_1 conv_bpf_c023_1) inductor l=1.000000000000e-06
RCONVBPF_c023_1 (conv_bpf_c023_1 0) resistor r=1.570796326795e+02
ECONVI_c023_1_00 (conv_i_src_c023_1_00 0 conv_bpf_c023_1 0) vcvs gain=9.807852804032e-01
SCONVI_c023_1_00 (conv_i_src_c023_1_00 conv_i_c023_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_00 (conv_q_src_c023_1_00 0 conv_bpf_c023_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_1_00 (conv_q_src_c023_1_00 conv_q_c023_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_01 (conv_i_src_c023_1_01 0 conv_bpf_c023_1 0) vcvs gain=8.314696123025e-01
SCONVI_c023_1_01 (conv_i_src_c023_1_01 conv_i_c023_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_01 (conv_q_src_c023_1_01 0 conv_bpf_c023_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_1_01 (conv_q_src_c023_1_01 conv_q_c023_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_02 (conv_i_src_c023_1_02 0 conv_bpf_c023_1 0) vcvs gain=5.555702330196e-01
SCONVI_c023_1_02 (conv_i_src_c023_1_02 conv_i_c023_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_02 (conv_q_src_c023_1_02 0 conv_bpf_c023_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_1_02 (conv_q_src_c023_1_02 conv_q_c023_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_03 (conv_i_src_c023_1_03 0 conv_bpf_c023_1 0) vcvs gain=1.950903220161e-01
SCONVI_c023_1_03 (conv_i_src_c023_1_03 conv_i_c023_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_03 (conv_q_src_c023_1_03 0 conv_bpf_c023_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_1_03 (conv_q_src_c023_1_03 conv_q_c023_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_04 (conv_i_src_c023_1_04 0 conv_bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_1_04 (conv_i_src_c023_1_04 conv_i_c023_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_04 (conv_q_src_c023_1_04 0 conv_bpf_c023_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_1_04 (conv_q_src_c023_1_04 conv_q_c023_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_05 (conv_i_src_c023_1_05 0 conv_bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_1_05 (conv_i_src_c023_1_05 conv_i_c023_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_05 (conv_q_src_c023_1_05 0 conv_bpf_c023_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_1_05 (conv_q_src_c023_1_05 conv_q_c023_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_06 (conv_i_src_c023_1_06 0 conv_bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_1_06 (conv_i_src_c023_1_06 conv_i_c023_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_06 (conv_q_src_c023_1_06 0 conv_bpf_c023_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_1_06 (conv_q_src_c023_1_06 conv_q_c023_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_07 (conv_i_src_c023_1_07 0 conv_bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_1_07 (conv_i_src_c023_1_07 conv_i_c023_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_07 (conv_q_src_c023_1_07 0 conv_bpf_c023_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_1_07 (conv_q_src_c023_1_07 conv_q_c023_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_08 (conv_i_src_c023_1_08 0 conv_bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_1_08 (conv_i_src_c023_1_08 conv_i_c023_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_08 (conv_q_src_c023_1_08 0 conv_bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_1_08 (conv_q_src_c023_1_08 conv_q_c023_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_09 (conv_i_src_c023_1_09 0 conv_bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_1_09 (conv_i_src_c023_1_09 conv_i_c023_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_09 (conv_q_src_c023_1_09 0 conv_bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_1_09 (conv_q_src_c023_1_09 conv_q_c023_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_10 (conv_i_src_c023_1_10 0 conv_bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_1_10 (conv_i_src_c023_1_10 conv_i_c023_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_10 (conv_q_src_c023_1_10 0 conv_bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_1_10 (conv_q_src_c023_1_10 conv_q_c023_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_11 (conv_i_src_c023_1_11 0 conv_bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_1_11 (conv_i_src_c023_1_11 conv_i_c023_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_11 (conv_q_src_c023_1_11 0 conv_bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_1_11 (conv_q_src_c023_1_11 conv_q_c023_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_12 (conv_i_src_c023_1_12 0 conv_bpf_c023_1 0) vcvs gain=1.950903220161e-01
SCONVI_c023_1_12 (conv_i_src_c023_1_12 conv_i_c023_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_12 (conv_q_src_c023_1_12 0 conv_bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_1_12 (conv_q_src_c023_1_12 conv_q_c023_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_13 (conv_i_src_c023_1_13 0 conv_bpf_c023_1 0) vcvs gain=5.555702330196e-01
SCONVI_c023_1_13 (conv_i_src_c023_1_13 conv_i_c023_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_13 (conv_q_src_c023_1_13 0 conv_bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_1_13 (conv_q_src_c023_1_13 conv_q_c023_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_14 (conv_i_src_c023_1_14 0 conv_bpf_c023_1 0) vcvs gain=8.314696123025e-01
SCONVI_c023_1_14 (conv_i_src_c023_1_14 conv_i_c023_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_14 (conv_q_src_c023_1_14 0 conv_bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_1_14 (conv_q_src_c023_1_14 conv_q_c023_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_1_15 (conv_i_src_c023_1_15 0 conv_bpf_c023_1 0) vcvs gain=9.807852804032e-01
SCONVI_c023_1_15 (conv_i_src_c023_1_15 conv_i_c023_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_1_15 (conv_q_src_c023_1_15 0 conv_bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_1_15 (conv_q_src_c023_1_15 conv_q_c023_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c023_1 (conv_i_c023_1 0) resistor r=1G
RCONVQ_c023_1 (conv_q_c023_1 0) resistor r=1G
RCONVINTI_c023_1 (conv_i_c023_1 ConvIcar_c023_1) resistor r=1k
CCONVINTI_c023_1 (ConvIcar_c023_1 0) capacitor c=80p
RCONVINTQ_c023_1 (conv_q_c023_1 ConvQcar_c023_1) resistor r=1k
CCONVINTQ_c023_1 (ConvQcar_c023_1 0) capacitor c=80p
save conv_bpf_c023_1 ConvIcar_c023_1 ConvQcar_c023_1

// conventional mixed baseline bl023, carrier_2: 750000000 Hz
CCONVBPF_c023_2 (bl023 n_conv_cbpf_c023_2) capacitor c=4.503163717437e-14
LCONVBPF_c023_2 (n_conv_cbpf_c023_2 conv_bpf_c023_2) inductor l=1.000000000000e-06
RCONVBPF_c023_2 (conv_bpf_c023_2 0) resistor r=2.356194490192e+02
ECONVI_c023_2_00 (conv_i_src_c023_2_00 0 conv_bpf_c023_2 0) vcvs gain=9.807852804032e-01
SCONVI_c023_2_00 (conv_i_src_c023_2_00 conv_i_c023_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_00 (conv_q_src_c023_2_00 0 conv_bpf_c023_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_2_00 (conv_q_src_c023_2_00 conv_q_c023_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_01 (conv_i_src_c023_2_01 0 conv_bpf_c023_2 0) vcvs gain=8.314696123025e-01
SCONVI_c023_2_01 (conv_i_src_c023_2_01 conv_i_c023_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_01 (conv_q_src_c023_2_01 0 conv_bpf_c023_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_2_01 (conv_q_src_c023_2_01 conv_q_c023_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_02 (conv_i_src_c023_2_02 0 conv_bpf_c023_2 0) vcvs gain=5.555702330196e-01
SCONVI_c023_2_02 (conv_i_src_c023_2_02 conv_i_c023_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_02 (conv_q_src_c023_2_02 0 conv_bpf_c023_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_2_02 (conv_q_src_c023_2_02 conv_q_c023_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_03 (conv_i_src_c023_2_03 0 conv_bpf_c023_2 0) vcvs gain=1.950903220161e-01
SCONVI_c023_2_03 (conv_i_src_c023_2_03 conv_i_c023_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_03 (conv_q_src_c023_2_03 0 conv_bpf_c023_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_2_03 (conv_q_src_c023_2_03 conv_q_c023_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_04 (conv_i_src_c023_2_04 0 conv_bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_2_04 (conv_i_src_c023_2_04 conv_i_c023_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_04 (conv_q_src_c023_2_04 0 conv_bpf_c023_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_2_04 (conv_q_src_c023_2_04 conv_q_c023_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_05 (conv_i_src_c023_2_05 0 conv_bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_2_05 (conv_i_src_c023_2_05 conv_i_c023_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_05 (conv_q_src_c023_2_05 0 conv_bpf_c023_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_2_05 (conv_q_src_c023_2_05 conv_q_c023_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_06 (conv_i_src_c023_2_06 0 conv_bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_2_06 (conv_i_src_c023_2_06 conv_i_c023_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_06 (conv_q_src_c023_2_06 0 conv_bpf_c023_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_2_06 (conv_q_src_c023_2_06 conv_q_c023_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_07 (conv_i_src_c023_2_07 0 conv_bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_2_07 (conv_i_src_c023_2_07 conv_i_c023_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_07 (conv_q_src_c023_2_07 0 conv_bpf_c023_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_2_07 (conv_q_src_c023_2_07 conv_q_c023_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_08 (conv_i_src_c023_2_08 0 conv_bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_2_08 (conv_i_src_c023_2_08 conv_i_c023_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_08 (conv_q_src_c023_2_08 0 conv_bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_2_08 (conv_q_src_c023_2_08 conv_q_c023_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_09 (conv_i_src_c023_2_09 0 conv_bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_2_09 (conv_i_src_c023_2_09 conv_i_c023_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_09 (conv_q_src_c023_2_09 0 conv_bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_2_09 (conv_q_src_c023_2_09 conv_q_c023_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_10 (conv_i_src_c023_2_10 0 conv_bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_2_10 (conv_i_src_c023_2_10 conv_i_c023_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_10 (conv_q_src_c023_2_10 0 conv_bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_2_10 (conv_q_src_c023_2_10 conv_q_c023_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_11 (conv_i_src_c023_2_11 0 conv_bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_2_11 (conv_i_src_c023_2_11 conv_i_c023_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_11 (conv_q_src_c023_2_11 0 conv_bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_2_11 (conv_q_src_c023_2_11 conv_q_c023_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_12 (conv_i_src_c023_2_12 0 conv_bpf_c023_2 0) vcvs gain=1.950903220161e-01
SCONVI_c023_2_12 (conv_i_src_c023_2_12 conv_i_c023_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_12 (conv_q_src_c023_2_12 0 conv_bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_2_12 (conv_q_src_c023_2_12 conv_q_c023_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_13 (conv_i_src_c023_2_13 0 conv_bpf_c023_2 0) vcvs gain=5.555702330196e-01
SCONVI_c023_2_13 (conv_i_src_c023_2_13 conv_i_c023_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_13 (conv_q_src_c023_2_13 0 conv_bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_2_13 (conv_q_src_c023_2_13 conv_q_c023_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_14 (conv_i_src_c023_2_14 0 conv_bpf_c023_2 0) vcvs gain=8.314696123025e-01
SCONVI_c023_2_14 (conv_i_src_c023_2_14 conv_i_c023_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_14 (conv_q_src_c023_2_14 0 conv_bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_2_14 (conv_q_src_c023_2_14 conv_q_c023_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_2_15 (conv_i_src_c023_2_15 0 conv_bpf_c023_2 0) vcvs gain=9.807852804032e-01
SCONVI_c023_2_15 (conv_i_src_c023_2_15 conv_i_c023_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_2_15 (conv_q_src_c023_2_15 0 conv_bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_2_15 (conv_q_src_c023_2_15 conv_q_c023_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c023_2 (conv_i_c023_2 0) resistor r=1G
RCONVQ_c023_2 (conv_q_c023_2 0) resistor r=1G
RCONVINTI_c023_2 (conv_i_c023_2 ConvIcar_c023_2) resistor r=1k
CCONVINTI_c023_2 (ConvIcar_c023_2 0) capacitor c=80p
RCONVINTQ_c023_2 (conv_q_c023_2 ConvQcar_c023_2) resistor r=1k
CCONVINTQ_c023_2 (ConvQcar_c023_2 0) capacitor c=80p
save conv_bpf_c023_2 ConvIcar_c023_2 ConvQcar_c023_2

// conventional mixed baseline bl023, carrier_3: 1000000000 Hz
CCONVBPF_c023_3 (bl023 n_conv_cbpf_c023_3) capacitor c=2.533029591058e-14
LCONVBPF_c023_3 (n_conv_cbpf_c023_3 conv_bpf_c023_3) inductor l=1.000000000000e-06
RCONVBPF_c023_3 (conv_bpf_c023_3 0) resistor r=3.141592653590e+02
ECONVI_c023_3_00 (conv_i_src_c023_3_00 0 conv_bpf_c023_3 0) vcvs gain=9.807852804032e-01
SCONVI_c023_3_00 (conv_i_src_c023_3_00 conv_i_c023_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_00 (conv_q_src_c023_3_00 0 conv_bpf_c023_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_3_00 (conv_q_src_c023_3_00 conv_q_c023_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_01 (conv_i_src_c023_3_01 0 conv_bpf_c023_3 0) vcvs gain=8.314696123025e-01
SCONVI_c023_3_01 (conv_i_src_c023_3_01 conv_i_c023_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_01 (conv_q_src_c023_3_01 0 conv_bpf_c023_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_3_01 (conv_q_src_c023_3_01 conv_q_c023_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_02 (conv_i_src_c023_3_02 0 conv_bpf_c023_3 0) vcvs gain=5.555702330196e-01
SCONVI_c023_3_02 (conv_i_src_c023_3_02 conv_i_c023_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_02 (conv_q_src_c023_3_02 0 conv_bpf_c023_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_3_02 (conv_q_src_c023_3_02 conv_q_c023_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_03 (conv_i_src_c023_3_03 0 conv_bpf_c023_3 0) vcvs gain=1.950903220161e-01
SCONVI_c023_3_03 (conv_i_src_c023_3_03 conv_i_c023_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_03 (conv_q_src_c023_3_03 0 conv_bpf_c023_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_3_03 (conv_q_src_c023_3_03 conv_q_c023_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_04 (conv_i_src_c023_3_04 0 conv_bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_3_04 (conv_i_src_c023_3_04 conv_i_c023_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_04 (conv_q_src_c023_3_04 0 conv_bpf_c023_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c023_3_04 (conv_q_src_c023_3_04 conv_q_c023_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_05 (conv_i_src_c023_3_05 0 conv_bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_3_05 (conv_i_src_c023_3_05 conv_i_c023_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_05 (conv_q_src_c023_3_05 0 conv_bpf_c023_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c023_3_05 (conv_q_src_c023_3_05 conv_q_c023_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_06 (conv_i_src_c023_3_06 0 conv_bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_3_06 (conv_i_src_c023_3_06 conv_i_c023_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_06 (conv_q_src_c023_3_06 0 conv_bpf_c023_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c023_3_06 (conv_q_src_c023_3_06 conv_q_c023_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_07 (conv_i_src_c023_3_07 0 conv_bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_3_07 (conv_i_src_c023_3_07 conv_i_c023_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_07 (conv_q_src_c023_3_07 0 conv_bpf_c023_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c023_3_07 (conv_q_src_c023_3_07 conv_q_c023_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_08 (conv_i_src_c023_3_08 0 conv_bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c023_3_08 (conv_i_src_c023_3_08 conv_i_c023_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_08 (conv_q_src_c023_3_08 0 conv_bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_3_08 (conv_q_src_c023_3_08 conv_q_c023_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_09 (conv_i_src_c023_3_09 0 conv_bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c023_3_09 (conv_i_src_c023_3_09 conv_i_c023_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_09 (conv_q_src_c023_3_09 0 conv_bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_3_09 (conv_q_src_c023_3_09 conv_q_c023_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_10 (conv_i_src_c023_3_10 0 conv_bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c023_3_10 (conv_i_src_c023_3_10 conv_i_c023_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_10 (conv_q_src_c023_3_10 0 conv_bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_3_10 (conv_q_src_c023_3_10 conv_q_c023_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_11 (conv_i_src_c023_3_11 0 conv_bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c023_3_11 (conv_i_src_c023_3_11 conv_i_c023_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_11 (conv_q_src_c023_3_11 0 conv_bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_3_11 (conv_q_src_c023_3_11 conv_q_c023_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_12 (conv_i_src_c023_3_12 0 conv_bpf_c023_3 0) vcvs gain=1.950903220161e-01
SCONVI_c023_3_12 (conv_i_src_c023_3_12 conv_i_c023_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_12 (conv_q_src_c023_3_12 0 conv_bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c023_3_12 (conv_q_src_c023_3_12 conv_q_c023_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_13 (conv_i_src_c023_3_13 0 conv_bpf_c023_3 0) vcvs gain=5.555702330196e-01
SCONVI_c023_3_13 (conv_i_src_c023_3_13 conv_i_c023_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_13 (conv_q_src_c023_3_13 0 conv_bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c023_3_13 (conv_q_src_c023_3_13 conv_q_c023_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_14 (conv_i_src_c023_3_14 0 conv_bpf_c023_3 0) vcvs gain=8.314696123025e-01
SCONVI_c023_3_14 (conv_i_src_c023_3_14 conv_i_c023_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_14 (conv_q_src_c023_3_14 0 conv_bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c023_3_14 (conv_q_src_c023_3_14 conv_q_c023_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c023_3_15 (conv_i_src_c023_3_15 0 conv_bpf_c023_3 0) vcvs gain=9.807852804032e-01
SCONVI_c023_3_15 (conv_i_src_c023_3_15 conv_i_c023_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c023_3_15 (conv_q_src_c023_3_15 0 conv_bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c023_3_15 (conv_q_src_c023_3_15 conv_q_c023_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c023_3 (conv_i_c023_3 0) resistor r=1G
RCONVQ_c023_3 (conv_q_c023_3 0) resistor r=1G
RCONVINTI_c023_3 (conv_i_c023_3 ConvIcar_c023_3) resistor r=1k
CCONVINTI_c023_3 (ConvIcar_c023_3 0) capacitor c=80p
RCONVINTQ_c023_3 (conv_q_c023_3 ConvQcar_c023_3) resistor r=1k
CCONVINTQ_c023_3 (ConvQcar_c023_3 0) capacitor c=80p
save conv_bpf_c023_3 ConvIcar_c023_3 ConvQcar_c023_3

// conventional mixed baseline bl024, carrier_0: 250000000 Hz
CCONVBPF_c024_0 (bl024 n_conv_cbpf_c024_0) capacitor c=4.052847345694e-13
LCONVBPF_c024_0 (n_conv_cbpf_c024_0 conv_bpf_c024_0) inductor l=1.000000000000e-06
RCONVBPF_c024_0 (conv_bpf_c024_0 0) resistor r=7.853981633974e+01
ECONVI_c024_0_00 (conv_i_src_c024_0_00 0 conv_bpf_c024_0 0) vcvs gain=9.807852804032e-01
SCONVI_c024_0_00 (conv_i_src_c024_0_00 conv_i_c024_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_00 (conv_q_src_c024_0_00 0 conv_bpf_c024_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_0_00 (conv_q_src_c024_0_00 conv_q_c024_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_01 (conv_i_src_c024_0_01 0 conv_bpf_c024_0 0) vcvs gain=8.314696123025e-01
SCONVI_c024_0_01 (conv_i_src_c024_0_01 conv_i_c024_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_01 (conv_q_src_c024_0_01 0 conv_bpf_c024_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_0_01 (conv_q_src_c024_0_01 conv_q_c024_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_02 (conv_i_src_c024_0_02 0 conv_bpf_c024_0 0) vcvs gain=5.555702330196e-01
SCONVI_c024_0_02 (conv_i_src_c024_0_02 conv_i_c024_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_02 (conv_q_src_c024_0_02 0 conv_bpf_c024_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_0_02 (conv_q_src_c024_0_02 conv_q_c024_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_03 (conv_i_src_c024_0_03 0 conv_bpf_c024_0 0) vcvs gain=1.950903220161e-01
SCONVI_c024_0_03 (conv_i_src_c024_0_03 conv_i_c024_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_03 (conv_q_src_c024_0_03 0 conv_bpf_c024_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_0_03 (conv_q_src_c024_0_03 conv_q_c024_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_04 (conv_i_src_c024_0_04 0 conv_bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_0_04 (conv_i_src_c024_0_04 conv_i_c024_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_04 (conv_q_src_c024_0_04 0 conv_bpf_c024_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_0_04 (conv_q_src_c024_0_04 conv_q_c024_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_05 (conv_i_src_c024_0_05 0 conv_bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_0_05 (conv_i_src_c024_0_05 conv_i_c024_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_05 (conv_q_src_c024_0_05 0 conv_bpf_c024_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_0_05 (conv_q_src_c024_0_05 conv_q_c024_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_06 (conv_i_src_c024_0_06 0 conv_bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_0_06 (conv_i_src_c024_0_06 conv_i_c024_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_06 (conv_q_src_c024_0_06 0 conv_bpf_c024_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_0_06 (conv_q_src_c024_0_06 conv_q_c024_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_07 (conv_i_src_c024_0_07 0 conv_bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_0_07 (conv_i_src_c024_0_07 conv_i_c024_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_07 (conv_q_src_c024_0_07 0 conv_bpf_c024_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_0_07 (conv_q_src_c024_0_07 conv_q_c024_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_08 (conv_i_src_c024_0_08 0 conv_bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_0_08 (conv_i_src_c024_0_08 conv_i_c024_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_08 (conv_q_src_c024_0_08 0 conv_bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_0_08 (conv_q_src_c024_0_08 conv_q_c024_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_09 (conv_i_src_c024_0_09 0 conv_bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_0_09 (conv_i_src_c024_0_09 conv_i_c024_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_09 (conv_q_src_c024_0_09 0 conv_bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_0_09 (conv_q_src_c024_0_09 conv_q_c024_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_10 (conv_i_src_c024_0_10 0 conv_bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_0_10 (conv_i_src_c024_0_10 conv_i_c024_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_10 (conv_q_src_c024_0_10 0 conv_bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_0_10 (conv_q_src_c024_0_10 conv_q_c024_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_11 (conv_i_src_c024_0_11 0 conv_bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_0_11 (conv_i_src_c024_0_11 conv_i_c024_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_11 (conv_q_src_c024_0_11 0 conv_bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_0_11 (conv_q_src_c024_0_11 conv_q_c024_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_12 (conv_i_src_c024_0_12 0 conv_bpf_c024_0 0) vcvs gain=1.950903220161e-01
SCONVI_c024_0_12 (conv_i_src_c024_0_12 conv_i_c024_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_12 (conv_q_src_c024_0_12 0 conv_bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_0_12 (conv_q_src_c024_0_12 conv_q_c024_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_13 (conv_i_src_c024_0_13 0 conv_bpf_c024_0 0) vcvs gain=5.555702330196e-01
SCONVI_c024_0_13 (conv_i_src_c024_0_13 conv_i_c024_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_13 (conv_q_src_c024_0_13 0 conv_bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_0_13 (conv_q_src_c024_0_13 conv_q_c024_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_14 (conv_i_src_c024_0_14 0 conv_bpf_c024_0 0) vcvs gain=8.314696123025e-01
SCONVI_c024_0_14 (conv_i_src_c024_0_14 conv_i_c024_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_14 (conv_q_src_c024_0_14 0 conv_bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_0_14 (conv_q_src_c024_0_14 conv_q_c024_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_0_15 (conv_i_src_c024_0_15 0 conv_bpf_c024_0 0) vcvs gain=9.807852804032e-01
SCONVI_c024_0_15 (conv_i_src_c024_0_15 conv_i_c024_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_0_15 (conv_q_src_c024_0_15 0 conv_bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_0_15 (conv_q_src_c024_0_15 conv_q_c024_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c024_0 (conv_i_c024_0 0) resistor r=1G
RCONVQ_c024_0 (conv_q_c024_0 0) resistor r=1G
RCONVINTI_c024_0 (conv_i_c024_0 ConvIcar_c024_0) resistor r=1k
CCONVINTI_c024_0 (ConvIcar_c024_0 0) capacitor c=80p
RCONVINTQ_c024_0 (conv_q_c024_0 ConvQcar_c024_0) resistor r=1k
CCONVINTQ_c024_0 (ConvQcar_c024_0 0) capacitor c=80p
save conv_bpf_c024_0 ConvIcar_c024_0 ConvQcar_c024_0

// conventional mixed baseline bl024, carrier_1: 500000000 Hz
CCONVBPF_c024_1 (bl024 n_conv_cbpf_c024_1) capacitor c=1.013211836423e-13
LCONVBPF_c024_1 (n_conv_cbpf_c024_1 conv_bpf_c024_1) inductor l=1.000000000000e-06
RCONVBPF_c024_1 (conv_bpf_c024_1 0) resistor r=1.570796326795e+02
ECONVI_c024_1_00 (conv_i_src_c024_1_00 0 conv_bpf_c024_1 0) vcvs gain=9.807852804032e-01
SCONVI_c024_1_00 (conv_i_src_c024_1_00 conv_i_c024_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_00 (conv_q_src_c024_1_00 0 conv_bpf_c024_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_1_00 (conv_q_src_c024_1_00 conv_q_c024_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_01 (conv_i_src_c024_1_01 0 conv_bpf_c024_1 0) vcvs gain=8.314696123025e-01
SCONVI_c024_1_01 (conv_i_src_c024_1_01 conv_i_c024_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_01 (conv_q_src_c024_1_01 0 conv_bpf_c024_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_1_01 (conv_q_src_c024_1_01 conv_q_c024_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_02 (conv_i_src_c024_1_02 0 conv_bpf_c024_1 0) vcvs gain=5.555702330196e-01
SCONVI_c024_1_02 (conv_i_src_c024_1_02 conv_i_c024_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_02 (conv_q_src_c024_1_02 0 conv_bpf_c024_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_1_02 (conv_q_src_c024_1_02 conv_q_c024_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_03 (conv_i_src_c024_1_03 0 conv_bpf_c024_1 0) vcvs gain=1.950903220161e-01
SCONVI_c024_1_03 (conv_i_src_c024_1_03 conv_i_c024_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_03 (conv_q_src_c024_1_03 0 conv_bpf_c024_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_1_03 (conv_q_src_c024_1_03 conv_q_c024_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_04 (conv_i_src_c024_1_04 0 conv_bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_1_04 (conv_i_src_c024_1_04 conv_i_c024_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_04 (conv_q_src_c024_1_04 0 conv_bpf_c024_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_1_04 (conv_q_src_c024_1_04 conv_q_c024_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_05 (conv_i_src_c024_1_05 0 conv_bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_1_05 (conv_i_src_c024_1_05 conv_i_c024_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_05 (conv_q_src_c024_1_05 0 conv_bpf_c024_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_1_05 (conv_q_src_c024_1_05 conv_q_c024_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_06 (conv_i_src_c024_1_06 0 conv_bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_1_06 (conv_i_src_c024_1_06 conv_i_c024_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_06 (conv_q_src_c024_1_06 0 conv_bpf_c024_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_1_06 (conv_q_src_c024_1_06 conv_q_c024_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_07 (conv_i_src_c024_1_07 0 conv_bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_1_07 (conv_i_src_c024_1_07 conv_i_c024_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_07 (conv_q_src_c024_1_07 0 conv_bpf_c024_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_1_07 (conv_q_src_c024_1_07 conv_q_c024_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_08 (conv_i_src_c024_1_08 0 conv_bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_1_08 (conv_i_src_c024_1_08 conv_i_c024_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_08 (conv_q_src_c024_1_08 0 conv_bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_1_08 (conv_q_src_c024_1_08 conv_q_c024_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_09 (conv_i_src_c024_1_09 0 conv_bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_1_09 (conv_i_src_c024_1_09 conv_i_c024_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_09 (conv_q_src_c024_1_09 0 conv_bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_1_09 (conv_q_src_c024_1_09 conv_q_c024_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_10 (conv_i_src_c024_1_10 0 conv_bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_1_10 (conv_i_src_c024_1_10 conv_i_c024_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_10 (conv_q_src_c024_1_10 0 conv_bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_1_10 (conv_q_src_c024_1_10 conv_q_c024_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_11 (conv_i_src_c024_1_11 0 conv_bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_1_11 (conv_i_src_c024_1_11 conv_i_c024_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_11 (conv_q_src_c024_1_11 0 conv_bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_1_11 (conv_q_src_c024_1_11 conv_q_c024_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_12 (conv_i_src_c024_1_12 0 conv_bpf_c024_1 0) vcvs gain=1.950903220161e-01
SCONVI_c024_1_12 (conv_i_src_c024_1_12 conv_i_c024_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_12 (conv_q_src_c024_1_12 0 conv_bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_1_12 (conv_q_src_c024_1_12 conv_q_c024_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_13 (conv_i_src_c024_1_13 0 conv_bpf_c024_1 0) vcvs gain=5.555702330196e-01
SCONVI_c024_1_13 (conv_i_src_c024_1_13 conv_i_c024_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_13 (conv_q_src_c024_1_13 0 conv_bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_1_13 (conv_q_src_c024_1_13 conv_q_c024_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_14 (conv_i_src_c024_1_14 0 conv_bpf_c024_1 0) vcvs gain=8.314696123025e-01
SCONVI_c024_1_14 (conv_i_src_c024_1_14 conv_i_c024_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_14 (conv_q_src_c024_1_14 0 conv_bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_1_14 (conv_q_src_c024_1_14 conv_q_c024_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_1_15 (conv_i_src_c024_1_15 0 conv_bpf_c024_1 0) vcvs gain=9.807852804032e-01
SCONVI_c024_1_15 (conv_i_src_c024_1_15 conv_i_c024_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_1_15 (conv_q_src_c024_1_15 0 conv_bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_1_15 (conv_q_src_c024_1_15 conv_q_c024_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c024_1 (conv_i_c024_1 0) resistor r=1G
RCONVQ_c024_1 (conv_q_c024_1 0) resistor r=1G
RCONVINTI_c024_1 (conv_i_c024_1 ConvIcar_c024_1) resistor r=1k
CCONVINTI_c024_1 (ConvIcar_c024_1 0) capacitor c=80p
RCONVINTQ_c024_1 (conv_q_c024_1 ConvQcar_c024_1) resistor r=1k
CCONVINTQ_c024_1 (ConvQcar_c024_1 0) capacitor c=80p
save conv_bpf_c024_1 ConvIcar_c024_1 ConvQcar_c024_1

// conventional mixed baseline bl024, carrier_2: 750000000 Hz
CCONVBPF_c024_2 (bl024 n_conv_cbpf_c024_2) capacitor c=4.503163717437e-14
LCONVBPF_c024_2 (n_conv_cbpf_c024_2 conv_bpf_c024_2) inductor l=1.000000000000e-06
RCONVBPF_c024_2 (conv_bpf_c024_2 0) resistor r=2.356194490192e+02
ECONVI_c024_2_00 (conv_i_src_c024_2_00 0 conv_bpf_c024_2 0) vcvs gain=9.807852804032e-01
SCONVI_c024_2_00 (conv_i_src_c024_2_00 conv_i_c024_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_00 (conv_q_src_c024_2_00 0 conv_bpf_c024_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_2_00 (conv_q_src_c024_2_00 conv_q_c024_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_01 (conv_i_src_c024_2_01 0 conv_bpf_c024_2 0) vcvs gain=8.314696123025e-01
SCONVI_c024_2_01 (conv_i_src_c024_2_01 conv_i_c024_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_01 (conv_q_src_c024_2_01 0 conv_bpf_c024_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_2_01 (conv_q_src_c024_2_01 conv_q_c024_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_02 (conv_i_src_c024_2_02 0 conv_bpf_c024_2 0) vcvs gain=5.555702330196e-01
SCONVI_c024_2_02 (conv_i_src_c024_2_02 conv_i_c024_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_02 (conv_q_src_c024_2_02 0 conv_bpf_c024_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_2_02 (conv_q_src_c024_2_02 conv_q_c024_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_03 (conv_i_src_c024_2_03 0 conv_bpf_c024_2 0) vcvs gain=1.950903220161e-01
SCONVI_c024_2_03 (conv_i_src_c024_2_03 conv_i_c024_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_03 (conv_q_src_c024_2_03 0 conv_bpf_c024_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_2_03 (conv_q_src_c024_2_03 conv_q_c024_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_04 (conv_i_src_c024_2_04 0 conv_bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_2_04 (conv_i_src_c024_2_04 conv_i_c024_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_04 (conv_q_src_c024_2_04 0 conv_bpf_c024_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_2_04 (conv_q_src_c024_2_04 conv_q_c024_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_05 (conv_i_src_c024_2_05 0 conv_bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_2_05 (conv_i_src_c024_2_05 conv_i_c024_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_05 (conv_q_src_c024_2_05 0 conv_bpf_c024_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_2_05 (conv_q_src_c024_2_05 conv_q_c024_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_06 (conv_i_src_c024_2_06 0 conv_bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_2_06 (conv_i_src_c024_2_06 conv_i_c024_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_06 (conv_q_src_c024_2_06 0 conv_bpf_c024_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_2_06 (conv_q_src_c024_2_06 conv_q_c024_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_07 (conv_i_src_c024_2_07 0 conv_bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_2_07 (conv_i_src_c024_2_07 conv_i_c024_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_07 (conv_q_src_c024_2_07 0 conv_bpf_c024_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_2_07 (conv_q_src_c024_2_07 conv_q_c024_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_08 (conv_i_src_c024_2_08 0 conv_bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_2_08 (conv_i_src_c024_2_08 conv_i_c024_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_08 (conv_q_src_c024_2_08 0 conv_bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_2_08 (conv_q_src_c024_2_08 conv_q_c024_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_09 (conv_i_src_c024_2_09 0 conv_bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_2_09 (conv_i_src_c024_2_09 conv_i_c024_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_09 (conv_q_src_c024_2_09 0 conv_bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_2_09 (conv_q_src_c024_2_09 conv_q_c024_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_10 (conv_i_src_c024_2_10 0 conv_bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_2_10 (conv_i_src_c024_2_10 conv_i_c024_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_10 (conv_q_src_c024_2_10 0 conv_bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_2_10 (conv_q_src_c024_2_10 conv_q_c024_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_11 (conv_i_src_c024_2_11 0 conv_bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_2_11 (conv_i_src_c024_2_11 conv_i_c024_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_11 (conv_q_src_c024_2_11 0 conv_bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_2_11 (conv_q_src_c024_2_11 conv_q_c024_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_12 (conv_i_src_c024_2_12 0 conv_bpf_c024_2 0) vcvs gain=1.950903220161e-01
SCONVI_c024_2_12 (conv_i_src_c024_2_12 conv_i_c024_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_12 (conv_q_src_c024_2_12 0 conv_bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_2_12 (conv_q_src_c024_2_12 conv_q_c024_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_13 (conv_i_src_c024_2_13 0 conv_bpf_c024_2 0) vcvs gain=5.555702330196e-01
SCONVI_c024_2_13 (conv_i_src_c024_2_13 conv_i_c024_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_13 (conv_q_src_c024_2_13 0 conv_bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_2_13 (conv_q_src_c024_2_13 conv_q_c024_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_14 (conv_i_src_c024_2_14 0 conv_bpf_c024_2 0) vcvs gain=8.314696123025e-01
SCONVI_c024_2_14 (conv_i_src_c024_2_14 conv_i_c024_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_14 (conv_q_src_c024_2_14 0 conv_bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_2_14 (conv_q_src_c024_2_14 conv_q_c024_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_2_15 (conv_i_src_c024_2_15 0 conv_bpf_c024_2 0) vcvs gain=9.807852804032e-01
SCONVI_c024_2_15 (conv_i_src_c024_2_15 conv_i_c024_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_2_15 (conv_q_src_c024_2_15 0 conv_bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_2_15 (conv_q_src_c024_2_15 conv_q_c024_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c024_2 (conv_i_c024_2 0) resistor r=1G
RCONVQ_c024_2 (conv_q_c024_2 0) resistor r=1G
RCONVINTI_c024_2 (conv_i_c024_2 ConvIcar_c024_2) resistor r=1k
CCONVINTI_c024_2 (ConvIcar_c024_2 0) capacitor c=80p
RCONVINTQ_c024_2 (conv_q_c024_2 ConvQcar_c024_2) resistor r=1k
CCONVINTQ_c024_2 (ConvQcar_c024_2 0) capacitor c=80p
save conv_bpf_c024_2 ConvIcar_c024_2 ConvQcar_c024_2

// conventional mixed baseline bl024, carrier_3: 1000000000 Hz
CCONVBPF_c024_3 (bl024 n_conv_cbpf_c024_3) capacitor c=2.533029591058e-14
LCONVBPF_c024_3 (n_conv_cbpf_c024_3 conv_bpf_c024_3) inductor l=1.000000000000e-06
RCONVBPF_c024_3 (conv_bpf_c024_3 0) resistor r=3.141592653590e+02
ECONVI_c024_3_00 (conv_i_src_c024_3_00 0 conv_bpf_c024_3 0) vcvs gain=9.807852804032e-01
SCONVI_c024_3_00 (conv_i_src_c024_3_00 conv_i_c024_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_00 (conv_q_src_c024_3_00 0 conv_bpf_c024_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_3_00 (conv_q_src_c024_3_00 conv_q_c024_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_01 (conv_i_src_c024_3_01 0 conv_bpf_c024_3 0) vcvs gain=8.314696123025e-01
SCONVI_c024_3_01 (conv_i_src_c024_3_01 conv_i_c024_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_01 (conv_q_src_c024_3_01 0 conv_bpf_c024_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_3_01 (conv_q_src_c024_3_01 conv_q_c024_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_02 (conv_i_src_c024_3_02 0 conv_bpf_c024_3 0) vcvs gain=5.555702330196e-01
SCONVI_c024_3_02 (conv_i_src_c024_3_02 conv_i_c024_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_02 (conv_q_src_c024_3_02 0 conv_bpf_c024_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_3_02 (conv_q_src_c024_3_02 conv_q_c024_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_03 (conv_i_src_c024_3_03 0 conv_bpf_c024_3 0) vcvs gain=1.950903220161e-01
SCONVI_c024_3_03 (conv_i_src_c024_3_03 conv_i_c024_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_03 (conv_q_src_c024_3_03 0 conv_bpf_c024_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_3_03 (conv_q_src_c024_3_03 conv_q_c024_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_04 (conv_i_src_c024_3_04 0 conv_bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_3_04 (conv_i_src_c024_3_04 conv_i_c024_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_04 (conv_q_src_c024_3_04 0 conv_bpf_c024_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c024_3_04 (conv_q_src_c024_3_04 conv_q_c024_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_05 (conv_i_src_c024_3_05 0 conv_bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_3_05 (conv_i_src_c024_3_05 conv_i_c024_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_05 (conv_q_src_c024_3_05 0 conv_bpf_c024_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c024_3_05 (conv_q_src_c024_3_05 conv_q_c024_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_06 (conv_i_src_c024_3_06 0 conv_bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_3_06 (conv_i_src_c024_3_06 conv_i_c024_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_06 (conv_q_src_c024_3_06 0 conv_bpf_c024_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c024_3_06 (conv_q_src_c024_3_06 conv_q_c024_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_07 (conv_i_src_c024_3_07 0 conv_bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_3_07 (conv_i_src_c024_3_07 conv_i_c024_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_07 (conv_q_src_c024_3_07 0 conv_bpf_c024_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c024_3_07 (conv_q_src_c024_3_07 conv_q_c024_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_08 (conv_i_src_c024_3_08 0 conv_bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c024_3_08 (conv_i_src_c024_3_08 conv_i_c024_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_08 (conv_q_src_c024_3_08 0 conv_bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_3_08 (conv_q_src_c024_3_08 conv_q_c024_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_09 (conv_i_src_c024_3_09 0 conv_bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c024_3_09 (conv_i_src_c024_3_09 conv_i_c024_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_09 (conv_q_src_c024_3_09 0 conv_bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_3_09 (conv_q_src_c024_3_09 conv_q_c024_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_10 (conv_i_src_c024_3_10 0 conv_bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c024_3_10 (conv_i_src_c024_3_10 conv_i_c024_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_10 (conv_q_src_c024_3_10 0 conv_bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_3_10 (conv_q_src_c024_3_10 conv_q_c024_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_11 (conv_i_src_c024_3_11 0 conv_bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c024_3_11 (conv_i_src_c024_3_11 conv_i_c024_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_11 (conv_q_src_c024_3_11 0 conv_bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_3_11 (conv_q_src_c024_3_11 conv_q_c024_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_12 (conv_i_src_c024_3_12 0 conv_bpf_c024_3 0) vcvs gain=1.950903220161e-01
SCONVI_c024_3_12 (conv_i_src_c024_3_12 conv_i_c024_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_12 (conv_q_src_c024_3_12 0 conv_bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c024_3_12 (conv_q_src_c024_3_12 conv_q_c024_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_13 (conv_i_src_c024_3_13 0 conv_bpf_c024_3 0) vcvs gain=5.555702330196e-01
SCONVI_c024_3_13 (conv_i_src_c024_3_13 conv_i_c024_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_13 (conv_q_src_c024_3_13 0 conv_bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c024_3_13 (conv_q_src_c024_3_13 conv_q_c024_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_14 (conv_i_src_c024_3_14 0 conv_bpf_c024_3 0) vcvs gain=8.314696123025e-01
SCONVI_c024_3_14 (conv_i_src_c024_3_14 conv_i_c024_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_14 (conv_q_src_c024_3_14 0 conv_bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c024_3_14 (conv_q_src_c024_3_14 conv_q_c024_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c024_3_15 (conv_i_src_c024_3_15 0 conv_bpf_c024_3 0) vcvs gain=9.807852804032e-01
SCONVI_c024_3_15 (conv_i_src_c024_3_15 conv_i_c024_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c024_3_15 (conv_q_src_c024_3_15 0 conv_bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c024_3_15 (conv_q_src_c024_3_15 conv_q_c024_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c024_3 (conv_i_c024_3 0) resistor r=1G
RCONVQ_c024_3 (conv_q_c024_3 0) resistor r=1G
RCONVINTI_c024_3 (conv_i_c024_3 ConvIcar_c024_3) resistor r=1k
CCONVINTI_c024_3 (ConvIcar_c024_3 0) capacitor c=80p
RCONVINTQ_c024_3 (conv_q_c024_3 ConvQcar_c024_3) resistor r=1k
CCONVINTQ_c024_3 (ConvQcar_c024_3 0) capacitor c=80p
save conv_bpf_c024_3 ConvIcar_c024_3 ConvQcar_c024_3

// conventional mixed baseline bl025, carrier_0: 250000000 Hz
CCONVBPF_c025_0 (bl025 n_conv_cbpf_c025_0) capacitor c=4.052847345694e-13
LCONVBPF_c025_0 (n_conv_cbpf_c025_0 conv_bpf_c025_0) inductor l=1.000000000000e-06
RCONVBPF_c025_0 (conv_bpf_c025_0 0) resistor r=7.853981633974e+01
ECONVI_c025_0_00 (conv_i_src_c025_0_00 0 conv_bpf_c025_0 0) vcvs gain=9.807852804032e-01
SCONVI_c025_0_00 (conv_i_src_c025_0_00 conv_i_c025_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_00 (conv_q_src_c025_0_00 0 conv_bpf_c025_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_0_00 (conv_q_src_c025_0_00 conv_q_c025_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_01 (conv_i_src_c025_0_01 0 conv_bpf_c025_0 0) vcvs gain=8.314696123025e-01
SCONVI_c025_0_01 (conv_i_src_c025_0_01 conv_i_c025_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_01 (conv_q_src_c025_0_01 0 conv_bpf_c025_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_0_01 (conv_q_src_c025_0_01 conv_q_c025_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_02 (conv_i_src_c025_0_02 0 conv_bpf_c025_0 0) vcvs gain=5.555702330196e-01
SCONVI_c025_0_02 (conv_i_src_c025_0_02 conv_i_c025_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_02 (conv_q_src_c025_0_02 0 conv_bpf_c025_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_0_02 (conv_q_src_c025_0_02 conv_q_c025_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_03 (conv_i_src_c025_0_03 0 conv_bpf_c025_0 0) vcvs gain=1.950903220161e-01
SCONVI_c025_0_03 (conv_i_src_c025_0_03 conv_i_c025_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_03 (conv_q_src_c025_0_03 0 conv_bpf_c025_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_0_03 (conv_q_src_c025_0_03 conv_q_c025_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_04 (conv_i_src_c025_0_04 0 conv_bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_0_04 (conv_i_src_c025_0_04 conv_i_c025_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_04 (conv_q_src_c025_0_04 0 conv_bpf_c025_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_0_04 (conv_q_src_c025_0_04 conv_q_c025_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_05 (conv_i_src_c025_0_05 0 conv_bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_0_05 (conv_i_src_c025_0_05 conv_i_c025_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_05 (conv_q_src_c025_0_05 0 conv_bpf_c025_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_0_05 (conv_q_src_c025_0_05 conv_q_c025_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_06 (conv_i_src_c025_0_06 0 conv_bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_0_06 (conv_i_src_c025_0_06 conv_i_c025_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_06 (conv_q_src_c025_0_06 0 conv_bpf_c025_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_0_06 (conv_q_src_c025_0_06 conv_q_c025_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_07 (conv_i_src_c025_0_07 0 conv_bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_0_07 (conv_i_src_c025_0_07 conv_i_c025_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_07 (conv_q_src_c025_0_07 0 conv_bpf_c025_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_0_07 (conv_q_src_c025_0_07 conv_q_c025_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_08 (conv_i_src_c025_0_08 0 conv_bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_0_08 (conv_i_src_c025_0_08 conv_i_c025_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_08 (conv_q_src_c025_0_08 0 conv_bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_0_08 (conv_q_src_c025_0_08 conv_q_c025_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_09 (conv_i_src_c025_0_09 0 conv_bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_0_09 (conv_i_src_c025_0_09 conv_i_c025_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_09 (conv_q_src_c025_0_09 0 conv_bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c025_0_09 (conv_q_src_c025_0_09 conv_q_c025_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_10 (conv_i_src_c025_0_10 0 conv_bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_0_10 (conv_i_src_c025_0_10 conv_i_c025_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_10 (conv_q_src_c025_0_10 0 conv_bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_0_10 (conv_q_src_c025_0_10 conv_q_c025_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_11 (conv_i_src_c025_0_11 0 conv_bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_0_11 (conv_i_src_c025_0_11 conv_i_c025_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_11 (conv_q_src_c025_0_11 0 conv_bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_0_11 (conv_q_src_c025_0_11 conv_q_c025_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_12 (conv_i_src_c025_0_12 0 conv_bpf_c025_0 0) vcvs gain=1.950903220161e-01
SCONVI_c025_0_12 (conv_i_src_c025_0_12 conv_i_c025_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_12 (conv_q_src_c025_0_12 0 conv_bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_0_12 (conv_q_src_c025_0_12 conv_q_c025_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_13 (conv_i_src_c025_0_13 0 conv_bpf_c025_0 0) vcvs gain=5.555702330196e-01
SCONVI_c025_0_13 (conv_i_src_c025_0_13 conv_i_c025_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_13 (conv_q_src_c025_0_13 0 conv_bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_0_13 (conv_q_src_c025_0_13 conv_q_c025_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_14 (conv_i_src_c025_0_14 0 conv_bpf_c025_0 0) vcvs gain=8.314696123025e-01
SCONVI_c025_0_14 (conv_i_src_c025_0_14 conv_i_c025_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_14 (conv_q_src_c025_0_14 0 conv_bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c025_0_14 (conv_q_src_c025_0_14 conv_q_c025_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_0_15 (conv_i_src_c025_0_15 0 conv_bpf_c025_0 0) vcvs gain=9.807852804032e-01
SCONVI_c025_0_15 (conv_i_src_c025_0_15 conv_i_c025_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_0_15 (conv_q_src_c025_0_15 0 conv_bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_0_15 (conv_q_src_c025_0_15 conv_q_c025_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c025_0 (conv_i_c025_0 0) resistor r=1G
RCONVQ_c025_0 (conv_q_c025_0 0) resistor r=1G
RCONVINTI_c025_0 (conv_i_c025_0 ConvIcar_c025_0) resistor r=1k
CCONVINTI_c025_0 (ConvIcar_c025_0 0) capacitor c=80p
RCONVINTQ_c025_0 (conv_q_c025_0 ConvQcar_c025_0) resistor r=1k
CCONVINTQ_c025_0 (ConvQcar_c025_0 0) capacitor c=80p
save conv_bpf_c025_0 ConvIcar_c025_0 ConvQcar_c025_0

// conventional mixed baseline bl025, carrier_1: 500000000 Hz
CCONVBPF_c025_1 (bl025 n_conv_cbpf_c025_1) capacitor c=1.013211836423e-13
LCONVBPF_c025_1 (n_conv_cbpf_c025_1 conv_bpf_c025_1) inductor l=1.000000000000e-06
RCONVBPF_c025_1 (conv_bpf_c025_1 0) resistor r=1.570796326795e+02
ECONVI_c025_1_00 (conv_i_src_c025_1_00 0 conv_bpf_c025_1 0) vcvs gain=9.807852804032e-01
SCONVI_c025_1_00 (conv_i_src_c025_1_00 conv_i_c025_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_00 (conv_q_src_c025_1_00 0 conv_bpf_c025_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_1_00 (conv_q_src_c025_1_00 conv_q_c025_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_01 (conv_i_src_c025_1_01 0 conv_bpf_c025_1 0) vcvs gain=8.314696123025e-01
SCONVI_c025_1_01 (conv_i_src_c025_1_01 conv_i_c025_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_01 (conv_q_src_c025_1_01 0 conv_bpf_c025_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_1_01 (conv_q_src_c025_1_01 conv_q_c025_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_02 (conv_i_src_c025_1_02 0 conv_bpf_c025_1 0) vcvs gain=5.555702330196e-01
SCONVI_c025_1_02 (conv_i_src_c025_1_02 conv_i_c025_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_02 (conv_q_src_c025_1_02 0 conv_bpf_c025_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_1_02 (conv_q_src_c025_1_02 conv_q_c025_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_03 (conv_i_src_c025_1_03 0 conv_bpf_c025_1 0) vcvs gain=1.950903220161e-01
SCONVI_c025_1_03 (conv_i_src_c025_1_03 conv_i_c025_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_03 (conv_q_src_c025_1_03 0 conv_bpf_c025_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_1_03 (conv_q_src_c025_1_03 conv_q_c025_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_04 (conv_i_src_c025_1_04 0 conv_bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_1_04 (conv_i_src_c025_1_04 conv_i_c025_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_04 (conv_q_src_c025_1_04 0 conv_bpf_c025_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_1_04 (conv_q_src_c025_1_04 conv_q_c025_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_05 (conv_i_src_c025_1_05 0 conv_bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_1_05 (conv_i_src_c025_1_05 conv_i_c025_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_05 (conv_q_src_c025_1_05 0 conv_bpf_c025_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_1_05 (conv_q_src_c025_1_05 conv_q_c025_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_06 (conv_i_src_c025_1_06 0 conv_bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_1_06 (conv_i_src_c025_1_06 conv_i_c025_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_06 (conv_q_src_c025_1_06 0 conv_bpf_c025_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_1_06 (conv_q_src_c025_1_06 conv_q_c025_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_07 (conv_i_src_c025_1_07 0 conv_bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_1_07 (conv_i_src_c025_1_07 conv_i_c025_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_07 (conv_q_src_c025_1_07 0 conv_bpf_c025_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_1_07 (conv_q_src_c025_1_07 conv_q_c025_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_08 (conv_i_src_c025_1_08 0 conv_bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_1_08 (conv_i_src_c025_1_08 conv_i_c025_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_08 (conv_q_src_c025_1_08 0 conv_bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_1_08 (conv_q_src_c025_1_08 conv_q_c025_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_09 (conv_i_src_c025_1_09 0 conv_bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_1_09 (conv_i_src_c025_1_09 conv_i_c025_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_09 (conv_q_src_c025_1_09 0 conv_bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c025_1_09 (conv_q_src_c025_1_09 conv_q_c025_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_10 (conv_i_src_c025_1_10 0 conv_bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_1_10 (conv_i_src_c025_1_10 conv_i_c025_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_10 (conv_q_src_c025_1_10 0 conv_bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_1_10 (conv_q_src_c025_1_10 conv_q_c025_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_11 (conv_i_src_c025_1_11 0 conv_bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_1_11 (conv_i_src_c025_1_11 conv_i_c025_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_11 (conv_q_src_c025_1_11 0 conv_bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_1_11 (conv_q_src_c025_1_11 conv_q_c025_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_12 (conv_i_src_c025_1_12 0 conv_bpf_c025_1 0) vcvs gain=1.950903220161e-01
SCONVI_c025_1_12 (conv_i_src_c025_1_12 conv_i_c025_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_12 (conv_q_src_c025_1_12 0 conv_bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_1_12 (conv_q_src_c025_1_12 conv_q_c025_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_13 (conv_i_src_c025_1_13 0 conv_bpf_c025_1 0) vcvs gain=5.555702330196e-01
SCONVI_c025_1_13 (conv_i_src_c025_1_13 conv_i_c025_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_13 (conv_q_src_c025_1_13 0 conv_bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_1_13 (conv_q_src_c025_1_13 conv_q_c025_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_14 (conv_i_src_c025_1_14 0 conv_bpf_c025_1 0) vcvs gain=8.314696123025e-01
SCONVI_c025_1_14 (conv_i_src_c025_1_14 conv_i_c025_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_14 (conv_q_src_c025_1_14 0 conv_bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c025_1_14 (conv_q_src_c025_1_14 conv_q_c025_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_1_15 (conv_i_src_c025_1_15 0 conv_bpf_c025_1 0) vcvs gain=9.807852804032e-01
SCONVI_c025_1_15 (conv_i_src_c025_1_15 conv_i_c025_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_1_15 (conv_q_src_c025_1_15 0 conv_bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_1_15 (conv_q_src_c025_1_15 conv_q_c025_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c025_1 (conv_i_c025_1 0) resistor r=1G
RCONVQ_c025_1 (conv_q_c025_1 0) resistor r=1G
RCONVINTI_c025_1 (conv_i_c025_1 ConvIcar_c025_1) resistor r=1k
CCONVINTI_c025_1 (ConvIcar_c025_1 0) capacitor c=80p
RCONVINTQ_c025_1 (conv_q_c025_1 ConvQcar_c025_1) resistor r=1k
CCONVINTQ_c025_1 (ConvQcar_c025_1 0) capacitor c=80p
save conv_bpf_c025_1 ConvIcar_c025_1 ConvQcar_c025_1

// conventional mixed baseline bl025, carrier_2: 750000000 Hz
CCONVBPF_c025_2 (bl025 n_conv_cbpf_c025_2) capacitor c=4.503163717437e-14
LCONVBPF_c025_2 (n_conv_cbpf_c025_2 conv_bpf_c025_2) inductor l=1.000000000000e-06
RCONVBPF_c025_2 (conv_bpf_c025_2 0) resistor r=2.356194490192e+02
ECONVI_c025_2_00 (conv_i_src_c025_2_00 0 conv_bpf_c025_2 0) vcvs gain=9.807852804032e-01
SCONVI_c025_2_00 (conv_i_src_c025_2_00 conv_i_c025_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_00 (conv_q_src_c025_2_00 0 conv_bpf_c025_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_2_00 (conv_q_src_c025_2_00 conv_q_c025_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_01 (conv_i_src_c025_2_01 0 conv_bpf_c025_2 0) vcvs gain=8.314696123025e-01
SCONVI_c025_2_01 (conv_i_src_c025_2_01 conv_i_c025_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_01 (conv_q_src_c025_2_01 0 conv_bpf_c025_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_2_01 (conv_q_src_c025_2_01 conv_q_c025_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_02 (conv_i_src_c025_2_02 0 conv_bpf_c025_2 0) vcvs gain=5.555702330196e-01
SCONVI_c025_2_02 (conv_i_src_c025_2_02 conv_i_c025_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_02 (conv_q_src_c025_2_02 0 conv_bpf_c025_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_2_02 (conv_q_src_c025_2_02 conv_q_c025_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_03 (conv_i_src_c025_2_03 0 conv_bpf_c025_2 0) vcvs gain=1.950903220161e-01
SCONVI_c025_2_03 (conv_i_src_c025_2_03 conv_i_c025_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_03 (conv_q_src_c025_2_03 0 conv_bpf_c025_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_2_03 (conv_q_src_c025_2_03 conv_q_c025_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_04 (conv_i_src_c025_2_04 0 conv_bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_2_04 (conv_i_src_c025_2_04 conv_i_c025_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_04 (conv_q_src_c025_2_04 0 conv_bpf_c025_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_2_04 (conv_q_src_c025_2_04 conv_q_c025_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_05 (conv_i_src_c025_2_05 0 conv_bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_2_05 (conv_i_src_c025_2_05 conv_i_c025_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_05 (conv_q_src_c025_2_05 0 conv_bpf_c025_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_2_05 (conv_q_src_c025_2_05 conv_q_c025_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_06 (conv_i_src_c025_2_06 0 conv_bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_2_06 (conv_i_src_c025_2_06 conv_i_c025_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_06 (conv_q_src_c025_2_06 0 conv_bpf_c025_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_2_06 (conv_q_src_c025_2_06 conv_q_c025_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_07 (conv_i_src_c025_2_07 0 conv_bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_2_07 (conv_i_src_c025_2_07 conv_i_c025_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_07 (conv_q_src_c025_2_07 0 conv_bpf_c025_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_2_07 (conv_q_src_c025_2_07 conv_q_c025_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_08 (conv_i_src_c025_2_08 0 conv_bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_2_08 (conv_i_src_c025_2_08 conv_i_c025_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_08 (conv_q_src_c025_2_08 0 conv_bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_2_08 (conv_q_src_c025_2_08 conv_q_c025_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_09 (conv_i_src_c025_2_09 0 conv_bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_2_09 (conv_i_src_c025_2_09 conv_i_c025_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_09 (conv_q_src_c025_2_09 0 conv_bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c025_2_09 (conv_q_src_c025_2_09 conv_q_c025_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_10 (conv_i_src_c025_2_10 0 conv_bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_2_10 (conv_i_src_c025_2_10 conv_i_c025_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_10 (conv_q_src_c025_2_10 0 conv_bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_2_10 (conv_q_src_c025_2_10 conv_q_c025_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_11 (conv_i_src_c025_2_11 0 conv_bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_2_11 (conv_i_src_c025_2_11 conv_i_c025_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_11 (conv_q_src_c025_2_11 0 conv_bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_2_11 (conv_q_src_c025_2_11 conv_q_c025_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_12 (conv_i_src_c025_2_12 0 conv_bpf_c025_2 0) vcvs gain=1.950903220161e-01
SCONVI_c025_2_12 (conv_i_src_c025_2_12 conv_i_c025_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_12 (conv_q_src_c025_2_12 0 conv_bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_2_12 (conv_q_src_c025_2_12 conv_q_c025_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_13 (conv_i_src_c025_2_13 0 conv_bpf_c025_2 0) vcvs gain=5.555702330196e-01
SCONVI_c025_2_13 (conv_i_src_c025_2_13 conv_i_c025_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_13 (conv_q_src_c025_2_13 0 conv_bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_2_13 (conv_q_src_c025_2_13 conv_q_c025_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_14 (conv_i_src_c025_2_14 0 conv_bpf_c025_2 0) vcvs gain=8.314696123025e-01
SCONVI_c025_2_14 (conv_i_src_c025_2_14 conv_i_c025_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_14 (conv_q_src_c025_2_14 0 conv_bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c025_2_14 (conv_q_src_c025_2_14 conv_q_c025_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_2_15 (conv_i_src_c025_2_15 0 conv_bpf_c025_2 0) vcvs gain=9.807852804032e-01
SCONVI_c025_2_15 (conv_i_src_c025_2_15 conv_i_c025_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_2_15 (conv_q_src_c025_2_15 0 conv_bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_2_15 (conv_q_src_c025_2_15 conv_q_c025_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c025_2 (conv_i_c025_2 0) resistor r=1G
RCONVQ_c025_2 (conv_q_c025_2 0) resistor r=1G
RCONVINTI_c025_2 (conv_i_c025_2 ConvIcar_c025_2) resistor r=1k
CCONVINTI_c025_2 (ConvIcar_c025_2 0) capacitor c=80p
RCONVINTQ_c025_2 (conv_q_c025_2 ConvQcar_c025_2) resistor r=1k
CCONVINTQ_c025_2 (ConvQcar_c025_2 0) capacitor c=80p
save conv_bpf_c025_2 ConvIcar_c025_2 ConvQcar_c025_2

// conventional mixed baseline bl025, carrier_3: 1000000000 Hz
CCONVBPF_c025_3 (bl025 n_conv_cbpf_c025_3) capacitor c=2.533029591058e-14
LCONVBPF_c025_3 (n_conv_cbpf_c025_3 conv_bpf_c025_3) inductor l=1.000000000000e-06
RCONVBPF_c025_3 (conv_bpf_c025_3 0) resistor r=3.141592653590e+02
ECONVI_c025_3_00 (conv_i_src_c025_3_00 0 conv_bpf_c025_3 0) vcvs gain=9.807852804032e-01
SCONVI_c025_3_00 (conv_i_src_c025_3_00 conv_i_c025_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_00 (conv_q_src_c025_3_00 0 conv_bpf_c025_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_3_00 (conv_q_src_c025_3_00 conv_q_c025_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_01 (conv_i_src_c025_3_01 0 conv_bpf_c025_3 0) vcvs gain=8.314696123025e-01
SCONVI_c025_3_01 (conv_i_src_c025_3_01 conv_i_c025_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_01 (conv_q_src_c025_3_01 0 conv_bpf_c025_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_3_01 (conv_q_src_c025_3_01 conv_q_c025_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_02 (conv_i_src_c025_3_02 0 conv_bpf_c025_3 0) vcvs gain=5.555702330196e-01
SCONVI_c025_3_02 (conv_i_src_c025_3_02 conv_i_c025_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_02 (conv_q_src_c025_3_02 0 conv_bpf_c025_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_3_02 (conv_q_src_c025_3_02 conv_q_c025_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_03 (conv_i_src_c025_3_03 0 conv_bpf_c025_3 0) vcvs gain=1.950903220161e-01
SCONVI_c025_3_03 (conv_i_src_c025_3_03 conv_i_c025_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_03 (conv_q_src_c025_3_03 0 conv_bpf_c025_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_3_03 (conv_q_src_c025_3_03 conv_q_c025_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_04 (conv_i_src_c025_3_04 0 conv_bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_3_04 (conv_i_src_c025_3_04 conv_i_c025_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_04 (conv_q_src_c025_3_04 0 conv_bpf_c025_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c025_3_04 (conv_q_src_c025_3_04 conv_q_c025_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_05 (conv_i_src_c025_3_05 0 conv_bpf_c025_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_3_05 (conv_i_src_c025_3_05 conv_i_c025_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_05 (conv_q_src_c025_3_05 0 conv_bpf_c025_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c025_3_05 (conv_q_src_c025_3_05 conv_q_c025_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_06 (conv_i_src_c025_3_06 0 conv_bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_3_06 (conv_i_src_c025_3_06 conv_i_c025_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_06 (conv_q_src_c025_3_06 0 conv_bpf_c025_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c025_3_06 (conv_q_src_c025_3_06 conv_q_c025_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_07 (conv_i_src_c025_3_07 0 conv_bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_3_07 (conv_i_src_c025_3_07 conv_i_c025_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_07 (conv_q_src_c025_3_07 0 conv_bpf_c025_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c025_3_07 (conv_q_src_c025_3_07 conv_q_c025_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_08 (conv_i_src_c025_3_08 0 conv_bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c025_3_08 (conv_i_src_c025_3_08 conv_i_c025_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_08 (conv_q_src_c025_3_08 0 conv_bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c025_3_08 (conv_q_src_c025_3_08 conv_q_c025_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_09 (conv_i_src_c025_3_09 0 conv_bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c025_3_09 (conv_i_src_c025_3_09 conv_i_c025_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_09 (conv_q_src_c025_3_09 0 conv_bpf_c025_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c025_3_09 (conv_q_src_c025_3_09 conv_q_c025_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_10 (conv_i_src_c025_3_10 0 conv_bpf_c025_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c025_3_10 (conv_i_src_c025_3_10 conv_i_c025_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_10 (conv_q_src_c025_3_10 0 conv_bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_3_10 (conv_q_src_c025_3_10 conv_q_c025_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_11 (conv_i_src_c025_3_11 0 conv_bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c025_3_11 (conv_i_src_c025_3_11 conv_i_c025_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_11 (conv_q_src_c025_3_11 0 conv_bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_3_11 (conv_q_src_c025_3_11 conv_q_c025_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_12 (conv_i_src_c025_3_12 0 conv_bpf_c025_3 0) vcvs gain=1.950903220161e-01
SCONVI_c025_3_12 (conv_i_src_c025_3_12 conv_i_c025_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_12 (conv_q_src_c025_3_12 0 conv_bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c025_3_12 (conv_q_src_c025_3_12 conv_q_c025_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_13 (conv_i_src_c025_3_13 0 conv_bpf_c025_3 0) vcvs gain=5.555702330196e-01
SCONVI_c025_3_13 (conv_i_src_c025_3_13 conv_i_c025_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_13 (conv_q_src_c025_3_13 0 conv_bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c025_3_13 (conv_q_src_c025_3_13 conv_q_c025_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c025_3_14 (conv_i_src_c025_3_14 0 conv_bpf_c025_3 0) vcvs gain=8.314696123025e-01
SCONVI_c025_3_14 (conv_i_src_c025_3_14 conv_i_c025_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c025_3_14 (conv_q_src_c025_3_14 0 conv_bpf_c025_3 0) vcvs gain=-5.555702330196e-01
