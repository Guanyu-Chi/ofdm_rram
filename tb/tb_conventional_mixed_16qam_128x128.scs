SCONVQ_c052_1_03 (conv_q_src_c052_1_03 conv_q_c052_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_04 (conv_i_src_c052_1_04 0 conv_bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_1_04 (conv_i_src_c052_1_04 conv_i_c052_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_04 (conv_q_src_c052_1_04 0 conv_bpf_c052_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c052_1_04 (conv_q_src_c052_1_04 conv_q_c052_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_05 (conv_i_src_c052_1_05 0 conv_bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_1_05 (conv_i_src_c052_1_05 conv_i_c052_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_05 (conv_q_src_c052_1_05 0 conv_bpf_c052_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_1_05 (conv_q_src_c052_1_05 conv_q_c052_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_06 (conv_i_src_c052_1_06 0 conv_bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_1_06 (conv_i_src_c052_1_06 conv_i_c052_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_06 (conv_q_src_c052_1_06 0 conv_bpf_c052_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_1_06 (conv_q_src_c052_1_06 conv_q_c052_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_07 (conv_i_src_c052_1_07 0 conv_bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_1_07 (conv_i_src_c052_1_07 conv_i_c052_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_07 (conv_q_src_c052_1_07 0 conv_bpf_c052_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_1_07 (conv_q_src_c052_1_07 conv_q_c052_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_08 (conv_i_src_c052_1_08 0 conv_bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_1_08 (conv_i_src_c052_1_08 conv_i_c052_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_08 (conv_q_src_c052_1_08 0 conv_bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_1_08 (conv_q_src_c052_1_08 conv_q_c052_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_09 (conv_i_src_c052_1_09 0 conv_bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_1_09 (conv_i_src_c052_1_09 conv_i_c052_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_09 (conv_q_src_c052_1_09 0 conv_bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_1_09 (conv_q_src_c052_1_09 conv_q_c052_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_10 (conv_i_src_c052_1_10 0 conv_bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_1_10 (conv_i_src_c052_1_10 conv_i_c052_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_10 (conv_q_src_c052_1_10 0 conv_bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_1_10 (conv_q_src_c052_1_10 conv_q_c052_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_11 (conv_i_src_c052_1_11 0 conv_bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_1_11 (conv_i_src_c052_1_11 conv_i_c052_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_11 (conv_q_src_c052_1_11 0 conv_bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_1_11 (conv_q_src_c052_1_11 conv_q_c052_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_12 (conv_i_src_c052_1_12 0 conv_bpf_c052_1 0) vcvs gain=1.950903220161e-01
SCONVI_c052_1_12 (conv_i_src_c052_1_12 conv_i_c052_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_12 (conv_q_src_c052_1_12 0 conv_bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_1_12 (conv_q_src_c052_1_12 conv_q_c052_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_13 (conv_i_src_c052_1_13 0 conv_bpf_c052_1 0) vcvs gain=5.555702330196e-01
SCONVI_c052_1_13 (conv_i_src_c052_1_13 conv_i_c052_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_13 (conv_q_src_c052_1_13 0 conv_bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_1_13 (conv_q_src_c052_1_13 conv_q_c052_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_14 (conv_i_src_c052_1_14 0 conv_bpf_c052_1 0) vcvs gain=8.314696123025e-01
SCONVI_c052_1_14 (conv_i_src_c052_1_14 conv_i_c052_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_14 (conv_q_src_c052_1_14 0 conv_bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_1_14 (conv_q_src_c052_1_14 conv_q_c052_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_1_15 (conv_i_src_c052_1_15 0 conv_bpf_c052_1 0) vcvs gain=9.807852804032e-01
SCONVI_c052_1_15 (conv_i_src_c052_1_15 conv_i_c052_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_1_15 (conv_q_src_c052_1_15 0 conv_bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_1_15 (conv_q_src_c052_1_15 conv_q_c052_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c052_1 (conv_i_c052_1 0) resistor r=1G
RCONVQ_c052_1 (conv_q_c052_1 0) resistor r=1G
RCONVINTI_c052_1 (conv_i_c052_1 ConvIcar_c052_1) resistor r=1k
CCONVINTI_c052_1 (ConvIcar_c052_1 0) capacitor c=80p
RCONVINTQ_c052_1 (conv_q_c052_1 ConvQcar_c052_1) resistor r=1k
CCONVINTQ_c052_1 (ConvQcar_c052_1 0) capacitor c=80p
save conv_bpf_c052_1 ConvIcar_c052_1 ConvQcar_c052_1

// conventional mixed baseline bl052, carrier_2: 750000000 Hz
CCONVBPF_c052_2 (bl052 n_conv_cbpf_c052_2) capacitor c=4.503163717437e-14
LCONVBPF_c052_2 (n_conv_cbpf_c052_2 conv_bpf_c052_2) inductor l=1.000000000000e-06
RCONVBPF_c052_2 (conv_bpf_c052_2 0) resistor r=2.356194490192e+02
ECONVI_c052_2_00 (conv_i_src_c052_2_00 0 conv_bpf_c052_2 0) vcvs gain=9.807852804032e-01
SCONVI_c052_2_00 (conv_i_src_c052_2_00 conv_i_c052_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_00 (conv_q_src_c052_2_00 0 conv_bpf_c052_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_2_00 (conv_q_src_c052_2_00 conv_q_c052_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_01 (conv_i_src_c052_2_01 0 conv_bpf_c052_2 0) vcvs gain=8.314696123025e-01
SCONVI_c052_2_01 (conv_i_src_c052_2_01 conv_i_c052_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_01 (conv_q_src_c052_2_01 0 conv_bpf_c052_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_2_01 (conv_q_src_c052_2_01 conv_q_c052_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_02 (conv_i_src_c052_2_02 0 conv_bpf_c052_2 0) vcvs gain=5.555702330196e-01
SCONVI_c052_2_02 (conv_i_src_c052_2_02 conv_i_c052_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_02 (conv_q_src_c052_2_02 0 conv_bpf_c052_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_2_02 (conv_q_src_c052_2_02 conv_q_c052_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_03 (conv_i_src_c052_2_03 0 conv_bpf_c052_2 0) vcvs gain=1.950903220161e-01
SCONVI_c052_2_03 (conv_i_src_c052_2_03 conv_i_c052_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_03 (conv_q_src_c052_2_03 0 conv_bpf_c052_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c052_2_03 (conv_q_src_c052_2_03 conv_q_c052_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_04 (conv_i_src_c052_2_04 0 conv_bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_2_04 (conv_i_src_c052_2_04 conv_i_c052_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_04 (conv_q_src_c052_2_04 0 conv_bpf_c052_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c052_2_04 (conv_q_src_c052_2_04 conv_q_c052_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_05 (conv_i_src_c052_2_05 0 conv_bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_2_05 (conv_i_src_c052_2_05 conv_i_c052_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_05 (conv_q_src_c052_2_05 0 conv_bpf_c052_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_2_05 (conv_q_src_c052_2_05 conv_q_c052_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_06 (conv_i_src_c052_2_06 0 conv_bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_2_06 (conv_i_src_c052_2_06 conv_i_c052_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_06 (conv_q_src_c052_2_06 0 conv_bpf_c052_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_2_06 (conv_q_src_c052_2_06 conv_q_c052_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_07 (conv_i_src_c052_2_07 0 conv_bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_2_07 (conv_i_src_c052_2_07 conv_i_c052_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_07 (conv_q_src_c052_2_07 0 conv_bpf_c052_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_2_07 (conv_q_src_c052_2_07 conv_q_c052_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_08 (conv_i_src_c052_2_08 0 conv_bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_2_08 (conv_i_src_c052_2_08 conv_i_c052_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_08 (conv_q_src_c052_2_08 0 conv_bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_2_08 (conv_q_src_c052_2_08 conv_q_c052_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_09 (conv_i_src_c052_2_09 0 conv_bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_2_09 (conv_i_src_c052_2_09 conv_i_c052_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_09 (conv_q_src_c052_2_09 0 conv_bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_2_09 (conv_q_src_c052_2_09 conv_q_c052_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_10 (conv_i_src_c052_2_10 0 conv_bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_2_10 (conv_i_src_c052_2_10 conv_i_c052_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_10 (conv_q_src_c052_2_10 0 conv_bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_2_10 (conv_q_src_c052_2_10 conv_q_c052_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_11 (conv_i_src_c052_2_11 0 conv_bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_2_11 (conv_i_src_c052_2_11 conv_i_c052_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_11 (conv_q_src_c052_2_11 0 conv_bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_2_11 (conv_q_src_c052_2_11 conv_q_c052_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_12 (conv_i_src_c052_2_12 0 conv_bpf_c052_2 0) vcvs gain=1.950903220161e-01
SCONVI_c052_2_12 (conv_i_src_c052_2_12 conv_i_c052_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_12 (conv_q_src_c052_2_12 0 conv_bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_2_12 (conv_q_src_c052_2_12 conv_q_c052_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_13 (conv_i_src_c052_2_13 0 conv_bpf_c052_2 0) vcvs gain=5.555702330196e-01
SCONVI_c052_2_13 (conv_i_src_c052_2_13 conv_i_c052_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_13 (conv_q_src_c052_2_13 0 conv_bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_2_13 (conv_q_src_c052_2_13 conv_q_c052_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_14 (conv_i_src_c052_2_14 0 conv_bpf_c052_2 0) vcvs gain=8.314696123025e-01
SCONVI_c052_2_14 (conv_i_src_c052_2_14 conv_i_c052_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_14 (conv_q_src_c052_2_14 0 conv_bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_2_14 (conv_q_src_c052_2_14 conv_q_c052_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_2_15 (conv_i_src_c052_2_15 0 conv_bpf_c052_2 0) vcvs gain=9.807852804032e-01
SCONVI_c052_2_15 (conv_i_src_c052_2_15 conv_i_c052_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_2_15 (conv_q_src_c052_2_15 0 conv_bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_2_15 (conv_q_src_c052_2_15 conv_q_c052_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c052_2 (conv_i_c052_2 0) resistor r=1G
RCONVQ_c052_2 (conv_q_c052_2 0) resistor r=1G
RCONVINTI_c052_2 (conv_i_c052_2 ConvIcar_c052_2) resistor r=1k
CCONVINTI_c052_2 (ConvIcar_c052_2 0) capacitor c=80p
RCONVINTQ_c052_2 (conv_q_c052_2 ConvQcar_c052_2) resistor r=1k
CCONVINTQ_c052_2 (ConvQcar_c052_2 0) capacitor c=80p
save conv_bpf_c052_2 ConvIcar_c052_2 ConvQcar_c052_2

// conventional mixed baseline bl052, carrier_3: 1000000000 Hz
CCONVBPF_c052_3 (bl052 n_conv_cbpf_c052_3) capacitor c=2.533029591058e-14
LCONVBPF_c052_3 (n_conv_cbpf_c052_3 conv_bpf_c052_3) inductor l=1.000000000000e-06
RCONVBPF_c052_3 (conv_bpf_c052_3 0) resistor r=3.141592653590e+02
ECONVI_c052_3_00 (conv_i_src_c052_3_00 0 conv_bpf_c052_3 0) vcvs gain=9.807852804032e-01
SCONVI_c052_3_00 (conv_i_src_c052_3_00 conv_i_c052_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_00 (conv_q_src_c052_3_00 0 conv_bpf_c052_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_3_00 (conv_q_src_c052_3_00 conv_q_c052_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_01 (conv_i_src_c052_3_01 0 conv_bpf_c052_3 0) vcvs gain=8.314696123025e-01
SCONVI_c052_3_01 (conv_i_src_c052_3_01 conv_i_c052_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_01 (conv_q_src_c052_3_01 0 conv_bpf_c052_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_3_01 (conv_q_src_c052_3_01 conv_q_c052_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_02 (conv_i_src_c052_3_02 0 conv_bpf_c052_3 0) vcvs gain=5.555702330196e-01
SCONVI_c052_3_02 (conv_i_src_c052_3_02 conv_i_c052_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_02 (conv_q_src_c052_3_02 0 conv_bpf_c052_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_3_02 (conv_q_src_c052_3_02 conv_q_c052_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_03 (conv_i_src_c052_3_03 0 conv_bpf_c052_3 0) vcvs gain=1.950903220161e-01
SCONVI_c052_3_03 (conv_i_src_c052_3_03 conv_i_c052_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_03 (conv_q_src_c052_3_03 0 conv_bpf_c052_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c052_3_03 (conv_q_src_c052_3_03 conv_q_c052_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_04 (conv_i_src_c052_3_04 0 conv_bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_3_04 (conv_i_src_c052_3_04 conv_i_c052_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_04 (conv_q_src_c052_3_04 0 conv_bpf_c052_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c052_3_04 (conv_q_src_c052_3_04 conv_q_c052_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_05 (conv_i_src_c052_3_05 0 conv_bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_3_05 (conv_i_src_c052_3_05 conv_i_c052_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_05 (conv_q_src_c052_3_05 0 conv_bpf_c052_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c052_3_05 (conv_q_src_c052_3_05 conv_q_c052_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_06 (conv_i_src_c052_3_06 0 conv_bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_3_06 (conv_i_src_c052_3_06 conv_i_c052_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_06 (conv_q_src_c052_3_06 0 conv_bpf_c052_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c052_3_06 (conv_q_src_c052_3_06 conv_q_c052_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_07 (conv_i_src_c052_3_07 0 conv_bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_3_07 (conv_i_src_c052_3_07 conv_i_c052_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_07 (conv_q_src_c052_3_07 0 conv_bpf_c052_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c052_3_07 (conv_q_src_c052_3_07 conv_q_c052_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_08 (conv_i_src_c052_3_08 0 conv_bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c052_3_08 (conv_i_src_c052_3_08 conv_i_c052_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_08 (conv_q_src_c052_3_08 0 conv_bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_3_08 (conv_q_src_c052_3_08 conv_q_c052_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_09 (conv_i_src_c052_3_09 0 conv_bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c052_3_09 (conv_i_src_c052_3_09 conv_i_c052_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_09 (conv_q_src_c052_3_09 0 conv_bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_3_09 (conv_q_src_c052_3_09 conv_q_c052_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_10 (conv_i_src_c052_3_10 0 conv_bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c052_3_10 (conv_i_src_c052_3_10 conv_i_c052_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_10 (conv_q_src_c052_3_10 0 conv_bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_3_10 (conv_q_src_c052_3_10 conv_q_c052_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_11 (conv_i_src_c052_3_11 0 conv_bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c052_3_11 (conv_i_src_c052_3_11 conv_i_c052_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_11 (conv_q_src_c052_3_11 0 conv_bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_3_11 (conv_q_src_c052_3_11 conv_q_c052_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_12 (conv_i_src_c052_3_12 0 conv_bpf_c052_3 0) vcvs gain=1.950903220161e-01
SCONVI_c052_3_12 (conv_i_src_c052_3_12 conv_i_c052_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_12 (conv_q_src_c052_3_12 0 conv_bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c052_3_12 (conv_q_src_c052_3_12 conv_q_c052_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_13 (conv_i_src_c052_3_13 0 conv_bpf_c052_3 0) vcvs gain=5.555702330196e-01
SCONVI_c052_3_13 (conv_i_src_c052_3_13 conv_i_c052_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_13 (conv_q_src_c052_3_13 0 conv_bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c052_3_13 (conv_q_src_c052_3_13 conv_q_c052_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_14 (conv_i_src_c052_3_14 0 conv_bpf_c052_3 0) vcvs gain=8.314696123025e-01
SCONVI_c052_3_14 (conv_i_src_c052_3_14 conv_i_c052_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_14 (conv_q_src_c052_3_14 0 conv_bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c052_3_14 (conv_q_src_c052_3_14 conv_q_c052_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c052_3_15 (conv_i_src_c052_3_15 0 conv_bpf_c052_3 0) vcvs gain=9.807852804032e-01
SCONVI_c052_3_15 (conv_i_src_c052_3_15 conv_i_c052_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c052_3_15 (conv_q_src_c052_3_15 0 conv_bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c052_3_15 (conv_q_src_c052_3_15 conv_q_c052_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c052_3 (conv_i_c052_3 0) resistor r=1G
RCONVQ_c052_3 (conv_q_c052_3 0) resistor r=1G
RCONVINTI_c052_3 (conv_i_c052_3 ConvIcar_c052_3) resistor r=1k
CCONVINTI_c052_3 (ConvIcar_c052_3 0) capacitor c=80p
RCONVINTQ_c052_3 (conv_q_c052_3 ConvQcar_c052_3) resistor r=1k
CCONVINTQ_c052_3 (ConvQcar_c052_3 0) capacitor c=80p
save conv_bpf_c052_3 ConvIcar_c052_3 ConvQcar_c052_3

// conventional mixed baseline bl053, carrier_0: 250000000 Hz
CCONVBPF_c053_0 (bl053 n_conv_cbpf_c053_0) capacitor c=4.052847345694e-13
LCONVBPF_c053_0 (n_conv_cbpf_c053_0 conv_bpf_c053_0) inductor l=1.000000000000e-06
RCONVBPF_c053_0 (conv_bpf_c053_0 0) resistor r=7.853981633974e+01
ECONVI_c053_0_00 (conv_i_src_c053_0_00 0 conv_bpf_c053_0 0) vcvs gain=9.807852804032e-01
SCONVI_c053_0_00 (conv_i_src_c053_0_00 conv_i_c053_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_00 (conv_q_src_c053_0_00 0 conv_bpf_c053_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_0_00 (conv_q_src_c053_0_00 conv_q_c053_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_01 (conv_i_src_c053_0_01 0 conv_bpf_c053_0 0) vcvs gain=8.314696123025e-01
SCONVI_c053_0_01 (conv_i_src_c053_0_01 conv_i_c053_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_01 (conv_q_src_c053_0_01 0 conv_bpf_c053_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_0_01 (conv_q_src_c053_0_01 conv_q_c053_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_02 (conv_i_src_c053_0_02 0 conv_bpf_c053_0 0) vcvs gain=5.555702330196e-01
SCONVI_c053_0_02 (conv_i_src_c053_0_02 conv_i_c053_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_02 (conv_q_src_c053_0_02 0 conv_bpf_c053_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_0_02 (conv_q_src_c053_0_02 conv_q_c053_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_03 (conv_i_src_c053_0_03 0 conv_bpf_c053_0 0) vcvs gain=1.950903220161e-01
SCONVI_c053_0_03 (conv_i_src_c053_0_03 conv_i_c053_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_03 (conv_q_src_c053_0_03 0 conv_bpf_c053_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_0_03 (conv_q_src_c053_0_03 conv_q_c053_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_04 (conv_i_src_c053_0_04 0 conv_bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_0_04 (conv_i_src_c053_0_04 conv_i_c053_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_04 (conv_q_src_c053_0_04 0 conv_bpf_c053_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_0_04 (conv_q_src_c053_0_04 conv_q_c053_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_05 (conv_i_src_c053_0_05 0 conv_bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_0_05 (conv_i_src_c053_0_05 conv_i_c053_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_05 (conv_q_src_c053_0_05 0 conv_bpf_c053_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_0_05 (conv_q_src_c053_0_05 conv_q_c053_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_06 (conv_i_src_c053_0_06 0 conv_bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_0_06 (conv_i_src_c053_0_06 conv_i_c053_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_06 (conv_q_src_c053_0_06 0 conv_bpf_c053_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_0_06 (conv_q_src_c053_0_06 conv_q_c053_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_07 (conv_i_src_c053_0_07 0 conv_bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_0_07 (conv_i_src_c053_0_07 conv_i_c053_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_07 (conv_q_src_c053_0_07 0 conv_bpf_c053_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_0_07 (conv_q_src_c053_0_07 conv_q_c053_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_08 (conv_i_src_c053_0_08 0 conv_bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_0_08 (conv_i_src_c053_0_08 conv_i_c053_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_08 (conv_q_src_c053_0_08 0 conv_bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_0_08 (conv_q_src_c053_0_08 conv_q_c053_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_09 (conv_i_src_c053_0_09 0 conv_bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_0_09 (conv_i_src_c053_0_09 conv_i_c053_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_09 (conv_q_src_c053_0_09 0 conv_bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_0_09 (conv_q_src_c053_0_09 conv_q_c053_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_10 (conv_i_src_c053_0_10 0 conv_bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_0_10 (conv_i_src_c053_0_10 conv_i_c053_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_10 (conv_q_src_c053_0_10 0 conv_bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_0_10 (conv_q_src_c053_0_10 conv_q_c053_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_11 (conv_i_src_c053_0_11 0 conv_bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_0_11 (conv_i_src_c053_0_11 conv_i_c053_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_11 (conv_q_src_c053_0_11 0 conv_bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_0_11 (conv_q_src_c053_0_11 conv_q_c053_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_12 (conv_i_src_c053_0_12 0 conv_bpf_c053_0 0) vcvs gain=1.950903220161e-01
SCONVI_c053_0_12 (conv_i_src_c053_0_12 conv_i_c053_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_12 (conv_q_src_c053_0_12 0 conv_bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_0_12 (conv_q_src_c053_0_12 conv_q_c053_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_13 (conv_i_src_c053_0_13 0 conv_bpf_c053_0 0) vcvs gain=5.555702330196e-01
SCONVI_c053_0_13 (conv_i_src_c053_0_13 conv_i_c053_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_13 (conv_q_src_c053_0_13 0 conv_bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_0_13 (conv_q_src_c053_0_13 conv_q_c053_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_14 (conv_i_src_c053_0_14 0 conv_bpf_c053_0 0) vcvs gain=8.314696123025e-01
SCONVI_c053_0_14 (conv_i_src_c053_0_14 conv_i_c053_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_14 (conv_q_src_c053_0_14 0 conv_bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_0_14 (conv_q_src_c053_0_14 conv_q_c053_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_0_15 (conv_i_src_c053_0_15 0 conv_bpf_c053_0 0) vcvs gain=9.807852804032e-01
SCONVI_c053_0_15 (conv_i_src_c053_0_15 conv_i_c053_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_0_15 (conv_q_src_c053_0_15 0 conv_bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_0_15 (conv_q_src_c053_0_15 conv_q_c053_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c053_0 (conv_i_c053_0 0) resistor r=1G
RCONVQ_c053_0 (conv_q_c053_0 0) resistor r=1G
RCONVINTI_c053_0 (conv_i_c053_0 ConvIcar_c053_0) resistor r=1k
CCONVINTI_c053_0 (ConvIcar_c053_0 0) capacitor c=80p
RCONVINTQ_c053_0 (conv_q_c053_0 ConvQcar_c053_0) resistor r=1k
CCONVINTQ_c053_0 (ConvQcar_c053_0 0) capacitor c=80p
save conv_bpf_c053_0 ConvIcar_c053_0 ConvQcar_c053_0

// conventional mixed baseline bl053, carrier_1: 500000000 Hz
CCONVBPF_c053_1 (bl053 n_conv_cbpf_c053_1) capacitor c=1.013211836423e-13
LCONVBPF_c053_1 (n_conv_cbpf_c053_1 conv_bpf_c053_1) inductor l=1.000000000000e-06
RCONVBPF_c053_1 (conv_bpf_c053_1 0) resistor r=1.570796326795e+02
ECONVI_c053_1_00 (conv_i_src_c053_1_00 0 conv_bpf_c053_1 0) vcvs gain=9.807852804032e-01
SCONVI_c053_1_00 (conv_i_src_c053_1_00 conv_i_c053_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_00 (conv_q_src_c053_1_00 0 conv_bpf_c053_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_1_00 (conv_q_src_c053_1_00 conv_q_c053_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_01 (conv_i_src_c053_1_01 0 conv_bpf_c053_1 0) vcvs gain=8.314696123025e-01
SCONVI_c053_1_01 (conv_i_src_c053_1_01 conv_i_c053_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_01 (conv_q_src_c053_1_01 0 conv_bpf_c053_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_1_01 (conv_q_src_c053_1_01 conv_q_c053_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_02 (conv_i_src_c053_1_02 0 conv_bpf_c053_1 0) vcvs gain=5.555702330196e-01
SCONVI_c053_1_02 (conv_i_src_c053_1_02 conv_i_c053_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_02 (conv_q_src_c053_1_02 0 conv_bpf_c053_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_1_02 (conv_q_src_c053_1_02 conv_q_c053_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_03 (conv_i_src_c053_1_03 0 conv_bpf_c053_1 0) vcvs gain=1.950903220161e-01
SCONVI_c053_1_03 (conv_i_src_c053_1_03 conv_i_c053_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_03 (conv_q_src_c053_1_03 0 conv_bpf_c053_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_1_03 (conv_q_src_c053_1_03 conv_q_c053_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_04 (conv_i_src_c053_1_04 0 conv_bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_1_04 (conv_i_src_c053_1_04 conv_i_c053_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_04 (conv_q_src_c053_1_04 0 conv_bpf_c053_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_1_04 (conv_q_src_c053_1_04 conv_q_c053_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_05 (conv_i_src_c053_1_05 0 conv_bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_1_05 (conv_i_src_c053_1_05 conv_i_c053_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_05 (conv_q_src_c053_1_05 0 conv_bpf_c053_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_1_05 (conv_q_src_c053_1_05 conv_q_c053_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_06 (conv_i_src_c053_1_06 0 conv_bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_1_06 (conv_i_src_c053_1_06 conv_i_c053_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_06 (conv_q_src_c053_1_06 0 conv_bpf_c053_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_1_06 (conv_q_src_c053_1_06 conv_q_c053_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_07 (conv_i_src_c053_1_07 0 conv_bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_1_07 (conv_i_src_c053_1_07 conv_i_c053_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_07 (conv_q_src_c053_1_07 0 conv_bpf_c053_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_1_07 (conv_q_src_c053_1_07 conv_q_c053_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_08 (conv_i_src_c053_1_08 0 conv_bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_1_08 (conv_i_src_c053_1_08 conv_i_c053_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_08 (conv_q_src_c053_1_08 0 conv_bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_1_08 (conv_q_src_c053_1_08 conv_q_c053_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_09 (conv_i_src_c053_1_09 0 conv_bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_1_09 (conv_i_src_c053_1_09 conv_i_c053_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_09 (conv_q_src_c053_1_09 0 conv_bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_1_09 (conv_q_src_c053_1_09 conv_q_c053_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_10 (conv_i_src_c053_1_10 0 conv_bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_1_10 (conv_i_src_c053_1_10 conv_i_c053_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_10 (conv_q_src_c053_1_10 0 conv_bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_1_10 (conv_q_src_c053_1_10 conv_q_c053_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_11 (conv_i_src_c053_1_11 0 conv_bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_1_11 (conv_i_src_c053_1_11 conv_i_c053_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_11 (conv_q_src_c053_1_11 0 conv_bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_1_11 (conv_q_src_c053_1_11 conv_q_c053_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_12 (conv_i_src_c053_1_12 0 conv_bpf_c053_1 0) vcvs gain=1.950903220161e-01
SCONVI_c053_1_12 (conv_i_src_c053_1_12 conv_i_c053_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_12 (conv_q_src_c053_1_12 0 conv_bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_1_12 (conv_q_src_c053_1_12 conv_q_c053_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_13 (conv_i_src_c053_1_13 0 conv_bpf_c053_1 0) vcvs gain=5.555702330196e-01
SCONVI_c053_1_13 (conv_i_src_c053_1_13 conv_i_c053_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_13 (conv_q_src_c053_1_13 0 conv_bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_1_13 (conv_q_src_c053_1_13 conv_q_c053_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_14 (conv_i_src_c053_1_14 0 conv_bpf_c053_1 0) vcvs gain=8.314696123025e-01
SCONVI_c053_1_14 (conv_i_src_c053_1_14 conv_i_c053_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_14 (conv_q_src_c053_1_14 0 conv_bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_1_14 (conv_q_src_c053_1_14 conv_q_c053_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_1_15 (conv_i_src_c053_1_15 0 conv_bpf_c053_1 0) vcvs gain=9.807852804032e-01
SCONVI_c053_1_15 (conv_i_src_c053_1_15 conv_i_c053_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_1_15 (conv_q_src_c053_1_15 0 conv_bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_1_15 (conv_q_src_c053_1_15 conv_q_c053_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c053_1 (conv_i_c053_1 0) resistor r=1G
RCONVQ_c053_1 (conv_q_c053_1 0) resistor r=1G
RCONVINTI_c053_1 (conv_i_c053_1 ConvIcar_c053_1) resistor r=1k
CCONVINTI_c053_1 (ConvIcar_c053_1 0) capacitor c=80p
RCONVINTQ_c053_1 (conv_q_c053_1 ConvQcar_c053_1) resistor r=1k
CCONVINTQ_c053_1 (ConvQcar_c053_1 0) capacitor c=80p
save conv_bpf_c053_1 ConvIcar_c053_1 ConvQcar_c053_1

// conventional mixed baseline bl053, carrier_2: 750000000 Hz
CCONVBPF_c053_2 (bl053 n_conv_cbpf_c053_2) capacitor c=4.503163717437e-14
LCONVBPF_c053_2 (n_conv_cbpf_c053_2 conv_bpf_c053_2) inductor l=1.000000000000e-06
RCONVBPF_c053_2 (conv_bpf_c053_2 0) resistor r=2.356194490192e+02
ECONVI_c053_2_00 (conv_i_src_c053_2_00 0 conv_bpf_c053_2 0) vcvs gain=9.807852804032e-01
SCONVI_c053_2_00 (conv_i_src_c053_2_00 conv_i_c053_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_00 (conv_q_src_c053_2_00 0 conv_bpf_c053_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_2_00 (conv_q_src_c053_2_00 conv_q_c053_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_01 (conv_i_src_c053_2_01 0 conv_bpf_c053_2 0) vcvs gain=8.314696123025e-01
SCONVI_c053_2_01 (conv_i_src_c053_2_01 conv_i_c053_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_01 (conv_q_src_c053_2_01 0 conv_bpf_c053_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_2_01 (conv_q_src_c053_2_01 conv_q_c053_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_02 (conv_i_src_c053_2_02 0 conv_bpf_c053_2 0) vcvs gain=5.555702330196e-01
SCONVI_c053_2_02 (conv_i_src_c053_2_02 conv_i_c053_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_02 (conv_q_src_c053_2_02 0 conv_bpf_c053_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_2_02 (conv_q_src_c053_2_02 conv_q_c053_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_03 (conv_i_src_c053_2_03 0 conv_bpf_c053_2 0) vcvs gain=1.950903220161e-01
SCONVI_c053_2_03 (conv_i_src_c053_2_03 conv_i_c053_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_03 (conv_q_src_c053_2_03 0 conv_bpf_c053_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_2_03 (conv_q_src_c053_2_03 conv_q_c053_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_04 (conv_i_src_c053_2_04 0 conv_bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_2_04 (conv_i_src_c053_2_04 conv_i_c053_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_04 (conv_q_src_c053_2_04 0 conv_bpf_c053_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_2_04 (conv_q_src_c053_2_04 conv_q_c053_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_05 (conv_i_src_c053_2_05 0 conv_bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_2_05 (conv_i_src_c053_2_05 conv_i_c053_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_05 (conv_q_src_c053_2_05 0 conv_bpf_c053_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_2_05 (conv_q_src_c053_2_05 conv_q_c053_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_06 (conv_i_src_c053_2_06 0 conv_bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_2_06 (conv_i_src_c053_2_06 conv_i_c053_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_06 (conv_q_src_c053_2_06 0 conv_bpf_c053_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_2_06 (conv_q_src_c053_2_06 conv_q_c053_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_07 (conv_i_src_c053_2_07 0 conv_bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_2_07 (conv_i_src_c053_2_07 conv_i_c053_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_07 (conv_q_src_c053_2_07 0 conv_bpf_c053_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_2_07 (conv_q_src_c053_2_07 conv_q_c053_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_08 (conv_i_src_c053_2_08 0 conv_bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_2_08 (conv_i_src_c053_2_08 conv_i_c053_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_08 (conv_q_src_c053_2_08 0 conv_bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_2_08 (conv_q_src_c053_2_08 conv_q_c053_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_09 (conv_i_src_c053_2_09 0 conv_bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_2_09 (conv_i_src_c053_2_09 conv_i_c053_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_09 (conv_q_src_c053_2_09 0 conv_bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_2_09 (conv_q_src_c053_2_09 conv_q_c053_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_10 (conv_i_src_c053_2_10 0 conv_bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_2_10 (conv_i_src_c053_2_10 conv_i_c053_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_10 (conv_q_src_c053_2_10 0 conv_bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_2_10 (conv_q_src_c053_2_10 conv_q_c053_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_11 (conv_i_src_c053_2_11 0 conv_bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_2_11 (conv_i_src_c053_2_11 conv_i_c053_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_11 (conv_q_src_c053_2_11 0 conv_bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_2_11 (conv_q_src_c053_2_11 conv_q_c053_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_12 (conv_i_src_c053_2_12 0 conv_bpf_c053_2 0) vcvs gain=1.950903220161e-01
SCONVI_c053_2_12 (conv_i_src_c053_2_12 conv_i_c053_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_12 (conv_q_src_c053_2_12 0 conv_bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_2_12 (conv_q_src_c053_2_12 conv_q_c053_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_13 (conv_i_src_c053_2_13 0 conv_bpf_c053_2 0) vcvs gain=5.555702330196e-01
SCONVI_c053_2_13 (conv_i_src_c053_2_13 conv_i_c053_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_13 (conv_q_src_c053_2_13 0 conv_bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_2_13 (conv_q_src_c053_2_13 conv_q_c053_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_14 (conv_i_src_c053_2_14 0 conv_bpf_c053_2 0) vcvs gain=8.314696123025e-01
SCONVI_c053_2_14 (conv_i_src_c053_2_14 conv_i_c053_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_14 (conv_q_src_c053_2_14 0 conv_bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_2_14 (conv_q_src_c053_2_14 conv_q_c053_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_2_15 (conv_i_src_c053_2_15 0 conv_bpf_c053_2 0) vcvs gain=9.807852804032e-01
SCONVI_c053_2_15 (conv_i_src_c053_2_15 conv_i_c053_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_2_15 (conv_q_src_c053_2_15 0 conv_bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_2_15 (conv_q_src_c053_2_15 conv_q_c053_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c053_2 (conv_i_c053_2 0) resistor r=1G
RCONVQ_c053_2 (conv_q_c053_2 0) resistor r=1G
RCONVINTI_c053_2 (conv_i_c053_2 ConvIcar_c053_2) resistor r=1k
CCONVINTI_c053_2 (ConvIcar_c053_2 0) capacitor c=80p
RCONVINTQ_c053_2 (conv_q_c053_2 ConvQcar_c053_2) resistor r=1k
CCONVINTQ_c053_2 (ConvQcar_c053_2 0) capacitor c=80p
save conv_bpf_c053_2 ConvIcar_c053_2 ConvQcar_c053_2

// conventional mixed baseline bl053, carrier_3: 1000000000 Hz
CCONVBPF_c053_3 (bl053 n_conv_cbpf_c053_3) capacitor c=2.533029591058e-14
LCONVBPF_c053_3 (n_conv_cbpf_c053_3 conv_bpf_c053_3) inductor l=1.000000000000e-06
RCONVBPF_c053_3 (conv_bpf_c053_3 0) resistor r=3.141592653590e+02
ECONVI_c053_3_00 (conv_i_src_c053_3_00 0 conv_bpf_c053_3 0) vcvs gain=9.807852804032e-01
SCONVI_c053_3_00 (conv_i_src_c053_3_00 conv_i_c053_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_00 (conv_q_src_c053_3_00 0 conv_bpf_c053_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_3_00 (conv_q_src_c053_3_00 conv_q_c053_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_01 (conv_i_src_c053_3_01 0 conv_bpf_c053_3 0) vcvs gain=8.314696123025e-01
SCONVI_c053_3_01 (conv_i_src_c053_3_01 conv_i_c053_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_01 (conv_q_src_c053_3_01 0 conv_bpf_c053_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_3_01 (conv_q_src_c053_3_01 conv_q_c053_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_02 (conv_i_src_c053_3_02 0 conv_bpf_c053_3 0) vcvs gain=5.555702330196e-01
SCONVI_c053_3_02 (conv_i_src_c053_3_02 conv_i_c053_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_02 (conv_q_src_c053_3_02 0 conv_bpf_c053_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_3_02 (conv_q_src_c053_3_02 conv_q_c053_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_03 (conv_i_src_c053_3_03 0 conv_bpf_c053_3 0) vcvs gain=1.950903220161e-01
SCONVI_c053_3_03 (conv_i_src_c053_3_03 conv_i_c053_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_03 (conv_q_src_c053_3_03 0 conv_bpf_c053_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_3_03 (conv_q_src_c053_3_03 conv_q_c053_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_04 (conv_i_src_c053_3_04 0 conv_bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_3_04 (conv_i_src_c053_3_04 conv_i_c053_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_04 (conv_q_src_c053_3_04 0 conv_bpf_c053_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c053_3_04 (conv_q_src_c053_3_04 conv_q_c053_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_05 (conv_i_src_c053_3_05 0 conv_bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_3_05 (conv_i_src_c053_3_05 conv_i_c053_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_05 (conv_q_src_c053_3_05 0 conv_bpf_c053_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c053_3_05 (conv_q_src_c053_3_05 conv_q_c053_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_06 (conv_i_src_c053_3_06 0 conv_bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_3_06 (conv_i_src_c053_3_06 conv_i_c053_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_06 (conv_q_src_c053_3_06 0 conv_bpf_c053_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c053_3_06 (conv_q_src_c053_3_06 conv_q_c053_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_07 (conv_i_src_c053_3_07 0 conv_bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_3_07 (conv_i_src_c053_3_07 conv_i_c053_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_07 (conv_q_src_c053_3_07 0 conv_bpf_c053_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c053_3_07 (conv_q_src_c053_3_07 conv_q_c053_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_08 (conv_i_src_c053_3_08 0 conv_bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c053_3_08 (conv_i_src_c053_3_08 conv_i_c053_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_08 (conv_q_src_c053_3_08 0 conv_bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_3_08 (conv_q_src_c053_3_08 conv_q_c053_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_09 (conv_i_src_c053_3_09 0 conv_bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c053_3_09 (conv_i_src_c053_3_09 conv_i_c053_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_09 (conv_q_src_c053_3_09 0 conv_bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_3_09 (conv_q_src_c053_3_09 conv_q_c053_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_10 (conv_i_src_c053_3_10 0 conv_bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c053_3_10 (conv_i_src_c053_3_10 conv_i_c053_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_10 (conv_q_src_c053_3_10 0 conv_bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_3_10 (conv_q_src_c053_3_10 conv_q_c053_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_11 (conv_i_src_c053_3_11 0 conv_bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c053_3_11 (conv_i_src_c053_3_11 conv_i_c053_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_11 (conv_q_src_c053_3_11 0 conv_bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_3_11 (conv_q_src_c053_3_11 conv_q_c053_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_12 (conv_i_src_c053_3_12 0 conv_bpf_c053_3 0) vcvs gain=1.950903220161e-01
SCONVI_c053_3_12 (conv_i_src_c053_3_12 conv_i_c053_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_12 (conv_q_src_c053_3_12 0 conv_bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c053_3_12 (conv_q_src_c053_3_12 conv_q_c053_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_13 (conv_i_src_c053_3_13 0 conv_bpf_c053_3 0) vcvs gain=5.555702330196e-01
SCONVI_c053_3_13 (conv_i_src_c053_3_13 conv_i_c053_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_13 (conv_q_src_c053_3_13 0 conv_bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c053_3_13 (conv_q_src_c053_3_13 conv_q_c053_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_14 (conv_i_src_c053_3_14 0 conv_bpf_c053_3 0) vcvs gain=8.314696123025e-01
SCONVI_c053_3_14 (conv_i_src_c053_3_14 conv_i_c053_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_14 (conv_q_src_c053_3_14 0 conv_bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c053_3_14 (conv_q_src_c053_3_14 conv_q_c053_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c053_3_15 (conv_i_src_c053_3_15 0 conv_bpf_c053_3 0) vcvs gain=9.807852804032e-01
SCONVI_c053_3_15 (conv_i_src_c053_3_15 conv_i_c053_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c053_3_15 (conv_q_src_c053_3_15 0 conv_bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c053_3_15 (conv_q_src_c053_3_15 conv_q_c053_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c053_3 (conv_i_c053_3 0) resistor r=1G
RCONVQ_c053_3 (conv_q_c053_3 0) resistor r=1G
RCONVINTI_c053_3 (conv_i_c053_3 ConvIcar_c053_3) resistor r=1k
CCONVINTI_c053_3 (ConvIcar_c053_3 0) capacitor c=80p
RCONVINTQ_c053_3 (conv_q_c053_3 ConvQcar_c053_3) resistor r=1k
CCONVINTQ_c053_3 (ConvQcar_c053_3 0) capacitor c=80p
save conv_bpf_c053_3 ConvIcar_c053_3 ConvQcar_c053_3

// conventional mixed baseline bl054, carrier_0: 250000000 Hz
CCONVBPF_c054_0 (bl054 n_conv_cbpf_c054_0) capacitor c=4.052847345694e-13
LCONVBPF_c054_0 (n_conv_cbpf_c054_0 conv_bpf_c054_0) inductor l=1.000000000000e-06
RCONVBPF_c054_0 (conv_bpf_c054_0 0) resistor r=7.853981633974e+01
ECONVI_c054_0_00 (conv_i_src_c054_0_00 0 conv_bpf_c054_0 0) vcvs gain=9.807852804032e-01
SCONVI_c054_0_00 (conv_i_src_c054_0_00 conv_i_c054_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_00 (conv_q_src_c054_0_00 0 conv_bpf_c054_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_0_00 (conv_q_src_c054_0_00 conv_q_c054_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_01 (conv_i_src_c054_0_01 0 conv_bpf_c054_0 0) vcvs gain=8.314696123025e-01
SCONVI_c054_0_01 (conv_i_src_c054_0_01 conv_i_c054_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_01 (conv_q_src_c054_0_01 0 conv_bpf_c054_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_0_01 (conv_q_src_c054_0_01 conv_q_c054_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_02 (conv_i_src_c054_0_02 0 conv_bpf_c054_0 0) vcvs gain=5.555702330196e-01
SCONVI_c054_0_02 (conv_i_src_c054_0_02 conv_i_c054_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_02 (conv_q_src_c054_0_02 0 conv_bpf_c054_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_0_02 (conv_q_src_c054_0_02 conv_q_c054_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_03 (conv_i_src_c054_0_03 0 conv_bpf_c054_0 0) vcvs gain=1.950903220161e-01
SCONVI_c054_0_03 (conv_i_src_c054_0_03 conv_i_c054_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_03 (conv_q_src_c054_0_03 0 conv_bpf_c054_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_0_03 (conv_q_src_c054_0_03 conv_q_c054_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_04 (conv_i_src_c054_0_04 0 conv_bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_0_04 (conv_i_src_c054_0_04 conv_i_c054_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_04 (conv_q_src_c054_0_04 0 conv_bpf_c054_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_0_04 (conv_q_src_c054_0_04 conv_q_c054_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_05 (conv_i_src_c054_0_05 0 conv_bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_0_05 (conv_i_src_c054_0_05 conv_i_c054_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_05 (conv_q_src_c054_0_05 0 conv_bpf_c054_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_0_05 (conv_q_src_c054_0_05 conv_q_c054_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_06 (conv_i_src_c054_0_06 0 conv_bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_0_06 (conv_i_src_c054_0_06 conv_i_c054_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_06 (conv_q_src_c054_0_06 0 conv_bpf_c054_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_0_06 (conv_q_src_c054_0_06 conv_q_c054_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_07 (conv_i_src_c054_0_07 0 conv_bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_0_07 (conv_i_src_c054_0_07 conv_i_c054_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_07 (conv_q_src_c054_0_07 0 conv_bpf_c054_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_0_07 (conv_q_src_c054_0_07 conv_q_c054_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_08 (conv_i_src_c054_0_08 0 conv_bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_0_08 (conv_i_src_c054_0_08 conv_i_c054_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_08 (conv_q_src_c054_0_08 0 conv_bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_0_08 (conv_q_src_c054_0_08 conv_q_c054_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_09 (conv_i_src_c054_0_09 0 conv_bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_0_09 (conv_i_src_c054_0_09 conv_i_c054_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_09 (conv_q_src_c054_0_09 0 conv_bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_0_09 (conv_q_src_c054_0_09 conv_q_c054_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_10 (conv_i_src_c054_0_10 0 conv_bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_0_10 (conv_i_src_c054_0_10 conv_i_c054_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_10 (conv_q_src_c054_0_10 0 conv_bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_0_10 (conv_q_src_c054_0_10 conv_q_c054_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_11 (conv_i_src_c054_0_11 0 conv_bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_0_11 (conv_i_src_c054_0_11 conv_i_c054_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_11 (conv_q_src_c054_0_11 0 conv_bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_0_11 (conv_q_src_c054_0_11 conv_q_c054_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_12 (conv_i_src_c054_0_12 0 conv_bpf_c054_0 0) vcvs gain=1.950903220161e-01
SCONVI_c054_0_12 (conv_i_src_c054_0_12 conv_i_c054_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_12 (conv_q_src_c054_0_12 0 conv_bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_0_12 (conv_q_src_c054_0_12 conv_q_c054_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_13 (conv_i_src_c054_0_13 0 conv_bpf_c054_0 0) vcvs gain=5.555702330196e-01
SCONVI_c054_0_13 (conv_i_src_c054_0_13 conv_i_c054_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_13 (conv_q_src_c054_0_13 0 conv_bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_0_13 (conv_q_src_c054_0_13 conv_q_c054_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_14 (conv_i_src_c054_0_14 0 conv_bpf_c054_0 0) vcvs gain=8.314696123025e-01
SCONVI_c054_0_14 (conv_i_src_c054_0_14 conv_i_c054_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_14 (conv_q_src_c054_0_14 0 conv_bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_0_14 (conv_q_src_c054_0_14 conv_q_c054_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_0_15 (conv_i_src_c054_0_15 0 conv_bpf_c054_0 0) vcvs gain=9.807852804032e-01
SCONVI_c054_0_15 (conv_i_src_c054_0_15 conv_i_c054_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_0_15 (conv_q_src_c054_0_15 0 conv_bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_0_15 (conv_q_src_c054_0_15 conv_q_c054_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c054_0 (conv_i_c054_0 0) resistor r=1G
RCONVQ_c054_0 (conv_q_c054_0 0) resistor r=1G
RCONVINTI_c054_0 (conv_i_c054_0 ConvIcar_c054_0) resistor r=1k
CCONVINTI_c054_0 (ConvIcar_c054_0 0) capacitor c=80p
RCONVINTQ_c054_0 (conv_q_c054_0 ConvQcar_c054_0) resistor r=1k
CCONVINTQ_c054_0 (ConvQcar_c054_0 0) capacitor c=80p
save conv_bpf_c054_0 ConvIcar_c054_0 ConvQcar_c054_0

// conventional mixed baseline bl054, carrier_1: 500000000 Hz
CCONVBPF_c054_1 (bl054 n_conv_cbpf_c054_1) capacitor c=1.013211836423e-13
LCONVBPF_c054_1 (n_conv_cbpf_c054_1 conv_bpf_c054_1) inductor l=1.000000000000e-06
RCONVBPF_c054_1 (conv_bpf_c054_1 0) resistor r=1.570796326795e+02
ECONVI_c054_1_00 (conv_i_src_c054_1_00 0 conv_bpf_c054_1 0) vcvs gain=9.807852804032e-01
SCONVI_c054_1_00 (conv_i_src_c054_1_00 conv_i_c054_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_00 (conv_q_src_c054_1_00 0 conv_bpf_c054_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_1_00 (conv_q_src_c054_1_00 conv_q_c054_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_01 (conv_i_src_c054_1_01 0 conv_bpf_c054_1 0) vcvs gain=8.314696123025e-01
SCONVI_c054_1_01 (conv_i_src_c054_1_01 conv_i_c054_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_01 (conv_q_src_c054_1_01 0 conv_bpf_c054_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_1_01 (conv_q_src_c054_1_01 conv_q_c054_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_02 (conv_i_src_c054_1_02 0 conv_bpf_c054_1 0) vcvs gain=5.555702330196e-01
SCONVI_c054_1_02 (conv_i_src_c054_1_02 conv_i_c054_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_02 (conv_q_src_c054_1_02 0 conv_bpf_c054_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_1_02 (conv_q_src_c054_1_02 conv_q_c054_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_03 (conv_i_src_c054_1_03 0 conv_bpf_c054_1 0) vcvs gain=1.950903220161e-01
SCONVI_c054_1_03 (conv_i_src_c054_1_03 conv_i_c054_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_03 (conv_q_src_c054_1_03 0 conv_bpf_c054_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_1_03 (conv_q_src_c054_1_03 conv_q_c054_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_04 (conv_i_src_c054_1_04 0 conv_bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_1_04 (conv_i_src_c054_1_04 conv_i_c054_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_04 (conv_q_src_c054_1_04 0 conv_bpf_c054_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_1_04 (conv_q_src_c054_1_04 conv_q_c054_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_05 (conv_i_src_c054_1_05 0 conv_bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_1_05 (conv_i_src_c054_1_05 conv_i_c054_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_05 (conv_q_src_c054_1_05 0 conv_bpf_c054_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_1_05 (conv_q_src_c054_1_05 conv_q_c054_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_06 (conv_i_src_c054_1_06 0 conv_bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_1_06 (conv_i_src_c054_1_06 conv_i_c054_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_06 (conv_q_src_c054_1_06 0 conv_bpf_c054_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_1_06 (conv_q_src_c054_1_06 conv_q_c054_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_07 (conv_i_src_c054_1_07 0 conv_bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_1_07 (conv_i_src_c054_1_07 conv_i_c054_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_07 (conv_q_src_c054_1_07 0 conv_bpf_c054_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_1_07 (conv_q_src_c054_1_07 conv_q_c054_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_08 (conv_i_src_c054_1_08 0 conv_bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_1_08 (conv_i_src_c054_1_08 conv_i_c054_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_08 (conv_q_src_c054_1_08 0 conv_bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_1_08 (conv_q_src_c054_1_08 conv_q_c054_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_09 (conv_i_src_c054_1_09 0 conv_bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_1_09 (conv_i_src_c054_1_09 conv_i_c054_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_09 (conv_q_src_c054_1_09 0 conv_bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_1_09 (conv_q_src_c054_1_09 conv_q_c054_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_10 (conv_i_src_c054_1_10 0 conv_bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_1_10 (conv_i_src_c054_1_10 conv_i_c054_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_10 (conv_q_src_c054_1_10 0 conv_bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_1_10 (conv_q_src_c054_1_10 conv_q_c054_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_11 (conv_i_src_c054_1_11 0 conv_bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_1_11 (conv_i_src_c054_1_11 conv_i_c054_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_11 (conv_q_src_c054_1_11 0 conv_bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_1_11 (conv_q_src_c054_1_11 conv_q_c054_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_12 (conv_i_src_c054_1_12 0 conv_bpf_c054_1 0) vcvs gain=1.950903220161e-01
SCONVI_c054_1_12 (conv_i_src_c054_1_12 conv_i_c054_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_12 (conv_q_src_c054_1_12 0 conv_bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_1_12 (conv_q_src_c054_1_12 conv_q_c054_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_13 (conv_i_src_c054_1_13 0 conv_bpf_c054_1 0) vcvs gain=5.555702330196e-01
SCONVI_c054_1_13 (conv_i_src_c054_1_13 conv_i_c054_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_13 (conv_q_src_c054_1_13 0 conv_bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_1_13 (conv_q_src_c054_1_13 conv_q_c054_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_14 (conv_i_src_c054_1_14 0 conv_bpf_c054_1 0) vcvs gain=8.314696123025e-01
SCONVI_c054_1_14 (conv_i_src_c054_1_14 conv_i_c054_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_14 (conv_q_src_c054_1_14 0 conv_bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_1_14 (conv_q_src_c054_1_14 conv_q_c054_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_1_15 (conv_i_src_c054_1_15 0 conv_bpf_c054_1 0) vcvs gain=9.807852804032e-01
SCONVI_c054_1_15 (conv_i_src_c054_1_15 conv_i_c054_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_1_15 (conv_q_src_c054_1_15 0 conv_bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_1_15 (conv_q_src_c054_1_15 conv_q_c054_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c054_1 (conv_i_c054_1 0) resistor r=1G
RCONVQ_c054_1 (conv_q_c054_1 0) resistor r=1G
RCONVINTI_c054_1 (conv_i_c054_1 ConvIcar_c054_1) resistor r=1k
CCONVINTI_c054_1 (ConvIcar_c054_1 0) capacitor c=80p
RCONVINTQ_c054_1 (conv_q_c054_1 ConvQcar_c054_1) resistor r=1k
CCONVINTQ_c054_1 (ConvQcar_c054_1 0) capacitor c=80p
save conv_bpf_c054_1 ConvIcar_c054_1 ConvQcar_c054_1

// conventional mixed baseline bl054, carrier_2: 750000000 Hz
CCONVBPF_c054_2 (bl054 n_conv_cbpf_c054_2) capacitor c=4.503163717437e-14
LCONVBPF_c054_2 (n_conv_cbpf_c054_2 conv_bpf_c054_2) inductor l=1.000000000000e-06
RCONVBPF_c054_2 (conv_bpf_c054_2 0) resistor r=2.356194490192e+02
ECONVI_c054_2_00 (conv_i_src_c054_2_00 0 conv_bpf_c054_2 0) vcvs gain=9.807852804032e-01
SCONVI_c054_2_00 (conv_i_src_c054_2_00 conv_i_c054_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_00 (conv_q_src_c054_2_00 0 conv_bpf_c054_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_2_00 (conv_q_src_c054_2_00 conv_q_c054_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_01 (conv_i_src_c054_2_01 0 conv_bpf_c054_2 0) vcvs gain=8.314696123025e-01
SCONVI_c054_2_01 (conv_i_src_c054_2_01 conv_i_c054_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_01 (conv_q_src_c054_2_01 0 conv_bpf_c054_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_2_01 (conv_q_src_c054_2_01 conv_q_c054_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_02 (conv_i_src_c054_2_02 0 conv_bpf_c054_2 0) vcvs gain=5.555702330196e-01
SCONVI_c054_2_02 (conv_i_src_c054_2_02 conv_i_c054_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_02 (conv_q_src_c054_2_02 0 conv_bpf_c054_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_2_02 (conv_q_src_c054_2_02 conv_q_c054_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_03 (conv_i_src_c054_2_03 0 conv_bpf_c054_2 0) vcvs gain=1.950903220161e-01
SCONVI_c054_2_03 (conv_i_src_c054_2_03 conv_i_c054_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_03 (conv_q_src_c054_2_03 0 conv_bpf_c054_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_2_03 (conv_q_src_c054_2_03 conv_q_c054_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_04 (conv_i_src_c054_2_04 0 conv_bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_2_04 (conv_i_src_c054_2_04 conv_i_c054_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_04 (conv_q_src_c054_2_04 0 conv_bpf_c054_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_2_04 (conv_q_src_c054_2_04 conv_q_c054_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_05 (conv_i_src_c054_2_05 0 conv_bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_2_05 (conv_i_src_c054_2_05 conv_i_c054_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_05 (conv_q_src_c054_2_05 0 conv_bpf_c054_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_2_05 (conv_q_src_c054_2_05 conv_q_c054_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_06 (conv_i_src_c054_2_06 0 conv_bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_2_06 (conv_i_src_c054_2_06 conv_i_c054_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_06 (conv_q_src_c054_2_06 0 conv_bpf_c054_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_2_06 (conv_q_src_c054_2_06 conv_q_c054_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_07 (conv_i_src_c054_2_07 0 conv_bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_2_07 (conv_i_src_c054_2_07 conv_i_c054_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_07 (conv_q_src_c054_2_07 0 conv_bpf_c054_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_2_07 (conv_q_src_c054_2_07 conv_q_c054_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_08 (conv_i_src_c054_2_08 0 conv_bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_2_08 (conv_i_src_c054_2_08 conv_i_c054_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_08 (conv_q_src_c054_2_08 0 conv_bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_2_08 (conv_q_src_c054_2_08 conv_q_c054_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_09 (conv_i_src_c054_2_09 0 conv_bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_2_09 (conv_i_src_c054_2_09 conv_i_c054_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_09 (conv_q_src_c054_2_09 0 conv_bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_2_09 (conv_q_src_c054_2_09 conv_q_c054_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_10 (conv_i_src_c054_2_10 0 conv_bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_2_10 (conv_i_src_c054_2_10 conv_i_c054_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_10 (conv_q_src_c054_2_10 0 conv_bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_2_10 (conv_q_src_c054_2_10 conv_q_c054_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_11 (conv_i_src_c054_2_11 0 conv_bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_2_11 (conv_i_src_c054_2_11 conv_i_c054_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_11 (conv_q_src_c054_2_11 0 conv_bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_2_11 (conv_q_src_c054_2_11 conv_q_c054_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_12 (conv_i_src_c054_2_12 0 conv_bpf_c054_2 0) vcvs gain=1.950903220161e-01
SCONVI_c054_2_12 (conv_i_src_c054_2_12 conv_i_c054_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_12 (conv_q_src_c054_2_12 0 conv_bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_2_12 (conv_q_src_c054_2_12 conv_q_c054_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_13 (conv_i_src_c054_2_13 0 conv_bpf_c054_2 0) vcvs gain=5.555702330196e-01
SCONVI_c054_2_13 (conv_i_src_c054_2_13 conv_i_c054_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_13 (conv_q_src_c054_2_13 0 conv_bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_2_13 (conv_q_src_c054_2_13 conv_q_c054_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_14 (conv_i_src_c054_2_14 0 conv_bpf_c054_2 0) vcvs gain=8.314696123025e-01
SCONVI_c054_2_14 (conv_i_src_c054_2_14 conv_i_c054_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_14 (conv_q_src_c054_2_14 0 conv_bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_2_14 (conv_q_src_c054_2_14 conv_q_c054_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_2_15 (conv_i_src_c054_2_15 0 conv_bpf_c054_2 0) vcvs gain=9.807852804032e-01
SCONVI_c054_2_15 (conv_i_src_c054_2_15 conv_i_c054_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_2_15 (conv_q_src_c054_2_15 0 conv_bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_2_15 (conv_q_src_c054_2_15 conv_q_c054_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c054_2 (conv_i_c054_2 0) resistor r=1G
RCONVQ_c054_2 (conv_q_c054_2 0) resistor r=1G
RCONVINTI_c054_2 (conv_i_c054_2 ConvIcar_c054_2) resistor r=1k
CCONVINTI_c054_2 (ConvIcar_c054_2 0) capacitor c=80p
RCONVINTQ_c054_2 (conv_q_c054_2 ConvQcar_c054_2) resistor r=1k
CCONVINTQ_c054_2 (ConvQcar_c054_2 0) capacitor c=80p
save conv_bpf_c054_2 ConvIcar_c054_2 ConvQcar_c054_2

// conventional mixed baseline bl054, carrier_3: 1000000000 Hz
CCONVBPF_c054_3 (bl054 n_conv_cbpf_c054_3) capacitor c=2.533029591058e-14
LCONVBPF_c054_3 (n_conv_cbpf_c054_3 conv_bpf_c054_3) inductor l=1.000000000000e-06
RCONVBPF_c054_3 (conv_bpf_c054_3 0) resistor r=3.141592653590e+02
ECONVI_c054_3_00 (conv_i_src_c054_3_00 0 conv_bpf_c054_3 0) vcvs gain=9.807852804032e-01
SCONVI_c054_3_00 (conv_i_src_c054_3_00 conv_i_c054_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_00 (conv_q_src_c054_3_00 0 conv_bpf_c054_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_3_00 (conv_q_src_c054_3_00 conv_q_c054_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_01 (conv_i_src_c054_3_01 0 conv_bpf_c054_3 0) vcvs gain=8.314696123025e-01
SCONVI_c054_3_01 (conv_i_src_c054_3_01 conv_i_c054_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_01 (conv_q_src_c054_3_01 0 conv_bpf_c054_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_3_01 (conv_q_src_c054_3_01 conv_q_c054_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_02 (conv_i_src_c054_3_02 0 conv_bpf_c054_3 0) vcvs gain=5.555702330196e-01
SCONVI_c054_3_02 (conv_i_src_c054_3_02 conv_i_c054_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_02 (conv_q_src_c054_3_02 0 conv_bpf_c054_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_3_02 (conv_q_src_c054_3_02 conv_q_c054_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_03 (conv_i_src_c054_3_03 0 conv_bpf_c054_3 0) vcvs gain=1.950903220161e-01
SCONVI_c054_3_03 (conv_i_src_c054_3_03 conv_i_c054_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_03 (conv_q_src_c054_3_03 0 conv_bpf_c054_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_3_03 (conv_q_src_c054_3_03 conv_q_c054_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_04 (conv_i_src_c054_3_04 0 conv_bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_3_04 (conv_i_src_c054_3_04 conv_i_c054_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_04 (conv_q_src_c054_3_04 0 conv_bpf_c054_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c054_3_04 (conv_q_src_c054_3_04 conv_q_c054_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_05 (conv_i_src_c054_3_05 0 conv_bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_3_05 (conv_i_src_c054_3_05 conv_i_c054_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_05 (conv_q_src_c054_3_05 0 conv_bpf_c054_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c054_3_05 (conv_q_src_c054_3_05 conv_q_c054_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_06 (conv_i_src_c054_3_06 0 conv_bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_3_06 (conv_i_src_c054_3_06 conv_i_c054_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_06 (conv_q_src_c054_3_06 0 conv_bpf_c054_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c054_3_06 (conv_q_src_c054_3_06 conv_q_c054_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_07 (conv_i_src_c054_3_07 0 conv_bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_3_07 (conv_i_src_c054_3_07 conv_i_c054_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_07 (conv_q_src_c054_3_07 0 conv_bpf_c054_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c054_3_07 (conv_q_src_c054_3_07 conv_q_c054_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_08 (conv_i_src_c054_3_08 0 conv_bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c054_3_08 (conv_i_src_c054_3_08 conv_i_c054_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_08 (conv_q_src_c054_3_08 0 conv_bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_3_08 (conv_q_src_c054_3_08 conv_q_c054_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_09 (conv_i_src_c054_3_09 0 conv_bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c054_3_09 (conv_i_src_c054_3_09 conv_i_c054_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_09 (conv_q_src_c054_3_09 0 conv_bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_3_09 (conv_q_src_c054_3_09 conv_q_c054_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_10 (conv_i_src_c054_3_10 0 conv_bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c054_3_10 (conv_i_src_c054_3_10 conv_i_c054_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_10 (conv_q_src_c054_3_10 0 conv_bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_3_10 (conv_q_src_c054_3_10 conv_q_c054_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_11 (conv_i_src_c054_3_11 0 conv_bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c054_3_11 (conv_i_src_c054_3_11 conv_i_c054_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_11 (conv_q_src_c054_3_11 0 conv_bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_3_11 (conv_q_src_c054_3_11 conv_q_c054_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_12 (conv_i_src_c054_3_12 0 conv_bpf_c054_3 0) vcvs gain=1.950903220161e-01
SCONVI_c054_3_12 (conv_i_src_c054_3_12 conv_i_c054_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_12 (conv_q_src_c054_3_12 0 conv_bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c054_3_12 (conv_q_src_c054_3_12 conv_q_c054_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_13 (conv_i_src_c054_3_13 0 conv_bpf_c054_3 0) vcvs gain=5.555702330196e-01
SCONVI_c054_3_13 (conv_i_src_c054_3_13 conv_i_c054_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_13 (conv_q_src_c054_3_13 0 conv_bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c054_3_13 (conv_q_src_c054_3_13 conv_q_c054_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_14 (conv_i_src_c054_3_14 0 conv_bpf_c054_3 0) vcvs gain=8.314696123025e-01
SCONVI_c054_3_14 (conv_i_src_c054_3_14 conv_i_c054_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_14 (conv_q_src_c054_3_14 0 conv_bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c054_3_14 (conv_q_src_c054_3_14 conv_q_c054_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c054_3_15 (conv_i_src_c054_3_15 0 conv_bpf_c054_3 0) vcvs gain=9.807852804032e-01
SCONVI_c054_3_15 (conv_i_src_c054_3_15 conv_i_c054_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c054_3_15 (conv_q_src_c054_3_15 0 conv_bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c054_3_15 (conv_q_src_c054_3_15 conv_q_c054_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c054_3 (conv_i_c054_3 0) resistor r=1G
RCONVQ_c054_3 (conv_q_c054_3 0) resistor r=1G
RCONVINTI_c054_3 (conv_i_c054_3 ConvIcar_c054_3) resistor r=1k
CCONVINTI_c054_3 (ConvIcar_c054_3 0) capacitor c=80p
RCONVINTQ_c054_3 (conv_q_c054_3 ConvQcar_c054_3) resistor r=1k
CCONVINTQ_c054_3 (ConvQcar_c054_3 0) capacitor c=80p
save conv_bpf_c054_3 ConvIcar_c054_3 ConvQcar_c054_3

// conventional mixed baseline bl055, carrier_0: 250000000 Hz
CCONVBPF_c055_0 (bl055 n_conv_cbpf_c055_0) capacitor c=4.052847345694e-13
LCONVBPF_c055_0 (n_conv_cbpf_c055_0 conv_bpf_c055_0) inductor l=1.000000000000e-06
RCONVBPF_c055_0 (conv_bpf_c055_0 0) resistor r=7.853981633974e+01
ECONVI_c055_0_00 (conv_i_src_c055_0_00 0 conv_bpf_c055_0 0) vcvs gain=9.807852804032e-01
SCONVI_c055_0_00 (conv_i_src_c055_0_00 conv_i_c055_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_00 (conv_q_src_c055_0_00 0 conv_bpf_c055_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_0_00 (conv_q_src_c055_0_00 conv_q_c055_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_01 (conv_i_src_c055_0_01 0 conv_bpf_c055_0 0) vcvs gain=8.314696123025e-01
SCONVI_c055_0_01 (conv_i_src_c055_0_01 conv_i_c055_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_01 (conv_q_src_c055_0_01 0 conv_bpf_c055_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_0_01 (conv_q_src_c055_0_01 conv_q_c055_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_02 (conv_i_src_c055_0_02 0 conv_bpf_c055_0 0) vcvs gain=5.555702330196e-01
SCONVI_c055_0_02 (conv_i_src_c055_0_02 conv_i_c055_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_02 (conv_q_src_c055_0_02 0 conv_bpf_c055_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_0_02 (conv_q_src_c055_0_02 conv_q_c055_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_03 (conv_i_src_c055_0_03 0 conv_bpf_c055_0 0) vcvs gain=1.950903220161e-01
SCONVI_c055_0_03 (conv_i_src_c055_0_03 conv_i_c055_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_03 (conv_q_src_c055_0_03 0 conv_bpf_c055_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_0_03 (conv_q_src_c055_0_03 conv_q_c055_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_04 (conv_i_src_c055_0_04 0 conv_bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_0_04 (conv_i_src_c055_0_04 conv_i_c055_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_04 (conv_q_src_c055_0_04 0 conv_bpf_c055_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_0_04 (conv_q_src_c055_0_04 conv_q_c055_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_05 (conv_i_src_c055_0_05 0 conv_bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_0_05 (conv_i_src_c055_0_05 conv_i_c055_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_05 (conv_q_src_c055_0_05 0 conv_bpf_c055_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_0_05 (conv_q_src_c055_0_05 conv_q_c055_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_06 (conv_i_src_c055_0_06 0 conv_bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_0_06 (conv_i_src_c055_0_06 conv_i_c055_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_06 (conv_q_src_c055_0_06 0 conv_bpf_c055_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_0_06 (conv_q_src_c055_0_06 conv_q_c055_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_07 (conv_i_src_c055_0_07 0 conv_bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_0_07 (conv_i_src_c055_0_07 conv_i_c055_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_07 (conv_q_src_c055_0_07 0 conv_bpf_c055_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_0_07 (conv_q_src_c055_0_07 conv_q_c055_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_08 (conv_i_src_c055_0_08 0 conv_bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_0_08 (conv_i_src_c055_0_08 conv_i_c055_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_08 (conv_q_src_c055_0_08 0 conv_bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_0_08 (conv_q_src_c055_0_08 conv_q_c055_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_09 (conv_i_src_c055_0_09 0 conv_bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_0_09 (conv_i_src_c055_0_09 conv_i_c055_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_09 (conv_q_src_c055_0_09 0 conv_bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_0_09 (conv_q_src_c055_0_09 conv_q_c055_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_10 (conv_i_src_c055_0_10 0 conv_bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_0_10 (conv_i_src_c055_0_10 conv_i_c055_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_10 (conv_q_src_c055_0_10 0 conv_bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_0_10 (conv_q_src_c055_0_10 conv_q_c055_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_11 (conv_i_src_c055_0_11 0 conv_bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_0_11 (conv_i_src_c055_0_11 conv_i_c055_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_11 (conv_q_src_c055_0_11 0 conv_bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_0_11 (conv_q_src_c055_0_11 conv_q_c055_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_12 (conv_i_src_c055_0_12 0 conv_bpf_c055_0 0) vcvs gain=1.950903220161e-01
SCONVI_c055_0_12 (conv_i_src_c055_0_12 conv_i_c055_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_12 (conv_q_src_c055_0_12 0 conv_bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_0_12 (conv_q_src_c055_0_12 conv_q_c055_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_13 (conv_i_src_c055_0_13 0 conv_bpf_c055_0 0) vcvs gain=5.555702330196e-01
SCONVI_c055_0_13 (conv_i_src_c055_0_13 conv_i_c055_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_13 (conv_q_src_c055_0_13 0 conv_bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_0_13 (conv_q_src_c055_0_13 conv_q_c055_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_14 (conv_i_src_c055_0_14 0 conv_bpf_c055_0 0) vcvs gain=8.314696123025e-01
SCONVI_c055_0_14 (conv_i_src_c055_0_14 conv_i_c055_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_14 (conv_q_src_c055_0_14 0 conv_bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_0_14 (conv_q_src_c055_0_14 conv_q_c055_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_0_15 (conv_i_src_c055_0_15 0 conv_bpf_c055_0 0) vcvs gain=9.807852804032e-01
SCONVI_c055_0_15 (conv_i_src_c055_0_15 conv_i_c055_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_0_15 (conv_q_src_c055_0_15 0 conv_bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_0_15 (conv_q_src_c055_0_15 conv_q_c055_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c055_0 (conv_i_c055_0 0) resistor r=1G
RCONVQ_c055_0 (conv_q_c055_0 0) resistor r=1G
RCONVINTI_c055_0 (conv_i_c055_0 ConvIcar_c055_0) resistor r=1k
CCONVINTI_c055_0 (ConvIcar_c055_0 0) capacitor c=80p
RCONVINTQ_c055_0 (conv_q_c055_0 ConvQcar_c055_0) resistor r=1k
CCONVINTQ_c055_0 (ConvQcar_c055_0 0) capacitor c=80p
save conv_bpf_c055_0 ConvIcar_c055_0 ConvQcar_c055_0

// conventional mixed baseline bl055, carrier_1: 500000000 Hz
CCONVBPF_c055_1 (bl055 n_conv_cbpf_c055_1) capacitor c=1.013211836423e-13
LCONVBPF_c055_1 (n_conv_cbpf_c055_1 conv_bpf_c055_1) inductor l=1.000000000000e-06
RCONVBPF_c055_1 (conv_bpf_c055_1 0) resistor r=1.570796326795e+02
ECONVI_c055_1_00 (conv_i_src_c055_1_00 0 conv_bpf_c055_1 0) vcvs gain=9.807852804032e-01
SCONVI_c055_1_00 (conv_i_src_c055_1_00 conv_i_c055_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_00 (conv_q_src_c055_1_00 0 conv_bpf_c055_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_1_00 (conv_q_src_c055_1_00 conv_q_c055_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_01 (conv_i_src_c055_1_01 0 conv_bpf_c055_1 0) vcvs gain=8.314696123025e-01
SCONVI_c055_1_01 (conv_i_src_c055_1_01 conv_i_c055_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_01 (conv_q_src_c055_1_01 0 conv_bpf_c055_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_1_01 (conv_q_src_c055_1_01 conv_q_c055_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_02 (conv_i_src_c055_1_02 0 conv_bpf_c055_1 0) vcvs gain=5.555702330196e-01
SCONVI_c055_1_02 (conv_i_src_c055_1_02 conv_i_c055_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_02 (conv_q_src_c055_1_02 0 conv_bpf_c055_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_1_02 (conv_q_src_c055_1_02 conv_q_c055_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_03 (conv_i_src_c055_1_03 0 conv_bpf_c055_1 0) vcvs gain=1.950903220161e-01
SCONVI_c055_1_03 (conv_i_src_c055_1_03 conv_i_c055_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_03 (conv_q_src_c055_1_03 0 conv_bpf_c055_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_1_03 (conv_q_src_c055_1_03 conv_q_c055_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_04 (conv_i_src_c055_1_04 0 conv_bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_1_04 (conv_i_src_c055_1_04 conv_i_c055_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_04 (conv_q_src_c055_1_04 0 conv_bpf_c055_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_1_04 (conv_q_src_c055_1_04 conv_q_c055_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_05 (conv_i_src_c055_1_05 0 conv_bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_1_05 (conv_i_src_c055_1_05 conv_i_c055_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_05 (conv_q_src_c055_1_05 0 conv_bpf_c055_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_1_05 (conv_q_src_c055_1_05 conv_q_c055_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_06 (conv_i_src_c055_1_06 0 conv_bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_1_06 (conv_i_src_c055_1_06 conv_i_c055_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_06 (conv_q_src_c055_1_06 0 conv_bpf_c055_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_1_06 (conv_q_src_c055_1_06 conv_q_c055_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_07 (conv_i_src_c055_1_07 0 conv_bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_1_07 (conv_i_src_c055_1_07 conv_i_c055_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_07 (conv_q_src_c055_1_07 0 conv_bpf_c055_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_1_07 (conv_q_src_c055_1_07 conv_q_c055_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_08 (conv_i_src_c055_1_08 0 conv_bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_1_08 (conv_i_src_c055_1_08 conv_i_c055_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_08 (conv_q_src_c055_1_08 0 conv_bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_1_08 (conv_q_src_c055_1_08 conv_q_c055_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_09 (conv_i_src_c055_1_09 0 conv_bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_1_09 (conv_i_src_c055_1_09 conv_i_c055_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_09 (conv_q_src_c055_1_09 0 conv_bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_1_09 (conv_q_src_c055_1_09 conv_q_c055_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_10 (conv_i_src_c055_1_10 0 conv_bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_1_10 (conv_i_src_c055_1_10 conv_i_c055_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_10 (conv_q_src_c055_1_10 0 conv_bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_1_10 (conv_q_src_c055_1_10 conv_q_c055_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_11 (conv_i_src_c055_1_11 0 conv_bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_1_11 (conv_i_src_c055_1_11 conv_i_c055_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_11 (conv_q_src_c055_1_11 0 conv_bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_1_11 (conv_q_src_c055_1_11 conv_q_c055_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_12 (conv_i_src_c055_1_12 0 conv_bpf_c055_1 0) vcvs gain=1.950903220161e-01
SCONVI_c055_1_12 (conv_i_src_c055_1_12 conv_i_c055_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_12 (conv_q_src_c055_1_12 0 conv_bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_1_12 (conv_q_src_c055_1_12 conv_q_c055_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_13 (conv_i_src_c055_1_13 0 conv_bpf_c055_1 0) vcvs gain=5.555702330196e-01
SCONVI_c055_1_13 (conv_i_src_c055_1_13 conv_i_c055_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_13 (conv_q_src_c055_1_13 0 conv_bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_1_13 (conv_q_src_c055_1_13 conv_q_c055_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_14 (conv_i_src_c055_1_14 0 conv_bpf_c055_1 0) vcvs gain=8.314696123025e-01
SCONVI_c055_1_14 (conv_i_src_c055_1_14 conv_i_c055_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_14 (conv_q_src_c055_1_14 0 conv_bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_1_14 (conv_q_src_c055_1_14 conv_q_c055_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_1_15 (conv_i_src_c055_1_15 0 conv_bpf_c055_1 0) vcvs gain=9.807852804032e-01
SCONVI_c055_1_15 (conv_i_src_c055_1_15 conv_i_c055_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_1_15 (conv_q_src_c055_1_15 0 conv_bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_1_15 (conv_q_src_c055_1_15 conv_q_c055_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c055_1 (conv_i_c055_1 0) resistor r=1G
RCONVQ_c055_1 (conv_q_c055_1 0) resistor r=1G
RCONVINTI_c055_1 (conv_i_c055_1 ConvIcar_c055_1) resistor r=1k
CCONVINTI_c055_1 (ConvIcar_c055_1 0) capacitor c=80p
RCONVINTQ_c055_1 (conv_q_c055_1 ConvQcar_c055_1) resistor r=1k
CCONVINTQ_c055_1 (ConvQcar_c055_1 0) capacitor c=80p
save conv_bpf_c055_1 ConvIcar_c055_1 ConvQcar_c055_1

// conventional mixed baseline bl055, carrier_2: 750000000 Hz
CCONVBPF_c055_2 (bl055 n_conv_cbpf_c055_2) capacitor c=4.503163717437e-14
LCONVBPF_c055_2 (n_conv_cbpf_c055_2 conv_bpf_c055_2) inductor l=1.000000000000e-06
RCONVBPF_c055_2 (conv_bpf_c055_2 0) resistor r=2.356194490192e+02
ECONVI_c055_2_00 (conv_i_src_c055_2_00 0 conv_bpf_c055_2 0) vcvs gain=9.807852804032e-01
SCONVI_c055_2_00 (conv_i_src_c055_2_00 conv_i_c055_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_00 (conv_q_src_c055_2_00 0 conv_bpf_c055_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_2_00 (conv_q_src_c055_2_00 conv_q_c055_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_01 (conv_i_src_c055_2_01 0 conv_bpf_c055_2 0) vcvs gain=8.314696123025e-01
SCONVI_c055_2_01 (conv_i_src_c055_2_01 conv_i_c055_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_01 (conv_q_src_c055_2_01 0 conv_bpf_c055_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_2_01 (conv_q_src_c055_2_01 conv_q_c055_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_02 (conv_i_src_c055_2_02 0 conv_bpf_c055_2 0) vcvs gain=5.555702330196e-01
SCONVI_c055_2_02 (conv_i_src_c055_2_02 conv_i_c055_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_02 (conv_q_src_c055_2_02 0 conv_bpf_c055_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_2_02 (conv_q_src_c055_2_02 conv_q_c055_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_03 (conv_i_src_c055_2_03 0 conv_bpf_c055_2 0) vcvs gain=1.950903220161e-01
SCONVI_c055_2_03 (conv_i_src_c055_2_03 conv_i_c055_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_03 (conv_q_src_c055_2_03 0 conv_bpf_c055_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_2_03 (conv_q_src_c055_2_03 conv_q_c055_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_04 (conv_i_src_c055_2_04 0 conv_bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_2_04 (conv_i_src_c055_2_04 conv_i_c055_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_04 (conv_q_src_c055_2_04 0 conv_bpf_c055_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_2_04 (conv_q_src_c055_2_04 conv_q_c055_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_05 (conv_i_src_c055_2_05 0 conv_bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_2_05 (conv_i_src_c055_2_05 conv_i_c055_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_05 (conv_q_src_c055_2_05 0 conv_bpf_c055_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_2_05 (conv_q_src_c055_2_05 conv_q_c055_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_06 (conv_i_src_c055_2_06 0 conv_bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_2_06 (conv_i_src_c055_2_06 conv_i_c055_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_06 (conv_q_src_c055_2_06 0 conv_bpf_c055_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_2_06 (conv_q_src_c055_2_06 conv_q_c055_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_07 (conv_i_src_c055_2_07 0 conv_bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_2_07 (conv_i_src_c055_2_07 conv_i_c055_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_07 (conv_q_src_c055_2_07 0 conv_bpf_c055_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_2_07 (conv_q_src_c055_2_07 conv_q_c055_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_08 (conv_i_src_c055_2_08 0 conv_bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_2_08 (conv_i_src_c055_2_08 conv_i_c055_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_08 (conv_q_src_c055_2_08 0 conv_bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_2_08 (conv_q_src_c055_2_08 conv_q_c055_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_09 (conv_i_src_c055_2_09 0 conv_bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_2_09 (conv_i_src_c055_2_09 conv_i_c055_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_09 (conv_q_src_c055_2_09 0 conv_bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_2_09 (conv_q_src_c055_2_09 conv_q_c055_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_10 (conv_i_src_c055_2_10 0 conv_bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_2_10 (conv_i_src_c055_2_10 conv_i_c055_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_10 (conv_q_src_c055_2_10 0 conv_bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_2_10 (conv_q_src_c055_2_10 conv_q_c055_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_11 (conv_i_src_c055_2_11 0 conv_bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_2_11 (conv_i_src_c055_2_11 conv_i_c055_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_11 (conv_q_src_c055_2_11 0 conv_bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_2_11 (conv_q_src_c055_2_11 conv_q_c055_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_12 (conv_i_src_c055_2_12 0 conv_bpf_c055_2 0) vcvs gain=1.950903220161e-01
SCONVI_c055_2_12 (conv_i_src_c055_2_12 conv_i_c055_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_12 (conv_q_src_c055_2_12 0 conv_bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_2_12 (conv_q_src_c055_2_12 conv_q_c055_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_13 (conv_i_src_c055_2_13 0 conv_bpf_c055_2 0) vcvs gain=5.555702330196e-01
SCONVI_c055_2_13 (conv_i_src_c055_2_13 conv_i_c055_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_13 (conv_q_src_c055_2_13 0 conv_bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_2_13 (conv_q_src_c055_2_13 conv_q_c055_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_14 (conv_i_src_c055_2_14 0 conv_bpf_c055_2 0) vcvs gain=8.314696123025e-01
SCONVI_c055_2_14 (conv_i_src_c055_2_14 conv_i_c055_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_14 (conv_q_src_c055_2_14 0 conv_bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_2_14 (conv_q_src_c055_2_14 conv_q_c055_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_2_15 (conv_i_src_c055_2_15 0 conv_bpf_c055_2 0) vcvs gain=9.807852804032e-01
SCONVI_c055_2_15 (conv_i_src_c055_2_15 conv_i_c055_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_2_15 (conv_q_src_c055_2_15 0 conv_bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_2_15 (conv_q_src_c055_2_15 conv_q_c055_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c055_2 (conv_i_c055_2 0) resistor r=1G
RCONVQ_c055_2 (conv_q_c055_2 0) resistor r=1G
RCONVINTI_c055_2 (conv_i_c055_2 ConvIcar_c055_2) resistor r=1k
CCONVINTI_c055_2 (ConvIcar_c055_2 0) capacitor c=80p
RCONVINTQ_c055_2 (conv_q_c055_2 ConvQcar_c055_2) resistor r=1k
CCONVINTQ_c055_2 (ConvQcar_c055_2 0) capacitor c=80p
save conv_bpf_c055_2 ConvIcar_c055_2 ConvQcar_c055_2

// conventional mixed baseline bl055, carrier_3: 1000000000 Hz
CCONVBPF_c055_3 (bl055 n_conv_cbpf_c055_3) capacitor c=2.533029591058e-14
LCONVBPF_c055_3 (n_conv_cbpf_c055_3 conv_bpf_c055_3) inductor l=1.000000000000e-06
RCONVBPF_c055_3 (conv_bpf_c055_3 0) resistor r=3.141592653590e+02
ECONVI_c055_3_00 (conv_i_src_c055_3_00 0 conv_bpf_c055_3 0) vcvs gain=9.807852804032e-01
SCONVI_c055_3_00 (conv_i_src_c055_3_00 conv_i_c055_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_00 (conv_q_src_c055_3_00 0 conv_bpf_c055_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_3_00 (conv_q_src_c055_3_00 conv_q_c055_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_01 (conv_i_src_c055_3_01 0 conv_bpf_c055_3 0) vcvs gain=8.314696123025e-01
SCONVI_c055_3_01 (conv_i_src_c055_3_01 conv_i_c055_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_01 (conv_q_src_c055_3_01 0 conv_bpf_c055_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_3_01 (conv_q_src_c055_3_01 conv_q_c055_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_02 (conv_i_src_c055_3_02 0 conv_bpf_c055_3 0) vcvs gain=5.555702330196e-01
SCONVI_c055_3_02 (conv_i_src_c055_3_02 conv_i_c055_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_02 (conv_q_src_c055_3_02 0 conv_bpf_c055_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_3_02 (conv_q_src_c055_3_02 conv_q_c055_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_03 (conv_i_src_c055_3_03 0 conv_bpf_c055_3 0) vcvs gain=1.950903220161e-01
SCONVI_c055_3_03 (conv_i_src_c055_3_03 conv_i_c055_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_03 (conv_q_src_c055_3_03 0 conv_bpf_c055_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_3_03 (conv_q_src_c055_3_03 conv_q_c055_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_04 (conv_i_src_c055_3_04 0 conv_bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_3_04 (conv_i_src_c055_3_04 conv_i_c055_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_04 (conv_q_src_c055_3_04 0 conv_bpf_c055_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c055_3_04 (conv_q_src_c055_3_04 conv_q_c055_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_05 (conv_i_src_c055_3_05 0 conv_bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_3_05 (conv_i_src_c055_3_05 conv_i_c055_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_05 (conv_q_src_c055_3_05 0 conv_bpf_c055_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c055_3_05 (conv_q_src_c055_3_05 conv_q_c055_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_06 (conv_i_src_c055_3_06 0 conv_bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_3_06 (conv_i_src_c055_3_06 conv_i_c055_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_06 (conv_q_src_c055_3_06 0 conv_bpf_c055_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c055_3_06 (conv_q_src_c055_3_06 conv_q_c055_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_07 (conv_i_src_c055_3_07 0 conv_bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_3_07 (conv_i_src_c055_3_07 conv_i_c055_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_07 (conv_q_src_c055_3_07 0 conv_bpf_c055_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c055_3_07 (conv_q_src_c055_3_07 conv_q_c055_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_08 (conv_i_src_c055_3_08 0 conv_bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c055_3_08 (conv_i_src_c055_3_08 conv_i_c055_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_08 (conv_q_src_c055_3_08 0 conv_bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_3_08 (conv_q_src_c055_3_08 conv_q_c055_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_09 (conv_i_src_c055_3_09 0 conv_bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c055_3_09 (conv_i_src_c055_3_09 conv_i_c055_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_09 (conv_q_src_c055_3_09 0 conv_bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_3_09 (conv_q_src_c055_3_09 conv_q_c055_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_10 (conv_i_src_c055_3_10 0 conv_bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c055_3_10 (conv_i_src_c055_3_10 conv_i_c055_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_10 (conv_q_src_c055_3_10 0 conv_bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_3_10 (conv_q_src_c055_3_10 conv_q_c055_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_11 (conv_i_src_c055_3_11 0 conv_bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c055_3_11 (conv_i_src_c055_3_11 conv_i_c055_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_11 (conv_q_src_c055_3_11 0 conv_bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_3_11 (conv_q_src_c055_3_11 conv_q_c055_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_12 (conv_i_src_c055_3_12 0 conv_bpf_c055_3 0) vcvs gain=1.950903220161e-01
SCONVI_c055_3_12 (conv_i_src_c055_3_12 conv_i_c055_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_12 (conv_q_src_c055_3_12 0 conv_bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c055_3_12 (conv_q_src_c055_3_12 conv_q_c055_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_13 (conv_i_src_c055_3_13 0 conv_bpf_c055_3 0) vcvs gain=5.555702330196e-01
SCONVI_c055_3_13 (conv_i_src_c055_3_13 conv_i_c055_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_13 (conv_q_src_c055_3_13 0 conv_bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c055_3_13 (conv_q_src_c055_3_13 conv_q_c055_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_14 (conv_i_src_c055_3_14 0 conv_bpf_c055_3 0) vcvs gain=8.314696123025e-01
SCONVI_c055_3_14 (conv_i_src_c055_3_14 conv_i_c055_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_14 (conv_q_src_c055_3_14 0 conv_bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c055_3_14 (conv_q_src_c055_3_14 conv_q_c055_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c055_3_15 (conv_i_src_c055_3_15 0 conv_bpf_c055_3 0) vcvs gain=9.807852804032e-01
SCONVI_c055_3_15 (conv_i_src_c055_3_15 conv_i_c055_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c055_3_15 (conv_q_src_c055_3_15 0 conv_bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c055_3_15 (conv_q_src_c055_3_15 conv_q_c055_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c055_3 (conv_i_c055_3 0) resistor r=1G
RCONVQ_c055_3 (conv_q_c055_3 0) resistor r=1G
RCONVINTI_c055_3 (conv_i_c055_3 ConvIcar_c055_3) resistor r=1k
CCONVINTI_c055_3 (ConvIcar_c055_3 0) capacitor c=80p
RCONVINTQ_c055_3 (conv_q_c055_3 ConvQcar_c055_3) resistor r=1k
CCONVINTQ_c055_3 (ConvQcar_c055_3 0) capacitor c=80p
save conv_bpf_c055_3 ConvIcar_c055_3 ConvQcar_c055_3

// conventional mixed baseline bl056, carrier_0: 250000000 Hz
CCONVBPF_c056_0 (bl056 n_conv_cbpf_c056_0) capacitor c=4.052847345694e-13
LCONVBPF_c056_0 (n_conv_cbpf_c056_0 conv_bpf_c056_0) inductor l=1.000000000000e-06
RCONVBPF_c056_0 (conv_bpf_c056_0 0) resistor r=7.853981633974e+01
ECONVI_c056_0_00 (conv_i_src_c056_0_00 0 conv_bpf_c056_0 0) vcvs gain=9.807852804032e-01
SCONVI_c056_0_00 (conv_i_src_c056_0_00 conv_i_c056_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_00 (conv_q_src_c056_0_00 0 conv_bpf_c056_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_0_00 (conv_q_src_c056_0_00 conv_q_c056_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_01 (conv_i_src_c056_0_01 0 conv_bpf_c056_0 0) vcvs gain=8.314696123025e-01
SCONVI_c056_0_01 (conv_i_src_c056_0_01 conv_i_c056_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_01 (conv_q_src_c056_0_01 0 conv_bpf_c056_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_0_01 (conv_q_src_c056_0_01 conv_q_c056_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_02 (conv_i_src_c056_0_02 0 conv_bpf_c056_0 0) vcvs gain=5.555702330196e-01
SCONVI_c056_0_02 (conv_i_src_c056_0_02 conv_i_c056_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_02 (conv_q_src_c056_0_02 0 conv_bpf_c056_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_0_02 (conv_q_src_c056_0_02 conv_q_c056_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_03 (conv_i_src_c056_0_03 0 conv_bpf_c056_0 0) vcvs gain=1.950903220161e-01
SCONVI_c056_0_03 (conv_i_src_c056_0_03 conv_i_c056_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_03 (conv_q_src_c056_0_03 0 conv_bpf_c056_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_0_03 (conv_q_src_c056_0_03 conv_q_c056_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_04 (conv_i_src_c056_0_04 0 conv_bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_0_04 (conv_i_src_c056_0_04 conv_i_c056_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_04 (conv_q_src_c056_0_04 0 conv_bpf_c056_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_0_04 (conv_q_src_c056_0_04 conv_q_c056_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_05 (conv_i_src_c056_0_05 0 conv_bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_0_05 (conv_i_src_c056_0_05 conv_i_c056_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_05 (conv_q_src_c056_0_05 0 conv_bpf_c056_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_0_05 (conv_q_src_c056_0_05 conv_q_c056_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_06 (conv_i_src_c056_0_06 0 conv_bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_0_06 (conv_i_src_c056_0_06 conv_i_c056_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_06 (conv_q_src_c056_0_06 0 conv_bpf_c056_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_0_06 (conv_q_src_c056_0_06 conv_q_c056_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_07 (conv_i_src_c056_0_07 0 conv_bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_0_07 (conv_i_src_c056_0_07 conv_i_c056_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_07 (conv_q_src_c056_0_07 0 conv_bpf_c056_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_0_07 (conv_q_src_c056_0_07 conv_q_c056_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_08 (conv_i_src_c056_0_08 0 conv_bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_0_08 (conv_i_src_c056_0_08 conv_i_c056_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_08 (conv_q_src_c056_0_08 0 conv_bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_0_08 (conv_q_src_c056_0_08 conv_q_c056_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_09 (conv_i_src_c056_0_09 0 conv_bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_0_09 (conv_i_src_c056_0_09 conv_i_c056_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_09 (conv_q_src_c056_0_09 0 conv_bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_0_09 (conv_q_src_c056_0_09 conv_q_c056_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_10 (conv_i_src_c056_0_10 0 conv_bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_0_10 (conv_i_src_c056_0_10 conv_i_c056_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_10 (conv_q_src_c056_0_10 0 conv_bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_0_10 (conv_q_src_c056_0_10 conv_q_c056_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_11 (conv_i_src_c056_0_11 0 conv_bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_0_11 (conv_i_src_c056_0_11 conv_i_c056_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_11 (conv_q_src_c056_0_11 0 conv_bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_0_11 (conv_q_src_c056_0_11 conv_q_c056_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_12 (conv_i_src_c056_0_12 0 conv_bpf_c056_0 0) vcvs gain=1.950903220161e-01
SCONVI_c056_0_12 (conv_i_src_c056_0_12 conv_i_c056_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_12 (conv_q_src_c056_0_12 0 conv_bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_0_12 (conv_q_src_c056_0_12 conv_q_c056_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_13 (conv_i_src_c056_0_13 0 conv_bpf_c056_0 0) vcvs gain=5.555702330196e-01
SCONVI_c056_0_13 (conv_i_src_c056_0_13 conv_i_c056_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_13 (conv_q_src_c056_0_13 0 conv_bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_0_13 (conv_q_src_c056_0_13 conv_q_c056_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_14 (conv_i_src_c056_0_14 0 conv_bpf_c056_0 0) vcvs gain=8.314696123025e-01
SCONVI_c056_0_14 (conv_i_src_c056_0_14 conv_i_c056_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_14 (conv_q_src_c056_0_14 0 conv_bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_0_14 (conv_q_src_c056_0_14 conv_q_c056_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_0_15 (conv_i_src_c056_0_15 0 conv_bpf_c056_0 0) vcvs gain=9.807852804032e-01
SCONVI_c056_0_15 (conv_i_src_c056_0_15 conv_i_c056_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_0_15 (conv_q_src_c056_0_15 0 conv_bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_0_15 (conv_q_src_c056_0_15 conv_q_c056_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c056_0 (conv_i_c056_0 0) resistor r=1G
RCONVQ_c056_0 (conv_q_c056_0 0) resistor r=1G
RCONVINTI_c056_0 (conv_i_c056_0 ConvIcar_c056_0) resistor r=1k
CCONVINTI_c056_0 (ConvIcar_c056_0 0) capacitor c=80p
RCONVINTQ_c056_0 (conv_q_c056_0 ConvQcar_c056_0) resistor r=1k
CCONVINTQ_c056_0 (ConvQcar_c056_0 0) capacitor c=80p
save conv_bpf_c056_0 ConvIcar_c056_0 ConvQcar_c056_0

// conventional mixed baseline bl056, carrier_1: 500000000 Hz
CCONVBPF_c056_1 (bl056 n_conv_cbpf_c056_1) capacitor c=1.013211836423e-13
LCONVBPF_c056_1 (n_conv_cbpf_c056_1 conv_bpf_c056_1) inductor l=1.000000000000e-06
RCONVBPF_c056_1 (conv_bpf_c056_1 0) resistor r=1.570796326795e+02
ECONVI_c056_1_00 (conv_i_src_c056_1_00 0 conv_bpf_c056_1 0) vcvs gain=9.807852804032e-01
SCONVI_c056_1_00 (conv_i_src_c056_1_00 conv_i_c056_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_00 (conv_q_src_c056_1_00 0 conv_bpf_c056_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_1_00 (conv_q_src_c056_1_00 conv_q_c056_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_01 (conv_i_src_c056_1_01 0 conv_bpf_c056_1 0) vcvs gain=8.314696123025e-01
SCONVI_c056_1_01 (conv_i_src_c056_1_01 conv_i_c056_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_01 (conv_q_src_c056_1_01 0 conv_bpf_c056_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_1_01 (conv_q_src_c056_1_01 conv_q_c056_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_02 (conv_i_src_c056_1_02 0 conv_bpf_c056_1 0) vcvs gain=5.555702330196e-01
SCONVI_c056_1_02 (conv_i_src_c056_1_02 conv_i_c056_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_02 (conv_q_src_c056_1_02 0 conv_bpf_c056_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_1_02 (conv_q_src_c056_1_02 conv_q_c056_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_03 (conv_i_src_c056_1_03 0 conv_bpf_c056_1 0) vcvs gain=1.950903220161e-01
SCONVI_c056_1_03 (conv_i_src_c056_1_03 conv_i_c056_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_03 (conv_q_src_c056_1_03 0 conv_bpf_c056_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_1_03 (conv_q_src_c056_1_03 conv_q_c056_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_04 (conv_i_src_c056_1_04 0 conv_bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_1_04 (conv_i_src_c056_1_04 conv_i_c056_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_04 (conv_q_src_c056_1_04 0 conv_bpf_c056_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_1_04 (conv_q_src_c056_1_04 conv_q_c056_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_05 (conv_i_src_c056_1_05 0 conv_bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_1_05 (conv_i_src_c056_1_05 conv_i_c056_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_05 (conv_q_src_c056_1_05 0 conv_bpf_c056_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_1_05 (conv_q_src_c056_1_05 conv_q_c056_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_06 (conv_i_src_c056_1_06 0 conv_bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_1_06 (conv_i_src_c056_1_06 conv_i_c056_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_06 (conv_q_src_c056_1_06 0 conv_bpf_c056_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_1_06 (conv_q_src_c056_1_06 conv_q_c056_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_07 (conv_i_src_c056_1_07 0 conv_bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_1_07 (conv_i_src_c056_1_07 conv_i_c056_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_07 (conv_q_src_c056_1_07 0 conv_bpf_c056_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_1_07 (conv_q_src_c056_1_07 conv_q_c056_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_08 (conv_i_src_c056_1_08 0 conv_bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_1_08 (conv_i_src_c056_1_08 conv_i_c056_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_08 (conv_q_src_c056_1_08 0 conv_bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_1_08 (conv_q_src_c056_1_08 conv_q_c056_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_09 (conv_i_src_c056_1_09 0 conv_bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_1_09 (conv_i_src_c056_1_09 conv_i_c056_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_09 (conv_q_src_c056_1_09 0 conv_bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_1_09 (conv_q_src_c056_1_09 conv_q_c056_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_10 (conv_i_src_c056_1_10 0 conv_bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_1_10 (conv_i_src_c056_1_10 conv_i_c056_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_10 (conv_q_src_c056_1_10 0 conv_bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_1_10 (conv_q_src_c056_1_10 conv_q_c056_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_11 (conv_i_src_c056_1_11 0 conv_bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_1_11 (conv_i_src_c056_1_11 conv_i_c056_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_11 (conv_q_src_c056_1_11 0 conv_bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_1_11 (conv_q_src_c056_1_11 conv_q_c056_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_12 (conv_i_src_c056_1_12 0 conv_bpf_c056_1 0) vcvs gain=1.950903220161e-01
SCONVI_c056_1_12 (conv_i_src_c056_1_12 conv_i_c056_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_12 (conv_q_src_c056_1_12 0 conv_bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_1_12 (conv_q_src_c056_1_12 conv_q_c056_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_13 (conv_i_src_c056_1_13 0 conv_bpf_c056_1 0) vcvs gain=5.555702330196e-01
SCONVI_c056_1_13 (conv_i_src_c056_1_13 conv_i_c056_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_13 (conv_q_src_c056_1_13 0 conv_bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_1_13 (conv_q_src_c056_1_13 conv_q_c056_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_14 (conv_i_src_c056_1_14 0 conv_bpf_c056_1 0) vcvs gain=8.314696123025e-01
SCONVI_c056_1_14 (conv_i_src_c056_1_14 conv_i_c056_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_14 (conv_q_src_c056_1_14 0 conv_bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_1_14 (conv_q_src_c056_1_14 conv_q_c056_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_1_15 (conv_i_src_c056_1_15 0 conv_bpf_c056_1 0) vcvs gain=9.807852804032e-01
SCONVI_c056_1_15 (conv_i_src_c056_1_15 conv_i_c056_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_1_15 (conv_q_src_c056_1_15 0 conv_bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_1_15 (conv_q_src_c056_1_15 conv_q_c056_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c056_1 (conv_i_c056_1 0) resistor r=1G
RCONVQ_c056_1 (conv_q_c056_1 0) resistor r=1G
RCONVINTI_c056_1 (conv_i_c056_1 ConvIcar_c056_1) resistor r=1k
CCONVINTI_c056_1 (ConvIcar_c056_1 0) capacitor c=80p
RCONVINTQ_c056_1 (conv_q_c056_1 ConvQcar_c056_1) resistor r=1k
CCONVINTQ_c056_1 (ConvQcar_c056_1 0) capacitor c=80p
save conv_bpf_c056_1 ConvIcar_c056_1 ConvQcar_c056_1

// conventional mixed baseline bl056, carrier_2: 750000000 Hz
CCONVBPF_c056_2 (bl056 n_conv_cbpf_c056_2) capacitor c=4.503163717437e-14
LCONVBPF_c056_2 (n_conv_cbpf_c056_2 conv_bpf_c056_2) inductor l=1.000000000000e-06
RCONVBPF_c056_2 (conv_bpf_c056_2 0) resistor r=2.356194490192e+02
ECONVI_c056_2_00 (conv_i_src_c056_2_00 0 conv_bpf_c056_2 0) vcvs gain=9.807852804032e-01
SCONVI_c056_2_00 (conv_i_src_c056_2_00 conv_i_c056_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_00 (conv_q_src_c056_2_00 0 conv_bpf_c056_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_2_00 (conv_q_src_c056_2_00 conv_q_c056_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_01 (conv_i_src_c056_2_01 0 conv_bpf_c056_2 0) vcvs gain=8.314696123025e-01
SCONVI_c056_2_01 (conv_i_src_c056_2_01 conv_i_c056_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_01 (conv_q_src_c056_2_01 0 conv_bpf_c056_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_2_01 (conv_q_src_c056_2_01 conv_q_c056_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_02 (conv_i_src_c056_2_02 0 conv_bpf_c056_2 0) vcvs gain=5.555702330196e-01
SCONVI_c056_2_02 (conv_i_src_c056_2_02 conv_i_c056_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_02 (conv_q_src_c056_2_02 0 conv_bpf_c056_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_2_02 (conv_q_src_c056_2_02 conv_q_c056_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_03 (conv_i_src_c056_2_03 0 conv_bpf_c056_2 0) vcvs gain=1.950903220161e-01
SCONVI_c056_2_03 (conv_i_src_c056_2_03 conv_i_c056_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_03 (conv_q_src_c056_2_03 0 conv_bpf_c056_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_2_03 (conv_q_src_c056_2_03 conv_q_c056_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_04 (conv_i_src_c056_2_04 0 conv_bpf_c056_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_2_04 (conv_i_src_c056_2_04 conv_i_c056_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_04 (conv_q_src_c056_2_04 0 conv_bpf_c056_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_2_04 (conv_q_src_c056_2_04 conv_q_c056_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_05 (conv_i_src_c056_2_05 0 conv_bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_2_05 (conv_i_src_c056_2_05 conv_i_c056_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_05 (conv_q_src_c056_2_05 0 conv_bpf_c056_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_2_05 (conv_q_src_c056_2_05 conv_q_c056_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_06 (conv_i_src_c056_2_06 0 conv_bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_2_06 (conv_i_src_c056_2_06 conv_i_c056_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_06 (conv_q_src_c056_2_06 0 conv_bpf_c056_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_2_06 (conv_q_src_c056_2_06 conv_q_c056_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_07 (conv_i_src_c056_2_07 0 conv_bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_2_07 (conv_i_src_c056_2_07 conv_i_c056_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_07 (conv_q_src_c056_2_07 0 conv_bpf_c056_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_2_07 (conv_q_src_c056_2_07 conv_q_c056_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_08 (conv_i_src_c056_2_08 0 conv_bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_2_08 (conv_i_src_c056_2_08 conv_i_c056_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_08 (conv_q_src_c056_2_08 0 conv_bpf_c056_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_2_08 (conv_q_src_c056_2_08 conv_q_c056_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_09 (conv_i_src_c056_2_09 0 conv_bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_2_09 (conv_i_src_c056_2_09 conv_i_c056_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_09 (conv_q_src_c056_2_09 0 conv_bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_2_09 (conv_q_src_c056_2_09 conv_q_c056_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_10 (conv_i_src_c056_2_10 0 conv_bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_2_10 (conv_i_src_c056_2_10 conv_i_c056_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_10 (conv_q_src_c056_2_10 0 conv_bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_2_10 (conv_q_src_c056_2_10 conv_q_c056_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_11 (conv_i_src_c056_2_11 0 conv_bpf_c056_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_2_11 (conv_i_src_c056_2_11 conv_i_c056_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_11 (conv_q_src_c056_2_11 0 conv_bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_2_11 (conv_q_src_c056_2_11 conv_q_c056_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_12 (conv_i_src_c056_2_12 0 conv_bpf_c056_2 0) vcvs gain=1.950903220161e-01
SCONVI_c056_2_12 (conv_i_src_c056_2_12 conv_i_c056_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_12 (conv_q_src_c056_2_12 0 conv_bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_2_12 (conv_q_src_c056_2_12 conv_q_c056_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_13 (conv_i_src_c056_2_13 0 conv_bpf_c056_2 0) vcvs gain=5.555702330196e-01
SCONVI_c056_2_13 (conv_i_src_c056_2_13 conv_i_c056_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_13 (conv_q_src_c056_2_13 0 conv_bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_2_13 (conv_q_src_c056_2_13 conv_q_c056_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_14 (conv_i_src_c056_2_14 0 conv_bpf_c056_2 0) vcvs gain=8.314696123025e-01
SCONVI_c056_2_14 (conv_i_src_c056_2_14 conv_i_c056_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_14 (conv_q_src_c056_2_14 0 conv_bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_2_14 (conv_q_src_c056_2_14 conv_q_c056_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_2_15 (conv_i_src_c056_2_15 0 conv_bpf_c056_2 0) vcvs gain=9.807852804032e-01
SCONVI_c056_2_15 (conv_i_src_c056_2_15 conv_i_c056_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_2_15 (conv_q_src_c056_2_15 0 conv_bpf_c056_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_2_15 (conv_q_src_c056_2_15 conv_q_c056_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c056_2 (conv_i_c056_2 0) resistor r=1G
RCONVQ_c056_2 (conv_q_c056_2 0) resistor r=1G
RCONVINTI_c056_2 (conv_i_c056_2 ConvIcar_c056_2) resistor r=1k
CCONVINTI_c056_2 (ConvIcar_c056_2 0) capacitor c=80p
RCONVINTQ_c056_2 (conv_q_c056_2 ConvQcar_c056_2) resistor r=1k
CCONVINTQ_c056_2 (ConvQcar_c056_2 0) capacitor c=80p
save conv_bpf_c056_2 ConvIcar_c056_2 ConvQcar_c056_2

// conventional mixed baseline bl056, carrier_3: 1000000000 Hz
CCONVBPF_c056_3 (bl056 n_conv_cbpf_c056_3) capacitor c=2.533029591058e-14
LCONVBPF_c056_3 (n_conv_cbpf_c056_3 conv_bpf_c056_3) inductor l=1.000000000000e-06
RCONVBPF_c056_3 (conv_bpf_c056_3 0) resistor r=3.141592653590e+02
ECONVI_c056_3_00 (conv_i_src_c056_3_00 0 conv_bpf_c056_3 0) vcvs gain=9.807852804032e-01
SCONVI_c056_3_00 (conv_i_src_c056_3_00 conv_i_c056_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_00 (conv_q_src_c056_3_00 0 conv_bpf_c056_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_3_00 (conv_q_src_c056_3_00 conv_q_c056_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_01 (conv_i_src_c056_3_01 0 conv_bpf_c056_3 0) vcvs gain=8.314696123025e-01
SCONVI_c056_3_01 (conv_i_src_c056_3_01 conv_i_c056_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_01 (conv_q_src_c056_3_01 0 conv_bpf_c056_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_3_01 (conv_q_src_c056_3_01 conv_q_c056_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_02 (conv_i_src_c056_3_02 0 conv_bpf_c056_3 0) vcvs gain=5.555702330196e-01
SCONVI_c056_3_02 (conv_i_src_c056_3_02 conv_i_c056_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_02 (conv_q_src_c056_3_02 0 conv_bpf_c056_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_3_02 (conv_q_src_c056_3_02 conv_q_c056_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_03 (conv_i_src_c056_3_03 0 conv_bpf_c056_3 0) vcvs gain=1.950903220161e-01
SCONVI_c056_3_03 (conv_i_src_c056_3_03 conv_i_c056_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_03 (conv_q_src_c056_3_03 0 conv_bpf_c056_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_3_03 (conv_q_src_c056_3_03 conv_q_c056_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_04 (conv_i_src_c056_3_04 0 conv_bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_3_04 (conv_i_src_c056_3_04 conv_i_c056_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_04 (conv_q_src_c056_3_04 0 conv_bpf_c056_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c056_3_04 (conv_q_src_c056_3_04 conv_q_c056_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_05 (conv_i_src_c056_3_05 0 conv_bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_3_05 (conv_i_src_c056_3_05 conv_i_c056_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_05 (conv_q_src_c056_3_05 0 conv_bpf_c056_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c056_3_05 (conv_q_src_c056_3_05 conv_q_c056_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_06 (conv_i_src_c056_3_06 0 conv_bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_3_06 (conv_i_src_c056_3_06 conv_i_c056_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_06 (conv_q_src_c056_3_06 0 conv_bpf_c056_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c056_3_06 (conv_q_src_c056_3_06 conv_q_c056_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_07 (conv_i_src_c056_3_07 0 conv_bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_3_07 (conv_i_src_c056_3_07 conv_i_c056_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_07 (conv_q_src_c056_3_07 0 conv_bpf_c056_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c056_3_07 (conv_q_src_c056_3_07 conv_q_c056_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_08 (conv_i_src_c056_3_08 0 conv_bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c056_3_08 (conv_i_src_c056_3_08 conv_i_c056_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_08 (conv_q_src_c056_3_08 0 conv_bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_3_08 (conv_q_src_c056_3_08 conv_q_c056_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_09 (conv_i_src_c056_3_09 0 conv_bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c056_3_09 (conv_i_src_c056_3_09 conv_i_c056_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_09 (conv_q_src_c056_3_09 0 conv_bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_3_09 (conv_q_src_c056_3_09 conv_q_c056_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_10 (conv_i_src_c056_3_10 0 conv_bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c056_3_10 (conv_i_src_c056_3_10 conv_i_c056_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_10 (conv_q_src_c056_3_10 0 conv_bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_3_10 (conv_q_src_c056_3_10 conv_q_c056_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_11 (conv_i_src_c056_3_11 0 conv_bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c056_3_11 (conv_i_src_c056_3_11 conv_i_c056_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_11 (conv_q_src_c056_3_11 0 conv_bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_3_11 (conv_q_src_c056_3_11 conv_q_c056_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_12 (conv_i_src_c056_3_12 0 conv_bpf_c056_3 0) vcvs gain=1.950903220161e-01
SCONVI_c056_3_12 (conv_i_src_c056_3_12 conv_i_c056_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_12 (conv_q_src_c056_3_12 0 conv_bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c056_3_12 (conv_q_src_c056_3_12 conv_q_c056_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_13 (conv_i_src_c056_3_13 0 conv_bpf_c056_3 0) vcvs gain=5.555702330196e-01
SCONVI_c056_3_13 (conv_i_src_c056_3_13 conv_i_c056_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_13 (conv_q_src_c056_3_13 0 conv_bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c056_3_13 (conv_q_src_c056_3_13 conv_q_c056_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_14 (conv_i_src_c056_3_14 0 conv_bpf_c056_3 0) vcvs gain=8.314696123025e-01
SCONVI_c056_3_14 (conv_i_src_c056_3_14 conv_i_c056_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_14 (conv_q_src_c056_3_14 0 conv_bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c056_3_14 (conv_q_src_c056_3_14 conv_q_c056_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c056_3_15 (conv_i_src_c056_3_15 0 conv_bpf_c056_3 0) vcvs gain=9.807852804032e-01
SCONVI_c056_3_15 (conv_i_src_c056_3_15 conv_i_c056_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c056_3_15 (conv_q_src_c056_3_15 0 conv_bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c056_3_15 (conv_q_src_c056_3_15 conv_q_c056_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c056_3 (conv_i_c056_3 0) resistor r=1G
RCONVQ_c056_3 (conv_q_c056_3 0) resistor r=1G
RCONVINTI_c056_3 (conv_i_c056_3 ConvIcar_c056_3) resistor r=1k
CCONVINTI_c056_3 (ConvIcar_c056_3 0) capacitor c=80p
RCONVINTQ_c056_3 (conv_q_c056_3 ConvQcar_c056_3) resistor r=1k
CCONVINTQ_c056_3 (ConvQcar_c056_3 0) capacitor c=80p
save conv_bpf_c056_3 ConvIcar_c056_3 ConvQcar_c056_3

// conventional mixed baseline bl057, carrier_0: 250000000 Hz
CCONVBPF_c057_0 (bl057 n_conv_cbpf_c057_0) capacitor c=4.052847345694e-13
LCONVBPF_c057_0 (n_conv_cbpf_c057_0 conv_bpf_c057_0) inductor l=1.000000000000e-06
RCONVBPF_c057_0 (conv_bpf_c057_0 0) resistor r=7.853981633974e+01
ECONVI_c057_0_00 (conv_i_src_c057_0_00 0 conv_bpf_c057_0 0) vcvs gain=9.807852804032e-01
SCONVI_c057_0_00 (conv_i_src_c057_0_00 conv_i_c057_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_00 (conv_q_src_c057_0_00 0 conv_bpf_c057_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_0_00 (conv_q_src_c057_0_00 conv_q_c057_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_01 (conv_i_src_c057_0_01 0 conv_bpf_c057_0 0) vcvs gain=8.314696123025e-01
SCONVI_c057_0_01 (conv_i_src_c057_0_01 conv_i_c057_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_01 (conv_q_src_c057_0_01 0 conv_bpf_c057_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_0_01 (conv_q_src_c057_0_01 conv_q_c057_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_02 (conv_i_src_c057_0_02 0 conv_bpf_c057_0 0) vcvs gain=5.555702330196e-01
SCONVI_c057_0_02 (conv_i_src_c057_0_02 conv_i_c057_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_02 (conv_q_src_c057_0_02 0 conv_bpf_c057_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_0_02 (conv_q_src_c057_0_02 conv_q_c057_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_03 (conv_i_src_c057_0_03 0 conv_bpf_c057_0 0) vcvs gain=1.950903220161e-01
SCONVI_c057_0_03 (conv_i_src_c057_0_03 conv_i_c057_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_03 (conv_q_src_c057_0_03 0 conv_bpf_c057_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_0_03 (conv_q_src_c057_0_03 conv_q_c057_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_04 (conv_i_src_c057_0_04 0 conv_bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_0_04 (conv_i_src_c057_0_04 conv_i_c057_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_04 (conv_q_src_c057_0_04 0 conv_bpf_c057_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_0_04 (conv_q_src_c057_0_04 conv_q_c057_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_05 (conv_i_src_c057_0_05 0 conv_bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_0_05 (conv_i_src_c057_0_05 conv_i_c057_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_05 (conv_q_src_c057_0_05 0 conv_bpf_c057_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_0_05 (conv_q_src_c057_0_05 conv_q_c057_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_06 (conv_i_src_c057_0_06 0 conv_bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_0_06 (conv_i_src_c057_0_06 conv_i_c057_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_06 (conv_q_src_c057_0_06 0 conv_bpf_c057_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_0_06 (conv_q_src_c057_0_06 conv_q_c057_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_07 (conv_i_src_c057_0_07 0 conv_bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_0_07 (conv_i_src_c057_0_07 conv_i_c057_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_07 (conv_q_src_c057_0_07 0 conv_bpf_c057_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_0_07 (conv_q_src_c057_0_07 conv_q_c057_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_08 (conv_i_src_c057_0_08 0 conv_bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_0_08 (conv_i_src_c057_0_08 conv_i_c057_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_08 (conv_q_src_c057_0_08 0 conv_bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_0_08 (conv_q_src_c057_0_08 conv_q_c057_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_09 (conv_i_src_c057_0_09 0 conv_bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_0_09 (conv_i_src_c057_0_09 conv_i_c057_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_09 (conv_q_src_c057_0_09 0 conv_bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_0_09 (conv_q_src_c057_0_09 conv_q_c057_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_10 (conv_i_src_c057_0_10 0 conv_bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_0_10 (conv_i_src_c057_0_10 conv_i_c057_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_10 (conv_q_src_c057_0_10 0 conv_bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_0_10 (conv_q_src_c057_0_10 conv_q_c057_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_11 (conv_i_src_c057_0_11 0 conv_bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_0_11 (conv_i_src_c057_0_11 conv_i_c057_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_11 (conv_q_src_c057_0_11 0 conv_bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_0_11 (conv_q_src_c057_0_11 conv_q_c057_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_12 (conv_i_src_c057_0_12 0 conv_bpf_c057_0 0) vcvs gain=1.950903220161e-01
SCONVI_c057_0_12 (conv_i_src_c057_0_12 conv_i_c057_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_12 (conv_q_src_c057_0_12 0 conv_bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_0_12 (conv_q_src_c057_0_12 conv_q_c057_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_13 (conv_i_src_c057_0_13 0 conv_bpf_c057_0 0) vcvs gain=5.555702330196e-01
SCONVI_c057_0_13 (conv_i_src_c057_0_13 conv_i_c057_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_13 (conv_q_src_c057_0_13 0 conv_bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_0_13 (conv_q_src_c057_0_13 conv_q_c057_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_14 (conv_i_src_c057_0_14 0 conv_bpf_c057_0 0) vcvs gain=8.314696123025e-01
SCONVI_c057_0_14 (conv_i_src_c057_0_14 conv_i_c057_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_14 (conv_q_src_c057_0_14 0 conv_bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_0_14 (conv_q_src_c057_0_14 conv_q_c057_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_0_15 (conv_i_src_c057_0_15 0 conv_bpf_c057_0 0) vcvs gain=9.807852804032e-01
SCONVI_c057_0_15 (conv_i_src_c057_0_15 conv_i_c057_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_0_15 (conv_q_src_c057_0_15 0 conv_bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_0_15 (conv_q_src_c057_0_15 conv_q_c057_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c057_0 (conv_i_c057_0 0) resistor r=1G
RCONVQ_c057_0 (conv_q_c057_0 0) resistor r=1G
RCONVINTI_c057_0 (conv_i_c057_0 ConvIcar_c057_0) resistor r=1k
CCONVINTI_c057_0 (ConvIcar_c057_0 0) capacitor c=80p
RCONVINTQ_c057_0 (conv_q_c057_0 ConvQcar_c057_0) resistor r=1k
CCONVINTQ_c057_0 (ConvQcar_c057_0 0) capacitor c=80p
save conv_bpf_c057_0 ConvIcar_c057_0 ConvQcar_c057_0

// conventional mixed baseline bl057, carrier_1: 500000000 Hz
CCONVBPF_c057_1 (bl057 n_conv_cbpf_c057_1) capacitor c=1.013211836423e-13
LCONVBPF_c057_1 (n_conv_cbpf_c057_1 conv_bpf_c057_1) inductor l=1.000000000000e-06
RCONVBPF_c057_1 (conv_bpf_c057_1 0) resistor r=1.570796326795e+02
ECONVI_c057_1_00 (conv_i_src_c057_1_00 0 conv_bpf_c057_1 0) vcvs gain=9.807852804032e-01
SCONVI_c057_1_00 (conv_i_src_c057_1_00 conv_i_c057_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_00 (conv_q_src_c057_1_00 0 conv_bpf_c057_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_1_00 (conv_q_src_c057_1_00 conv_q_c057_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_01 (conv_i_src_c057_1_01 0 conv_bpf_c057_1 0) vcvs gain=8.314696123025e-01
SCONVI_c057_1_01 (conv_i_src_c057_1_01 conv_i_c057_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_01 (conv_q_src_c057_1_01 0 conv_bpf_c057_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_1_01 (conv_q_src_c057_1_01 conv_q_c057_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_02 (conv_i_src_c057_1_02 0 conv_bpf_c057_1 0) vcvs gain=5.555702330196e-01
SCONVI_c057_1_02 (conv_i_src_c057_1_02 conv_i_c057_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_02 (conv_q_src_c057_1_02 0 conv_bpf_c057_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_1_02 (conv_q_src_c057_1_02 conv_q_c057_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_03 (conv_i_src_c057_1_03 0 conv_bpf_c057_1 0) vcvs gain=1.950903220161e-01
SCONVI_c057_1_03 (conv_i_src_c057_1_03 conv_i_c057_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_03 (conv_q_src_c057_1_03 0 conv_bpf_c057_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_1_03 (conv_q_src_c057_1_03 conv_q_c057_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_04 (conv_i_src_c057_1_04 0 conv_bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_1_04 (conv_i_src_c057_1_04 conv_i_c057_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_04 (conv_q_src_c057_1_04 0 conv_bpf_c057_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_1_04 (conv_q_src_c057_1_04 conv_q_c057_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_05 (conv_i_src_c057_1_05 0 conv_bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_1_05 (conv_i_src_c057_1_05 conv_i_c057_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_05 (conv_q_src_c057_1_05 0 conv_bpf_c057_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_1_05 (conv_q_src_c057_1_05 conv_q_c057_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_06 (conv_i_src_c057_1_06 0 conv_bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_1_06 (conv_i_src_c057_1_06 conv_i_c057_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_06 (conv_q_src_c057_1_06 0 conv_bpf_c057_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_1_06 (conv_q_src_c057_1_06 conv_q_c057_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_07 (conv_i_src_c057_1_07 0 conv_bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_1_07 (conv_i_src_c057_1_07 conv_i_c057_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_07 (conv_q_src_c057_1_07 0 conv_bpf_c057_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_1_07 (conv_q_src_c057_1_07 conv_q_c057_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_08 (conv_i_src_c057_1_08 0 conv_bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_1_08 (conv_i_src_c057_1_08 conv_i_c057_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_08 (conv_q_src_c057_1_08 0 conv_bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_1_08 (conv_q_src_c057_1_08 conv_q_c057_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_09 (conv_i_src_c057_1_09 0 conv_bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_1_09 (conv_i_src_c057_1_09 conv_i_c057_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_09 (conv_q_src_c057_1_09 0 conv_bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_1_09 (conv_q_src_c057_1_09 conv_q_c057_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_10 (conv_i_src_c057_1_10 0 conv_bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_1_10 (conv_i_src_c057_1_10 conv_i_c057_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_10 (conv_q_src_c057_1_10 0 conv_bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_1_10 (conv_q_src_c057_1_10 conv_q_c057_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_11 (conv_i_src_c057_1_11 0 conv_bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_1_11 (conv_i_src_c057_1_11 conv_i_c057_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_11 (conv_q_src_c057_1_11 0 conv_bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_1_11 (conv_q_src_c057_1_11 conv_q_c057_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_12 (conv_i_src_c057_1_12 0 conv_bpf_c057_1 0) vcvs gain=1.950903220161e-01
SCONVI_c057_1_12 (conv_i_src_c057_1_12 conv_i_c057_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_12 (conv_q_src_c057_1_12 0 conv_bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_1_12 (conv_q_src_c057_1_12 conv_q_c057_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_13 (conv_i_src_c057_1_13 0 conv_bpf_c057_1 0) vcvs gain=5.555702330196e-01
SCONVI_c057_1_13 (conv_i_src_c057_1_13 conv_i_c057_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_13 (conv_q_src_c057_1_13 0 conv_bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_1_13 (conv_q_src_c057_1_13 conv_q_c057_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_14 (conv_i_src_c057_1_14 0 conv_bpf_c057_1 0) vcvs gain=8.314696123025e-01
SCONVI_c057_1_14 (conv_i_src_c057_1_14 conv_i_c057_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_14 (conv_q_src_c057_1_14 0 conv_bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_1_14 (conv_q_src_c057_1_14 conv_q_c057_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_1_15 (conv_i_src_c057_1_15 0 conv_bpf_c057_1 0) vcvs gain=9.807852804032e-01
SCONVI_c057_1_15 (conv_i_src_c057_1_15 conv_i_c057_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_1_15 (conv_q_src_c057_1_15 0 conv_bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_1_15 (conv_q_src_c057_1_15 conv_q_c057_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c057_1 (conv_i_c057_1 0) resistor r=1G
RCONVQ_c057_1 (conv_q_c057_1 0) resistor r=1G
RCONVINTI_c057_1 (conv_i_c057_1 ConvIcar_c057_1) resistor r=1k
CCONVINTI_c057_1 (ConvIcar_c057_1 0) capacitor c=80p
RCONVINTQ_c057_1 (conv_q_c057_1 ConvQcar_c057_1) resistor r=1k
CCONVINTQ_c057_1 (ConvQcar_c057_1 0) capacitor c=80p
save conv_bpf_c057_1 ConvIcar_c057_1 ConvQcar_c057_1

// conventional mixed baseline bl057, carrier_2: 750000000 Hz
CCONVBPF_c057_2 (bl057 n_conv_cbpf_c057_2) capacitor c=4.503163717437e-14
LCONVBPF_c057_2 (n_conv_cbpf_c057_2 conv_bpf_c057_2) inductor l=1.000000000000e-06
RCONVBPF_c057_2 (conv_bpf_c057_2 0) resistor r=2.356194490192e+02
ECONVI_c057_2_00 (conv_i_src_c057_2_00 0 conv_bpf_c057_2 0) vcvs gain=9.807852804032e-01
SCONVI_c057_2_00 (conv_i_src_c057_2_00 conv_i_c057_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_00 (conv_q_src_c057_2_00 0 conv_bpf_c057_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_2_00 (conv_q_src_c057_2_00 conv_q_c057_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_01 (conv_i_src_c057_2_01 0 conv_bpf_c057_2 0) vcvs gain=8.314696123025e-01
SCONVI_c057_2_01 (conv_i_src_c057_2_01 conv_i_c057_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_01 (conv_q_src_c057_2_01 0 conv_bpf_c057_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_2_01 (conv_q_src_c057_2_01 conv_q_c057_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_02 (conv_i_src_c057_2_02 0 conv_bpf_c057_2 0) vcvs gain=5.555702330196e-01
SCONVI_c057_2_02 (conv_i_src_c057_2_02 conv_i_c057_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_02 (conv_q_src_c057_2_02 0 conv_bpf_c057_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_2_02 (conv_q_src_c057_2_02 conv_q_c057_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_03 (conv_i_src_c057_2_03 0 conv_bpf_c057_2 0) vcvs gain=1.950903220161e-01
SCONVI_c057_2_03 (conv_i_src_c057_2_03 conv_i_c057_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_03 (conv_q_src_c057_2_03 0 conv_bpf_c057_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_2_03 (conv_q_src_c057_2_03 conv_q_c057_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_04 (conv_i_src_c057_2_04 0 conv_bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_2_04 (conv_i_src_c057_2_04 conv_i_c057_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_04 (conv_q_src_c057_2_04 0 conv_bpf_c057_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_2_04 (conv_q_src_c057_2_04 conv_q_c057_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_05 (conv_i_src_c057_2_05 0 conv_bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_2_05 (conv_i_src_c057_2_05 conv_i_c057_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_05 (conv_q_src_c057_2_05 0 conv_bpf_c057_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_2_05 (conv_q_src_c057_2_05 conv_q_c057_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_06 (conv_i_src_c057_2_06 0 conv_bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_2_06 (conv_i_src_c057_2_06 conv_i_c057_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_06 (conv_q_src_c057_2_06 0 conv_bpf_c057_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_2_06 (conv_q_src_c057_2_06 conv_q_c057_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_07 (conv_i_src_c057_2_07 0 conv_bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_2_07 (conv_i_src_c057_2_07 conv_i_c057_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_07 (conv_q_src_c057_2_07 0 conv_bpf_c057_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_2_07 (conv_q_src_c057_2_07 conv_q_c057_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_08 (conv_i_src_c057_2_08 0 conv_bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_2_08 (conv_i_src_c057_2_08 conv_i_c057_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_08 (conv_q_src_c057_2_08 0 conv_bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_2_08 (conv_q_src_c057_2_08 conv_q_c057_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_09 (conv_i_src_c057_2_09 0 conv_bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_2_09 (conv_i_src_c057_2_09 conv_i_c057_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_09 (conv_q_src_c057_2_09 0 conv_bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_2_09 (conv_q_src_c057_2_09 conv_q_c057_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_10 (conv_i_src_c057_2_10 0 conv_bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_2_10 (conv_i_src_c057_2_10 conv_i_c057_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_10 (conv_q_src_c057_2_10 0 conv_bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_2_10 (conv_q_src_c057_2_10 conv_q_c057_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_11 (conv_i_src_c057_2_11 0 conv_bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_2_11 (conv_i_src_c057_2_11 conv_i_c057_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_11 (conv_q_src_c057_2_11 0 conv_bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_2_11 (conv_q_src_c057_2_11 conv_q_c057_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_12 (conv_i_src_c057_2_12 0 conv_bpf_c057_2 0) vcvs gain=1.950903220161e-01
SCONVI_c057_2_12 (conv_i_src_c057_2_12 conv_i_c057_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_12 (conv_q_src_c057_2_12 0 conv_bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_2_12 (conv_q_src_c057_2_12 conv_q_c057_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_13 (conv_i_src_c057_2_13 0 conv_bpf_c057_2 0) vcvs gain=5.555702330196e-01
SCONVI_c057_2_13 (conv_i_src_c057_2_13 conv_i_c057_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_13 (conv_q_src_c057_2_13 0 conv_bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_2_13 (conv_q_src_c057_2_13 conv_q_c057_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_14 (conv_i_src_c057_2_14 0 conv_bpf_c057_2 0) vcvs gain=8.314696123025e-01
SCONVI_c057_2_14 (conv_i_src_c057_2_14 conv_i_c057_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_14 (conv_q_src_c057_2_14 0 conv_bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_2_14 (conv_q_src_c057_2_14 conv_q_c057_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_2_15 (conv_i_src_c057_2_15 0 conv_bpf_c057_2 0) vcvs gain=9.807852804032e-01
SCONVI_c057_2_15 (conv_i_src_c057_2_15 conv_i_c057_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_2_15 (conv_q_src_c057_2_15 0 conv_bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_2_15 (conv_q_src_c057_2_15 conv_q_c057_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c057_2 (conv_i_c057_2 0) resistor r=1G
RCONVQ_c057_2 (conv_q_c057_2 0) resistor r=1G
RCONVINTI_c057_2 (conv_i_c057_2 ConvIcar_c057_2) resistor r=1k
CCONVINTI_c057_2 (ConvIcar_c057_2 0) capacitor c=80p
RCONVINTQ_c057_2 (conv_q_c057_2 ConvQcar_c057_2) resistor r=1k
CCONVINTQ_c057_2 (ConvQcar_c057_2 0) capacitor c=80p
save conv_bpf_c057_2 ConvIcar_c057_2 ConvQcar_c057_2

// conventional mixed baseline bl057, carrier_3: 1000000000 Hz
CCONVBPF_c057_3 (bl057 n_conv_cbpf_c057_3) capacitor c=2.533029591058e-14
LCONVBPF_c057_3 (n_conv_cbpf_c057_3 conv_bpf_c057_3) inductor l=1.000000000000e-06
RCONVBPF_c057_3 (conv_bpf_c057_3 0) resistor r=3.141592653590e+02
ECONVI_c057_3_00 (conv_i_src_c057_3_00 0 conv_bpf_c057_3 0) vcvs gain=9.807852804032e-01
SCONVI_c057_3_00 (conv_i_src_c057_3_00 conv_i_c057_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_00 (conv_q_src_c057_3_00 0 conv_bpf_c057_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_3_00 (conv_q_src_c057_3_00 conv_q_c057_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_01 (conv_i_src_c057_3_01 0 conv_bpf_c057_3 0) vcvs gain=8.314696123025e-01
SCONVI_c057_3_01 (conv_i_src_c057_3_01 conv_i_c057_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_01 (conv_q_src_c057_3_01 0 conv_bpf_c057_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_3_01 (conv_q_src_c057_3_01 conv_q_c057_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_02 (conv_i_src_c057_3_02 0 conv_bpf_c057_3 0) vcvs gain=5.555702330196e-01
SCONVI_c057_3_02 (conv_i_src_c057_3_02 conv_i_c057_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_02 (conv_q_src_c057_3_02 0 conv_bpf_c057_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_3_02 (conv_q_src_c057_3_02 conv_q_c057_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_03 (conv_i_src_c057_3_03 0 conv_bpf_c057_3 0) vcvs gain=1.950903220161e-01
SCONVI_c057_3_03 (conv_i_src_c057_3_03 conv_i_c057_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_03 (conv_q_src_c057_3_03 0 conv_bpf_c057_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_3_03 (conv_q_src_c057_3_03 conv_q_c057_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_04 (conv_i_src_c057_3_04 0 conv_bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_3_04 (conv_i_src_c057_3_04 conv_i_c057_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_04 (conv_q_src_c057_3_04 0 conv_bpf_c057_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c057_3_04 (conv_q_src_c057_3_04 conv_q_c057_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_05 (conv_i_src_c057_3_05 0 conv_bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_3_05 (conv_i_src_c057_3_05 conv_i_c057_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_05 (conv_q_src_c057_3_05 0 conv_bpf_c057_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c057_3_05 (conv_q_src_c057_3_05 conv_q_c057_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_06 (conv_i_src_c057_3_06 0 conv_bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_3_06 (conv_i_src_c057_3_06 conv_i_c057_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_06 (conv_q_src_c057_3_06 0 conv_bpf_c057_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c057_3_06 (conv_q_src_c057_3_06 conv_q_c057_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_07 (conv_i_src_c057_3_07 0 conv_bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_3_07 (conv_i_src_c057_3_07 conv_i_c057_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_07 (conv_q_src_c057_3_07 0 conv_bpf_c057_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c057_3_07 (conv_q_src_c057_3_07 conv_q_c057_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_08 (conv_i_src_c057_3_08 0 conv_bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c057_3_08 (conv_i_src_c057_3_08 conv_i_c057_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_08 (conv_q_src_c057_3_08 0 conv_bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_3_08 (conv_q_src_c057_3_08 conv_q_c057_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_09 (conv_i_src_c057_3_09 0 conv_bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c057_3_09 (conv_i_src_c057_3_09 conv_i_c057_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_09 (conv_q_src_c057_3_09 0 conv_bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_3_09 (conv_q_src_c057_3_09 conv_q_c057_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_10 (conv_i_src_c057_3_10 0 conv_bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c057_3_10 (conv_i_src_c057_3_10 conv_i_c057_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_10 (conv_q_src_c057_3_10 0 conv_bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_3_10 (conv_q_src_c057_3_10 conv_q_c057_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_11 (conv_i_src_c057_3_11 0 conv_bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c057_3_11 (conv_i_src_c057_3_11 conv_i_c057_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_11 (conv_q_src_c057_3_11 0 conv_bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_3_11 (conv_q_src_c057_3_11 conv_q_c057_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_12 (conv_i_src_c057_3_12 0 conv_bpf_c057_3 0) vcvs gain=1.950903220161e-01
SCONVI_c057_3_12 (conv_i_src_c057_3_12 conv_i_c057_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_12 (conv_q_src_c057_3_12 0 conv_bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c057_3_12 (conv_q_src_c057_3_12 conv_q_c057_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_13 (conv_i_src_c057_3_13 0 conv_bpf_c057_3 0) vcvs gain=5.555702330196e-01
SCONVI_c057_3_13 (conv_i_src_c057_3_13 conv_i_c057_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_13 (conv_q_src_c057_3_13 0 conv_bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c057_3_13 (conv_q_src_c057_3_13 conv_q_c057_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_14 (conv_i_src_c057_3_14 0 conv_bpf_c057_3 0) vcvs gain=8.314696123025e-01
SCONVI_c057_3_14 (conv_i_src_c057_3_14 conv_i_c057_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_14 (conv_q_src_c057_3_14 0 conv_bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c057_3_14 (conv_q_src_c057_3_14 conv_q_c057_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c057_3_15 (conv_i_src_c057_3_15 0 conv_bpf_c057_3 0) vcvs gain=9.807852804032e-01
SCONVI_c057_3_15 (conv_i_src_c057_3_15 conv_i_c057_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c057_3_15 (conv_q_src_c057_3_15 0 conv_bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c057_3_15 (conv_q_src_c057_3_15 conv_q_c057_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c057_3 (conv_i_c057_3 0) resistor r=1G
RCONVQ_c057_3 (conv_q_c057_3 0) resistor r=1G
RCONVINTI_c057_3 (conv_i_c057_3 ConvIcar_c057_3) resistor r=1k
CCONVINTI_c057_3 (ConvIcar_c057_3 0) capacitor c=80p
RCONVINTQ_c057_3 (conv_q_c057_3 ConvQcar_c057_3) resistor r=1k
CCONVINTQ_c057_3 (ConvQcar_c057_3 0) capacitor c=80p
save conv_bpf_c057_3 ConvIcar_c057_3 ConvQcar_c057_3

// conventional mixed baseline bl058, carrier_0: 250000000 Hz
CCONVBPF_c058_0 (bl058 n_conv_cbpf_c058_0) capacitor c=4.052847345694e-13
LCONVBPF_c058_0 (n_conv_cbpf_c058_0 conv_bpf_c058_0) inductor l=1.000000000000e-06
RCONVBPF_c058_0 (conv_bpf_c058_0 0) resistor r=7.853981633974e+01
ECONVI_c058_0_00 (conv_i_src_c058_0_00 0 conv_bpf_c058_0 0) vcvs gain=9.807852804032e-01
SCONVI_c058_0_00 (conv_i_src_c058_0_00 conv_i_c058_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_00 (conv_q_src_c058_0_00 0 conv_bpf_c058_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_0_00 (conv_q_src_c058_0_00 conv_q_c058_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_01 (conv_i_src_c058_0_01 0 conv_bpf_c058_0 0) vcvs gain=8.314696123025e-01
SCONVI_c058_0_01 (conv_i_src_c058_0_01 conv_i_c058_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_01 (conv_q_src_c058_0_01 0 conv_bpf_c058_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_0_01 (conv_q_src_c058_0_01 conv_q_c058_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_02 (conv_i_src_c058_0_02 0 conv_bpf_c058_0 0) vcvs gain=5.555702330196e-01
SCONVI_c058_0_02 (conv_i_src_c058_0_02 conv_i_c058_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_02 (conv_q_src_c058_0_02 0 conv_bpf_c058_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_0_02 (conv_q_src_c058_0_02 conv_q_c058_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_03 (conv_i_src_c058_0_03 0 conv_bpf_c058_0 0) vcvs gain=1.950903220161e-01
SCONVI_c058_0_03 (conv_i_src_c058_0_03 conv_i_c058_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_03 (conv_q_src_c058_0_03 0 conv_bpf_c058_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_0_03 (conv_q_src_c058_0_03 conv_q_c058_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_04 (conv_i_src_c058_0_04 0 conv_bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_0_04 (conv_i_src_c058_0_04 conv_i_c058_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_04 (conv_q_src_c058_0_04 0 conv_bpf_c058_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_0_04 (conv_q_src_c058_0_04 conv_q_c058_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_05 (conv_i_src_c058_0_05 0 conv_bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_0_05 (conv_i_src_c058_0_05 conv_i_c058_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_05 (conv_q_src_c058_0_05 0 conv_bpf_c058_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_0_05 (conv_q_src_c058_0_05 conv_q_c058_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_06 (conv_i_src_c058_0_06 0 conv_bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_0_06 (conv_i_src_c058_0_06 conv_i_c058_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_06 (conv_q_src_c058_0_06 0 conv_bpf_c058_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_0_06 (conv_q_src_c058_0_06 conv_q_c058_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_07 (conv_i_src_c058_0_07 0 conv_bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_0_07 (conv_i_src_c058_0_07 conv_i_c058_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_07 (conv_q_src_c058_0_07 0 conv_bpf_c058_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_0_07 (conv_q_src_c058_0_07 conv_q_c058_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_08 (conv_i_src_c058_0_08 0 conv_bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_0_08 (conv_i_src_c058_0_08 conv_i_c058_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_08 (conv_q_src_c058_0_08 0 conv_bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_0_08 (conv_q_src_c058_0_08 conv_q_c058_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_09 (conv_i_src_c058_0_09 0 conv_bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_0_09 (conv_i_src_c058_0_09 conv_i_c058_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_09 (conv_q_src_c058_0_09 0 conv_bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_0_09 (conv_q_src_c058_0_09 conv_q_c058_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_10 (conv_i_src_c058_0_10 0 conv_bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_0_10 (conv_i_src_c058_0_10 conv_i_c058_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_10 (conv_q_src_c058_0_10 0 conv_bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_0_10 (conv_q_src_c058_0_10 conv_q_c058_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_11 (conv_i_src_c058_0_11 0 conv_bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_0_11 (conv_i_src_c058_0_11 conv_i_c058_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_11 (conv_q_src_c058_0_11 0 conv_bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_0_11 (conv_q_src_c058_0_11 conv_q_c058_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_12 (conv_i_src_c058_0_12 0 conv_bpf_c058_0 0) vcvs gain=1.950903220161e-01
SCONVI_c058_0_12 (conv_i_src_c058_0_12 conv_i_c058_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_12 (conv_q_src_c058_0_12 0 conv_bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_0_12 (conv_q_src_c058_0_12 conv_q_c058_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_13 (conv_i_src_c058_0_13 0 conv_bpf_c058_0 0) vcvs gain=5.555702330196e-01
SCONVI_c058_0_13 (conv_i_src_c058_0_13 conv_i_c058_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_13 (conv_q_src_c058_0_13 0 conv_bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_0_13 (conv_q_src_c058_0_13 conv_q_c058_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_14 (conv_i_src_c058_0_14 0 conv_bpf_c058_0 0) vcvs gain=8.314696123025e-01
SCONVI_c058_0_14 (conv_i_src_c058_0_14 conv_i_c058_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_14 (conv_q_src_c058_0_14 0 conv_bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_0_14 (conv_q_src_c058_0_14 conv_q_c058_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_0_15 (conv_i_src_c058_0_15 0 conv_bpf_c058_0 0) vcvs gain=9.807852804032e-01
SCONVI_c058_0_15 (conv_i_src_c058_0_15 conv_i_c058_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_0_15 (conv_q_src_c058_0_15 0 conv_bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_0_15 (conv_q_src_c058_0_15 conv_q_c058_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c058_0 (conv_i_c058_0 0) resistor r=1G
RCONVQ_c058_0 (conv_q_c058_0 0) resistor r=1G
RCONVINTI_c058_0 (conv_i_c058_0 ConvIcar_c058_0) resistor r=1k
CCONVINTI_c058_0 (ConvIcar_c058_0 0) capacitor c=80p
RCONVINTQ_c058_0 (conv_q_c058_0 ConvQcar_c058_0) resistor r=1k
CCONVINTQ_c058_0 (ConvQcar_c058_0 0) capacitor c=80p
save conv_bpf_c058_0 ConvIcar_c058_0 ConvQcar_c058_0

// conventional mixed baseline bl058, carrier_1: 500000000 Hz
CCONVBPF_c058_1 (bl058 n_conv_cbpf_c058_1) capacitor c=1.013211836423e-13
LCONVBPF_c058_1 (n_conv_cbpf_c058_1 conv_bpf_c058_1) inductor l=1.000000000000e-06
RCONVBPF_c058_1 (conv_bpf_c058_1 0) resistor r=1.570796326795e+02
ECONVI_c058_1_00 (conv_i_src_c058_1_00 0 conv_bpf_c058_1 0) vcvs gain=9.807852804032e-01
SCONVI_c058_1_00 (conv_i_src_c058_1_00 conv_i_c058_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_00 (conv_q_src_c058_1_00 0 conv_bpf_c058_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_1_00 (conv_q_src_c058_1_00 conv_q_c058_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_01 (conv_i_src_c058_1_01 0 conv_bpf_c058_1 0) vcvs gain=8.314696123025e-01
SCONVI_c058_1_01 (conv_i_src_c058_1_01 conv_i_c058_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_01 (conv_q_src_c058_1_01 0 conv_bpf_c058_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_1_01 (conv_q_src_c058_1_01 conv_q_c058_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_02 (conv_i_src_c058_1_02 0 conv_bpf_c058_1 0) vcvs gain=5.555702330196e-01
SCONVI_c058_1_02 (conv_i_src_c058_1_02 conv_i_c058_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_02 (conv_q_src_c058_1_02 0 conv_bpf_c058_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_1_02 (conv_q_src_c058_1_02 conv_q_c058_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_03 (conv_i_src_c058_1_03 0 conv_bpf_c058_1 0) vcvs gain=1.950903220161e-01
SCONVI_c058_1_03 (conv_i_src_c058_1_03 conv_i_c058_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_03 (conv_q_src_c058_1_03 0 conv_bpf_c058_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_1_03 (conv_q_src_c058_1_03 conv_q_c058_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_04 (conv_i_src_c058_1_04 0 conv_bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_1_04 (conv_i_src_c058_1_04 conv_i_c058_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_04 (conv_q_src_c058_1_04 0 conv_bpf_c058_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_1_04 (conv_q_src_c058_1_04 conv_q_c058_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_05 (conv_i_src_c058_1_05 0 conv_bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_1_05 (conv_i_src_c058_1_05 conv_i_c058_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_05 (conv_q_src_c058_1_05 0 conv_bpf_c058_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_1_05 (conv_q_src_c058_1_05 conv_q_c058_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_06 (conv_i_src_c058_1_06 0 conv_bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_1_06 (conv_i_src_c058_1_06 conv_i_c058_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_06 (conv_q_src_c058_1_06 0 conv_bpf_c058_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_1_06 (conv_q_src_c058_1_06 conv_q_c058_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_07 (conv_i_src_c058_1_07 0 conv_bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_1_07 (conv_i_src_c058_1_07 conv_i_c058_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_07 (conv_q_src_c058_1_07 0 conv_bpf_c058_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_1_07 (conv_q_src_c058_1_07 conv_q_c058_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_08 (conv_i_src_c058_1_08 0 conv_bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_1_08 (conv_i_src_c058_1_08 conv_i_c058_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_08 (conv_q_src_c058_1_08 0 conv_bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_1_08 (conv_q_src_c058_1_08 conv_q_c058_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_09 (conv_i_src_c058_1_09 0 conv_bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_1_09 (conv_i_src_c058_1_09 conv_i_c058_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_09 (conv_q_src_c058_1_09 0 conv_bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_1_09 (conv_q_src_c058_1_09 conv_q_c058_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_10 (conv_i_src_c058_1_10 0 conv_bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_1_10 (conv_i_src_c058_1_10 conv_i_c058_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_10 (conv_q_src_c058_1_10 0 conv_bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_1_10 (conv_q_src_c058_1_10 conv_q_c058_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_11 (conv_i_src_c058_1_11 0 conv_bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_1_11 (conv_i_src_c058_1_11 conv_i_c058_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_11 (conv_q_src_c058_1_11 0 conv_bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_1_11 (conv_q_src_c058_1_11 conv_q_c058_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_12 (conv_i_src_c058_1_12 0 conv_bpf_c058_1 0) vcvs gain=1.950903220161e-01
SCONVI_c058_1_12 (conv_i_src_c058_1_12 conv_i_c058_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_12 (conv_q_src_c058_1_12 0 conv_bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_1_12 (conv_q_src_c058_1_12 conv_q_c058_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_13 (conv_i_src_c058_1_13 0 conv_bpf_c058_1 0) vcvs gain=5.555702330196e-01
SCONVI_c058_1_13 (conv_i_src_c058_1_13 conv_i_c058_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_13 (conv_q_src_c058_1_13 0 conv_bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_1_13 (conv_q_src_c058_1_13 conv_q_c058_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_14 (conv_i_src_c058_1_14 0 conv_bpf_c058_1 0) vcvs gain=8.314696123025e-01
SCONVI_c058_1_14 (conv_i_src_c058_1_14 conv_i_c058_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_14 (conv_q_src_c058_1_14 0 conv_bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_1_14 (conv_q_src_c058_1_14 conv_q_c058_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_1_15 (conv_i_src_c058_1_15 0 conv_bpf_c058_1 0) vcvs gain=9.807852804032e-01
SCONVI_c058_1_15 (conv_i_src_c058_1_15 conv_i_c058_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_1_15 (conv_q_src_c058_1_15 0 conv_bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_1_15 (conv_q_src_c058_1_15 conv_q_c058_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c058_1 (conv_i_c058_1 0) resistor r=1G
RCONVQ_c058_1 (conv_q_c058_1 0) resistor r=1G
RCONVINTI_c058_1 (conv_i_c058_1 ConvIcar_c058_1) resistor r=1k
CCONVINTI_c058_1 (ConvIcar_c058_1 0) capacitor c=80p
RCONVINTQ_c058_1 (conv_q_c058_1 ConvQcar_c058_1) resistor r=1k
CCONVINTQ_c058_1 (ConvQcar_c058_1 0) capacitor c=80p
save conv_bpf_c058_1 ConvIcar_c058_1 ConvQcar_c058_1

// conventional mixed baseline bl058, carrier_2: 750000000 Hz
CCONVBPF_c058_2 (bl058 n_conv_cbpf_c058_2) capacitor c=4.503163717437e-14
LCONVBPF_c058_2 (n_conv_cbpf_c058_2 conv_bpf_c058_2) inductor l=1.000000000000e-06
RCONVBPF_c058_2 (conv_bpf_c058_2 0) resistor r=2.356194490192e+02
ECONVI_c058_2_00 (conv_i_src_c058_2_00 0 conv_bpf_c058_2 0) vcvs gain=9.807852804032e-01
SCONVI_c058_2_00 (conv_i_src_c058_2_00 conv_i_c058_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_00 (conv_q_src_c058_2_00 0 conv_bpf_c058_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_2_00 (conv_q_src_c058_2_00 conv_q_c058_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_01 (conv_i_src_c058_2_01 0 conv_bpf_c058_2 0) vcvs gain=8.314696123025e-01
SCONVI_c058_2_01 (conv_i_src_c058_2_01 conv_i_c058_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_01 (conv_q_src_c058_2_01 0 conv_bpf_c058_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_2_01 (conv_q_src_c058_2_01 conv_q_c058_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_02 (conv_i_src_c058_2_02 0 conv_bpf_c058_2 0) vcvs gain=5.555702330196e-01
SCONVI_c058_2_02 (conv_i_src_c058_2_02 conv_i_c058_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_02 (conv_q_src_c058_2_02 0 conv_bpf_c058_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_2_02 (conv_q_src_c058_2_02 conv_q_c058_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_03 (conv_i_src_c058_2_03 0 conv_bpf_c058_2 0) vcvs gain=1.950903220161e-01
SCONVI_c058_2_03 (conv_i_src_c058_2_03 conv_i_c058_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_03 (conv_q_src_c058_2_03 0 conv_bpf_c058_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_2_03 (conv_q_src_c058_2_03 conv_q_c058_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_04 (conv_i_src_c058_2_04 0 conv_bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_2_04 (conv_i_src_c058_2_04 conv_i_c058_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_04 (conv_q_src_c058_2_04 0 conv_bpf_c058_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_2_04 (conv_q_src_c058_2_04 conv_q_c058_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_05 (conv_i_src_c058_2_05 0 conv_bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_2_05 (conv_i_src_c058_2_05 conv_i_c058_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_05 (conv_q_src_c058_2_05 0 conv_bpf_c058_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_2_05 (conv_q_src_c058_2_05 conv_q_c058_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_06 (conv_i_src_c058_2_06 0 conv_bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_2_06 (conv_i_src_c058_2_06 conv_i_c058_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_06 (conv_q_src_c058_2_06 0 conv_bpf_c058_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_2_06 (conv_q_src_c058_2_06 conv_q_c058_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_07 (conv_i_src_c058_2_07 0 conv_bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_2_07 (conv_i_src_c058_2_07 conv_i_c058_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_07 (conv_q_src_c058_2_07 0 conv_bpf_c058_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_2_07 (conv_q_src_c058_2_07 conv_q_c058_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_08 (conv_i_src_c058_2_08 0 conv_bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_2_08 (conv_i_src_c058_2_08 conv_i_c058_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_08 (conv_q_src_c058_2_08 0 conv_bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_2_08 (conv_q_src_c058_2_08 conv_q_c058_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_09 (conv_i_src_c058_2_09 0 conv_bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_2_09 (conv_i_src_c058_2_09 conv_i_c058_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_09 (conv_q_src_c058_2_09 0 conv_bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_2_09 (conv_q_src_c058_2_09 conv_q_c058_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_10 (conv_i_src_c058_2_10 0 conv_bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_2_10 (conv_i_src_c058_2_10 conv_i_c058_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_10 (conv_q_src_c058_2_10 0 conv_bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_2_10 (conv_q_src_c058_2_10 conv_q_c058_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_11 (conv_i_src_c058_2_11 0 conv_bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_2_11 (conv_i_src_c058_2_11 conv_i_c058_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_11 (conv_q_src_c058_2_11 0 conv_bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_2_11 (conv_q_src_c058_2_11 conv_q_c058_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_12 (conv_i_src_c058_2_12 0 conv_bpf_c058_2 0) vcvs gain=1.950903220161e-01
SCONVI_c058_2_12 (conv_i_src_c058_2_12 conv_i_c058_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_12 (conv_q_src_c058_2_12 0 conv_bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_2_12 (conv_q_src_c058_2_12 conv_q_c058_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_13 (conv_i_src_c058_2_13 0 conv_bpf_c058_2 0) vcvs gain=5.555702330196e-01
SCONVI_c058_2_13 (conv_i_src_c058_2_13 conv_i_c058_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_13 (conv_q_src_c058_2_13 0 conv_bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_2_13 (conv_q_src_c058_2_13 conv_q_c058_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_14 (conv_i_src_c058_2_14 0 conv_bpf_c058_2 0) vcvs gain=8.314696123025e-01
SCONVI_c058_2_14 (conv_i_src_c058_2_14 conv_i_c058_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_14 (conv_q_src_c058_2_14 0 conv_bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_2_14 (conv_q_src_c058_2_14 conv_q_c058_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_2_15 (conv_i_src_c058_2_15 0 conv_bpf_c058_2 0) vcvs gain=9.807852804032e-01
SCONVI_c058_2_15 (conv_i_src_c058_2_15 conv_i_c058_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_2_15 (conv_q_src_c058_2_15 0 conv_bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_2_15 (conv_q_src_c058_2_15 conv_q_c058_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c058_2 (conv_i_c058_2 0) resistor r=1G
RCONVQ_c058_2 (conv_q_c058_2 0) resistor r=1G
RCONVINTI_c058_2 (conv_i_c058_2 ConvIcar_c058_2) resistor r=1k
CCONVINTI_c058_2 (ConvIcar_c058_2 0) capacitor c=80p
RCONVINTQ_c058_2 (conv_q_c058_2 ConvQcar_c058_2) resistor r=1k
CCONVINTQ_c058_2 (ConvQcar_c058_2 0) capacitor c=80p
save conv_bpf_c058_2 ConvIcar_c058_2 ConvQcar_c058_2

// conventional mixed baseline bl058, carrier_3: 1000000000 Hz
CCONVBPF_c058_3 (bl058 n_conv_cbpf_c058_3) capacitor c=2.533029591058e-14
LCONVBPF_c058_3 (n_conv_cbpf_c058_3 conv_bpf_c058_3) inductor l=1.000000000000e-06
RCONVBPF_c058_3 (conv_bpf_c058_3 0) resistor r=3.141592653590e+02
ECONVI_c058_3_00 (conv_i_src_c058_3_00 0 conv_bpf_c058_3 0) vcvs gain=9.807852804032e-01
SCONVI_c058_3_00 (conv_i_src_c058_3_00 conv_i_c058_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_00 (conv_q_src_c058_3_00 0 conv_bpf_c058_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_3_00 (conv_q_src_c058_3_00 conv_q_c058_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_01 (conv_i_src_c058_3_01 0 conv_bpf_c058_3 0) vcvs gain=8.314696123025e-01
SCONVI_c058_3_01 (conv_i_src_c058_3_01 conv_i_c058_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_01 (conv_q_src_c058_3_01 0 conv_bpf_c058_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_3_01 (conv_q_src_c058_3_01 conv_q_c058_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_02 (conv_i_src_c058_3_02 0 conv_bpf_c058_3 0) vcvs gain=5.555702330196e-01
SCONVI_c058_3_02 (conv_i_src_c058_3_02 conv_i_c058_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_02 (conv_q_src_c058_3_02 0 conv_bpf_c058_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_3_02 (conv_q_src_c058_3_02 conv_q_c058_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_03 (conv_i_src_c058_3_03 0 conv_bpf_c058_3 0) vcvs gain=1.950903220161e-01
SCONVI_c058_3_03 (conv_i_src_c058_3_03 conv_i_c058_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_03 (conv_q_src_c058_3_03 0 conv_bpf_c058_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_3_03 (conv_q_src_c058_3_03 conv_q_c058_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_04 (conv_i_src_c058_3_04 0 conv_bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_3_04 (conv_i_src_c058_3_04 conv_i_c058_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_04 (conv_q_src_c058_3_04 0 conv_bpf_c058_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c058_3_04 (conv_q_src_c058_3_04 conv_q_c058_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_05 (conv_i_src_c058_3_05 0 conv_bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_3_05 (conv_i_src_c058_3_05 conv_i_c058_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_05 (conv_q_src_c058_3_05 0 conv_bpf_c058_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c058_3_05 (conv_q_src_c058_3_05 conv_q_c058_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_06 (conv_i_src_c058_3_06 0 conv_bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_3_06 (conv_i_src_c058_3_06 conv_i_c058_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_06 (conv_q_src_c058_3_06 0 conv_bpf_c058_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c058_3_06 (conv_q_src_c058_3_06 conv_q_c058_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_07 (conv_i_src_c058_3_07 0 conv_bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_3_07 (conv_i_src_c058_3_07 conv_i_c058_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_07 (conv_q_src_c058_3_07 0 conv_bpf_c058_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c058_3_07 (conv_q_src_c058_3_07 conv_q_c058_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_08 (conv_i_src_c058_3_08 0 conv_bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c058_3_08 (conv_i_src_c058_3_08 conv_i_c058_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_08 (conv_q_src_c058_3_08 0 conv_bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_3_08 (conv_q_src_c058_3_08 conv_q_c058_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_09 (conv_i_src_c058_3_09 0 conv_bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c058_3_09 (conv_i_src_c058_3_09 conv_i_c058_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_09 (conv_q_src_c058_3_09 0 conv_bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_3_09 (conv_q_src_c058_3_09 conv_q_c058_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_10 (conv_i_src_c058_3_10 0 conv_bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c058_3_10 (conv_i_src_c058_3_10 conv_i_c058_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_10 (conv_q_src_c058_3_10 0 conv_bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_3_10 (conv_q_src_c058_3_10 conv_q_c058_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_11 (conv_i_src_c058_3_11 0 conv_bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c058_3_11 (conv_i_src_c058_3_11 conv_i_c058_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_11 (conv_q_src_c058_3_11 0 conv_bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_3_11 (conv_q_src_c058_3_11 conv_q_c058_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_12 (conv_i_src_c058_3_12 0 conv_bpf_c058_3 0) vcvs gain=1.950903220161e-01
SCONVI_c058_3_12 (conv_i_src_c058_3_12 conv_i_c058_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_12 (conv_q_src_c058_3_12 0 conv_bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c058_3_12 (conv_q_src_c058_3_12 conv_q_c058_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_13 (conv_i_src_c058_3_13 0 conv_bpf_c058_3 0) vcvs gain=5.555702330196e-01
SCONVI_c058_3_13 (conv_i_src_c058_3_13 conv_i_c058_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_13 (conv_q_src_c058_3_13 0 conv_bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c058_3_13 (conv_q_src_c058_3_13 conv_q_c058_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_14 (conv_i_src_c058_3_14 0 conv_bpf_c058_3 0) vcvs gain=8.314696123025e-01
SCONVI_c058_3_14 (conv_i_src_c058_3_14 conv_i_c058_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_14 (conv_q_src_c058_3_14 0 conv_bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c058_3_14 (conv_q_src_c058_3_14 conv_q_c058_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c058_3_15 (conv_i_src_c058_3_15 0 conv_bpf_c058_3 0) vcvs gain=9.807852804032e-01
SCONVI_c058_3_15 (conv_i_src_c058_3_15 conv_i_c058_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c058_3_15 (conv_q_src_c058_3_15 0 conv_bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c058_3_15 (conv_q_src_c058_3_15 conv_q_c058_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c058_3 (conv_i_c058_3 0) resistor r=1G
RCONVQ_c058_3 (conv_q_c058_3 0) resistor r=1G
RCONVINTI_c058_3 (conv_i_c058_3 ConvIcar_c058_3) resistor r=1k
CCONVINTI_c058_3 (ConvIcar_c058_3 0) capacitor c=80p
RCONVINTQ_c058_3 (conv_q_c058_3 ConvQcar_c058_3) resistor r=1k
CCONVINTQ_c058_3 (ConvQcar_c058_3 0) capacitor c=80p
save conv_bpf_c058_3 ConvIcar_c058_3 ConvQcar_c058_3

// conventional mixed baseline bl059, carrier_0: 250000000 Hz
CCONVBPF_c059_0 (bl059 n_conv_cbpf_c059_0) capacitor c=4.052847345694e-13
LCONVBPF_c059_0 (n_conv_cbpf_c059_0 conv_bpf_c059_0) inductor l=1.000000000000e-06
RCONVBPF_c059_0 (conv_bpf_c059_0 0) resistor r=7.853981633974e+01
ECONVI_c059_0_00 (conv_i_src_c059_0_00 0 conv_bpf_c059_0 0) vcvs gain=9.807852804032e-01
SCONVI_c059_0_00 (conv_i_src_c059_0_00 conv_i_c059_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_00 (conv_q_src_c059_0_00 0 conv_bpf_c059_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_0_00 (conv_q_src_c059_0_00 conv_q_c059_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_01 (conv_i_src_c059_0_01 0 conv_bpf_c059_0 0) vcvs gain=8.314696123025e-01
SCONVI_c059_0_01 (conv_i_src_c059_0_01 conv_i_c059_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_01 (conv_q_src_c059_0_01 0 conv_bpf_c059_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_0_01 (conv_q_src_c059_0_01 conv_q_c059_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_02 (conv_i_src_c059_0_02 0 conv_bpf_c059_0 0) vcvs gain=5.555702330196e-01
SCONVI_c059_0_02 (conv_i_src_c059_0_02 conv_i_c059_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_02 (conv_q_src_c059_0_02 0 conv_bpf_c059_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_0_02 (conv_q_src_c059_0_02 conv_q_c059_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_03 (conv_i_src_c059_0_03 0 conv_bpf_c059_0 0) vcvs gain=1.950903220161e-01
SCONVI_c059_0_03 (conv_i_src_c059_0_03 conv_i_c059_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_03 (conv_q_src_c059_0_03 0 conv_bpf_c059_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_0_03 (conv_q_src_c059_0_03 conv_q_c059_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_04 (conv_i_src_c059_0_04 0 conv_bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_0_04 (conv_i_src_c059_0_04 conv_i_c059_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_04 (conv_q_src_c059_0_04 0 conv_bpf_c059_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_0_04 (conv_q_src_c059_0_04 conv_q_c059_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_05 (conv_i_src_c059_0_05 0 conv_bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_0_05 (conv_i_src_c059_0_05 conv_i_c059_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_05 (conv_q_src_c059_0_05 0 conv_bpf_c059_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_0_05 (conv_q_src_c059_0_05 conv_q_c059_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_06 (conv_i_src_c059_0_06 0 conv_bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_0_06 (conv_i_src_c059_0_06 conv_i_c059_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_06 (conv_q_src_c059_0_06 0 conv_bpf_c059_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_0_06 (conv_q_src_c059_0_06 conv_q_c059_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_07 (conv_i_src_c059_0_07 0 conv_bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_0_07 (conv_i_src_c059_0_07 conv_i_c059_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_07 (conv_q_src_c059_0_07 0 conv_bpf_c059_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_0_07 (conv_q_src_c059_0_07 conv_q_c059_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_08 (conv_i_src_c059_0_08 0 conv_bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_0_08 (conv_i_src_c059_0_08 conv_i_c059_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_08 (conv_q_src_c059_0_08 0 conv_bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_0_08 (conv_q_src_c059_0_08 conv_q_c059_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_09 (conv_i_src_c059_0_09 0 conv_bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_0_09 (conv_i_src_c059_0_09 conv_i_c059_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_09 (conv_q_src_c059_0_09 0 conv_bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_0_09 (conv_q_src_c059_0_09 conv_q_c059_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_10 (conv_i_src_c059_0_10 0 conv_bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_0_10 (conv_i_src_c059_0_10 conv_i_c059_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_10 (conv_q_src_c059_0_10 0 conv_bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_0_10 (conv_q_src_c059_0_10 conv_q_c059_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_11 (conv_i_src_c059_0_11 0 conv_bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_0_11 (conv_i_src_c059_0_11 conv_i_c059_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_11 (conv_q_src_c059_0_11 0 conv_bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_0_11 (conv_q_src_c059_0_11 conv_q_c059_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_12 (conv_i_src_c059_0_12 0 conv_bpf_c059_0 0) vcvs gain=1.950903220161e-01
SCONVI_c059_0_12 (conv_i_src_c059_0_12 conv_i_c059_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_12 (conv_q_src_c059_0_12 0 conv_bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_0_12 (conv_q_src_c059_0_12 conv_q_c059_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_13 (conv_i_src_c059_0_13 0 conv_bpf_c059_0 0) vcvs gain=5.555702330196e-01
SCONVI_c059_0_13 (conv_i_src_c059_0_13 conv_i_c059_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_13 (conv_q_src_c059_0_13 0 conv_bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_0_13 (conv_q_src_c059_0_13 conv_q_c059_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_14 (conv_i_src_c059_0_14 0 conv_bpf_c059_0 0) vcvs gain=8.314696123025e-01
SCONVI_c059_0_14 (conv_i_src_c059_0_14 conv_i_c059_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_14 (conv_q_src_c059_0_14 0 conv_bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_0_14 (conv_q_src_c059_0_14 conv_q_c059_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_0_15 (conv_i_src_c059_0_15 0 conv_bpf_c059_0 0) vcvs gain=9.807852804032e-01
SCONVI_c059_0_15 (conv_i_src_c059_0_15 conv_i_c059_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_0_15 (conv_q_src_c059_0_15 0 conv_bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_0_15 (conv_q_src_c059_0_15 conv_q_c059_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c059_0 (conv_i_c059_0 0) resistor r=1G
RCONVQ_c059_0 (conv_q_c059_0 0) resistor r=1G
RCONVINTI_c059_0 (conv_i_c059_0 ConvIcar_c059_0) resistor r=1k
CCONVINTI_c059_0 (ConvIcar_c059_0 0) capacitor c=80p
RCONVINTQ_c059_0 (conv_q_c059_0 ConvQcar_c059_0) resistor r=1k
CCONVINTQ_c059_0 (ConvQcar_c059_0 0) capacitor c=80p
save conv_bpf_c059_0 ConvIcar_c059_0 ConvQcar_c059_0

// conventional mixed baseline bl059, carrier_1: 500000000 Hz
CCONVBPF_c059_1 (bl059 n_conv_cbpf_c059_1) capacitor c=1.013211836423e-13
LCONVBPF_c059_1 (n_conv_cbpf_c059_1 conv_bpf_c059_1) inductor l=1.000000000000e-06
RCONVBPF_c059_1 (conv_bpf_c059_1 0) resistor r=1.570796326795e+02
ECONVI_c059_1_00 (conv_i_src_c059_1_00 0 conv_bpf_c059_1 0) vcvs gain=9.807852804032e-01
SCONVI_c059_1_00 (conv_i_src_c059_1_00 conv_i_c059_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_00 (conv_q_src_c059_1_00 0 conv_bpf_c059_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_1_00 (conv_q_src_c059_1_00 conv_q_c059_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_01 (conv_i_src_c059_1_01 0 conv_bpf_c059_1 0) vcvs gain=8.314696123025e-01
SCONVI_c059_1_01 (conv_i_src_c059_1_01 conv_i_c059_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_01 (conv_q_src_c059_1_01 0 conv_bpf_c059_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_1_01 (conv_q_src_c059_1_01 conv_q_c059_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_02 (conv_i_src_c059_1_02 0 conv_bpf_c059_1 0) vcvs gain=5.555702330196e-01
SCONVI_c059_1_02 (conv_i_src_c059_1_02 conv_i_c059_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_02 (conv_q_src_c059_1_02 0 conv_bpf_c059_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_1_02 (conv_q_src_c059_1_02 conv_q_c059_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_03 (conv_i_src_c059_1_03 0 conv_bpf_c059_1 0) vcvs gain=1.950903220161e-01
SCONVI_c059_1_03 (conv_i_src_c059_1_03 conv_i_c059_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_03 (conv_q_src_c059_1_03 0 conv_bpf_c059_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_1_03 (conv_q_src_c059_1_03 conv_q_c059_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_04 (conv_i_src_c059_1_04 0 conv_bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_1_04 (conv_i_src_c059_1_04 conv_i_c059_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_04 (conv_q_src_c059_1_04 0 conv_bpf_c059_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_1_04 (conv_q_src_c059_1_04 conv_q_c059_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_05 (conv_i_src_c059_1_05 0 conv_bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_1_05 (conv_i_src_c059_1_05 conv_i_c059_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_05 (conv_q_src_c059_1_05 0 conv_bpf_c059_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_1_05 (conv_q_src_c059_1_05 conv_q_c059_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_06 (conv_i_src_c059_1_06 0 conv_bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_1_06 (conv_i_src_c059_1_06 conv_i_c059_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_06 (conv_q_src_c059_1_06 0 conv_bpf_c059_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_1_06 (conv_q_src_c059_1_06 conv_q_c059_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_07 (conv_i_src_c059_1_07 0 conv_bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_1_07 (conv_i_src_c059_1_07 conv_i_c059_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_07 (conv_q_src_c059_1_07 0 conv_bpf_c059_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_1_07 (conv_q_src_c059_1_07 conv_q_c059_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_08 (conv_i_src_c059_1_08 0 conv_bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_1_08 (conv_i_src_c059_1_08 conv_i_c059_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_08 (conv_q_src_c059_1_08 0 conv_bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_1_08 (conv_q_src_c059_1_08 conv_q_c059_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_09 (conv_i_src_c059_1_09 0 conv_bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_1_09 (conv_i_src_c059_1_09 conv_i_c059_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_09 (conv_q_src_c059_1_09 0 conv_bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_1_09 (conv_q_src_c059_1_09 conv_q_c059_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_10 (conv_i_src_c059_1_10 0 conv_bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_1_10 (conv_i_src_c059_1_10 conv_i_c059_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_10 (conv_q_src_c059_1_10 0 conv_bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_1_10 (conv_q_src_c059_1_10 conv_q_c059_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_11 (conv_i_src_c059_1_11 0 conv_bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_1_11 (conv_i_src_c059_1_11 conv_i_c059_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_11 (conv_q_src_c059_1_11 0 conv_bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_1_11 (conv_q_src_c059_1_11 conv_q_c059_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_12 (conv_i_src_c059_1_12 0 conv_bpf_c059_1 0) vcvs gain=1.950903220161e-01
SCONVI_c059_1_12 (conv_i_src_c059_1_12 conv_i_c059_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_12 (conv_q_src_c059_1_12 0 conv_bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_1_12 (conv_q_src_c059_1_12 conv_q_c059_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_13 (conv_i_src_c059_1_13 0 conv_bpf_c059_1 0) vcvs gain=5.555702330196e-01
SCONVI_c059_1_13 (conv_i_src_c059_1_13 conv_i_c059_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_13 (conv_q_src_c059_1_13 0 conv_bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_1_13 (conv_q_src_c059_1_13 conv_q_c059_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_14 (conv_i_src_c059_1_14 0 conv_bpf_c059_1 0) vcvs gain=8.314696123025e-01
SCONVI_c059_1_14 (conv_i_src_c059_1_14 conv_i_c059_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_14 (conv_q_src_c059_1_14 0 conv_bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_1_14 (conv_q_src_c059_1_14 conv_q_c059_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_1_15 (conv_i_src_c059_1_15 0 conv_bpf_c059_1 0) vcvs gain=9.807852804032e-01
SCONVI_c059_1_15 (conv_i_src_c059_1_15 conv_i_c059_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_1_15 (conv_q_src_c059_1_15 0 conv_bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_1_15 (conv_q_src_c059_1_15 conv_q_c059_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c059_1 (conv_i_c059_1 0) resistor r=1G
RCONVQ_c059_1 (conv_q_c059_1 0) resistor r=1G
RCONVINTI_c059_1 (conv_i_c059_1 ConvIcar_c059_1) resistor r=1k
CCONVINTI_c059_1 (ConvIcar_c059_1 0) capacitor c=80p
RCONVINTQ_c059_1 (conv_q_c059_1 ConvQcar_c059_1) resistor r=1k
CCONVINTQ_c059_1 (ConvQcar_c059_1 0) capacitor c=80p
save conv_bpf_c059_1 ConvIcar_c059_1 ConvQcar_c059_1

// conventional mixed baseline bl059, carrier_2: 750000000 Hz
CCONVBPF_c059_2 (bl059 n_conv_cbpf_c059_2) capacitor c=4.503163717437e-14
LCONVBPF_c059_2 (n_conv_cbpf_c059_2 conv_bpf_c059_2) inductor l=1.000000000000e-06
RCONVBPF_c059_2 (conv_bpf_c059_2 0) resistor r=2.356194490192e+02
ECONVI_c059_2_00 (conv_i_src_c059_2_00 0 conv_bpf_c059_2 0) vcvs gain=9.807852804032e-01
SCONVI_c059_2_00 (conv_i_src_c059_2_00 conv_i_c059_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_00 (conv_q_src_c059_2_00 0 conv_bpf_c059_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_2_00 (conv_q_src_c059_2_00 conv_q_c059_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_01 (conv_i_src_c059_2_01 0 conv_bpf_c059_2 0) vcvs gain=8.314696123025e-01
SCONVI_c059_2_01 (conv_i_src_c059_2_01 conv_i_c059_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_01 (conv_q_src_c059_2_01 0 conv_bpf_c059_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_2_01 (conv_q_src_c059_2_01 conv_q_c059_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_02 (conv_i_src_c059_2_02 0 conv_bpf_c059_2 0) vcvs gain=5.555702330196e-01
SCONVI_c059_2_02 (conv_i_src_c059_2_02 conv_i_c059_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_02 (conv_q_src_c059_2_02 0 conv_bpf_c059_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_2_02 (conv_q_src_c059_2_02 conv_q_c059_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_03 (conv_i_src_c059_2_03 0 conv_bpf_c059_2 0) vcvs gain=1.950903220161e-01
SCONVI_c059_2_03 (conv_i_src_c059_2_03 conv_i_c059_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_03 (conv_q_src_c059_2_03 0 conv_bpf_c059_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_2_03 (conv_q_src_c059_2_03 conv_q_c059_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_04 (conv_i_src_c059_2_04 0 conv_bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_2_04 (conv_i_src_c059_2_04 conv_i_c059_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_04 (conv_q_src_c059_2_04 0 conv_bpf_c059_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_2_04 (conv_q_src_c059_2_04 conv_q_c059_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_05 (conv_i_src_c059_2_05 0 conv_bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_2_05 (conv_i_src_c059_2_05 conv_i_c059_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_05 (conv_q_src_c059_2_05 0 conv_bpf_c059_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_2_05 (conv_q_src_c059_2_05 conv_q_c059_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_06 (conv_i_src_c059_2_06 0 conv_bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_2_06 (conv_i_src_c059_2_06 conv_i_c059_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_06 (conv_q_src_c059_2_06 0 conv_bpf_c059_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_2_06 (conv_q_src_c059_2_06 conv_q_c059_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_07 (conv_i_src_c059_2_07 0 conv_bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_2_07 (conv_i_src_c059_2_07 conv_i_c059_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_07 (conv_q_src_c059_2_07 0 conv_bpf_c059_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_2_07 (conv_q_src_c059_2_07 conv_q_c059_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_08 (conv_i_src_c059_2_08 0 conv_bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_2_08 (conv_i_src_c059_2_08 conv_i_c059_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_08 (conv_q_src_c059_2_08 0 conv_bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_2_08 (conv_q_src_c059_2_08 conv_q_c059_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_09 (conv_i_src_c059_2_09 0 conv_bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_2_09 (conv_i_src_c059_2_09 conv_i_c059_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_09 (conv_q_src_c059_2_09 0 conv_bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_2_09 (conv_q_src_c059_2_09 conv_q_c059_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_10 (conv_i_src_c059_2_10 0 conv_bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_2_10 (conv_i_src_c059_2_10 conv_i_c059_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_10 (conv_q_src_c059_2_10 0 conv_bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_2_10 (conv_q_src_c059_2_10 conv_q_c059_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_11 (conv_i_src_c059_2_11 0 conv_bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_2_11 (conv_i_src_c059_2_11 conv_i_c059_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_11 (conv_q_src_c059_2_11 0 conv_bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_2_11 (conv_q_src_c059_2_11 conv_q_c059_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_12 (conv_i_src_c059_2_12 0 conv_bpf_c059_2 0) vcvs gain=1.950903220161e-01
SCONVI_c059_2_12 (conv_i_src_c059_2_12 conv_i_c059_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_12 (conv_q_src_c059_2_12 0 conv_bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_2_12 (conv_q_src_c059_2_12 conv_q_c059_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_13 (conv_i_src_c059_2_13 0 conv_bpf_c059_2 0) vcvs gain=5.555702330196e-01
SCONVI_c059_2_13 (conv_i_src_c059_2_13 conv_i_c059_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_13 (conv_q_src_c059_2_13 0 conv_bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_2_13 (conv_q_src_c059_2_13 conv_q_c059_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_14 (conv_i_src_c059_2_14 0 conv_bpf_c059_2 0) vcvs gain=8.314696123025e-01
SCONVI_c059_2_14 (conv_i_src_c059_2_14 conv_i_c059_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_14 (conv_q_src_c059_2_14 0 conv_bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_2_14 (conv_q_src_c059_2_14 conv_q_c059_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_2_15 (conv_i_src_c059_2_15 0 conv_bpf_c059_2 0) vcvs gain=9.807852804032e-01
SCONVI_c059_2_15 (conv_i_src_c059_2_15 conv_i_c059_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_2_15 (conv_q_src_c059_2_15 0 conv_bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_2_15 (conv_q_src_c059_2_15 conv_q_c059_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c059_2 (conv_i_c059_2 0) resistor r=1G
RCONVQ_c059_2 (conv_q_c059_2 0) resistor r=1G
RCONVINTI_c059_2 (conv_i_c059_2 ConvIcar_c059_2) resistor r=1k
CCONVINTI_c059_2 (ConvIcar_c059_2 0) capacitor c=80p
RCONVINTQ_c059_2 (conv_q_c059_2 ConvQcar_c059_2) resistor r=1k
CCONVINTQ_c059_2 (ConvQcar_c059_2 0) capacitor c=80p
save conv_bpf_c059_2 ConvIcar_c059_2 ConvQcar_c059_2

// conventional mixed baseline bl059, carrier_3: 1000000000 Hz
CCONVBPF_c059_3 (bl059 n_conv_cbpf_c059_3) capacitor c=2.533029591058e-14
LCONVBPF_c059_3 (n_conv_cbpf_c059_3 conv_bpf_c059_3) inductor l=1.000000000000e-06
RCONVBPF_c059_3 (conv_bpf_c059_3 0) resistor r=3.141592653590e+02
ECONVI_c059_3_00 (conv_i_src_c059_3_00 0 conv_bpf_c059_3 0) vcvs gain=9.807852804032e-01
SCONVI_c059_3_00 (conv_i_src_c059_3_00 conv_i_c059_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_00 (conv_q_src_c059_3_00 0 conv_bpf_c059_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_3_00 (conv_q_src_c059_3_00 conv_q_c059_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_01 (conv_i_src_c059_3_01 0 conv_bpf_c059_3 0) vcvs gain=8.314696123025e-01
SCONVI_c059_3_01 (conv_i_src_c059_3_01 conv_i_c059_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_01 (conv_q_src_c059_3_01 0 conv_bpf_c059_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_3_01 (conv_q_src_c059_3_01 conv_q_c059_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_02 (conv_i_src_c059_3_02 0 conv_bpf_c059_3 0) vcvs gain=5.555702330196e-01
SCONVI_c059_3_02 (conv_i_src_c059_3_02 conv_i_c059_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_02 (conv_q_src_c059_3_02 0 conv_bpf_c059_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_3_02 (conv_q_src_c059_3_02 conv_q_c059_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_03 (conv_i_src_c059_3_03 0 conv_bpf_c059_3 0) vcvs gain=1.950903220161e-01
SCONVI_c059_3_03 (conv_i_src_c059_3_03 conv_i_c059_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_03 (conv_q_src_c059_3_03 0 conv_bpf_c059_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_3_03 (conv_q_src_c059_3_03 conv_q_c059_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_04 (conv_i_src_c059_3_04 0 conv_bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_3_04 (conv_i_src_c059_3_04 conv_i_c059_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_04 (conv_q_src_c059_3_04 0 conv_bpf_c059_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c059_3_04 (conv_q_src_c059_3_04 conv_q_c059_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_05 (conv_i_src_c059_3_05 0 conv_bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_3_05 (conv_i_src_c059_3_05 conv_i_c059_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_05 (conv_q_src_c059_3_05 0 conv_bpf_c059_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c059_3_05 (conv_q_src_c059_3_05 conv_q_c059_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_06 (conv_i_src_c059_3_06 0 conv_bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_3_06 (conv_i_src_c059_3_06 conv_i_c059_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_06 (conv_q_src_c059_3_06 0 conv_bpf_c059_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c059_3_06 (conv_q_src_c059_3_06 conv_q_c059_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_07 (conv_i_src_c059_3_07 0 conv_bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_3_07 (conv_i_src_c059_3_07 conv_i_c059_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_07 (conv_q_src_c059_3_07 0 conv_bpf_c059_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c059_3_07 (conv_q_src_c059_3_07 conv_q_c059_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_08 (conv_i_src_c059_3_08 0 conv_bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c059_3_08 (conv_i_src_c059_3_08 conv_i_c059_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_08 (conv_q_src_c059_3_08 0 conv_bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_3_08 (conv_q_src_c059_3_08 conv_q_c059_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_09 (conv_i_src_c059_3_09 0 conv_bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c059_3_09 (conv_i_src_c059_3_09 conv_i_c059_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_09 (conv_q_src_c059_3_09 0 conv_bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_3_09 (conv_q_src_c059_3_09 conv_q_c059_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_10 (conv_i_src_c059_3_10 0 conv_bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c059_3_10 (conv_i_src_c059_3_10 conv_i_c059_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_10 (conv_q_src_c059_3_10 0 conv_bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_3_10 (conv_q_src_c059_3_10 conv_q_c059_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_11 (conv_i_src_c059_3_11 0 conv_bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c059_3_11 (conv_i_src_c059_3_11 conv_i_c059_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_11 (conv_q_src_c059_3_11 0 conv_bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_3_11 (conv_q_src_c059_3_11 conv_q_c059_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_12 (conv_i_src_c059_3_12 0 conv_bpf_c059_3 0) vcvs gain=1.950903220161e-01
SCONVI_c059_3_12 (conv_i_src_c059_3_12 conv_i_c059_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_12 (conv_q_src_c059_3_12 0 conv_bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c059_3_12 (conv_q_src_c059_3_12 conv_q_c059_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_13 (conv_i_src_c059_3_13 0 conv_bpf_c059_3 0) vcvs gain=5.555702330196e-01
SCONVI_c059_3_13 (conv_i_src_c059_3_13 conv_i_c059_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_13 (conv_q_src_c059_3_13 0 conv_bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c059_3_13 (conv_q_src_c059_3_13 conv_q_c059_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_14 (conv_i_src_c059_3_14 0 conv_bpf_c059_3 0) vcvs gain=8.314696123025e-01
SCONVI_c059_3_14 (conv_i_src_c059_3_14 conv_i_c059_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_14 (conv_q_src_c059_3_14 0 conv_bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c059_3_14 (conv_q_src_c059_3_14 conv_q_c059_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c059_3_15 (conv_i_src_c059_3_15 0 conv_bpf_c059_3 0) vcvs gain=9.807852804032e-01
SCONVI_c059_3_15 (conv_i_src_c059_3_15 conv_i_c059_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c059_3_15 (conv_q_src_c059_3_15 0 conv_bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c059_3_15 (conv_q_src_c059_3_15 conv_q_c059_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c059_3 (conv_i_c059_3 0) resistor r=1G
RCONVQ_c059_3 (conv_q_c059_3 0) resistor r=1G
RCONVINTI_c059_3 (conv_i_c059_3 ConvIcar_c059_3) resistor r=1k
CCONVINTI_c059_3 (ConvIcar_c059_3 0) capacitor c=80p
RCONVINTQ_c059_3 (conv_q_c059_3 ConvQcar_c059_3) resistor r=1k
CCONVINTQ_c059_3 (ConvQcar_c059_3 0) capacitor c=80p
save conv_bpf_c059_3 ConvIcar_c059_3 ConvQcar_c059_3

// conventional mixed baseline bl060, carrier_0: 250000000 Hz
CCONVBPF_c060_0 (bl060 n_conv_cbpf_c060_0) capacitor c=4.052847345694e-13
LCONVBPF_c060_0 (n_conv_cbpf_c060_0 conv_bpf_c060_0) inductor l=1.000000000000e-06
RCONVBPF_c060_0 (conv_bpf_c060_0 0) resistor r=7.853981633974e+01
ECONVI_c060_0_00 (conv_i_src_c060_0_00 0 conv_bpf_c060_0 0) vcvs gain=9.807852804032e-01
SCONVI_c060_0_00 (conv_i_src_c060_0_00 conv_i_c060_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_00 (conv_q_src_c060_0_00 0 conv_bpf_c060_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_0_00 (conv_q_src_c060_0_00 conv_q_c060_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_01 (conv_i_src_c060_0_01 0 conv_bpf_c060_0 0) vcvs gain=8.314696123025e-01
SCONVI_c060_0_01 (conv_i_src_c060_0_01 conv_i_c060_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_01 (conv_q_src_c060_0_01 0 conv_bpf_c060_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_0_01 (conv_q_src_c060_0_01 conv_q_c060_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_02 (conv_i_src_c060_0_02 0 conv_bpf_c060_0 0) vcvs gain=5.555702330196e-01
SCONVI_c060_0_02 (conv_i_src_c060_0_02 conv_i_c060_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_02 (conv_q_src_c060_0_02 0 conv_bpf_c060_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_0_02 (conv_q_src_c060_0_02 conv_q_c060_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_03 (conv_i_src_c060_0_03 0 conv_bpf_c060_0 0) vcvs gain=1.950903220161e-01
SCONVI_c060_0_03 (conv_i_src_c060_0_03 conv_i_c060_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_03 (conv_q_src_c060_0_03 0 conv_bpf_c060_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_0_03 (conv_q_src_c060_0_03 conv_q_c060_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_04 (conv_i_src_c060_0_04 0 conv_bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_0_04 (conv_i_src_c060_0_04 conv_i_c060_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_04 (conv_q_src_c060_0_04 0 conv_bpf_c060_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_0_04 (conv_q_src_c060_0_04 conv_q_c060_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_05 (conv_i_src_c060_0_05 0 conv_bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_0_05 (conv_i_src_c060_0_05 conv_i_c060_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_05 (conv_q_src_c060_0_05 0 conv_bpf_c060_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_0_05 (conv_q_src_c060_0_05 conv_q_c060_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_06 (conv_i_src_c060_0_06 0 conv_bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_0_06 (conv_i_src_c060_0_06 conv_i_c060_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_06 (conv_q_src_c060_0_06 0 conv_bpf_c060_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_0_06 (conv_q_src_c060_0_06 conv_q_c060_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_07 (conv_i_src_c060_0_07 0 conv_bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_0_07 (conv_i_src_c060_0_07 conv_i_c060_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_07 (conv_q_src_c060_0_07 0 conv_bpf_c060_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_0_07 (conv_q_src_c060_0_07 conv_q_c060_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_08 (conv_i_src_c060_0_08 0 conv_bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_0_08 (conv_i_src_c060_0_08 conv_i_c060_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_08 (conv_q_src_c060_0_08 0 conv_bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_0_08 (conv_q_src_c060_0_08 conv_q_c060_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_09 (conv_i_src_c060_0_09 0 conv_bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_0_09 (conv_i_src_c060_0_09 conv_i_c060_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_09 (conv_q_src_c060_0_09 0 conv_bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_0_09 (conv_q_src_c060_0_09 conv_q_c060_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_10 (conv_i_src_c060_0_10 0 conv_bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_0_10 (conv_i_src_c060_0_10 conv_i_c060_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_10 (conv_q_src_c060_0_10 0 conv_bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_0_10 (conv_q_src_c060_0_10 conv_q_c060_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_11 (conv_i_src_c060_0_11 0 conv_bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_0_11 (conv_i_src_c060_0_11 conv_i_c060_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_11 (conv_q_src_c060_0_11 0 conv_bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_0_11 (conv_q_src_c060_0_11 conv_q_c060_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_12 (conv_i_src_c060_0_12 0 conv_bpf_c060_0 0) vcvs gain=1.950903220161e-01
SCONVI_c060_0_12 (conv_i_src_c060_0_12 conv_i_c060_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_12 (conv_q_src_c060_0_12 0 conv_bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_0_12 (conv_q_src_c060_0_12 conv_q_c060_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_13 (conv_i_src_c060_0_13 0 conv_bpf_c060_0 0) vcvs gain=5.555702330196e-01
SCONVI_c060_0_13 (conv_i_src_c060_0_13 conv_i_c060_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_13 (conv_q_src_c060_0_13 0 conv_bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_0_13 (conv_q_src_c060_0_13 conv_q_c060_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_14 (conv_i_src_c060_0_14 0 conv_bpf_c060_0 0) vcvs gain=8.314696123025e-01
SCONVI_c060_0_14 (conv_i_src_c060_0_14 conv_i_c060_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_14 (conv_q_src_c060_0_14 0 conv_bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_0_14 (conv_q_src_c060_0_14 conv_q_c060_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_0_15 (conv_i_src_c060_0_15 0 conv_bpf_c060_0 0) vcvs gain=9.807852804032e-01
SCONVI_c060_0_15 (conv_i_src_c060_0_15 conv_i_c060_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_0_15 (conv_q_src_c060_0_15 0 conv_bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_0_15 (conv_q_src_c060_0_15 conv_q_c060_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c060_0 (conv_i_c060_0 0) resistor r=1G
RCONVQ_c060_0 (conv_q_c060_0 0) resistor r=1G
RCONVINTI_c060_0 (conv_i_c060_0 ConvIcar_c060_0) resistor r=1k
CCONVINTI_c060_0 (ConvIcar_c060_0 0) capacitor c=80p
RCONVINTQ_c060_0 (conv_q_c060_0 ConvQcar_c060_0) resistor r=1k
CCONVINTQ_c060_0 (ConvQcar_c060_0 0) capacitor c=80p
save conv_bpf_c060_0 ConvIcar_c060_0 ConvQcar_c060_0

// conventional mixed baseline bl060, carrier_1: 500000000 Hz
CCONVBPF_c060_1 (bl060 n_conv_cbpf_c060_1) capacitor c=1.013211836423e-13
LCONVBPF_c060_1 (n_conv_cbpf_c060_1 conv_bpf_c060_1) inductor l=1.000000000000e-06
RCONVBPF_c060_1 (conv_bpf_c060_1 0) resistor r=1.570796326795e+02
ECONVI_c060_1_00 (conv_i_src_c060_1_00 0 conv_bpf_c060_1 0) vcvs gain=9.807852804032e-01
SCONVI_c060_1_00 (conv_i_src_c060_1_00 conv_i_c060_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_00 (conv_q_src_c060_1_00 0 conv_bpf_c060_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_1_00 (conv_q_src_c060_1_00 conv_q_c060_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_01 (conv_i_src_c060_1_01 0 conv_bpf_c060_1 0) vcvs gain=8.314696123025e-01
SCONVI_c060_1_01 (conv_i_src_c060_1_01 conv_i_c060_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_01 (conv_q_src_c060_1_01 0 conv_bpf_c060_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_1_01 (conv_q_src_c060_1_01 conv_q_c060_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_02 (conv_i_src_c060_1_02 0 conv_bpf_c060_1 0) vcvs gain=5.555702330196e-01
SCONVI_c060_1_02 (conv_i_src_c060_1_02 conv_i_c060_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_02 (conv_q_src_c060_1_02 0 conv_bpf_c060_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_1_02 (conv_q_src_c060_1_02 conv_q_c060_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_03 (conv_i_src_c060_1_03 0 conv_bpf_c060_1 0) vcvs gain=1.950903220161e-01
SCONVI_c060_1_03 (conv_i_src_c060_1_03 conv_i_c060_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_03 (conv_q_src_c060_1_03 0 conv_bpf_c060_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_1_03 (conv_q_src_c060_1_03 conv_q_c060_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_04 (conv_i_src_c060_1_04 0 conv_bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_1_04 (conv_i_src_c060_1_04 conv_i_c060_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_04 (conv_q_src_c060_1_04 0 conv_bpf_c060_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_1_04 (conv_q_src_c060_1_04 conv_q_c060_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_05 (conv_i_src_c060_1_05 0 conv_bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_1_05 (conv_i_src_c060_1_05 conv_i_c060_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_05 (conv_q_src_c060_1_05 0 conv_bpf_c060_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_1_05 (conv_q_src_c060_1_05 conv_q_c060_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_06 (conv_i_src_c060_1_06 0 conv_bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_1_06 (conv_i_src_c060_1_06 conv_i_c060_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_06 (conv_q_src_c060_1_06 0 conv_bpf_c060_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_1_06 (conv_q_src_c060_1_06 conv_q_c060_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_07 (conv_i_src_c060_1_07 0 conv_bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_1_07 (conv_i_src_c060_1_07 conv_i_c060_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_07 (conv_q_src_c060_1_07 0 conv_bpf_c060_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_1_07 (conv_q_src_c060_1_07 conv_q_c060_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_08 (conv_i_src_c060_1_08 0 conv_bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_1_08 (conv_i_src_c060_1_08 conv_i_c060_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_08 (conv_q_src_c060_1_08 0 conv_bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_1_08 (conv_q_src_c060_1_08 conv_q_c060_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_09 (conv_i_src_c060_1_09 0 conv_bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_1_09 (conv_i_src_c060_1_09 conv_i_c060_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_09 (conv_q_src_c060_1_09 0 conv_bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_1_09 (conv_q_src_c060_1_09 conv_q_c060_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_10 (conv_i_src_c060_1_10 0 conv_bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_1_10 (conv_i_src_c060_1_10 conv_i_c060_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_10 (conv_q_src_c060_1_10 0 conv_bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_1_10 (conv_q_src_c060_1_10 conv_q_c060_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_11 (conv_i_src_c060_1_11 0 conv_bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_1_11 (conv_i_src_c060_1_11 conv_i_c060_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_11 (conv_q_src_c060_1_11 0 conv_bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_1_11 (conv_q_src_c060_1_11 conv_q_c060_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_12 (conv_i_src_c060_1_12 0 conv_bpf_c060_1 0) vcvs gain=1.950903220161e-01
SCONVI_c060_1_12 (conv_i_src_c060_1_12 conv_i_c060_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_12 (conv_q_src_c060_1_12 0 conv_bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_1_12 (conv_q_src_c060_1_12 conv_q_c060_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_13 (conv_i_src_c060_1_13 0 conv_bpf_c060_1 0) vcvs gain=5.555702330196e-01
SCONVI_c060_1_13 (conv_i_src_c060_1_13 conv_i_c060_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_13 (conv_q_src_c060_1_13 0 conv_bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_1_13 (conv_q_src_c060_1_13 conv_q_c060_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_14 (conv_i_src_c060_1_14 0 conv_bpf_c060_1 0) vcvs gain=8.314696123025e-01
SCONVI_c060_1_14 (conv_i_src_c060_1_14 conv_i_c060_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_14 (conv_q_src_c060_1_14 0 conv_bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_1_14 (conv_q_src_c060_1_14 conv_q_c060_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_1_15 (conv_i_src_c060_1_15 0 conv_bpf_c060_1 0) vcvs gain=9.807852804032e-01
SCONVI_c060_1_15 (conv_i_src_c060_1_15 conv_i_c060_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_1_15 (conv_q_src_c060_1_15 0 conv_bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_1_15 (conv_q_src_c060_1_15 conv_q_c060_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c060_1 (conv_i_c060_1 0) resistor r=1G
RCONVQ_c060_1 (conv_q_c060_1 0) resistor r=1G
RCONVINTI_c060_1 (conv_i_c060_1 ConvIcar_c060_1) resistor r=1k
CCONVINTI_c060_1 (ConvIcar_c060_1 0) capacitor c=80p
RCONVINTQ_c060_1 (conv_q_c060_1 ConvQcar_c060_1) resistor r=1k
CCONVINTQ_c060_1 (ConvQcar_c060_1 0) capacitor c=80p
save conv_bpf_c060_1 ConvIcar_c060_1 ConvQcar_c060_1

// conventional mixed baseline bl060, carrier_2: 750000000 Hz
CCONVBPF_c060_2 (bl060 n_conv_cbpf_c060_2) capacitor c=4.503163717437e-14
LCONVBPF_c060_2 (n_conv_cbpf_c060_2 conv_bpf_c060_2) inductor l=1.000000000000e-06
RCONVBPF_c060_2 (conv_bpf_c060_2 0) resistor r=2.356194490192e+02
ECONVI_c060_2_00 (conv_i_src_c060_2_00 0 conv_bpf_c060_2 0) vcvs gain=9.807852804032e-01
SCONVI_c060_2_00 (conv_i_src_c060_2_00 conv_i_c060_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_00 (conv_q_src_c060_2_00 0 conv_bpf_c060_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_2_00 (conv_q_src_c060_2_00 conv_q_c060_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_01 (conv_i_src_c060_2_01 0 conv_bpf_c060_2 0) vcvs gain=8.314696123025e-01
SCONVI_c060_2_01 (conv_i_src_c060_2_01 conv_i_c060_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_01 (conv_q_src_c060_2_01 0 conv_bpf_c060_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_2_01 (conv_q_src_c060_2_01 conv_q_c060_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_02 (conv_i_src_c060_2_02 0 conv_bpf_c060_2 0) vcvs gain=5.555702330196e-01
SCONVI_c060_2_02 (conv_i_src_c060_2_02 conv_i_c060_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_02 (conv_q_src_c060_2_02 0 conv_bpf_c060_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_2_02 (conv_q_src_c060_2_02 conv_q_c060_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_03 (conv_i_src_c060_2_03 0 conv_bpf_c060_2 0) vcvs gain=1.950903220161e-01
SCONVI_c060_2_03 (conv_i_src_c060_2_03 conv_i_c060_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_03 (conv_q_src_c060_2_03 0 conv_bpf_c060_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_2_03 (conv_q_src_c060_2_03 conv_q_c060_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_04 (conv_i_src_c060_2_04 0 conv_bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_2_04 (conv_i_src_c060_2_04 conv_i_c060_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_04 (conv_q_src_c060_2_04 0 conv_bpf_c060_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_2_04 (conv_q_src_c060_2_04 conv_q_c060_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_05 (conv_i_src_c060_2_05 0 conv_bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_2_05 (conv_i_src_c060_2_05 conv_i_c060_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_05 (conv_q_src_c060_2_05 0 conv_bpf_c060_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_2_05 (conv_q_src_c060_2_05 conv_q_c060_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_06 (conv_i_src_c060_2_06 0 conv_bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_2_06 (conv_i_src_c060_2_06 conv_i_c060_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_06 (conv_q_src_c060_2_06 0 conv_bpf_c060_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_2_06 (conv_q_src_c060_2_06 conv_q_c060_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_07 (conv_i_src_c060_2_07 0 conv_bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_2_07 (conv_i_src_c060_2_07 conv_i_c060_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_07 (conv_q_src_c060_2_07 0 conv_bpf_c060_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_2_07 (conv_q_src_c060_2_07 conv_q_c060_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_08 (conv_i_src_c060_2_08 0 conv_bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_2_08 (conv_i_src_c060_2_08 conv_i_c060_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_08 (conv_q_src_c060_2_08 0 conv_bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_2_08 (conv_q_src_c060_2_08 conv_q_c060_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_09 (conv_i_src_c060_2_09 0 conv_bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_2_09 (conv_i_src_c060_2_09 conv_i_c060_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_09 (conv_q_src_c060_2_09 0 conv_bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_2_09 (conv_q_src_c060_2_09 conv_q_c060_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_10 (conv_i_src_c060_2_10 0 conv_bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_2_10 (conv_i_src_c060_2_10 conv_i_c060_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_10 (conv_q_src_c060_2_10 0 conv_bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_2_10 (conv_q_src_c060_2_10 conv_q_c060_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_11 (conv_i_src_c060_2_11 0 conv_bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_2_11 (conv_i_src_c060_2_11 conv_i_c060_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_11 (conv_q_src_c060_2_11 0 conv_bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_2_11 (conv_q_src_c060_2_11 conv_q_c060_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_12 (conv_i_src_c060_2_12 0 conv_bpf_c060_2 0) vcvs gain=1.950903220161e-01
SCONVI_c060_2_12 (conv_i_src_c060_2_12 conv_i_c060_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_12 (conv_q_src_c060_2_12 0 conv_bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_2_12 (conv_q_src_c060_2_12 conv_q_c060_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_13 (conv_i_src_c060_2_13 0 conv_bpf_c060_2 0) vcvs gain=5.555702330196e-01
SCONVI_c060_2_13 (conv_i_src_c060_2_13 conv_i_c060_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_13 (conv_q_src_c060_2_13 0 conv_bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_2_13 (conv_q_src_c060_2_13 conv_q_c060_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_14 (conv_i_src_c060_2_14 0 conv_bpf_c060_2 0) vcvs gain=8.314696123025e-01
SCONVI_c060_2_14 (conv_i_src_c060_2_14 conv_i_c060_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_14 (conv_q_src_c060_2_14 0 conv_bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_2_14 (conv_q_src_c060_2_14 conv_q_c060_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_2_15 (conv_i_src_c060_2_15 0 conv_bpf_c060_2 0) vcvs gain=9.807852804032e-01
SCONVI_c060_2_15 (conv_i_src_c060_2_15 conv_i_c060_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_2_15 (conv_q_src_c060_2_15 0 conv_bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_2_15 (conv_q_src_c060_2_15 conv_q_c060_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c060_2 (conv_i_c060_2 0) resistor r=1G
RCONVQ_c060_2 (conv_q_c060_2 0) resistor r=1G
RCONVINTI_c060_2 (conv_i_c060_2 ConvIcar_c060_2) resistor r=1k
CCONVINTI_c060_2 (ConvIcar_c060_2 0) capacitor c=80p
RCONVINTQ_c060_2 (conv_q_c060_2 ConvQcar_c060_2) resistor r=1k
CCONVINTQ_c060_2 (ConvQcar_c060_2 0) capacitor c=80p
save conv_bpf_c060_2 ConvIcar_c060_2 ConvQcar_c060_2

// conventional mixed baseline bl060, carrier_3: 1000000000 Hz
CCONVBPF_c060_3 (bl060 n_conv_cbpf_c060_3) capacitor c=2.533029591058e-14
LCONVBPF_c060_3 (n_conv_cbpf_c060_3 conv_bpf_c060_3) inductor l=1.000000000000e-06
RCONVBPF_c060_3 (conv_bpf_c060_3 0) resistor r=3.141592653590e+02
ECONVI_c060_3_00 (conv_i_src_c060_3_00 0 conv_bpf_c060_3 0) vcvs gain=9.807852804032e-01
SCONVI_c060_3_00 (conv_i_src_c060_3_00 conv_i_c060_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_00 (conv_q_src_c060_3_00 0 conv_bpf_c060_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_3_00 (conv_q_src_c060_3_00 conv_q_c060_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_01 (conv_i_src_c060_3_01 0 conv_bpf_c060_3 0) vcvs gain=8.314696123025e-01
SCONVI_c060_3_01 (conv_i_src_c060_3_01 conv_i_c060_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_01 (conv_q_src_c060_3_01 0 conv_bpf_c060_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_3_01 (conv_q_src_c060_3_01 conv_q_c060_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_02 (conv_i_src_c060_3_02 0 conv_bpf_c060_3 0) vcvs gain=5.555702330196e-01
SCONVI_c060_3_02 (conv_i_src_c060_3_02 conv_i_c060_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_02 (conv_q_src_c060_3_02 0 conv_bpf_c060_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_3_02 (conv_q_src_c060_3_02 conv_q_c060_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_03 (conv_i_src_c060_3_03 0 conv_bpf_c060_3 0) vcvs gain=1.950903220161e-01
SCONVI_c060_3_03 (conv_i_src_c060_3_03 conv_i_c060_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_03 (conv_q_src_c060_3_03 0 conv_bpf_c060_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_3_03 (conv_q_src_c060_3_03 conv_q_c060_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_04 (conv_i_src_c060_3_04 0 conv_bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_3_04 (conv_i_src_c060_3_04 conv_i_c060_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_04 (conv_q_src_c060_3_04 0 conv_bpf_c060_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c060_3_04 (conv_q_src_c060_3_04 conv_q_c060_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_05 (conv_i_src_c060_3_05 0 conv_bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_3_05 (conv_i_src_c060_3_05 conv_i_c060_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_05 (conv_q_src_c060_3_05 0 conv_bpf_c060_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c060_3_05 (conv_q_src_c060_3_05 conv_q_c060_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_06 (conv_i_src_c060_3_06 0 conv_bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_3_06 (conv_i_src_c060_3_06 conv_i_c060_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_06 (conv_q_src_c060_3_06 0 conv_bpf_c060_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c060_3_06 (conv_q_src_c060_3_06 conv_q_c060_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_07 (conv_i_src_c060_3_07 0 conv_bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_3_07 (conv_i_src_c060_3_07 conv_i_c060_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_07 (conv_q_src_c060_3_07 0 conv_bpf_c060_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c060_3_07 (conv_q_src_c060_3_07 conv_q_c060_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_08 (conv_i_src_c060_3_08 0 conv_bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c060_3_08 (conv_i_src_c060_3_08 conv_i_c060_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_08 (conv_q_src_c060_3_08 0 conv_bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_3_08 (conv_q_src_c060_3_08 conv_q_c060_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_09 (conv_i_src_c060_3_09 0 conv_bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c060_3_09 (conv_i_src_c060_3_09 conv_i_c060_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_09 (conv_q_src_c060_3_09 0 conv_bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_3_09 (conv_q_src_c060_3_09 conv_q_c060_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_10 (conv_i_src_c060_3_10 0 conv_bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c060_3_10 (conv_i_src_c060_3_10 conv_i_c060_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_10 (conv_q_src_c060_3_10 0 conv_bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_3_10 (conv_q_src_c060_3_10 conv_q_c060_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_11 (conv_i_src_c060_3_11 0 conv_bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c060_3_11 (conv_i_src_c060_3_11 conv_i_c060_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_11 (conv_q_src_c060_3_11 0 conv_bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_3_11 (conv_q_src_c060_3_11 conv_q_c060_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_12 (conv_i_src_c060_3_12 0 conv_bpf_c060_3 0) vcvs gain=1.950903220161e-01
SCONVI_c060_3_12 (conv_i_src_c060_3_12 conv_i_c060_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_12 (conv_q_src_c060_3_12 0 conv_bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c060_3_12 (conv_q_src_c060_3_12 conv_q_c060_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_13 (conv_i_src_c060_3_13 0 conv_bpf_c060_3 0) vcvs gain=5.555702330196e-01
SCONVI_c060_3_13 (conv_i_src_c060_3_13 conv_i_c060_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_13 (conv_q_src_c060_3_13 0 conv_bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c060_3_13 (conv_q_src_c060_3_13 conv_q_c060_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_14 (conv_i_src_c060_3_14 0 conv_bpf_c060_3 0) vcvs gain=8.314696123025e-01
SCONVI_c060_3_14 (conv_i_src_c060_3_14 conv_i_c060_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_14 (conv_q_src_c060_3_14 0 conv_bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c060_3_14 (conv_q_src_c060_3_14 conv_q_c060_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c060_3_15 (conv_i_src_c060_3_15 0 conv_bpf_c060_3 0) vcvs gain=9.807852804032e-01
SCONVI_c060_3_15 (conv_i_src_c060_3_15 conv_i_c060_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c060_3_15 (conv_q_src_c060_3_15 0 conv_bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c060_3_15 (conv_q_src_c060_3_15 conv_q_c060_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c060_3 (conv_i_c060_3 0) resistor r=1G
RCONVQ_c060_3 (conv_q_c060_3 0) resistor r=1G
RCONVINTI_c060_3 (conv_i_c060_3 ConvIcar_c060_3) resistor r=1k
CCONVINTI_c060_3 (ConvIcar_c060_3 0) capacitor c=80p
RCONVINTQ_c060_3 (conv_q_c060_3 ConvQcar_c060_3) resistor r=1k
CCONVINTQ_c060_3 (ConvQcar_c060_3 0) capacitor c=80p
save conv_bpf_c060_3 ConvIcar_c060_3 ConvQcar_c060_3

// conventional mixed baseline bl061, carrier_0: 250000000 Hz
CCONVBPF_c061_0 (bl061 n_conv_cbpf_c061_0) capacitor c=4.052847345694e-13
LCONVBPF_c061_0 (n_conv_cbpf_c061_0 conv_bpf_c061_0) inductor l=1.000000000000e-06
RCONVBPF_c061_0 (conv_bpf_c061_0 0) resistor r=7.853981633974e+01
ECONVI_c061_0_00 (conv_i_src_c061_0_00 0 conv_bpf_c061_0 0) vcvs gain=9.807852804032e-01
SCONVI_c061_0_00 (conv_i_src_c061_0_00 conv_i_c061_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_00 (conv_q_src_c061_0_00 0 conv_bpf_c061_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_0_00 (conv_q_src_c061_0_00 conv_q_c061_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_01 (conv_i_src_c061_0_01 0 conv_bpf_c061_0 0) vcvs gain=8.314696123025e-01
SCONVI_c061_0_01 (conv_i_src_c061_0_01 conv_i_c061_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_01 (conv_q_src_c061_0_01 0 conv_bpf_c061_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_0_01 (conv_q_src_c061_0_01 conv_q_c061_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_02 (conv_i_src_c061_0_02 0 conv_bpf_c061_0 0) vcvs gain=5.555702330196e-01
SCONVI_c061_0_02 (conv_i_src_c061_0_02 conv_i_c061_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_02 (conv_q_src_c061_0_02 0 conv_bpf_c061_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_0_02 (conv_q_src_c061_0_02 conv_q_c061_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_03 (conv_i_src_c061_0_03 0 conv_bpf_c061_0 0) vcvs gain=1.950903220161e-01
SCONVI_c061_0_03 (conv_i_src_c061_0_03 conv_i_c061_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_03 (conv_q_src_c061_0_03 0 conv_bpf_c061_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_0_03 (conv_q_src_c061_0_03 conv_q_c061_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_04 (conv_i_src_c061_0_04 0 conv_bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_0_04 (conv_i_src_c061_0_04 conv_i_c061_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_04 (conv_q_src_c061_0_04 0 conv_bpf_c061_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_0_04 (conv_q_src_c061_0_04 conv_q_c061_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_05 (conv_i_src_c061_0_05 0 conv_bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_0_05 (conv_i_src_c061_0_05 conv_i_c061_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_05 (conv_q_src_c061_0_05 0 conv_bpf_c061_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_0_05 (conv_q_src_c061_0_05 conv_q_c061_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_06 (conv_i_src_c061_0_06 0 conv_bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_0_06 (conv_i_src_c061_0_06 conv_i_c061_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_06 (conv_q_src_c061_0_06 0 conv_bpf_c061_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_0_06 (conv_q_src_c061_0_06 conv_q_c061_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_07 (conv_i_src_c061_0_07 0 conv_bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_0_07 (conv_i_src_c061_0_07 conv_i_c061_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_07 (conv_q_src_c061_0_07 0 conv_bpf_c061_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_0_07 (conv_q_src_c061_0_07 conv_q_c061_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_08 (conv_i_src_c061_0_08 0 conv_bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_0_08 (conv_i_src_c061_0_08 conv_i_c061_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_08 (conv_q_src_c061_0_08 0 conv_bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_0_08 (conv_q_src_c061_0_08 conv_q_c061_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_09 (conv_i_src_c061_0_09 0 conv_bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_0_09 (conv_i_src_c061_0_09 conv_i_c061_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_09 (conv_q_src_c061_0_09 0 conv_bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_0_09 (conv_q_src_c061_0_09 conv_q_c061_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_10 (conv_i_src_c061_0_10 0 conv_bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_0_10 (conv_i_src_c061_0_10 conv_i_c061_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_10 (conv_q_src_c061_0_10 0 conv_bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_0_10 (conv_q_src_c061_0_10 conv_q_c061_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_11 (conv_i_src_c061_0_11 0 conv_bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_0_11 (conv_i_src_c061_0_11 conv_i_c061_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_11 (conv_q_src_c061_0_11 0 conv_bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_0_11 (conv_q_src_c061_0_11 conv_q_c061_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_12 (conv_i_src_c061_0_12 0 conv_bpf_c061_0 0) vcvs gain=1.950903220161e-01
SCONVI_c061_0_12 (conv_i_src_c061_0_12 conv_i_c061_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_12 (conv_q_src_c061_0_12 0 conv_bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_0_12 (conv_q_src_c061_0_12 conv_q_c061_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_13 (conv_i_src_c061_0_13 0 conv_bpf_c061_0 0) vcvs gain=5.555702330196e-01
SCONVI_c061_0_13 (conv_i_src_c061_0_13 conv_i_c061_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_13 (conv_q_src_c061_0_13 0 conv_bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_0_13 (conv_q_src_c061_0_13 conv_q_c061_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_14 (conv_i_src_c061_0_14 0 conv_bpf_c061_0 0) vcvs gain=8.314696123025e-01
SCONVI_c061_0_14 (conv_i_src_c061_0_14 conv_i_c061_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_14 (conv_q_src_c061_0_14 0 conv_bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_0_14 (conv_q_src_c061_0_14 conv_q_c061_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_0_15 (conv_i_src_c061_0_15 0 conv_bpf_c061_0 0) vcvs gain=9.807852804032e-01
SCONVI_c061_0_15 (conv_i_src_c061_0_15 conv_i_c061_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_0_15 (conv_q_src_c061_0_15 0 conv_bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_0_15 (conv_q_src_c061_0_15 conv_q_c061_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c061_0 (conv_i_c061_0 0) resistor r=1G
RCONVQ_c061_0 (conv_q_c061_0 0) resistor r=1G
RCONVINTI_c061_0 (conv_i_c061_0 ConvIcar_c061_0) resistor r=1k
CCONVINTI_c061_0 (ConvIcar_c061_0 0) capacitor c=80p
RCONVINTQ_c061_0 (conv_q_c061_0 ConvQcar_c061_0) resistor r=1k
CCONVINTQ_c061_0 (ConvQcar_c061_0 0) capacitor c=80p
save conv_bpf_c061_0 ConvIcar_c061_0 ConvQcar_c061_0

// conventional mixed baseline bl061, carrier_1: 500000000 Hz
CCONVBPF_c061_1 (bl061 n_conv_cbpf_c061_1) capacitor c=1.013211836423e-13
LCONVBPF_c061_1 (n_conv_cbpf_c061_1 conv_bpf_c061_1) inductor l=1.000000000000e-06
RCONVBPF_c061_1 (conv_bpf_c061_1 0) resistor r=1.570796326795e+02
ECONVI_c061_1_00 (conv_i_src_c061_1_00 0 conv_bpf_c061_1 0) vcvs gain=9.807852804032e-01
SCONVI_c061_1_00 (conv_i_src_c061_1_00 conv_i_c061_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_00 (conv_q_src_c061_1_00 0 conv_bpf_c061_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_1_00 (conv_q_src_c061_1_00 conv_q_c061_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_01 (conv_i_src_c061_1_01 0 conv_bpf_c061_1 0) vcvs gain=8.314696123025e-01
SCONVI_c061_1_01 (conv_i_src_c061_1_01 conv_i_c061_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_01 (conv_q_src_c061_1_01 0 conv_bpf_c061_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_1_01 (conv_q_src_c061_1_01 conv_q_c061_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_02 (conv_i_src_c061_1_02 0 conv_bpf_c061_1 0) vcvs gain=5.555702330196e-01
SCONVI_c061_1_02 (conv_i_src_c061_1_02 conv_i_c061_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_02 (conv_q_src_c061_1_02 0 conv_bpf_c061_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_1_02 (conv_q_src_c061_1_02 conv_q_c061_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_03 (conv_i_src_c061_1_03 0 conv_bpf_c061_1 0) vcvs gain=1.950903220161e-01
SCONVI_c061_1_03 (conv_i_src_c061_1_03 conv_i_c061_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_03 (conv_q_src_c061_1_03 0 conv_bpf_c061_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_1_03 (conv_q_src_c061_1_03 conv_q_c061_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_04 (conv_i_src_c061_1_04 0 conv_bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_1_04 (conv_i_src_c061_1_04 conv_i_c061_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_04 (conv_q_src_c061_1_04 0 conv_bpf_c061_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_1_04 (conv_q_src_c061_1_04 conv_q_c061_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_05 (conv_i_src_c061_1_05 0 conv_bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_1_05 (conv_i_src_c061_1_05 conv_i_c061_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_05 (conv_q_src_c061_1_05 0 conv_bpf_c061_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_1_05 (conv_q_src_c061_1_05 conv_q_c061_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_06 (conv_i_src_c061_1_06 0 conv_bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_1_06 (conv_i_src_c061_1_06 conv_i_c061_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_06 (conv_q_src_c061_1_06 0 conv_bpf_c061_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_1_06 (conv_q_src_c061_1_06 conv_q_c061_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_07 (conv_i_src_c061_1_07 0 conv_bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_1_07 (conv_i_src_c061_1_07 conv_i_c061_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_07 (conv_q_src_c061_1_07 0 conv_bpf_c061_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_1_07 (conv_q_src_c061_1_07 conv_q_c061_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_08 (conv_i_src_c061_1_08 0 conv_bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_1_08 (conv_i_src_c061_1_08 conv_i_c061_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_08 (conv_q_src_c061_1_08 0 conv_bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_1_08 (conv_q_src_c061_1_08 conv_q_c061_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_09 (conv_i_src_c061_1_09 0 conv_bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_1_09 (conv_i_src_c061_1_09 conv_i_c061_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_09 (conv_q_src_c061_1_09 0 conv_bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_1_09 (conv_q_src_c061_1_09 conv_q_c061_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_10 (conv_i_src_c061_1_10 0 conv_bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_1_10 (conv_i_src_c061_1_10 conv_i_c061_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_10 (conv_q_src_c061_1_10 0 conv_bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_1_10 (conv_q_src_c061_1_10 conv_q_c061_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_11 (conv_i_src_c061_1_11 0 conv_bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_1_11 (conv_i_src_c061_1_11 conv_i_c061_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_11 (conv_q_src_c061_1_11 0 conv_bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_1_11 (conv_q_src_c061_1_11 conv_q_c061_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_12 (conv_i_src_c061_1_12 0 conv_bpf_c061_1 0) vcvs gain=1.950903220161e-01
SCONVI_c061_1_12 (conv_i_src_c061_1_12 conv_i_c061_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_12 (conv_q_src_c061_1_12 0 conv_bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_1_12 (conv_q_src_c061_1_12 conv_q_c061_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_13 (conv_i_src_c061_1_13 0 conv_bpf_c061_1 0) vcvs gain=5.555702330196e-01
SCONVI_c061_1_13 (conv_i_src_c061_1_13 conv_i_c061_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_13 (conv_q_src_c061_1_13 0 conv_bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_1_13 (conv_q_src_c061_1_13 conv_q_c061_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_14 (conv_i_src_c061_1_14 0 conv_bpf_c061_1 0) vcvs gain=8.314696123025e-01
SCONVI_c061_1_14 (conv_i_src_c061_1_14 conv_i_c061_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_14 (conv_q_src_c061_1_14 0 conv_bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_1_14 (conv_q_src_c061_1_14 conv_q_c061_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_1_15 (conv_i_src_c061_1_15 0 conv_bpf_c061_1 0) vcvs gain=9.807852804032e-01
SCONVI_c061_1_15 (conv_i_src_c061_1_15 conv_i_c061_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_1_15 (conv_q_src_c061_1_15 0 conv_bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_1_15 (conv_q_src_c061_1_15 conv_q_c061_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c061_1 (conv_i_c061_1 0) resistor r=1G
RCONVQ_c061_1 (conv_q_c061_1 0) resistor r=1G
RCONVINTI_c061_1 (conv_i_c061_1 ConvIcar_c061_1) resistor r=1k
CCONVINTI_c061_1 (ConvIcar_c061_1 0) capacitor c=80p
RCONVINTQ_c061_1 (conv_q_c061_1 ConvQcar_c061_1) resistor r=1k
CCONVINTQ_c061_1 (ConvQcar_c061_1 0) capacitor c=80p
save conv_bpf_c061_1 ConvIcar_c061_1 ConvQcar_c061_1

// conventional mixed baseline bl061, carrier_2: 750000000 Hz
CCONVBPF_c061_2 (bl061 n_conv_cbpf_c061_2) capacitor c=4.503163717437e-14
LCONVBPF_c061_2 (n_conv_cbpf_c061_2 conv_bpf_c061_2) inductor l=1.000000000000e-06
RCONVBPF_c061_2 (conv_bpf_c061_2 0) resistor r=2.356194490192e+02
ECONVI_c061_2_00 (conv_i_src_c061_2_00 0 conv_bpf_c061_2 0) vcvs gain=9.807852804032e-01
SCONVI_c061_2_00 (conv_i_src_c061_2_00 conv_i_c061_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_00 (conv_q_src_c061_2_00 0 conv_bpf_c061_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_2_00 (conv_q_src_c061_2_00 conv_q_c061_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_01 (conv_i_src_c061_2_01 0 conv_bpf_c061_2 0) vcvs gain=8.314696123025e-01
SCONVI_c061_2_01 (conv_i_src_c061_2_01 conv_i_c061_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_01 (conv_q_src_c061_2_01 0 conv_bpf_c061_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_2_01 (conv_q_src_c061_2_01 conv_q_c061_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_02 (conv_i_src_c061_2_02 0 conv_bpf_c061_2 0) vcvs gain=5.555702330196e-01
SCONVI_c061_2_02 (conv_i_src_c061_2_02 conv_i_c061_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_02 (conv_q_src_c061_2_02 0 conv_bpf_c061_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_2_02 (conv_q_src_c061_2_02 conv_q_c061_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_03 (conv_i_src_c061_2_03 0 conv_bpf_c061_2 0) vcvs gain=1.950903220161e-01
SCONVI_c061_2_03 (conv_i_src_c061_2_03 conv_i_c061_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_03 (conv_q_src_c061_2_03 0 conv_bpf_c061_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_2_03 (conv_q_src_c061_2_03 conv_q_c061_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_04 (conv_i_src_c061_2_04 0 conv_bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_2_04 (conv_i_src_c061_2_04 conv_i_c061_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_04 (conv_q_src_c061_2_04 0 conv_bpf_c061_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_2_04 (conv_q_src_c061_2_04 conv_q_c061_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_05 (conv_i_src_c061_2_05 0 conv_bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_2_05 (conv_i_src_c061_2_05 conv_i_c061_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_05 (conv_q_src_c061_2_05 0 conv_bpf_c061_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_2_05 (conv_q_src_c061_2_05 conv_q_c061_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_06 (conv_i_src_c061_2_06 0 conv_bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_2_06 (conv_i_src_c061_2_06 conv_i_c061_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_06 (conv_q_src_c061_2_06 0 conv_bpf_c061_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_2_06 (conv_q_src_c061_2_06 conv_q_c061_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_07 (conv_i_src_c061_2_07 0 conv_bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_2_07 (conv_i_src_c061_2_07 conv_i_c061_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_07 (conv_q_src_c061_2_07 0 conv_bpf_c061_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_2_07 (conv_q_src_c061_2_07 conv_q_c061_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_08 (conv_i_src_c061_2_08 0 conv_bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_2_08 (conv_i_src_c061_2_08 conv_i_c061_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_08 (conv_q_src_c061_2_08 0 conv_bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_2_08 (conv_q_src_c061_2_08 conv_q_c061_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_09 (conv_i_src_c061_2_09 0 conv_bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_2_09 (conv_i_src_c061_2_09 conv_i_c061_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_09 (conv_q_src_c061_2_09 0 conv_bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_2_09 (conv_q_src_c061_2_09 conv_q_c061_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_10 (conv_i_src_c061_2_10 0 conv_bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_2_10 (conv_i_src_c061_2_10 conv_i_c061_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_10 (conv_q_src_c061_2_10 0 conv_bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_2_10 (conv_q_src_c061_2_10 conv_q_c061_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_11 (conv_i_src_c061_2_11 0 conv_bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_2_11 (conv_i_src_c061_2_11 conv_i_c061_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_11 (conv_q_src_c061_2_11 0 conv_bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_2_11 (conv_q_src_c061_2_11 conv_q_c061_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_12 (conv_i_src_c061_2_12 0 conv_bpf_c061_2 0) vcvs gain=1.950903220161e-01
SCONVI_c061_2_12 (conv_i_src_c061_2_12 conv_i_c061_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_12 (conv_q_src_c061_2_12 0 conv_bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_2_12 (conv_q_src_c061_2_12 conv_q_c061_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_13 (conv_i_src_c061_2_13 0 conv_bpf_c061_2 0) vcvs gain=5.555702330196e-01
SCONVI_c061_2_13 (conv_i_src_c061_2_13 conv_i_c061_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_13 (conv_q_src_c061_2_13 0 conv_bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_2_13 (conv_q_src_c061_2_13 conv_q_c061_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_14 (conv_i_src_c061_2_14 0 conv_bpf_c061_2 0) vcvs gain=8.314696123025e-01
SCONVI_c061_2_14 (conv_i_src_c061_2_14 conv_i_c061_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_14 (conv_q_src_c061_2_14 0 conv_bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_2_14 (conv_q_src_c061_2_14 conv_q_c061_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_2_15 (conv_i_src_c061_2_15 0 conv_bpf_c061_2 0) vcvs gain=9.807852804032e-01
SCONVI_c061_2_15 (conv_i_src_c061_2_15 conv_i_c061_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_2_15 (conv_q_src_c061_2_15 0 conv_bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_2_15 (conv_q_src_c061_2_15 conv_q_c061_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c061_2 (conv_i_c061_2 0) resistor r=1G
RCONVQ_c061_2 (conv_q_c061_2 0) resistor r=1G
RCONVINTI_c061_2 (conv_i_c061_2 ConvIcar_c061_2) resistor r=1k
CCONVINTI_c061_2 (ConvIcar_c061_2 0) capacitor c=80p
RCONVINTQ_c061_2 (conv_q_c061_2 ConvQcar_c061_2) resistor r=1k
CCONVINTQ_c061_2 (ConvQcar_c061_2 0) capacitor c=80p
save conv_bpf_c061_2 ConvIcar_c061_2 ConvQcar_c061_2

// conventional mixed baseline bl061, carrier_3: 1000000000 Hz
CCONVBPF_c061_3 (bl061 n_conv_cbpf_c061_3) capacitor c=2.533029591058e-14
LCONVBPF_c061_3 (n_conv_cbpf_c061_3 conv_bpf_c061_3) inductor l=1.000000000000e-06
RCONVBPF_c061_3 (conv_bpf_c061_3 0) resistor r=3.141592653590e+02
ECONVI_c061_3_00 (conv_i_src_c061_3_00 0 conv_bpf_c061_3 0) vcvs gain=9.807852804032e-01
SCONVI_c061_3_00 (conv_i_src_c061_3_00 conv_i_c061_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_00 (conv_q_src_c061_3_00 0 conv_bpf_c061_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_3_00 (conv_q_src_c061_3_00 conv_q_c061_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_01 (conv_i_src_c061_3_01 0 conv_bpf_c061_3 0) vcvs gain=8.314696123025e-01
SCONVI_c061_3_01 (conv_i_src_c061_3_01 conv_i_c061_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_01 (conv_q_src_c061_3_01 0 conv_bpf_c061_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_3_01 (conv_q_src_c061_3_01 conv_q_c061_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_02 (conv_i_src_c061_3_02 0 conv_bpf_c061_3 0) vcvs gain=5.555702330196e-01
SCONVI_c061_3_02 (conv_i_src_c061_3_02 conv_i_c061_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_02 (conv_q_src_c061_3_02 0 conv_bpf_c061_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_3_02 (conv_q_src_c061_3_02 conv_q_c061_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_03 (conv_i_src_c061_3_03 0 conv_bpf_c061_3 0) vcvs gain=1.950903220161e-01
SCONVI_c061_3_03 (conv_i_src_c061_3_03 conv_i_c061_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_03 (conv_q_src_c061_3_03 0 conv_bpf_c061_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_3_03 (conv_q_src_c061_3_03 conv_q_c061_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_04 (conv_i_src_c061_3_04 0 conv_bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_3_04 (conv_i_src_c061_3_04 conv_i_c061_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_04 (conv_q_src_c061_3_04 0 conv_bpf_c061_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c061_3_04 (conv_q_src_c061_3_04 conv_q_c061_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_05 (conv_i_src_c061_3_05 0 conv_bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_3_05 (conv_i_src_c061_3_05 conv_i_c061_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_05 (conv_q_src_c061_3_05 0 conv_bpf_c061_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c061_3_05 (conv_q_src_c061_3_05 conv_q_c061_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_06 (conv_i_src_c061_3_06 0 conv_bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_3_06 (conv_i_src_c061_3_06 conv_i_c061_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_06 (conv_q_src_c061_3_06 0 conv_bpf_c061_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c061_3_06 (conv_q_src_c061_3_06 conv_q_c061_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_07 (conv_i_src_c061_3_07 0 conv_bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_3_07 (conv_i_src_c061_3_07 conv_i_c061_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_07 (conv_q_src_c061_3_07 0 conv_bpf_c061_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c061_3_07 (conv_q_src_c061_3_07 conv_q_c061_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_08 (conv_i_src_c061_3_08 0 conv_bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c061_3_08 (conv_i_src_c061_3_08 conv_i_c061_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_08 (conv_q_src_c061_3_08 0 conv_bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_3_08 (conv_q_src_c061_3_08 conv_q_c061_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_09 (conv_i_src_c061_3_09 0 conv_bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c061_3_09 (conv_i_src_c061_3_09 conv_i_c061_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_09 (conv_q_src_c061_3_09 0 conv_bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_3_09 (conv_q_src_c061_3_09 conv_q_c061_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_10 (conv_i_src_c061_3_10 0 conv_bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c061_3_10 (conv_i_src_c061_3_10 conv_i_c061_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_10 (conv_q_src_c061_3_10 0 conv_bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_3_10 (conv_q_src_c061_3_10 conv_q_c061_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_11 (conv_i_src_c061_3_11 0 conv_bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c061_3_11 (conv_i_src_c061_3_11 conv_i_c061_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_11 (conv_q_src_c061_3_11 0 conv_bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_3_11 (conv_q_src_c061_3_11 conv_q_c061_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_12 (conv_i_src_c061_3_12 0 conv_bpf_c061_3 0) vcvs gain=1.950903220161e-01
SCONVI_c061_3_12 (conv_i_src_c061_3_12 conv_i_c061_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_12 (conv_q_src_c061_3_12 0 conv_bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c061_3_12 (conv_q_src_c061_3_12 conv_q_c061_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_13 (conv_i_src_c061_3_13 0 conv_bpf_c061_3 0) vcvs gain=5.555702330196e-01
SCONVI_c061_3_13 (conv_i_src_c061_3_13 conv_i_c061_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_13 (conv_q_src_c061_3_13 0 conv_bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c061_3_13 (conv_q_src_c061_3_13 conv_q_c061_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_14 (conv_i_src_c061_3_14 0 conv_bpf_c061_3 0) vcvs gain=8.314696123025e-01
SCONVI_c061_3_14 (conv_i_src_c061_3_14 conv_i_c061_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_14 (conv_q_src_c061_3_14 0 conv_bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c061_3_14 (conv_q_src_c061_3_14 conv_q_c061_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c061_3_15 (conv_i_src_c061_3_15 0 conv_bpf_c061_3 0) vcvs gain=9.807852804032e-01
SCONVI_c061_3_15 (conv_i_src_c061_3_15 conv_i_c061_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c061_3_15 (conv_q_src_c061_3_15 0 conv_bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c061_3_15 (conv_q_src_c061_3_15 conv_q_c061_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c061_3 (conv_i_c061_3 0) resistor r=1G
RCONVQ_c061_3 (conv_q_c061_3 0) resistor r=1G
RCONVINTI_c061_3 (conv_i_c061_3 ConvIcar_c061_3) resistor r=1k
CCONVINTI_c061_3 (ConvIcar_c061_3 0) capacitor c=80p
RCONVINTQ_c061_3 (conv_q_c061_3 ConvQcar_c061_3) resistor r=1k
CCONVINTQ_c061_3 (ConvQcar_c061_3 0) capacitor c=80p
save conv_bpf_c061_3 ConvIcar_c061_3 ConvQcar_c061_3

// conventional mixed baseline bl062, carrier_0: 250000000 Hz
CCONVBPF_c062_0 (bl062 n_conv_cbpf_c062_0) capacitor c=4.052847345694e-13
LCONVBPF_c062_0 (n_conv_cbpf_c062_0 conv_bpf_c062_0) inductor l=1.000000000000e-06
RCONVBPF_c062_0 (conv_bpf_c062_0 0) resistor r=7.853981633974e+01
ECONVI_c062_0_00 (conv_i_src_c062_0_00 0 conv_bpf_c062_0 0) vcvs gain=9.807852804032e-01
SCONVI_c062_0_00 (conv_i_src_c062_0_00 conv_i_c062_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_00 (conv_q_src_c062_0_00 0 conv_bpf_c062_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_0_00 (conv_q_src_c062_0_00 conv_q_c062_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_01 (conv_i_src_c062_0_01 0 conv_bpf_c062_0 0) vcvs gain=8.314696123025e-01
SCONVI_c062_0_01 (conv_i_src_c062_0_01 conv_i_c062_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_01 (conv_q_src_c062_0_01 0 conv_bpf_c062_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_0_01 (conv_q_src_c062_0_01 conv_q_c062_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_02 (conv_i_src_c062_0_02 0 conv_bpf_c062_0 0) vcvs gain=5.555702330196e-01
SCONVI_c062_0_02 (conv_i_src_c062_0_02 conv_i_c062_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_02 (conv_q_src_c062_0_02 0 conv_bpf_c062_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_0_02 (conv_q_src_c062_0_02 conv_q_c062_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_03 (conv_i_src_c062_0_03 0 conv_bpf_c062_0 0) vcvs gain=1.950903220161e-01
SCONVI_c062_0_03 (conv_i_src_c062_0_03 conv_i_c062_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_03 (conv_q_src_c062_0_03 0 conv_bpf_c062_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_0_03 (conv_q_src_c062_0_03 conv_q_c062_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_04 (conv_i_src_c062_0_04 0 conv_bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_0_04 (conv_i_src_c062_0_04 conv_i_c062_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_04 (conv_q_src_c062_0_04 0 conv_bpf_c062_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_0_04 (conv_q_src_c062_0_04 conv_q_c062_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_05 (conv_i_src_c062_0_05 0 conv_bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_0_05 (conv_i_src_c062_0_05 conv_i_c062_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_05 (conv_q_src_c062_0_05 0 conv_bpf_c062_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_0_05 (conv_q_src_c062_0_05 conv_q_c062_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_06 (conv_i_src_c062_0_06 0 conv_bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_0_06 (conv_i_src_c062_0_06 conv_i_c062_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_06 (conv_q_src_c062_0_06 0 conv_bpf_c062_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_0_06 (conv_q_src_c062_0_06 conv_q_c062_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_07 (conv_i_src_c062_0_07 0 conv_bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_0_07 (conv_i_src_c062_0_07 conv_i_c062_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_07 (conv_q_src_c062_0_07 0 conv_bpf_c062_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_0_07 (conv_q_src_c062_0_07 conv_q_c062_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_08 (conv_i_src_c062_0_08 0 conv_bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_0_08 (conv_i_src_c062_0_08 conv_i_c062_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_08 (conv_q_src_c062_0_08 0 conv_bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_0_08 (conv_q_src_c062_0_08 conv_q_c062_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_09 (conv_i_src_c062_0_09 0 conv_bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_0_09 (conv_i_src_c062_0_09 conv_i_c062_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_09 (conv_q_src_c062_0_09 0 conv_bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_0_09 (conv_q_src_c062_0_09 conv_q_c062_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_10 (conv_i_src_c062_0_10 0 conv_bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_0_10 (conv_i_src_c062_0_10 conv_i_c062_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_10 (conv_q_src_c062_0_10 0 conv_bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_0_10 (conv_q_src_c062_0_10 conv_q_c062_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_11 (conv_i_src_c062_0_11 0 conv_bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_0_11 (conv_i_src_c062_0_11 conv_i_c062_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_11 (conv_q_src_c062_0_11 0 conv_bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_0_11 (conv_q_src_c062_0_11 conv_q_c062_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_12 (conv_i_src_c062_0_12 0 conv_bpf_c062_0 0) vcvs gain=1.950903220161e-01
SCONVI_c062_0_12 (conv_i_src_c062_0_12 conv_i_c062_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_12 (conv_q_src_c062_0_12 0 conv_bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_0_12 (conv_q_src_c062_0_12 conv_q_c062_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_13 (conv_i_src_c062_0_13 0 conv_bpf_c062_0 0) vcvs gain=5.555702330196e-01
SCONVI_c062_0_13 (conv_i_src_c062_0_13 conv_i_c062_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_13 (conv_q_src_c062_0_13 0 conv_bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_0_13 (conv_q_src_c062_0_13 conv_q_c062_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_14 (conv_i_src_c062_0_14 0 conv_bpf_c062_0 0) vcvs gain=8.314696123025e-01
SCONVI_c062_0_14 (conv_i_src_c062_0_14 conv_i_c062_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_14 (conv_q_src_c062_0_14 0 conv_bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_0_14 (conv_q_src_c062_0_14 conv_q_c062_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_0_15 (conv_i_src_c062_0_15 0 conv_bpf_c062_0 0) vcvs gain=9.807852804032e-01
SCONVI_c062_0_15 (conv_i_src_c062_0_15 conv_i_c062_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_0_15 (conv_q_src_c062_0_15 0 conv_bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_0_15 (conv_q_src_c062_0_15 conv_q_c062_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c062_0 (conv_i_c062_0 0) resistor r=1G
RCONVQ_c062_0 (conv_q_c062_0 0) resistor r=1G
RCONVINTI_c062_0 (conv_i_c062_0 ConvIcar_c062_0) resistor r=1k
CCONVINTI_c062_0 (ConvIcar_c062_0 0) capacitor c=80p
RCONVINTQ_c062_0 (conv_q_c062_0 ConvQcar_c062_0) resistor r=1k
CCONVINTQ_c062_0 (ConvQcar_c062_0 0) capacitor c=80p
save conv_bpf_c062_0 ConvIcar_c062_0 ConvQcar_c062_0

// conventional mixed baseline bl062, carrier_1: 500000000 Hz
CCONVBPF_c062_1 (bl062 n_conv_cbpf_c062_1) capacitor c=1.013211836423e-13
LCONVBPF_c062_1 (n_conv_cbpf_c062_1 conv_bpf_c062_1) inductor l=1.000000000000e-06
RCONVBPF_c062_1 (conv_bpf_c062_1 0) resistor r=1.570796326795e+02
ECONVI_c062_1_00 (conv_i_src_c062_1_00 0 conv_bpf_c062_1 0) vcvs gain=9.807852804032e-01
SCONVI_c062_1_00 (conv_i_src_c062_1_00 conv_i_c062_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_00 (conv_q_src_c062_1_00 0 conv_bpf_c062_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_1_00 (conv_q_src_c062_1_00 conv_q_c062_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_01 (conv_i_src_c062_1_01 0 conv_bpf_c062_1 0) vcvs gain=8.314696123025e-01
SCONVI_c062_1_01 (conv_i_src_c062_1_01 conv_i_c062_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_01 (conv_q_src_c062_1_01 0 conv_bpf_c062_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_1_01 (conv_q_src_c062_1_01 conv_q_c062_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_02 (conv_i_src_c062_1_02 0 conv_bpf_c062_1 0) vcvs gain=5.555702330196e-01
SCONVI_c062_1_02 (conv_i_src_c062_1_02 conv_i_c062_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_02 (conv_q_src_c062_1_02 0 conv_bpf_c062_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_1_02 (conv_q_src_c062_1_02 conv_q_c062_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_03 (conv_i_src_c062_1_03 0 conv_bpf_c062_1 0) vcvs gain=1.950903220161e-01
SCONVI_c062_1_03 (conv_i_src_c062_1_03 conv_i_c062_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_03 (conv_q_src_c062_1_03 0 conv_bpf_c062_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_1_03 (conv_q_src_c062_1_03 conv_q_c062_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_04 (conv_i_src_c062_1_04 0 conv_bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_1_04 (conv_i_src_c062_1_04 conv_i_c062_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_04 (conv_q_src_c062_1_04 0 conv_bpf_c062_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_1_04 (conv_q_src_c062_1_04 conv_q_c062_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_05 (conv_i_src_c062_1_05 0 conv_bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_1_05 (conv_i_src_c062_1_05 conv_i_c062_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_05 (conv_q_src_c062_1_05 0 conv_bpf_c062_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_1_05 (conv_q_src_c062_1_05 conv_q_c062_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_06 (conv_i_src_c062_1_06 0 conv_bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_1_06 (conv_i_src_c062_1_06 conv_i_c062_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_06 (conv_q_src_c062_1_06 0 conv_bpf_c062_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_1_06 (conv_q_src_c062_1_06 conv_q_c062_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_07 (conv_i_src_c062_1_07 0 conv_bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_1_07 (conv_i_src_c062_1_07 conv_i_c062_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_07 (conv_q_src_c062_1_07 0 conv_bpf_c062_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_1_07 (conv_q_src_c062_1_07 conv_q_c062_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_08 (conv_i_src_c062_1_08 0 conv_bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_1_08 (conv_i_src_c062_1_08 conv_i_c062_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_08 (conv_q_src_c062_1_08 0 conv_bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_1_08 (conv_q_src_c062_1_08 conv_q_c062_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_09 (conv_i_src_c062_1_09 0 conv_bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_1_09 (conv_i_src_c062_1_09 conv_i_c062_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_09 (conv_q_src_c062_1_09 0 conv_bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_1_09 (conv_q_src_c062_1_09 conv_q_c062_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_10 (conv_i_src_c062_1_10 0 conv_bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_1_10 (conv_i_src_c062_1_10 conv_i_c062_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_10 (conv_q_src_c062_1_10 0 conv_bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_1_10 (conv_q_src_c062_1_10 conv_q_c062_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_11 (conv_i_src_c062_1_11 0 conv_bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_1_11 (conv_i_src_c062_1_11 conv_i_c062_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_11 (conv_q_src_c062_1_11 0 conv_bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_1_11 (conv_q_src_c062_1_11 conv_q_c062_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_12 (conv_i_src_c062_1_12 0 conv_bpf_c062_1 0) vcvs gain=1.950903220161e-01
SCONVI_c062_1_12 (conv_i_src_c062_1_12 conv_i_c062_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_12 (conv_q_src_c062_1_12 0 conv_bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_1_12 (conv_q_src_c062_1_12 conv_q_c062_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_13 (conv_i_src_c062_1_13 0 conv_bpf_c062_1 0) vcvs gain=5.555702330196e-01
SCONVI_c062_1_13 (conv_i_src_c062_1_13 conv_i_c062_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_13 (conv_q_src_c062_1_13 0 conv_bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_1_13 (conv_q_src_c062_1_13 conv_q_c062_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_14 (conv_i_src_c062_1_14 0 conv_bpf_c062_1 0) vcvs gain=8.314696123025e-01
SCONVI_c062_1_14 (conv_i_src_c062_1_14 conv_i_c062_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_14 (conv_q_src_c062_1_14 0 conv_bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_1_14 (conv_q_src_c062_1_14 conv_q_c062_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_1_15 (conv_i_src_c062_1_15 0 conv_bpf_c062_1 0) vcvs gain=9.807852804032e-01
SCONVI_c062_1_15 (conv_i_src_c062_1_15 conv_i_c062_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_1_15 (conv_q_src_c062_1_15 0 conv_bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_1_15 (conv_q_src_c062_1_15 conv_q_c062_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c062_1 (conv_i_c062_1 0) resistor r=1G
RCONVQ_c062_1 (conv_q_c062_1 0) resistor r=1G
RCONVINTI_c062_1 (conv_i_c062_1 ConvIcar_c062_1) resistor r=1k
CCONVINTI_c062_1 (ConvIcar_c062_1 0) capacitor c=80p
RCONVINTQ_c062_1 (conv_q_c062_1 ConvQcar_c062_1) resistor r=1k
CCONVINTQ_c062_1 (ConvQcar_c062_1 0) capacitor c=80p
save conv_bpf_c062_1 ConvIcar_c062_1 ConvQcar_c062_1

// conventional mixed baseline bl062, carrier_2: 750000000 Hz
CCONVBPF_c062_2 (bl062 n_conv_cbpf_c062_2) capacitor c=4.503163717437e-14
LCONVBPF_c062_2 (n_conv_cbpf_c062_2 conv_bpf_c062_2) inductor l=1.000000000000e-06
RCONVBPF_c062_2 (conv_bpf_c062_2 0) resistor r=2.356194490192e+02
ECONVI_c062_2_00 (conv_i_src_c062_2_00 0 conv_bpf_c062_2 0) vcvs gain=9.807852804032e-01
SCONVI_c062_2_00 (conv_i_src_c062_2_00 conv_i_c062_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_00 (conv_q_src_c062_2_00 0 conv_bpf_c062_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_2_00 (conv_q_src_c062_2_00 conv_q_c062_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_01 (conv_i_src_c062_2_01 0 conv_bpf_c062_2 0) vcvs gain=8.314696123025e-01
SCONVI_c062_2_01 (conv_i_src_c062_2_01 conv_i_c062_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_01 (conv_q_src_c062_2_01 0 conv_bpf_c062_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_2_01 (conv_q_src_c062_2_01 conv_q_c062_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_02 (conv_i_src_c062_2_02 0 conv_bpf_c062_2 0) vcvs gain=5.555702330196e-01
SCONVI_c062_2_02 (conv_i_src_c062_2_02 conv_i_c062_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_02 (conv_q_src_c062_2_02 0 conv_bpf_c062_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_2_02 (conv_q_src_c062_2_02 conv_q_c062_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_03 (conv_i_src_c062_2_03 0 conv_bpf_c062_2 0) vcvs gain=1.950903220161e-01
SCONVI_c062_2_03 (conv_i_src_c062_2_03 conv_i_c062_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_03 (conv_q_src_c062_2_03 0 conv_bpf_c062_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_2_03 (conv_q_src_c062_2_03 conv_q_c062_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_04 (conv_i_src_c062_2_04 0 conv_bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_2_04 (conv_i_src_c062_2_04 conv_i_c062_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_04 (conv_q_src_c062_2_04 0 conv_bpf_c062_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_2_04 (conv_q_src_c062_2_04 conv_q_c062_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_05 (conv_i_src_c062_2_05 0 conv_bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_2_05 (conv_i_src_c062_2_05 conv_i_c062_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_05 (conv_q_src_c062_2_05 0 conv_bpf_c062_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_2_05 (conv_q_src_c062_2_05 conv_q_c062_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_06 (conv_i_src_c062_2_06 0 conv_bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_2_06 (conv_i_src_c062_2_06 conv_i_c062_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_06 (conv_q_src_c062_2_06 0 conv_bpf_c062_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_2_06 (conv_q_src_c062_2_06 conv_q_c062_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_07 (conv_i_src_c062_2_07 0 conv_bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_2_07 (conv_i_src_c062_2_07 conv_i_c062_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_07 (conv_q_src_c062_2_07 0 conv_bpf_c062_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_2_07 (conv_q_src_c062_2_07 conv_q_c062_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_08 (conv_i_src_c062_2_08 0 conv_bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_2_08 (conv_i_src_c062_2_08 conv_i_c062_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_08 (conv_q_src_c062_2_08 0 conv_bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_2_08 (conv_q_src_c062_2_08 conv_q_c062_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_09 (conv_i_src_c062_2_09 0 conv_bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_2_09 (conv_i_src_c062_2_09 conv_i_c062_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_09 (conv_q_src_c062_2_09 0 conv_bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_2_09 (conv_q_src_c062_2_09 conv_q_c062_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_10 (conv_i_src_c062_2_10 0 conv_bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_2_10 (conv_i_src_c062_2_10 conv_i_c062_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_10 (conv_q_src_c062_2_10 0 conv_bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_2_10 (conv_q_src_c062_2_10 conv_q_c062_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_11 (conv_i_src_c062_2_11 0 conv_bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_2_11 (conv_i_src_c062_2_11 conv_i_c062_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_11 (conv_q_src_c062_2_11 0 conv_bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_2_11 (conv_q_src_c062_2_11 conv_q_c062_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_12 (conv_i_src_c062_2_12 0 conv_bpf_c062_2 0) vcvs gain=1.950903220161e-01
SCONVI_c062_2_12 (conv_i_src_c062_2_12 conv_i_c062_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_12 (conv_q_src_c062_2_12 0 conv_bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_2_12 (conv_q_src_c062_2_12 conv_q_c062_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_13 (conv_i_src_c062_2_13 0 conv_bpf_c062_2 0) vcvs gain=5.555702330196e-01
SCONVI_c062_2_13 (conv_i_src_c062_2_13 conv_i_c062_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_13 (conv_q_src_c062_2_13 0 conv_bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_2_13 (conv_q_src_c062_2_13 conv_q_c062_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_14 (conv_i_src_c062_2_14 0 conv_bpf_c062_2 0) vcvs gain=8.314696123025e-01
SCONVI_c062_2_14 (conv_i_src_c062_2_14 conv_i_c062_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_14 (conv_q_src_c062_2_14 0 conv_bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_2_14 (conv_q_src_c062_2_14 conv_q_c062_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_2_15 (conv_i_src_c062_2_15 0 conv_bpf_c062_2 0) vcvs gain=9.807852804032e-01
SCONVI_c062_2_15 (conv_i_src_c062_2_15 conv_i_c062_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_2_15 (conv_q_src_c062_2_15 0 conv_bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_2_15 (conv_q_src_c062_2_15 conv_q_c062_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c062_2 (conv_i_c062_2 0) resistor r=1G
RCONVQ_c062_2 (conv_q_c062_2 0) resistor r=1G
RCONVINTI_c062_2 (conv_i_c062_2 ConvIcar_c062_2) resistor r=1k
CCONVINTI_c062_2 (ConvIcar_c062_2 0) capacitor c=80p
RCONVINTQ_c062_2 (conv_q_c062_2 ConvQcar_c062_2) resistor r=1k
CCONVINTQ_c062_2 (ConvQcar_c062_2 0) capacitor c=80p
save conv_bpf_c062_2 ConvIcar_c062_2 ConvQcar_c062_2

// conventional mixed baseline bl062, carrier_3: 1000000000 Hz
CCONVBPF_c062_3 (bl062 n_conv_cbpf_c062_3) capacitor c=2.533029591058e-14
LCONVBPF_c062_3 (n_conv_cbpf_c062_3 conv_bpf_c062_3) inductor l=1.000000000000e-06
RCONVBPF_c062_3 (conv_bpf_c062_3 0) resistor r=3.141592653590e+02
ECONVI_c062_3_00 (conv_i_src_c062_3_00 0 conv_bpf_c062_3 0) vcvs gain=9.807852804032e-01
SCONVI_c062_3_00 (conv_i_src_c062_3_00 conv_i_c062_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_00 (conv_q_src_c062_3_00 0 conv_bpf_c062_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_3_00 (conv_q_src_c062_3_00 conv_q_c062_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_01 (conv_i_src_c062_3_01 0 conv_bpf_c062_3 0) vcvs gain=8.314696123025e-01
SCONVI_c062_3_01 (conv_i_src_c062_3_01 conv_i_c062_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_01 (conv_q_src_c062_3_01 0 conv_bpf_c062_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_3_01 (conv_q_src_c062_3_01 conv_q_c062_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_02 (conv_i_src_c062_3_02 0 conv_bpf_c062_3 0) vcvs gain=5.555702330196e-01
SCONVI_c062_3_02 (conv_i_src_c062_3_02 conv_i_c062_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_02 (conv_q_src_c062_3_02 0 conv_bpf_c062_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_3_02 (conv_q_src_c062_3_02 conv_q_c062_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_03 (conv_i_src_c062_3_03 0 conv_bpf_c062_3 0) vcvs gain=1.950903220161e-01
SCONVI_c062_3_03 (conv_i_src_c062_3_03 conv_i_c062_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_03 (conv_q_src_c062_3_03 0 conv_bpf_c062_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_3_03 (conv_q_src_c062_3_03 conv_q_c062_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_04 (conv_i_src_c062_3_04 0 conv_bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_3_04 (conv_i_src_c062_3_04 conv_i_c062_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_04 (conv_q_src_c062_3_04 0 conv_bpf_c062_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c062_3_04 (conv_q_src_c062_3_04 conv_q_c062_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_05 (conv_i_src_c062_3_05 0 conv_bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_3_05 (conv_i_src_c062_3_05 conv_i_c062_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_05 (conv_q_src_c062_3_05 0 conv_bpf_c062_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c062_3_05 (conv_q_src_c062_3_05 conv_q_c062_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_06 (conv_i_src_c062_3_06 0 conv_bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_3_06 (conv_i_src_c062_3_06 conv_i_c062_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_06 (conv_q_src_c062_3_06 0 conv_bpf_c062_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c062_3_06 (conv_q_src_c062_3_06 conv_q_c062_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_07 (conv_i_src_c062_3_07 0 conv_bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_3_07 (conv_i_src_c062_3_07 conv_i_c062_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_07 (conv_q_src_c062_3_07 0 conv_bpf_c062_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c062_3_07 (conv_q_src_c062_3_07 conv_q_c062_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_08 (conv_i_src_c062_3_08 0 conv_bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c062_3_08 (conv_i_src_c062_3_08 conv_i_c062_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_08 (conv_q_src_c062_3_08 0 conv_bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_3_08 (conv_q_src_c062_3_08 conv_q_c062_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_09 (conv_i_src_c062_3_09 0 conv_bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c062_3_09 (conv_i_src_c062_3_09 conv_i_c062_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_09 (conv_q_src_c062_3_09 0 conv_bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_3_09 (conv_q_src_c062_3_09 conv_q_c062_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_10 (conv_i_src_c062_3_10 0 conv_bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c062_3_10 (conv_i_src_c062_3_10 conv_i_c062_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_10 (conv_q_src_c062_3_10 0 conv_bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_3_10 (conv_q_src_c062_3_10 conv_q_c062_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_11 (conv_i_src_c062_3_11 0 conv_bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c062_3_11 (conv_i_src_c062_3_11 conv_i_c062_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_11 (conv_q_src_c062_3_11 0 conv_bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_3_11 (conv_q_src_c062_3_11 conv_q_c062_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_12 (conv_i_src_c062_3_12 0 conv_bpf_c062_3 0) vcvs gain=1.950903220161e-01
SCONVI_c062_3_12 (conv_i_src_c062_3_12 conv_i_c062_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_12 (conv_q_src_c062_3_12 0 conv_bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c062_3_12 (conv_q_src_c062_3_12 conv_q_c062_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_13 (conv_i_src_c062_3_13 0 conv_bpf_c062_3 0) vcvs gain=5.555702330196e-01
SCONVI_c062_3_13 (conv_i_src_c062_3_13 conv_i_c062_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_13 (conv_q_src_c062_3_13 0 conv_bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c062_3_13 (conv_q_src_c062_3_13 conv_q_c062_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_14 (conv_i_src_c062_3_14 0 conv_bpf_c062_3 0) vcvs gain=8.314696123025e-01
SCONVI_c062_3_14 (conv_i_src_c062_3_14 conv_i_c062_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_14 (conv_q_src_c062_3_14 0 conv_bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c062_3_14 (conv_q_src_c062_3_14 conv_q_c062_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c062_3_15 (conv_i_src_c062_3_15 0 conv_bpf_c062_3 0) vcvs gain=9.807852804032e-01
SCONVI_c062_3_15 (conv_i_src_c062_3_15 conv_i_c062_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c062_3_15 (conv_q_src_c062_3_15 0 conv_bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c062_3_15 (conv_q_src_c062_3_15 conv_q_c062_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c062_3 (conv_i_c062_3 0) resistor r=1G
RCONVQ_c062_3 (conv_q_c062_3 0) resistor r=1G
RCONVINTI_c062_3 (conv_i_c062_3 ConvIcar_c062_3) resistor r=1k
CCONVINTI_c062_3 (ConvIcar_c062_3 0) capacitor c=80p
RCONVINTQ_c062_3 (conv_q_c062_3 ConvQcar_c062_3) resistor r=1k
CCONVINTQ_c062_3 (ConvQcar_c062_3 0) capacitor c=80p
save conv_bpf_c062_3 ConvIcar_c062_3 ConvQcar_c062_3

// conventional mixed baseline bl063, carrier_0: 250000000 Hz
CCONVBPF_c063_0 (bl063 n_conv_cbpf_c063_0) capacitor c=4.052847345694e-13
LCONVBPF_c063_0 (n_conv_cbpf_c063_0 conv_bpf_c063_0) inductor l=1.000000000000e-06
RCONVBPF_c063_0 (conv_bpf_c063_0 0) resistor r=7.853981633974e+01
ECONVI_c063_0_00 (conv_i_src_c063_0_00 0 conv_bpf_c063_0 0) vcvs gain=9.807852804032e-01
SCONVI_c063_0_00 (conv_i_src_c063_0_00 conv_i_c063_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_00 (conv_q_src_c063_0_00 0 conv_bpf_c063_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_0_00 (conv_q_src_c063_0_00 conv_q_c063_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_01 (conv_i_src_c063_0_01 0 conv_bpf_c063_0 0) vcvs gain=8.314696123025e-01
SCONVI_c063_0_01 (conv_i_src_c063_0_01 conv_i_c063_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_01 (conv_q_src_c063_0_01 0 conv_bpf_c063_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_0_01 (conv_q_src_c063_0_01 conv_q_c063_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_02 (conv_i_src_c063_0_02 0 conv_bpf_c063_0 0) vcvs gain=5.555702330196e-01
SCONVI_c063_0_02 (conv_i_src_c063_0_02 conv_i_c063_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_02 (conv_q_src_c063_0_02 0 conv_bpf_c063_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_0_02 (conv_q_src_c063_0_02 conv_q_c063_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_03 (conv_i_src_c063_0_03 0 conv_bpf_c063_0 0) vcvs gain=1.950903220161e-01
SCONVI_c063_0_03 (conv_i_src_c063_0_03 conv_i_c063_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_03 (conv_q_src_c063_0_03 0 conv_bpf_c063_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_0_03 (conv_q_src_c063_0_03 conv_q_c063_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_04 (conv_i_src_c063_0_04 0 conv_bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_0_04 (conv_i_src_c063_0_04 conv_i_c063_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_04 (conv_q_src_c063_0_04 0 conv_bpf_c063_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_0_04 (conv_q_src_c063_0_04 conv_q_c063_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_05 (conv_i_src_c063_0_05 0 conv_bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_0_05 (conv_i_src_c063_0_05 conv_i_c063_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_05 (conv_q_src_c063_0_05 0 conv_bpf_c063_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_0_05 (conv_q_src_c063_0_05 conv_q_c063_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_06 (conv_i_src_c063_0_06 0 conv_bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_0_06 (conv_i_src_c063_0_06 conv_i_c063_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_06 (conv_q_src_c063_0_06 0 conv_bpf_c063_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_0_06 (conv_q_src_c063_0_06 conv_q_c063_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_07 (conv_i_src_c063_0_07 0 conv_bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_0_07 (conv_i_src_c063_0_07 conv_i_c063_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_07 (conv_q_src_c063_0_07 0 conv_bpf_c063_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_0_07 (conv_q_src_c063_0_07 conv_q_c063_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_08 (conv_i_src_c063_0_08 0 conv_bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_0_08 (conv_i_src_c063_0_08 conv_i_c063_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_08 (conv_q_src_c063_0_08 0 conv_bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_0_08 (conv_q_src_c063_0_08 conv_q_c063_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_09 (conv_i_src_c063_0_09 0 conv_bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_0_09 (conv_i_src_c063_0_09 conv_i_c063_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_09 (conv_q_src_c063_0_09 0 conv_bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_0_09 (conv_q_src_c063_0_09 conv_q_c063_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_10 (conv_i_src_c063_0_10 0 conv_bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_0_10 (conv_i_src_c063_0_10 conv_i_c063_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_10 (conv_q_src_c063_0_10 0 conv_bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_0_10 (conv_q_src_c063_0_10 conv_q_c063_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_11 (conv_i_src_c063_0_11 0 conv_bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_0_11 (conv_i_src_c063_0_11 conv_i_c063_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_11 (conv_q_src_c063_0_11 0 conv_bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_0_11 (conv_q_src_c063_0_11 conv_q_c063_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_12 (conv_i_src_c063_0_12 0 conv_bpf_c063_0 0) vcvs gain=1.950903220161e-01
SCONVI_c063_0_12 (conv_i_src_c063_0_12 conv_i_c063_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_12 (conv_q_src_c063_0_12 0 conv_bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_0_12 (conv_q_src_c063_0_12 conv_q_c063_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_13 (conv_i_src_c063_0_13 0 conv_bpf_c063_0 0) vcvs gain=5.555702330196e-01
SCONVI_c063_0_13 (conv_i_src_c063_0_13 conv_i_c063_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_13 (conv_q_src_c063_0_13 0 conv_bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_0_13 (conv_q_src_c063_0_13 conv_q_c063_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_14 (conv_i_src_c063_0_14 0 conv_bpf_c063_0 0) vcvs gain=8.314696123025e-01
SCONVI_c063_0_14 (conv_i_src_c063_0_14 conv_i_c063_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_14 (conv_q_src_c063_0_14 0 conv_bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_0_14 (conv_q_src_c063_0_14 conv_q_c063_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_0_15 (conv_i_src_c063_0_15 0 conv_bpf_c063_0 0) vcvs gain=9.807852804032e-01
SCONVI_c063_0_15 (conv_i_src_c063_0_15 conv_i_c063_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_0_15 (conv_q_src_c063_0_15 0 conv_bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_0_15 (conv_q_src_c063_0_15 conv_q_c063_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c063_0 (conv_i_c063_0 0) resistor r=1G
RCONVQ_c063_0 (conv_q_c063_0 0) resistor r=1G
RCONVINTI_c063_0 (conv_i_c063_0 ConvIcar_c063_0) resistor r=1k
CCONVINTI_c063_0 (ConvIcar_c063_0 0) capacitor c=80p
RCONVINTQ_c063_0 (conv_q_c063_0 ConvQcar_c063_0) resistor r=1k
CCONVINTQ_c063_0 (ConvQcar_c063_0 0) capacitor c=80p
save conv_bpf_c063_0 ConvIcar_c063_0 ConvQcar_c063_0

// conventional mixed baseline bl063, carrier_1: 500000000 Hz
CCONVBPF_c063_1 (bl063 n_conv_cbpf_c063_1) capacitor c=1.013211836423e-13
LCONVBPF_c063_1 (n_conv_cbpf_c063_1 conv_bpf_c063_1) inductor l=1.000000000000e-06
RCONVBPF_c063_1 (conv_bpf_c063_1 0) resistor r=1.570796326795e+02
ECONVI_c063_1_00 (conv_i_src_c063_1_00 0 conv_bpf_c063_1 0) vcvs gain=9.807852804032e-01
SCONVI_c063_1_00 (conv_i_src_c063_1_00 conv_i_c063_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_00 (conv_q_src_c063_1_00 0 conv_bpf_c063_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_1_00 (conv_q_src_c063_1_00 conv_q_c063_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_01 (conv_i_src_c063_1_01 0 conv_bpf_c063_1 0) vcvs gain=8.314696123025e-01
SCONVI_c063_1_01 (conv_i_src_c063_1_01 conv_i_c063_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_01 (conv_q_src_c063_1_01 0 conv_bpf_c063_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_1_01 (conv_q_src_c063_1_01 conv_q_c063_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_02 (conv_i_src_c063_1_02 0 conv_bpf_c063_1 0) vcvs gain=5.555702330196e-01
SCONVI_c063_1_02 (conv_i_src_c063_1_02 conv_i_c063_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_02 (conv_q_src_c063_1_02 0 conv_bpf_c063_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_1_02 (conv_q_src_c063_1_02 conv_q_c063_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_03 (conv_i_src_c063_1_03 0 conv_bpf_c063_1 0) vcvs gain=1.950903220161e-01
SCONVI_c063_1_03 (conv_i_src_c063_1_03 conv_i_c063_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_03 (conv_q_src_c063_1_03 0 conv_bpf_c063_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_1_03 (conv_q_src_c063_1_03 conv_q_c063_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_04 (conv_i_src_c063_1_04 0 conv_bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_1_04 (conv_i_src_c063_1_04 conv_i_c063_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_04 (conv_q_src_c063_1_04 0 conv_bpf_c063_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_1_04 (conv_q_src_c063_1_04 conv_q_c063_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_05 (conv_i_src_c063_1_05 0 conv_bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_1_05 (conv_i_src_c063_1_05 conv_i_c063_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_05 (conv_q_src_c063_1_05 0 conv_bpf_c063_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_1_05 (conv_q_src_c063_1_05 conv_q_c063_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_06 (conv_i_src_c063_1_06 0 conv_bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_1_06 (conv_i_src_c063_1_06 conv_i_c063_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_06 (conv_q_src_c063_1_06 0 conv_bpf_c063_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_1_06 (conv_q_src_c063_1_06 conv_q_c063_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_07 (conv_i_src_c063_1_07 0 conv_bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_1_07 (conv_i_src_c063_1_07 conv_i_c063_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_07 (conv_q_src_c063_1_07 0 conv_bpf_c063_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_1_07 (conv_q_src_c063_1_07 conv_q_c063_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_08 (conv_i_src_c063_1_08 0 conv_bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_1_08 (conv_i_src_c063_1_08 conv_i_c063_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_08 (conv_q_src_c063_1_08 0 conv_bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_1_08 (conv_q_src_c063_1_08 conv_q_c063_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_09 (conv_i_src_c063_1_09 0 conv_bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_1_09 (conv_i_src_c063_1_09 conv_i_c063_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_09 (conv_q_src_c063_1_09 0 conv_bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_1_09 (conv_q_src_c063_1_09 conv_q_c063_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_10 (conv_i_src_c063_1_10 0 conv_bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_1_10 (conv_i_src_c063_1_10 conv_i_c063_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_10 (conv_q_src_c063_1_10 0 conv_bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_1_10 (conv_q_src_c063_1_10 conv_q_c063_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_11 (conv_i_src_c063_1_11 0 conv_bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_1_11 (conv_i_src_c063_1_11 conv_i_c063_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_11 (conv_q_src_c063_1_11 0 conv_bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_1_11 (conv_q_src_c063_1_11 conv_q_c063_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_12 (conv_i_src_c063_1_12 0 conv_bpf_c063_1 0) vcvs gain=1.950903220161e-01
SCONVI_c063_1_12 (conv_i_src_c063_1_12 conv_i_c063_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_12 (conv_q_src_c063_1_12 0 conv_bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_1_12 (conv_q_src_c063_1_12 conv_q_c063_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_13 (conv_i_src_c063_1_13 0 conv_bpf_c063_1 0) vcvs gain=5.555702330196e-01
SCONVI_c063_1_13 (conv_i_src_c063_1_13 conv_i_c063_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_13 (conv_q_src_c063_1_13 0 conv_bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_1_13 (conv_q_src_c063_1_13 conv_q_c063_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_14 (conv_i_src_c063_1_14 0 conv_bpf_c063_1 0) vcvs gain=8.314696123025e-01
SCONVI_c063_1_14 (conv_i_src_c063_1_14 conv_i_c063_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_14 (conv_q_src_c063_1_14 0 conv_bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_1_14 (conv_q_src_c063_1_14 conv_q_c063_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_1_15 (conv_i_src_c063_1_15 0 conv_bpf_c063_1 0) vcvs gain=9.807852804032e-01
SCONVI_c063_1_15 (conv_i_src_c063_1_15 conv_i_c063_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_1_15 (conv_q_src_c063_1_15 0 conv_bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_1_15 (conv_q_src_c063_1_15 conv_q_c063_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c063_1 (conv_i_c063_1 0) resistor r=1G
RCONVQ_c063_1 (conv_q_c063_1 0) resistor r=1G
RCONVINTI_c063_1 (conv_i_c063_1 ConvIcar_c063_1) resistor r=1k
CCONVINTI_c063_1 (ConvIcar_c063_1 0) capacitor c=80p
RCONVINTQ_c063_1 (conv_q_c063_1 ConvQcar_c063_1) resistor r=1k
CCONVINTQ_c063_1 (ConvQcar_c063_1 0) capacitor c=80p
save conv_bpf_c063_1 ConvIcar_c063_1 ConvQcar_c063_1

// conventional mixed baseline bl063, carrier_2: 750000000 Hz
CCONVBPF_c063_2 (bl063 n_conv_cbpf_c063_2) capacitor c=4.503163717437e-14
LCONVBPF_c063_2 (n_conv_cbpf_c063_2 conv_bpf_c063_2) inductor l=1.000000000000e-06
RCONVBPF_c063_2 (conv_bpf_c063_2 0) resistor r=2.356194490192e+02
ECONVI_c063_2_00 (conv_i_src_c063_2_00 0 conv_bpf_c063_2 0) vcvs gain=9.807852804032e-01
SCONVI_c063_2_00 (conv_i_src_c063_2_00 conv_i_c063_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_00 (conv_q_src_c063_2_00 0 conv_bpf_c063_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_2_00 (conv_q_src_c063_2_00 conv_q_c063_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_01 (conv_i_src_c063_2_01 0 conv_bpf_c063_2 0) vcvs gain=8.314696123025e-01
SCONVI_c063_2_01 (conv_i_src_c063_2_01 conv_i_c063_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_01 (conv_q_src_c063_2_01 0 conv_bpf_c063_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_2_01 (conv_q_src_c063_2_01 conv_q_c063_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_02 (conv_i_src_c063_2_02 0 conv_bpf_c063_2 0) vcvs gain=5.555702330196e-01
SCONVI_c063_2_02 (conv_i_src_c063_2_02 conv_i_c063_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_02 (conv_q_src_c063_2_02 0 conv_bpf_c063_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_2_02 (conv_q_src_c063_2_02 conv_q_c063_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_03 (conv_i_src_c063_2_03 0 conv_bpf_c063_2 0) vcvs gain=1.950903220161e-01
SCONVI_c063_2_03 (conv_i_src_c063_2_03 conv_i_c063_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_03 (conv_q_src_c063_2_03 0 conv_bpf_c063_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_2_03 (conv_q_src_c063_2_03 conv_q_c063_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_04 (conv_i_src_c063_2_04 0 conv_bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_2_04 (conv_i_src_c063_2_04 conv_i_c063_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_04 (conv_q_src_c063_2_04 0 conv_bpf_c063_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_2_04 (conv_q_src_c063_2_04 conv_q_c063_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_05 (conv_i_src_c063_2_05 0 conv_bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_2_05 (conv_i_src_c063_2_05 conv_i_c063_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_05 (conv_q_src_c063_2_05 0 conv_bpf_c063_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_2_05 (conv_q_src_c063_2_05 conv_q_c063_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_06 (conv_i_src_c063_2_06 0 conv_bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_2_06 (conv_i_src_c063_2_06 conv_i_c063_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_06 (conv_q_src_c063_2_06 0 conv_bpf_c063_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_2_06 (conv_q_src_c063_2_06 conv_q_c063_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_07 (conv_i_src_c063_2_07 0 conv_bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_2_07 (conv_i_src_c063_2_07 conv_i_c063_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_07 (conv_q_src_c063_2_07 0 conv_bpf_c063_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_2_07 (conv_q_src_c063_2_07 conv_q_c063_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_08 (conv_i_src_c063_2_08 0 conv_bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_2_08 (conv_i_src_c063_2_08 conv_i_c063_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_08 (conv_q_src_c063_2_08 0 conv_bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_2_08 (conv_q_src_c063_2_08 conv_q_c063_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_09 (conv_i_src_c063_2_09 0 conv_bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_2_09 (conv_i_src_c063_2_09 conv_i_c063_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_09 (conv_q_src_c063_2_09 0 conv_bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_2_09 (conv_q_src_c063_2_09 conv_q_c063_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_10 (conv_i_src_c063_2_10 0 conv_bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_2_10 (conv_i_src_c063_2_10 conv_i_c063_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_10 (conv_q_src_c063_2_10 0 conv_bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_2_10 (conv_q_src_c063_2_10 conv_q_c063_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_11 (conv_i_src_c063_2_11 0 conv_bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_2_11 (conv_i_src_c063_2_11 conv_i_c063_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_11 (conv_q_src_c063_2_11 0 conv_bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_2_11 (conv_q_src_c063_2_11 conv_q_c063_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_12 (conv_i_src_c063_2_12 0 conv_bpf_c063_2 0) vcvs gain=1.950903220161e-01
SCONVI_c063_2_12 (conv_i_src_c063_2_12 conv_i_c063_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_12 (conv_q_src_c063_2_12 0 conv_bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_2_12 (conv_q_src_c063_2_12 conv_q_c063_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_13 (conv_i_src_c063_2_13 0 conv_bpf_c063_2 0) vcvs gain=5.555702330196e-01
SCONVI_c063_2_13 (conv_i_src_c063_2_13 conv_i_c063_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_13 (conv_q_src_c063_2_13 0 conv_bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_2_13 (conv_q_src_c063_2_13 conv_q_c063_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_14 (conv_i_src_c063_2_14 0 conv_bpf_c063_2 0) vcvs gain=8.314696123025e-01
SCONVI_c063_2_14 (conv_i_src_c063_2_14 conv_i_c063_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_14 (conv_q_src_c063_2_14 0 conv_bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_2_14 (conv_q_src_c063_2_14 conv_q_c063_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_2_15 (conv_i_src_c063_2_15 0 conv_bpf_c063_2 0) vcvs gain=9.807852804032e-01
SCONVI_c063_2_15 (conv_i_src_c063_2_15 conv_i_c063_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_2_15 (conv_q_src_c063_2_15 0 conv_bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_2_15 (conv_q_src_c063_2_15 conv_q_c063_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c063_2 (conv_i_c063_2 0) resistor r=1G
RCONVQ_c063_2 (conv_q_c063_2 0) resistor r=1G
RCONVINTI_c063_2 (conv_i_c063_2 ConvIcar_c063_2) resistor r=1k
CCONVINTI_c063_2 (ConvIcar_c063_2 0) capacitor c=80p
RCONVINTQ_c063_2 (conv_q_c063_2 ConvQcar_c063_2) resistor r=1k
CCONVINTQ_c063_2 (ConvQcar_c063_2 0) capacitor c=80p
save conv_bpf_c063_2 ConvIcar_c063_2 ConvQcar_c063_2

// conventional mixed baseline bl063, carrier_3: 1000000000 Hz
CCONVBPF_c063_3 (bl063 n_conv_cbpf_c063_3) capacitor c=2.533029591058e-14
LCONVBPF_c063_3 (n_conv_cbpf_c063_3 conv_bpf_c063_3) inductor l=1.000000000000e-06
RCONVBPF_c063_3 (conv_bpf_c063_3 0) resistor r=3.141592653590e+02
ECONVI_c063_3_00 (conv_i_src_c063_3_00 0 conv_bpf_c063_3 0) vcvs gain=9.807852804032e-01
SCONVI_c063_3_00 (conv_i_src_c063_3_00 conv_i_c063_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_00 (conv_q_src_c063_3_00 0 conv_bpf_c063_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_3_00 (conv_q_src_c063_3_00 conv_q_c063_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_01 (conv_i_src_c063_3_01 0 conv_bpf_c063_3 0) vcvs gain=8.314696123025e-01
SCONVI_c063_3_01 (conv_i_src_c063_3_01 conv_i_c063_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_01 (conv_q_src_c063_3_01 0 conv_bpf_c063_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_3_01 (conv_q_src_c063_3_01 conv_q_c063_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_02 (conv_i_src_c063_3_02 0 conv_bpf_c063_3 0) vcvs gain=5.555702330196e-01
SCONVI_c063_3_02 (conv_i_src_c063_3_02 conv_i_c063_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_02 (conv_q_src_c063_3_02 0 conv_bpf_c063_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_3_02 (conv_q_src_c063_3_02 conv_q_c063_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_03 (conv_i_src_c063_3_03 0 conv_bpf_c063_3 0) vcvs gain=1.950903220161e-01
SCONVI_c063_3_03 (conv_i_src_c063_3_03 conv_i_c063_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_03 (conv_q_src_c063_3_03 0 conv_bpf_c063_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_3_03 (conv_q_src_c063_3_03 conv_q_c063_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_04 (conv_i_src_c063_3_04 0 conv_bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_3_04 (conv_i_src_c063_3_04 conv_i_c063_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_04 (conv_q_src_c063_3_04 0 conv_bpf_c063_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c063_3_04 (conv_q_src_c063_3_04 conv_q_c063_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_05 (conv_i_src_c063_3_05 0 conv_bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_3_05 (conv_i_src_c063_3_05 conv_i_c063_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_05 (conv_q_src_c063_3_05 0 conv_bpf_c063_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c063_3_05 (conv_q_src_c063_3_05 conv_q_c063_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_06 (conv_i_src_c063_3_06 0 conv_bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_3_06 (conv_i_src_c063_3_06 conv_i_c063_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_06 (conv_q_src_c063_3_06 0 conv_bpf_c063_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c063_3_06 (conv_q_src_c063_3_06 conv_q_c063_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_07 (conv_i_src_c063_3_07 0 conv_bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_3_07 (conv_i_src_c063_3_07 conv_i_c063_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_07 (conv_q_src_c063_3_07 0 conv_bpf_c063_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c063_3_07 (conv_q_src_c063_3_07 conv_q_c063_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_08 (conv_i_src_c063_3_08 0 conv_bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c063_3_08 (conv_i_src_c063_3_08 conv_i_c063_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_08 (conv_q_src_c063_3_08 0 conv_bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_3_08 (conv_q_src_c063_3_08 conv_q_c063_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_09 (conv_i_src_c063_3_09 0 conv_bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c063_3_09 (conv_i_src_c063_3_09 conv_i_c063_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_09 (conv_q_src_c063_3_09 0 conv_bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_3_09 (conv_q_src_c063_3_09 conv_q_c063_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_10 (conv_i_src_c063_3_10 0 conv_bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c063_3_10 (conv_i_src_c063_3_10 conv_i_c063_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_10 (conv_q_src_c063_3_10 0 conv_bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_3_10 (conv_q_src_c063_3_10 conv_q_c063_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_11 (conv_i_src_c063_3_11 0 conv_bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c063_3_11 (conv_i_src_c063_3_11 conv_i_c063_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_11 (conv_q_src_c063_3_11 0 conv_bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_3_11 (conv_q_src_c063_3_11 conv_q_c063_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_12 (conv_i_src_c063_3_12 0 conv_bpf_c063_3 0) vcvs gain=1.950903220161e-01
SCONVI_c063_3_12 (conv_i_src_c063_3_12 conv_i_c063_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_12 (conv_q_src_c063_3_12 0 conv_bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c063_3_12 (conv_q_src_c063_3_12 conv_q_c063_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_13 (conv_i_src_c063_3_13 0 conv_bpf_c063_3 0) vcvs gain=5.555702330196e-01
SCONVI_c063_3_13 (conv_i_src_c063_3_13 conv_i_c063_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_13 (conv_q_src_c063_3_13 0 conv_bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c063_3_13 (conv_q_src_c063_3_13 conv_q_c063_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_14 (conv_i_src_c063_3_14 0 conv_bpf_c063_3 0) vcvs gain=8.314696123025e-01
SCONVI_c063_3_14 (conv_i_src_c063_3_14 conv_i_c063_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_14 (conv_q_src_c063_3_14 0 conv_bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c063_3_14 (conv_q_src_c063_3_14 conv_q_c063_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c063_3_15 (conv_i_src_c063_3_15 0 conv_bpf_c063_3 0) vcvs gain=9.807852804032e-01
SCONVI_c063_3_15 (conv_i_src_c063_3_15 conv_i_c063_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c063_3_15 (conv_q_src_c063_3_15 0 conv_bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c063_3_15 (conv_q_src_c063_3_15 conv_q_c063_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c063_3 (conv_i_c063_3 0) resistor r=1G
RCONVQ_c063_3 (conv_q_c063_3 0) resistor r=1G
RCONVINTI_c063_3 (conv_i_c063_3 ConvIcar_c063_3) resistor r=1k
CCONVINTI_c063_3 (ConvIcar_c063_3 0) capacitor c=80p
RCONVINTQ_c063_3 (conv_q_c063_3 ConvQcar_c063_3) resistor r=1k
CCONVINTQ_c063_3 (ConvQcar_c063_3 0) capacitor c=80p
save conv_bpf_c063_3 ConvIcar_c063_3 ConvQcar_c063_3

// conventional mixed baseline bl064, carrier_0: 250000000 Hz
CCONVBPF_c064_0 (bl064 n_conv_cbpf_c064_0) capacitor c=4.052847345694e-13
LCONVBPF_c064_0 (n_conv_cbpf_c064_0 conv_bpf_c064_0) inductor l=1.000000000000e-06
RCONVBPF_c064_0 (conv_bpf_c064_0 0) resistor r=7.853981633974e+01
ECONVI_c064_0_00 (conv_i_src_c064_0_00 0 conv_bpf_c064_0 0) vcvs gain=9.807852804032e-01
SCONVI_c064_0_00 (conv_i_src_c064_0_00 conv_i_c064_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_00 (conv_q_src_c064_0_00 0 conv_bpf_c064_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_0_00 (conv_q_src_c064_0_00 conv_q_c064_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_01 (conv_i_src_c064_0_01 0 conv_bpf_c064_0 0) vcvs gain=8.314696123025e-01
SCONVI_c064_0_01 (conv_i_src_c064_0_01 conv_i_c064_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_01 (conv_q_src_c064_0_01 0 conv_bpf_c064_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_0_01 (conv_q_src_c064_0_01 conv_q_c064_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_02 (conv_i_src_c064_0_02 0 conv_bpf_c064_0 0) vcvs gain=5.555702330196e-01
SCONVI_c064_0_02 (conv_i_src_c064_0_02 conv_i_c064_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_02 (conv_q_src_c064_0_02 0 conv_bpf_c064_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_0_02 (conv_q_src_c064_0_02 conv_q_c064_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_03 (conv_i_src_c064_0_03 0 conv_bpf_c064_0 0) vcvs gain=1.950903220161e-01
SCONVI_c064_0_03 (conv_i_src_c064_0_03 conv_i_c064_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_03 (conv_q_src_c064_0_03 0 conv_bpf_c064_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_0_03 (conv_q_src_c064_0_03 conv_q_c064_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_04 (conv_i_src_c064_0_04 0 conv_bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_0_04 (conv_i_src_c064_0_04 conv_i_c064_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_04 (conv_q_src_c064_0_04 0 conv_bpf_c064_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_0_04 (conv_q_src_c064_0_04 conv_q_c064_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_05 (conv_i_src_c064_0_05 0 conv_bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_0_05 (conv_i_src_c064_0_05 conv_i_c064_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_05 (conv_q_src_c064_0_05 0 conv_bpf_c064_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_0_05 (conv_q_src_c064_0_05 conv_q_c064_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_06 (conv_i_src_c064_0_06 0 conv_bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_0_06 (conv_i_src_c064_0_06 conv_i_c064_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_06 (conv_q_src_c064_0_06 0 conv_bpf_c064_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_0_06 (conv_q_src_c064_0_06 conv_q_c064_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_07 (conv_i_src_c064_0_07 0 conv_bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_0_07 (conv_i_src_c064_0_07 conv_i_c064_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_07 (conv_q_src_c064_0_07 0 conv_bpf_c064_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_0_07 (conv_q_src_c064_0_07 conv_q_c064_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_08 (conv_i_src_c064_0_08 0 conv_bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_0_08 (conv_i_src_c064_0_08 conv_i_c064_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_08 (conv_q_src_c064_0_08 0 conv_bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_0_08 (conv_q_src_c064_0_08 conv_q_c064_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_09 (conv_i_src_c064_0_09 0 conv_bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_0_09 (conv_i_src_c064_0_09 conv_i_c064_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_09 (conv_q_src_c064_0_09 0 conv_bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_0_09 (conv_q_src_c064_0_09 conv_q_c064_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_10 (conv_i_src_c064_0_10 0 conv_bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_0_10 (conv_i_src_c064_0_10 conv_i_c064_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_10 (conv_q_src_c064_0_10 0 conv_bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_0_10 (conv_q_src_c064_0_10 conv_q_c064_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_11 (conv_i_src_c064_0_11 0 conv_bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_0_11 (conv_i_src_c064_0_11 conv_i_c064_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_11 (conv_q_src_c064_0_11 0 conv_bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_0_11 (conv_q_src_c064_0_11 conv_q_c064_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_12 (conv_i_src_c064_0_12 0 conv_bpf_c064_0 0) vcvs gain=1.950903220161e-01
SCONVI_c064_0_12 (conv_i_src_c064_0_12 conv_i_c064_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_12 (conv_q_src_c064_0_12 0 conv_bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_0_12 (conv_q_src_c064_0_12 conv_q_c064_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_13 (conv_i_src_c064_0_13 0 conv_bpf_c064_0 0) vcvs gain=5.555702330196e-01
SCONVI_c064_0_13 (conv_i_src_c064_0_13 conv_i_c064_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_13 (conv_q_src_c064_0_13 0 conv_bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_0_13 (conv_q_src_c064_0_13 conv_q_c064_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_14 (conv_i_src_c064_0_14 0 conv_bpf_c064_0 0) vcvs gain=8.314696123025e-01
SCONVI_c064_0_14 (conv_i_src_c064_0_14 conv_i_c064_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_14 (conv_q_src_c064_0_14 0 conv_bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_0_14 (conv_q_src_c064_0_14 conv_q_c064_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_0_15 (conv_i_src_c064_0_15 0 conv_bpf_c064_0 0) vcvs gain=9.807852804032e-01
SCONVI_c064_0_15 (conv_i_src_c064_0_15 conv_i_c064_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_0_15 (conv_q_src_c064_0_15 0 conv_bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_0_15 (conv_q_src_c064_0_15 conv_q_c064_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c064_0 (conv_i_c064_0 0) resistor r=1G
RCONVQ_c064_0 (conv_q_c064_0 0) resistor r=1G
RCONVINTI_c064_0 (conv_i_c064_0 ConvIcar_c064_0) resistor r=1k
CCONVINTI_c064_0 (ConvIcar_c064_0 0) capacitor c=80p
RCONVINTQ_c064_0 (conv_q_c064_0 ConvQcar_c064_0) resistor r=1k
CCONVINTQ_c064_0 (ConvQcar_c064_0 0) capacitor c=80p
save conv_bpf_c064_0 ConvIcar_c064_0 ConvQcar_c064_0

// conventional mixed baseline bl064, carrier_1: 500000000 Hz
CCONVBPF_c064_1 (bl064 n_conv_cbpf_c064_1) capacitor c=1.013211836423e-13
LCONVBPF_c064_1 (n_conv_cbpf_c064_1 conv_bpf_c064_1) inductor l=1.000000000000e-06
RCONVBPF_c064_1 (conv_bpf_c064_1 0) resistor r=1.570796326795e+02
ECONVI_c064_1_00 (conv_i_src_c064_1_00 0 conv_bpf_c064_1 0) vcvs gain=9.807852804032e-01
SCONVI_c064_1_00 (conv_i_src_c064_1_00 conv_i_c064_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_00 (conv_q_src_c064_1_00 0 conv_bpf_c064_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_1_00 (conv_q_src_c064_1_00 conv_q_c064_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_01 (conv_i_src_c064_1_01 0 conv_bpf_c064_1 0) vcvs gain=8.314696123025e-01
SCONVI_c064_1_01 (conv_i_src_c064_1_01 conv_i_c064_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_01 (conv_q_src_c064_1_01 0 conv_bpf_c064_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_1_01 (conv_q_src_c064_1_01 conv_q_c064_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_02 (conv_i_src_c064_1_02 0 conv_bpf_c064_1 0) vcvs gain=5.555702330196e-01
SCONVI_c064_1_02 (conv_i_src_c064_1_02 conv_i_c064_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_02 (conv_q_src_c064_1_02 0 conv_bpf_c064_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_1_02 (conv_q_src_c064_1_02 conv_q_c064_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_03 (conv_i_src_c064_1_03 0 conv_bpf_c064_1 0) vcvs gain=1.950903220161e-01
SCONVI_c064_1_03 (conv_i_src_c064_1_03 conv_i_c064_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_03 (conv_q_src_c064_1_03 0 conv_bpf_c064_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_1_03 (conv_q_src_c064_1_03 conv_q_c064_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_04 (conv_i_src_c064_1_04 0 conv_bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_1_04 (conv_i_src_c064_1_04 conv_i_c064_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_04 (conv_q_src_c064_1_04 0 conv_bpf_c064_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_1_04 (conv_q_src_c064_1_04 conv_q_c064_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_05 (conv_i_src_c064_1_05 0 conv_bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_1_05 (conv_i_src_c064_1_05 conv_i_c064_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_05 (conv_q_src_c064_1_05 0 conv_bpf_c064_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_1_05 (conv_q_src_c064_1_05 conv_q_c064_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_06 (conv_i_src_c064_1_06 0 conv_bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_1_06 (conv_i_src_c064_1_06 conv_i_c064_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_06 (conv_q_src_c064_1_06 0 conv_bpf_c064_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_1_06 (conv_q_src_c064_1_06 conv_q_c064_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_07 (conv_i_src_c064_1_07 0 conv_bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_1_07 (conv_i_src_c064_1_07 conv_i_c064_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_07 (conv_q_src_c064_1_07 0 conv_bpf_c064_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_1_07 (conv_q_src_c064_1_07 conv_q_c064_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_08 (conv_i_src_c064_1_08 0 conv_bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_1_08 (conv_i_src_c064_1_08 conv_i_c064_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_08 (conv_q_src_c064_1_08 0 conv_bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_1_08 (conv_q_src_c064_1_08 conv_q_c064_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_09 (conv_i_src_c064_1_09 0 conv_bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_1_09 (conv_i_src_c064_1_09 conv_i_c064_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_09 (conv_q_src_c064_1_09 0 conv_bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_1_09 (conv_q_src_c064_1_09 conv_q_c064_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_10 (conv_i_src_c064_1_10 0 conv_bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_1_10 (conv_i_src_c064_1_10 conv_i_c064_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_10 (conv_q_src_c064_1_10 0 conv_bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_1_10 (conv_q_src_c064_1_10 conv_q_c064_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_11 (conv_i_src_c064_1_11 0 conv_bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_1_11 (conv_i_src_c064_1_11 conv_i_c064_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_11 (conv_q_src_c064_1_11 0 conv_bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_1_11 (conv_q_src_c064_1_11 conv_q_c064_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_12 (conv_i_src_c064_1_12 0 conv_bpf_c064_1 0) vcvs gain=1.950903220161e-01
SCONVI_c064_1_12 (conv_i_src_c064_1_12 conv_i_c064_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_12 (conv_q_src_c064_1_12 0 conv_bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_1_12 (conv_q_src_c064_1_12 conv_q_c064_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_13 (conv_i_src_c064_1_13 0 conv_bpf_c064_1 0) vcvs gain=5.555702330196e-01
SCONVI_c064_1_13 (conv_i_src_c064_1_13 conv_i_c064_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_13 (conv_q_src_c064_1_13 0 conv_bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_1_13 (conv_q_src_c064_1_13 conv_q_c064_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_14 (conv_i_src_c064_1_14 0 conv_bpf_c064_1 0) vcvs gain=8.314696123025e-01
SCONVI_c064_1_14 (conv_i_src_c064_1_14 conv_i_c064_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_14 (conv_q_src_c064_1_14 0 conv_bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_1_14 (conv_q_src_c064_1_14 conv_q_c064_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_1_15 (conv_i_src_c064_1_15 0 conv_bpf_c064_1 0) vcvs gain=9.807852804032e-01
SCONVI_c064_1_15 (conv_i_src_c064_1_15 conv_i_c064_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_1_15 (conv_q_src_c064_1_15 0 conv_bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_1_15 (conv_q_src_c064_1_15 conv_q_c064_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c064_1 (conv_i_c064_1 0) resistor r=1G
RCONVQ_c064_1 (conv_q_c064_1 0) resistor r=1G
RCONVINTI_c064_1 (conv_i_c064_1 ConvIcar_c064_1) resistor r=1k
CCONVINTI_c064_1 (ConvIcar_c064_1 0) capacitor c=80p
RCONVINTQ_c064_1 (conv_q_c064_1 ConvQcar_c064_1) resistor r=1k
CCONVINTQ_c064_1 (ConvQcar_c064_1 0) capacitor c=80p
save conv_bpf_c064_1 ConvIcar_c064_1 ConvQcar_c064_1

// conventional mixed baseline bl064, carrier_2: 750000000 Hz
CCONVBPF_c064_2 (bl064 n_conv_cbpf_c064_2) capacitor c=4.503163717437e-14
LCONVBPF_c064_2 (n_conv_cbpf_c064_2 conv_bpf_c064_2) inductor l=1.000000000000e-06
RCONVBPF_c064_2 (conv_bpf_c064_2 0) resistor r=2.356194490192e+02
ECONVI_c064_2_00 (conv_i_src_c064_2_00 0 conv_bpf_c064_2 0) vcvs gain=9.807852804032e-01
SCONVI_c064_2_00 (conv_i_src_c064_2_00 conv_i_c064_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_00 (conv_q_src_c064_2_00 0 conv_bpf_c064_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_2_00 (conv_q_src_c064_2_00 conv_q_c064_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_01 (conv_i_src_c064_2_01 0 conv_bpf_c064_2 0) vcvs gain=8.314696123025e-01
SCONVI_c064_2_01 (conv_i_src_c064_2_01 conv_i_c064_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_01 (conv_q_src_c064_2_01 0 conv_bpf_c064_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_2_01 (conv_q_src_c064_2_01 conv_q_c064_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_02 (conv_i_src_c064_2_02 0 conv_bpf_c064_2 0) vcvs gain=5.555702330196e-01
SCONVI_c064_2_02 (conv_i_src_c064_2_02 conv_i_c064_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_02 (conv_q_src_c064_2_02 0 conv_bpf_c064_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_2_02 (conv_q_src_c064_2_02 conv_q_c064_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_03 (conv_i_src_c064_2_03 0 conv_bpf_c064_2 0) vcvs gain=1.950903220161e-01
SCONVI_c064_2_03 (conv_i_src_c064_2_03 conv_i_c064_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_03 (conv_q_src_c064_2_03 0 conv_bpf_c064_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_2_03 (conv_q_src_c064_2_03 conv_q_c064_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_04 (conv_i_src_c064_2_04 0 conv_bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_2_04 (conv_i_src_c064_2_04 conv_i_c064_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_04 (conv_q_src_c064_2_04 0 conv_bpf_c064_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_2_04 (conv_q_src_c064_2_04 conv_q_c064_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_05 (conv_i_src_c064_2_05 0 conv_bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_2_05 (conv_i_src_c064_2_05 conv_i_c064_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_05 (conv_q_src_c064_2_05 0 conv_bpf_c064_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_2_05 (conv_q_src_c064_2_05 conv_q_c064_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_06 (conv_i_src_c064_2_06 0 conv_bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_2_06 (conv_i_src_c064_2_06 conv_i_c064_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_06 (conv_q_src_c064_2_06 0 conv_bpf_c064_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_2_06 (conv_q_src_c064_2_06 conv_q_c064_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_07 (conv_i_src_c064_2_07 0 conv_bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_2_07 (conv_i_src_c064_2_07 conv_i_c064_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_07 (conv_q_src_c064_2_07 0 conv_bpf_c064_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_2_07 (conv_q_src_c064_2_07 conv_q_c064_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_08 (conv_i_src_c064_2_08 0 conv_bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_2_08 (conv_i_src_c064_2_08 conv_i_c064_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_08 (conv_q_src_c064_2_08 0 conv_bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_2_08 (conv_q_src_c064_2_08 conv_q_c064_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_09 (conv_i_src_c064_2_09 0 conv_bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_2_09 (conv_i_src_c064_2_09 conv_i_c064_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_09 (conv_q_src_c064_2_09 0 conv_bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_2_09 (conv_q_src_c064_2_09 conv_q_c064_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_10 (conv_i_src_c064_2_10 0 conv_bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_2_10 (conv_i_src_c064_2_10 conv_i_c064_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_10 (conv_q_src_c064_2_10 0 conv_bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_2_10 (conv_q_src_c064_2_10 conv_q_c064_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_11 (conv_i_src_c064_2_11 0 conv_bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_2_11 (conv_i_src_c064_2_11 conv_i_c064_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_11 (conv_q_src_c064_2_11 0 conv_bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_2_11 (conv_q_src_c064_2_11 conv_q_c064_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_12 (conv_i_src_c064_2_12 0 conv_bpf_c064_2 0) vcvs gain=1.950903220161e-01
SCONVI_c064_2_12 (conv_i_src_c064_2_12 conv_i_c064_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_12 (conv_q_src_c064_2_12 0 conv_bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_2_12 (conv_q_src_c064_2_12 conv_q_c064_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_13 (conv_i_src_c064_2_13 0 conv_bpf_c064_2 0) vcvs gain=5.555702330196e-01
SCONVI_c064_2_13 (conv_i_src_c064_2_13 conv_i_c064_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_13 (conv_q_src_c064_2_13 0 conv_bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_2_13 (conv_q_src_c064_2_13 conv_q_c064_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_14 (conv_i_src_c064_2_14 0 conv_bpf_c064_2 0) vcvs gain=8.314696123025e-01
SCONVI_c064_2_14 (conv_i_src_c064_2_14 conv_i_c064_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_14 (conv_q_src_c064_2_14 0 conv_bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_2_14 (conv_q_src_c064_2_14 conv_q_c064_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_2_15 (conv_i_src_c064_2_15 0 conv_bpf_c064_2 0) vcvs gain=9.807852804032e-01
SCONVI_c064_2_15 (conv_i_src_c064_2_15 conv_i_c064_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_2_15 (conv_q_src_c064_2_15 0 conv_bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_2_15 (conv_q_src_c064_2_15 conv_q_c064_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c064_2 (conv_i_c064_2 0) resistor r=1G
RCONVQ_c064_2 (conv_q_c064_2 0) resistor r=1G
RCONVINTI_c064_2 (conv_i_c064_2 ConvIcar_c064_2) resistor r=1k
CCONVINTI_c064_2 (ConvIcar_c064_2 0) capacitor c=80p
RCONVINTQ_c064_2 (conv_q_c064_2 ConvQcar_c064_2) resistor r=1k
CCONVINTQ_c064_2 (ConvQcar_c064_2 0) capacitor c=80p
save conv_bpf_c064_2 ConvIcar_c064_2 ConvQcar_c064_2

// conventional mixed baseline bl064, carrier_3: 1000000000 Hz
CCONVBPF_c064_3 (bl064 n_conv_cbpf_c064_3) capacitor c=2.533029591058e-14
LCONVBPF_c064_3 (n_conv_cbpf_c064_3 conv_bpf_c064_3) inductor l=1.000000000000e-06
RCONVBPF_c064_3 (conv_bpf_c064_3 0) resistor r=3.141592653590e+02
ECONVI_c064_3_00 (conv_i_src_c064_3_00 0 conv_bpf_c064_3 0) vcvs gain=9.807852804032e-01
SCONVI_c064_3_00 (conv_i_src_c064_3_00 conv_i_c064_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_00 (conv_q_src_c064_3_00 0 conv_bpf_c064_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_3_00 (conv_q_src_c064_3_00 conv_q_c064_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_01 (conv_i_src_c064_3_01 0 conv_bpf_c064_3 0) vcvs gain=8.314696123025e-01
SCONVI_c064_3_01 (conv_i_src_c064_3_01 conv_i_c064_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_01 (conv_q_src_c064_3_01 0 conv_bpf_c064_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_3_01 (conv_q_src_c064_3_01 conv_q_c064_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_02 (conv_i_src_c064_3_02 0 conv_bpf_c064_3 0) vcvs gain=5.555702330196e-01
SCONVI_c064_3_02 (conv_i_src_c064_3_02 conv_i_c064_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_02 (conv_q_src_c064_3_02 0 conv_bpf_c064_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_3_02 (conv_q_src_c064_3_02 conv_q_c064_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_03 (conv_i_src_c064_3_03 0 conv_bpf_c064_3 0) vcvs gain=1.950903220161e-01
SCONVI_c064_3_03 (conv_i_src_c064_3_03 conv_i_c064_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_03 (conv_q_src_c064_3_03 0 conv_bpf_c064_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_3_03 (conv_q_src_c064_3_03 conv_q_c064_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_04 (conv_i_src_c064_3_04 0 conv_bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_3_04 (conv_i_src_c064_3_04 conv_i_c064_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_04 (conv_q_src_c064_3_04 0 conv_bpf_c064_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c064_3_04 (conv_q_src_c064_3_04 conv_q_c064_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_05 (conv_i_src_c064_3_05 0 conv_bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_3_05 (conv_i_src_c064_3_05 conv_i_c064_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_05 (conv_q_src_c064_3_05 0 conv_bpf_c064_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c064_3_05 (conv_q_src_c064_3_05 conv_q_c064_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_06 (conv_i_src_c064_3_06 0 conv_bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_3_06 (conv_i_src_c064_3_06 conv_i_c064_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_06 (conv_q_src_c064_3_06 0 conv_bpf_c064_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c064_3_06 (conv_q_src_c064_3_06 conv_q_c064_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_07 (conv_i_src_c064_3_07 0 conv_bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_3_07 (conv_i_src_c064_3_07 conv_i_c064_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_07 (conv_q_src_c064_3_07 0 conv_bpf_c064_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c064_3_07 (conv_q_src_c064_3_07 conv_q_c064_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_08 (conv_i_src_c064_3_08 0 conv_bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c064_3_08 (conv_i_src_c064_3_08 conv_i_c064_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_08 (conv_q_src_c064_3_08 0 conv_bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_3_08 (conv_q_src_c064_3_08 conv_q_c064_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_09 (conv_i_src_c064_3_09 0 conv_bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c064_3_09 (conv_i_src_c064_3_09 conv_i_c064_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_09 (conv_q_src_c064_3_09 0 conv_bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_3_09 (conv_q_src_c064_3_09 conv_q_c064_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_10 (conv_i_src_c064_3_10 0 conv_bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c064_3_10 (conv_i_src_c064_3_10 conv_i_c064_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_10 (conv_q_src_c064_3_10 0 conv_bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_3_10 (conv_q_src_c064_3_10 conv_q_c064_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_11 (conv_i_src_c064_3_11 0 conv_bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c064_3_11 (conv_i_src_c064_3_11 conv_i_c064_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_11 (conv_q_src_c064_3_11 0 conv_bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_3_11 (conv_q_src_c064_3_11 conv_q_c064_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_12 (conv_i_src_c064_3_12 0 conv_bpf_c064_3 0) vcvs gain=1.950903220161e-01
SCONVI_c064_3_12 (conv_i_src_c064_3_12 conv_i_c064_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_12 (conv_q_src_c064_3_12 0 conv_bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c064_3_12 (conv_q_src_c064_3_12 conv_q_c064_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_13 (conv_i_src_c064_3_13 0 conv_bpf_c064_3 0) vcvs gain=5.555702330196e-01
SCONVI_c064_3_13 (conv_i_src_c064_3_13 conv_i_c064_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_13 (conv_q_src_c064_3_13 0 conv_bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c064_3_13 (conv_q_src_c064_3_13 conv_q_c064_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_14 (conv_i_src_c064_3_14 0 conv_bpf_c064_3 0) vcvs gain=8.314696123025e-01
SCONVI_c064_3_14 (conv_i_src_c064_3_14 conv_i_c064_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_14 (conv_q_src_c064_3_14 0 conv_bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c064_3_14 (conv_q_src_c064_3_14 conv_q_c064_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c064_3_15 (conv_i_src_c064_3_15 0 conv_bpf_c064_3 0) vcvs gain=9.807852804032e-01
SCONVI_c064_3_15 (conv_i_src_c064_3_15 conv_i_c064_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c064_3_15 (conv_q_src_c064_3_15 0 conv_bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c064_3_15 (conv_q_src_c064_3_15 conv_q_c064_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c064_3 (conv_i_c064_3 0) resistor r=1G
RCONVQ_c064_3 (conv_q_c064_3 0) resistor r=1G
RCONVINTI_c064_3 (conv_i_c064_3 ConvIcar_c064_3) resistor r=1k
CCONVINTI_c064_3 (ConvIcar_c064_3 0) capacitor c=80p
RCONVINTQ_c064_3 (conv_q_c064_3 ConvQcar_c064_3) resistor r=1k
CCONVINTQ_c064_3 (ConvQcar_c064_3 0) capacitor c=80p
save conv_bpf_c064_3 ConvIcar_c064_3 ConvQcar_c064_3

// conventional mixed baseline bl065, carrier_0: 250000000 Hz
CCONVBPF_c065_0 (bl065 n_conv_cbpf_c065_0) capacitor c=4.052847345694e-13
LCONVBPF_c065_0 (n_conv_cbpf_c065_0 conv_bpf_c065_0) inductor l=1.000000000000e-06
RCONVBPF_c065_0 (conv_bpf_c065_0 0) resistor r=7.853981633974e+01
ECONVI_c065_0_00 (conv_i_src_c065_0_00 0 conv_bpf_c065_0 0) vcvs gain=9.807852804032e-01
SCONVI_c065_0_00 (conv_i_src_c065_0_00 conv_i_c065_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_00 (conv_q_src_c065_0_00 0 conv_bpf_c065_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_0_00 (conv_q_src_c065_0_00 conv_q_c065_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_01 (conv_i_src_c065_0_01 0 conv_bpf_c065_0 0) vcvs gain=8.314696123025e-01
SCONVI_c065_0_01 (conv_i_src_c065_0_01 conv_i_c065_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_01 (conv_q_src_c065_0_01 0 conv_bpf_c065_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_0_01 (conv_q_src_c065_0_01 conv_q_c065_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_02 (conv_i_src_c065_0_02 0 conv_bpf_c065_0 0) vcvs gain=5.555702330196e-01
SCONVI_c065_0_02 (conv_i_src_c065_0_02 conv_i_c065_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_02 (conv_q_src_c065_0_02 0 conv_bpf_c065_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_0_02 (conv_q_src_c065_0_02 conv_q_c065_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_03 (conv_i_src_c065_0_03 0 conv_bpf_c065_0 0) vcvs gain=1.950903220161e-01
SCONVI_c065_0_03 (conv_i_src_c065_0_03 conv_i_c065_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_03 (conv_q_src_c065_0_03 0 conv_bpf_c065_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_0_03 (conv_q_src_c065_0_03 conv_q_c065_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_04 (conv_i_src_c065_0_04 0 conv_bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_0_04 (conv_i_src_c065_0_04 conv_i_c065_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_04 (conv_q_src_c065_0_04 0 conv_bpf_c065_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_0_04 (conv_q_src_c065_0_04 conv_q_c065_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_05 (conv_i_src_c065_0_05 0 conv_bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_0_05 (conv_i_src_c065_0_05 conv_i_c065_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_05 (conv_q_src_c065_0_05 0 conv_bpf_c065_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_0_05 (conv_q_src_c065_0_05 conv_q_c065_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_06 (conv_i_src_c065_0_06 0 conv_bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_0_06 (conv_i_src_c065_0_06 conv_i_c065_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_06 (conv_q_src_c065_0_06 0 conv_bpf_c065_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_0_06 (conv_q_src_c065_0_06 conv_q_c065_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_07 (conv_i_src_c065_0_07 0 conv_bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_0_07 (conv_i_src_c065_0_07 conv_i_c065_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_07 (conv_q_src_c065_0_07 0 conv_bpf_c065_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_0_07 (conv_q_src_c065_0_07 conv_q_c065_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_08 (conv_i_src_c065_0_08 0 conv_bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_0_08 (conv_i_src_c065_0_08 conv_i_c065_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_08 (conv_q_src_c065_0_08 0 conv_bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c065_0_08 (conv_q_src_c065_0_08 conv_q_c065_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_09 (conv_i_src_c065_0_09 0 conv_bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_0_09 (conv_i_src_c065_0_09 conv_i_c065_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_09 (conv_q_src_c065_0_09 0 conv_bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_0_09 (conv_q_src_c065_0_09 conv_q_c065_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_10 (conv_i_src_c065_0_10 0 conv_bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_0_10 (conv_i_src_c065_0_10 conv_i_c065_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_10 (conv_q_src_c065_0_10 0 conv_bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_0_10 (conv_q_src_c065_0_10 conv_q_c065_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_11 (conv_i_src_c065_0_11 0 conv_bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_0_11 (conv_i_src_c065_0_11 conv_i_c065_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_11 (conv_q_src_c065_0_11 0 conv_bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_0_11 (conv_q_src_c065_0_11 conv_q_c065_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_12 (conv_i_src_c065_0_12 0 conv_bpf_c065_0 0) vcvs gain=1.950903220161e-01
SCONVI_c065_0_12 (conv_i_src_c065_0_12 conv_i_c065_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_12 (conv_q_src_c065_0_12 0 conv_bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_0_12 (conv_q_src_c065_0_12 conv_q_c065_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_13 (conv_i_src_c065_0_13 0 conv_bpf_c065_0 0) vcvs gain=5.555702330196e-01
SCONVI_c065_0_13 (conv_i_src_c065_0_13 conv_i_c065_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_13 (conv_q_src_c065_0_13 0 conv_bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_0_13 (conv_q_src_c065_0_13 conv_q_c065_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_14 (conv_i_src_c065_0_14 0 conv_bpf_c065_0 0) vcvs gain=8.314696123025e-01
SCONVI_c065_0_14 (conv_i_src_c065_0_14 conv_i_c065_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_14 (conv_q_src_c065_0_14 0 conv_bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_0_14 (conv_q_src_c065_0_14 conv_q_c065_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_0_15 (conv_i_src_c065_0_15 0 conv_bpf_c065_0 0) vcvs gain=9.807852804032e-01
SCONVI_c065_0_15 (conv_i_src_c065_0_15 conv_i_c065_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_0_15 (conv_q_src_c065_0_15 0 conv_bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c065_0_15 (conv_q_src_c065_0_15 conv_q_c065_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c065_0 (conv_i_c065_0 0) resistor r=1G
RCONVQ_c065_0 (conv_q_c065_0 0) resistor r=1G
RCONVINTI_c065_0 (conv_i_c065_0 ConvIcar_c065_0) resistor r=1k
CCONVINTI_c065_0 (ConvIcar_c065_0 0) capacitor c=80p
RCONVINTQ_c065_0 (conv_q_c065_0 ConvQcar_c065_0) resistor r=1k
CCONVINTQ_c065_0 (ConvQcar_c065_0 0) capacitor c=80p
save conv_bpf_c065_0 ConvIcar_c065_0 ConvQcar_c065_0

// conventional mixed baseline bl065, carrier_1: 500000000 Hz
CCONVBPF_c065_1 (bl065 n_conv_cbpf_c065_1) capacitor c=1.013211836423e-13
LCONVBPF_c065_1 (n_conv_cbpf_c065_1 conv_bpf_c065_1) inductor l=1.000000000000e-06
RCONVBPF_c065_1 (conv_bpf_c065_1 0) resistor r=1.570796326795e+02
ECONVI_c065_1_00 (conv_i_src_c065_1_00 0 conv_bpf_c065_1 0) vcvs gain=9.807852804032e-01
SCONVI_c065_1_00 (conv_i_src_c065_1_00 conv_i_c065_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_00 (conv_q_src_c065_1_00 0 conv_bpf_c065_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_1_00 (conv_q_src_c065_1_00 conv_q_c065_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_01 (conv_i_src_c065_1_01 0 conv_bpf_c065_1 0) vcvs gain=8.314696123025e-01
SCONVI_c065_1_01 (conv_i_src_c065_1_01 conv_i_c065_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_01 (conv_q_src_c065_1_01 0 conv_bpf_c065_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_1_01 (conv_q_src_c065_1_01 conv_q_c065_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_02 (conv_i_src_c065_1_02 0 conv_bpf_c065_1 0) vcvs gain=5.555702330196e-01
SCONVI_c065_1_02 (conv_i_src_c065_1_02 conv_i_c065_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_02 (conv_q_src_c065_1_02 0 conv_bpf_c065_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_1_02 (conv_q_src_c065_1_02 conv_q_c065_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_03 (conv_i_src_c065_1_03 0 conv_bpf_c065_1 0) vcvs gain=1.950903220161e-01
SCONVI_c065_1_03 (conv_i_src_c065_1_03 conv_i_c065_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_03 (conv_q_src_c065_1_03 0 conv_bpf_c065_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_1_03 (conv_q_src_c065_1_03 conv_q_c065_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_04 (conv_i_src_c065_1_04 0 conv_bpf_c065_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_1_04 (conv_i_src_c065_1_04 conv_i_c065_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_04 (conv_q_src_c065_1_04 0 conv_bpf_c065_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_1_04 (conv_q_src_c065_1_04 conv_q_c065_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_05 (conv_i_src_c065_1_05 0 conv_bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_1_05 (conv_i_src_c065_1_05 conv_i_c065_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_05 (conv_q_src_c065_1_05 0 conv_bpf_c065_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_1_05 (conv_q_src_c065_1_05 conv_q_c065_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_06 (conv_i_src_c065_1_06 0 conv_bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_1_06 (conv_i_src_c065_1_06 conv_i_c065_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_06 (conv_q_src_c065_1_06 0 conv_bpf_c065_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_1_06 (conv_q_src_c065_1_06 conv_q_c065_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_07 (conv_i_src_c065_1_07 0 conv_bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_1_07 (conv_i_src_c065_1_07 conv_i_c065_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_07 (conv_q_src_c065_1_07 0 conv_bpf_c065_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_1_07 (conv_q_src_c065_1_07 conv_q_c065_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_08 (conv_i_src_c065_1_08 0 conv_bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_1_08 (conv_i_src_c065_1_08 conv_i_c065_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_08 (conv_q_src_c065_1_08 0 conv_bpf_c065_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c065_1_08 (conv_q_src_c065_1_08 conv_q_c065_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_09 (conv_i_src_c065_1_09 0 conv_bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_1_09 (conv_i_src_c065_1_09 conv_i_c065_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_09 (conv_q_src_c065_1_09 0 conv_bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_1_09 (conv_q_src_c065_1_09 conv_q_c065_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_10 (conv_i_src_c065_1_10 0 conv_bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_1_10 (conv_i_src_c065_1_10 conv_i_c065_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_10 (conv_q_src_c065_1_10 0 conv_bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_1_10 (conv_q_src_c065_1_10 conv_q_c065_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_11 (conv_i_src_c065_1_11 0 conv_bpf_c065_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_1_11 (conv_i_src_c065_1_11 conv_i_c065_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_11 (conv_q_src_c065_1_11 0 conv_bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_1_11 (conv_q_src_c065_1_11 conv_q_c065_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_12 (conv_i_src_c065_1_12 0 conv_bpf_c065_1 0) vcvs gain=1.950903220161e-01
SCONVI_c065_1_12 (conv_i_src_c065_1_12 conv_i_c065_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_12 (conv_q_src_c065_1_12 0 conv_bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_1_12 (conv_q_src_c065_1_12 conv_q_c065_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_13 (conv_i_src_c065_1_13 0 conv_bpf_c065_1 0) vcvs gain=5.555702330196e-01
SCONVI_c065_1_13 (conv_i_src_c065_1_13 conv_i_c065_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_13 (conv_q_src_c065_1_13 0 conv_bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_1_13 (conv_q_src_c065_1_13 conv_q_c065_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_14 (conv_i_src_c065_1_14 0 conv_bpf_c065_1 0) vcvs gain=8.314696123025e-01
SCONVI_c065_1_14 (conv_i_src_c065_1_14 conv_i_c065_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_14 (conv_q_src_c065_1_14 0 conv_bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_1_14 (conv_q_src_c065_1_14 conv_q_c065_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_1_15 (conv_i_src_c065_1_15 0 conv_bpf_c065_1 0) vcvs gain=9.807852804032e-01
SCONVI_c065_1_15 (conv_i_src_c065_1_15 conv_i_c065_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_1_15 (conv_q_src_c065_1_15 0 conv_bpf_c065_1 0) vcvs gain=-1.950903220161e-01
