SCONVI_c118_0_11 (conv_i_src_c118_0_11 conv_i_c118_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_11 (conv_q_src_c118_0_11 0 conv_bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_0_11 (conv_q_src_c118_0_11 conv_q_c118_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_12 (conv_i_src_c118_0_12 0 conv_bpf_c118_0 0) vcvs gain=1.950903220161e-01
SCONVI_c118_0_12 (conv_i_src_c118_0_12 conv_i_c118_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_12 (conv_q_src_c118_0_12 0 conv_bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_0_12 (conv_q_src_c118_0_12 conv_q_c118_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_13 (conv_i_src_c118_0_13 0 conv_bpf_c118_0 0) vcvs gain=5.555702330196e-01
SCONVI_c118_0_13 (conv_i_src_c118_0_13 conv_i_c118_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_13 (conv_q_src_c118_0_13 0 conv_bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_0_13 (conv_q_src_c118_0_13 conv_q_c118_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_14 (conv_i_src_c118_0_14 0 conv_bpf_c118_0 0) vcvs gain=8.314696123025e-01
SCONVI_c118_0_14 (conv_i_src_c118_0_14 conv_i_c118_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_14 (conv_q_src_c118_0_14 0 conv_bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_0_14 (conv_q_src_c118_0_14 conv_q_c118_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_0_15 (conv_i_src_c118_0_15 0 conv_bpf_c118_0 0) vcvs gain=9.807852804032e-01
SCONVI_c118_0_15 (conv_i_src_c118_0_15 conv_i_c118_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_0_15 (conv_q_src_c118_0_15 0 conv_bpf_c118_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_0_15 (conv_q_src_c118_0_15 conv_q_c118_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c118_0 (conv_i_c118_0 0) resistor r=1G
RCONVQ_c118_0 (conv_q_c118_0 0) resistor r=1G
RCONVINTI_c118_0 (conv_i_c118_0 ConvIcar_c118_0) resistor r=1k
CCONVINTI_c118_0 (ConvIcar_c118_0 0) capacitor c=80p
RCONVINTQ_c118_0 (conv_q_c118_0 ConvQcar_c118_0) resistor r=1k
CCONVINTQ_c118_0 (ConvQcar_c118_0 0) capacitor c=80p
save conv_bpf_c118_0 ConvIcar_c118_0 ConvQcar_c118_0

// conventional mixed baseline bl118, carrier_1: 500000000 Hz
CCONVBPF_c118_1 (bl118 n_conv_cbpf_c118_1) capacitor c=1.013211836423e-13
LCONVBPF_c118_1 (n_conv_cbpf_c118_1 conv_bpf_c118_1) inductor l=1.000000000000e-06
RCONVBPF_c118_1 (conv_bpf_c118_1 0) resistor r=1.570796326795e+02
ECONVI_c118_1_00 (conv_i_src_c118_1_00 0 conv_bpf_c118_1 0) vcvs gain=9.807852804032e-01
SCONVI_c118_1_00 (conv_i_src_c118_1_00 conv_i_c118_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_00 (conv_q_src_c118_1_00 0 conv_bpf_c118_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_1_00 (conv_q_src_c118_1_00 conv_q_c118_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_01 (conv_i_src_c118_1_01 0 conv_bpf_c118_1 0) vcvs gain=8.314696123025e-01
SCONVI_c118_1_01 (conv_i_src_c118_1_01 conv_i_c118_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_01 (conv_q_src_c118_1_01 0 conv_bpf_c118_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_1_01 (conv_q_src_c118_1_01 conv_q_c118_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_02 (conv_i_src_c118_1_02 0 conv_bpf_c118_1 0) vcvs gain=5.555702330196e-01
SCONVI_c118_1_02 (conv_i_src_c118_1_02 conv_i_c118_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_02 (conv_q_src_c118_1_02 0 conv_bpf_c118_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_1_02 (conv_q_src_c118_1_02 conv_q_c118_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_03 (conv_i_src_c118_1_03 0 conv_bpf_c118_1 0) vcvs gain=1.950903220161e-01
SCONVI_c118_1_03 (conv_i_src_c118_1_03 conv_i_c118_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_03 (conv_q_src_c118_1_03 0 conv_bpf_c118_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_1_03 (conv_q_src_c118_1_03 conv_q_c118_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_04 (conv_i_src_c118_1_04 0 conv_bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c118_1_04 (conv_i_src_c118_1_04 conv_i_c118_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_04 (conv_q_src_c118_1_04 0 conv_bpf_c118_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_1_04 (conv_q_src_c118_1_04 conv_q_c118_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_05 (conv_i_src_c118_1_05 0 conv_bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_1_05 (conv_i_src_c118_1_05 conv_i_c118_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_05 (conv_q_src_c118_1_05 0 conv_bpf_c118_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_1_05 (conv_q_src_c118_1_05 conv_q_c118_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_06 (conv_i_src_c118_1_06 0 conv_bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_1_06 (conv_i_src_c118_1_06 conv_i_c118_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_06 (conv_q_src_c118_1_06 0 conv_bpf_c118_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_1_06 (conv_q_src_c118_1_06 conv_q_c118_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_07 (conv_i_src_c118_1_07 0 conv_bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_1_07 (conv_i_src_c118_1_07 conv_i_c118_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_07 (conv_q_src_c118_1_07 0 conv_bpf_c118_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_1_07 (conv_q_src_c118_1_07 conv_q_c118_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_08 (conv_i_src_c118_1_08 0 conv_bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_1_08 (conv_i_src_c118_1_08 conv_i_c118_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_08 (conv_q_src_c118_1_08 0 conv_bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_1_08 (conv_q_src_c118_1_08 conv_q_c118_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_09 (conv_i_src_c118_1_09 0 conv_bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_1_09 (conv_i_src_c118_1_09 conv_i_c118_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_09 (conv_q_src_c118_1_09 0 conv_bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_1_09 (conv_q_src_c118_1_09 conv_q_c118_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_10 (conv_i_src_c118_1_10 0 conv_bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_1_10 (conv_i_src_c118_1_10 conv_i_c118_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_10 (conv_q_src_c118_1_10 0 conv_bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_1_10 (conv_q_src_c118_1_10 conv_q_c118_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_11 (conv_i_src_c118_1_11 0 conv_bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c118_1_11 (conv_i_src_c118_1_11 conv_i_c118_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_11 (conv_q_src_c118_1_11 0 conv_bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_1_11 (conv_q_src_c118_1_11 conv_q_c118_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_12 (conv_i_src_c118_1_12 0 conv_bpf_c118_1 0) vcvs gain=1.950903220161e-01
SCONVI_c118_1_12 (conv_i_src_c118_1_12 conv_i_c118_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_12 (conv_q_src_c118_1_12 0 conv_bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_1_12 (conv_q_src_c118_1_12 conv_q_c118_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_13 (conv_i_src_c118_1_13 0 conv_bpf_c118_1 0) vcvs gain=5.555702330196e-01
SCONVI_c118_1_13 (conv_i_src_c118_1_13 conv_i_c118_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_13 (conv_q_src_c118_1_13 0 conv_bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_1_13 (conv_q_src_c118_1_13 conv_q_c118_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_14 (conv_i_src_c118_1_14 0 conv_bpf_c118_1 0) vcvs gain=8.314696123025e-01
SCONVI_c118_1_14 (conv_i_src_c118_1_14 conv_i_c118_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_14 (conv_q_src_c118_1_14 0 conv_bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_1_14 (conv_q_src_c118_1_14 conv_q_c118_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_1_15 (conv_i_src_c118_1_15 0 conv_bpf_c118_1 0) vcvs gain=9.807852804032e-01
SCONVI_c118_1_15 (conv_i_src_c118_1_15 conv_i_c118_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_1_15 (conv_q_src_c118_1_15 0 conv_bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_1_15 (conv_q_src_c118_1_15 conv_q_c118_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c118_1 (conv_i_c118_1 0) resistor r=1G
RCONVQ_c118_1 (conv_q_c118_1 0) resistor r=1G
RCONVINTI_c118_1 (conv_i_c118_1 ConvIcar_c118_1) resistor r=1k
CCONVINTI_c118_1 (ConvIcar_c118_1 0) capacitor c=80p
RCONVINTQ_c118_1 (conv_q_c118_1 ConvQcar_c118_1) resistor r=1k
CCONVINTQ_c118_1 (ConvQcar_c118_1 0) capacitor c=80p
save conv_bpf_c118_1 ConvIcar_c118_1 ConvQcar_c118_1

// conventional mixed baseline bl118, carrier_2: 750000000 Hz
CCONVBPF_c118_2 (bl118 n_conv_cbpf_c118_2) capacitor c=4.503163717437e-14
LCONVBPF_c118_2 (n_conv_cbpf_c118_2 conv_bpf_c118_2) inductor l=1.000000000000e-06
RCONVBPF_c118_2 (conv_bpf_c118_2 0) resistor r=2.356194490192e+02
ECONVI_c118_2_00 (conv_i_src_c118_2_00 0 conv_bpf_c118_2 0) vcvs gain=9.807852804032e-01
SCONVI_c118_2_00 (conv_i_src_c118_2_00 conv_i_c118_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_00 (conv_q_src_c118_2_00 0 conv_bpf_c118_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_2_00 (conv_q_src_c118_2_00 conv_q_c118_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_01 (conv_i_src_c118_2_01 0 conv_bpf_c118_2 0) vcvs gain=8.314696123025e-01
SCONVI_c118_2_01 (conv_i_src_c118_2_01 conv_i_c118_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_01 (conv_q_src_c118_2_01 0 conv_bpf_c118_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_2_01 (conv_q_src_c118_2_01 conv_q_c118_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_02 (conv_i_src_c118_2_02 0 conv_bpf_c118_2 0) vcvs gain=5.555702330196e-01
SCONVI_c118_2_02 (conv_i_src_c118_2_02 conv_i_c118_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_02 (conv_q_src_c118_2_02 0 conv_bpf_c118_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_2_02 (conv_q_src_c118_2_02 conv_q_c118_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_03 (conv_i_src_c118_2_03 0 conv_bpf_c118_2 0) vcvs gain=1.950903220161e-01
SCONVI_c118_2_03 (conv_i_src_c118_2_03 conv_i_c118_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_03 (conv_q_src_c118_2_03 0 conv_bpf_c118_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_2_03 (conv_q_src_c118_2_03 conv_q_c118_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_04 (conv_i_src_c118_2_04 0 conv_bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c118_2_04 (conv_i_src_c118_2_04 conv_i_c118_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_04 (conv_q_src_c118_2_04 0 conv_bpf_c118_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_2_04 (conv_q_src_c118_2_04 conv_q_c118_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_05 (conv_i_src_c118_2_05 0 conv_bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_2_05 (conv_i_src_c118_2_05 conv_i_c118_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_05 (conv_q_src_c118_2_05 0 conv_bpf_c118_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_2_05 (conv_q_src_c118_2_05 conv_q_c118_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_06 (conv_i_src_c118_2_06 0 conv_bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_2_06 (conv_i_src_c118_2_06 conv_i_c118_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_06 (conv_q_src_c118_2_06 0 conv_bpf_c118_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_2_06 (conv_q_src_c118_2_06 conv_q_c118_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_07 (conv_i_src_c118_2_07 0 conv_bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_2_07 (conv_i_src_c118_2_07 conv_i_c118_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_07 (conv_q_src_c118_2_07 0 conv_bpf_c118_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_2_07 (conv_q_src_c118_2_07 conv_q_c118_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_08 (conv_i_src_c118_2_08 0 conv_bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_2_08 (conv_i_src_c118_2_08 conv_i_c118_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_08 (conv_q_src_c118_2_08 0 conv_bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_2_08 (conv_q_src_c118_2_08 conv_q_c118_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_09 (conv_i_src_c118_2_09 0 conv_bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_2_09 (conv_i_src_c118_2_09 conv_i_c118_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_09 (conv_q_src_c118_2_09 0 conv_bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_2_09 (conv_q_src_c118_2_09 conv_q_c118_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_10 (conv_i_src_c118_2_10 0 conv_bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_2_10 (conv_i_src_c118_2_10 conv_i_c118_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_10 (conv_q_src_c118_2_10 0 conv_bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_2_10 (conv_q_src_c118_2_10 conv_q_c118_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_11 (conv_i_src_c118_2_11 0 conv_bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c118_2_11 (conv_i_src_c118_2_11 conv_i_c118_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_11 (conv_q_src_c118_2_11 0 conv_bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_2_11 (conv_q_src_c118_2_11 conv_q_c118_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_12 (conv_i_src_c118_2_12 0 conv_bpf_c118_2 0) vcvs gain=1.950903220161e-01
SCONVI_c118_2_12 (conv_i_src_c118_2_12 conv_i_c118_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_12 (conv_q_src_c118_2_12 0 conv_bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_2_12 (conv_q_src_c118_2_12 conv_q_c118_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_13 (conv_i_src_c118_2_13 0 conv_bpf_c118_2 0) vcvs gain=5.555702330196e-01
SCONVI_c118_2_13 (conv_i_src_c118_2_13 conv_i_c118_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_13 (conv_q_src_c118_2_13 0 conv_bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_2_13 (conv_q_src_c118_2_13 conv_q_c118_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_14 (conv_i_src_c118_2_14 0 conv_bpf_c118_2 0) vcvs gain=8.314696123025e-01
SCONVI_c118_2_14 (conv_i_src_c118_2_14 conv_i_c118_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_14 (conv_q_src_c118_2_14 0 conv_bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_2_14 (conv_q_src_c118_2_14 conv_q_c118_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_2_15 (conv_i_src_c118_2_15 0 conv_bpf_c118_2 0) vcvs gain=9.807852804032e-01
SCONVI_c118_2_15 (conv_i_src_c118_2_15 conv_i_c118_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_2_15 (conv_q_src_c118_2_15 0 conv_bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_2_15 (conv_q_src_c118_2_15 conv_q_c118_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c118_2 (conv_i_c118_2 0) resistor r=1G
RCONVQ_c118_2 (conv_q_c118_2 0) resistor r=1G
RCONVINTI_c118_2 (conv_i_c118_2 ConvIcar_c118_2) resistor r=1k
CCONVINTI_c118_2 (ConvIcar_c118_2 0) capacitor c=80p
RCONVINTQ_c118_2 (conv_q_c118_2 ConvQcar_c118_2) resistor r=1k
CCONVINTQ_c118_2 (ConvQcar_c118_2 0) capacitor c=80p
save conv_bpf_c118_2 ConvIcar_c118_2 ConvQcar_c118_2

// conventional mixed baseline bl118, carrier_3: 1000000000 Hz
CCONVBPF_c118_3 (bl118 n_conv_cbpf_c118_3) capacitor c=2.533029591058e-14
LCONVBPF_c118_3 (n_conv_cbpf_c118_3 conv_bpf_c118_3) inductor l=1.000000000000e-06
RCONVBPF_c118_3 (conv_bpf_c118_3 0) resistor r=3.141592653590e+02
ECONVI_c118_3_00 (conv_i_src_c118_3_00 0 conv_bpf_c118_3 0) vcvs gain=9.807852804032e-01
SCONVI_c118_3_00 (conv_i_src_c118_3_00 conv_i_c118_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_00 (conv_q_src_c118_3_00 0 conv_bpf_c118_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_3_00 (conv_q_src_c118_3_00 conv_q_c118_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_01 (conv_i_src_c118_3_01 0 conv_bpf_c118_3 0) vcvs gain=8.314696123025e-01
SCONVI_c118_3_01 (conv_i_src_c118_3_01 conv_i_c118_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_01 (conv_q_src_c118_3_01 0 conv_bpf_c118_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_3_01 (conv_q_src_c118_3_01 conv_q_c118_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_02 (conv_i_src_c118_3_02 0 conv_bpf_c118_3 0) vcvs gain=5.555702330196e-01
SCONVI_c118_3_02 (conv_i_src_c118_3_02 conv_i_c118_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_02 (conv_q_src_c118_3_02 0 conv_bpf_c118_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_3_02 (conv_q_src_c118_3_02 conv_q_c118_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_03 (conv_i_src_c118_3_03 0 conv_bpf_c118_3 0) vcvs gain=1.950903220161e-01
SCONVI_c118_3_03 (conv_i_src_c118_3_03 conv_i_c118_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_03 (conv_q_src_c118_3_03 0 conv_bpf_c118_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_3_03 (conv_q_src_c118_3_03 conv_q_c118_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_04 (conv_i_src_c118_3_04 0 conv_bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c118_3_04 (conv_i_src_c118_3_04 conv_i_c118_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_04 (conv_q_src_c118_3_04 0 conv_bpf_c118_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c118_3_04 (conv_q_src_c118_3_04 conv_q_c118_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_05 (conv_i_src_c118_3_05 0 conv_bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_3_05 (conv_i_src_c118_3_05 conv_i_c118_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_05 (conv_q_src_c118_3_05 0 conv_bpf_c118_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c118_3_05 (conv_q_src_c118_3_05 conv_q_c118_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_06 (conv_i_src_c118_3_06 0 conv_bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_3_06 (conv_i_src_c118_3_06 conv_i_c118_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_06 (conv_q_src_c118_3_06 0 conv_bpf_c118_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c118_3_06 (conv_q_src_c118_3_06 conv_q_c118_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_07 (conv_i_src_c118_3_07 0 conv_bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_3_07 (conv_i_src_c118_3_07 conv_i_c118_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_07 (conv_q_src_c118_3_07 0 conv_bpf_c118_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c118_3_07 (conv_q_src_c118_3_07 conv_q_c118_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_08 (conv_i_src_c118_3_08 0 conv_bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c118_3_08 (conv_i_src_c118_3_08 conv_i_c118_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_08 (conv_q_src_c118_3_08 0 conv_bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_3_08 (conv_q_src_c118_3_08 conv_q_c118_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_09 (conv_i_src_c118_3_09 0 conv_bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c118_3_09 (conv_i_src_c118_3_09 conv_i_c118_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_09 (conv_q_src_c118_3_09 0 conv_bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_3_09 (conv_q_src_c118_3_09 conv_q_c118_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_10 (conv_i_src_c118_3_10 0 conv_bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c118_3_10 (conv_i_src_c118_3_10 conv_i_c118_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_10 (conv_q_src_c118_3_10 0 conv_bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_3_10 (conv_q_src_c118_3_10 conv_q_c118_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_11 (conv_i_src_c118_3_11 0 conv_bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c118_3_11 (conv_i_src_c118_3_11 conv_i_c118_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_11 (conv_q_src_c118_3_11 0 conv_bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_3_11 (conv_q_src_c118_3_11 conv_q_c118_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_12 (conv_i_src_c118_3_12 0 conv_bpf_c118_3 0) vcvs gain=1.950903220161e-01
SCONVI_c118_3_12 (conv_i_src_c118_3_12 conv_i_c118_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_12 (conv_q_src_c118_3_12 0 conv_bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c118_3_12 (conv_q_src_c118_3_12 conv_q_c118_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_13 (conv_i_src_c118_3_13 0 conv_bpf_c118_3 0) vcvs gain=5.555702330196e-01
SCONVI_c118_3_13 (conv_i_src_c118_3_13 conv_i_c118_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_13 (conv_q_src_c118_3_13 0 conv_bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c118_3_13 (conv_q_src_c118_3_13 conv_q_c118_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_14 (conv_i_src_c118_3_14 0 conv_bpf_c118_3 0) vcvs gain=8.314696123025e-01
SCONVI_c118_3_14 (conv_i_src_c118_3_14 conv_i_c118_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_14 (conv_q_src_c118_3_14 0 conv_bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c118_3_14 (conv_q_src_c118_3_14 conv_q_c118_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c118_3_15 (conv_i_src_c118_3_15 0 conv_bpf_c118_3 0) vcvs gain=9.807852804032e-01
SCONVI_c118_3_15 (conv_i_src_c118_3_15 conv_i_c118_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c118_3_15 (conv_q_src_c118_3_15 0 conv_bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c118_3_15 (conv_q_src_c118_3_15 conv_q_c118_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c118_3 (conv_i_c118_3 0) resistor r=1G
RCONVQ_c118_3 (conv_q_c118_3 0) resistor r=1G
RCONVINTI_c118_3 (conv_i_c118_3 ConvIcar_c118_3) resistor r=1k
CCONVINTI_c118_3 (ConvIcar_c118_3 0) capacitor c=80p
RCONVINTQ_c118_3 (conv_q_c118_3 ConvQcar_c118_3) resistor r=1k
CCONVINTQ_c118_3 (ConvQcar_c118_3 0) capacitor c=80p
save conv_bpf_c118_3 ConvIcar_c118_3 ConvQcar_c118_3

// conventional mixed baseline bl119, carrier_0: 250000000 Hz
CCONVBPF_c119_0 (bl119 n_conv_cbpf_c119_0) capacitor c=4.052847345694e-13
LCONVBPF_c119_0 (n_conv_cbpf_c119_0 conv_bpf_c119_0) inductor l=1.000000000000e-06
RCONVBPF_c119_0 (conv_bpf_c119_0 0) resistor r=7.853981633974e+01
ECONVI_c119_0_00 (conv_i_src_c119_0_00 0 conv_bpf_c119_0 0) vcvs gain=9.807852804032e-01
SCONVI_c119_0_00 (conv_i_src_c119_0_00 conv_i_c119_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_00 (conv_q_src_c119_0_00 0 conv_bpf_c119_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_0_00 (conv_q_src_c119_0_00 conv_q_c119_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_01 (conv_i_src_c119_0_01 0 conv_bpf_c119_0 0) vcvs gain=8.314696123025e-01
SCONVI_c119_0_01 (conv_i_src_c119_0_01 conv_i_c119_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_01 (conv_q_src_c119_0_01 0 conv_bpf_c119_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_0_01 (conv_q_src_c119_0_01 conv_q_c119_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_02 (conv_i_src_c119_0_02 0 conv_bpf_c119_0 0) vcvs gain=5.555702330196e-01
SCONVI_c119_0_02 (conv_i_src_c119_0_02 conv_i_c119_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_02 (conv_q_src_c119_0_02 0 conv_bpf_c119_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_0_02 (conv_q_src_c119_0_02 conv_q_c119_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_03 (conv_i_src_c119_0_03 0 conv_bpf_c119_0 0) vcvs gain=1.950903220161e-01
SCONVI_c119_0_03 (conv_i_src_c119_0_03 conv_i_c119_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_03 (conv_q_src_c119_0_03 0 conv_bpf_c119_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_0_03 (conv_q_src_c119_0_03 conv_q_c119_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_04 (conv_i_src_c119_0_04 0 conv_bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_0_04 (conv_i_src_c119_0_04 conv_i_c119_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_04 (conv_q_src_c119_0_04 0 conv_bpf_c119_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_0_04 (conv_q_src_c119_0_04 conv_q_c119_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_05 (conv_i_src_c119_0_05 0 conv_bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_0_05 (conv_i_src_c119_0_05 conv_i_c119_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_05 (conv_q_src_c119_0_05 0 conv_bpf_c119_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_0_05 (conv_q_src_c119_0_05 conv_q_c119_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_06 (conv_i_src_c119_0_06 0 conv_bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_0_06 (conv_i_src_c119_0_06 conv_i_c119_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_06 (conv_q_src_c119_0_06 0 conv_bpf_c119_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_0_06 (conv_q_src_c119_0_06 conv_q_c119_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_07 (conv_i_src_c119_0_07 0 conv_bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_0_07 (conv_i_src_c119_0_07 conv_i_c119_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_07 (conv_q_src_c119_0_07 0 conv_bpf_c119_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_0_07 (conv_q_src_c119_0_07 conv_q_c119_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_08 (conv_i_src_c119_0_08 0 conv_bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_0_08 (conv_i_src_c119_0_08 conv_i_c119_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_08 (conv_q_src_c119_0_08 0 conv_bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_0_08 (conv_q_src_c119_0_08 conv_q_c119_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_09 (conv_i_src_c119_0_09 0 conv_bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_0_09 (conv_i_src_c119_0_09 conv_i_c119_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_09 (conv_q_src_c119_0_09 0 conv_bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_0_09 (conv_q_src_c119_0_09 conv_q_c119_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_10 (conv_i_src_c119_0_10 0 conv_bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_0_10 (conv_i_src_c119_0_10 conv_i_c119_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_10 (conv_q_src_c119_0_10 0 conv_bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_0_10 (conv_q_src_c119_0_10 conv_q_c119_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_11 (conv_i_src_c119_0_11 0 conv_bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_0_11 (conv_i_src_c119_0_11 conv_i_c119_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_11 (conv_q_src_c119_0_11 0 conv_bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_0_11 (conv_q_src_c119_0_11 conv_q_c119_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_12 (conv_i_src_c119_0_12 0 conv_bpf_c119_0 0) vcvs gain=1.950903220161e-01
SCONVI_c119_0_12 (conv_i_src_c119_0_12 conv_i_c119_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_12 (conv_q_src_c119_0_12 0 conv_bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_0_12 (conv_q_src_c119_0_12 conv_q_c119_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_13 (conv_i_src_c119_0_13 0 conv_bpf_c119_0 0) vcvs gain=5.555702330196e-01
SCONVI_c119_0_13 (conv_i_src_c119_0_13 conv_i_c119_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_13 (conv_q_src_c119_0_13 0 conv_bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_0_13 (conv_q_src_c119_0_13 conv_q_c119_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_14 (conv_i_src_c119_0_14 0 conv_bpf_c119_0 0) vcvs gain=8.314696123025e-01
SCONVI_c119_0_14 (conv_i_src_c119_0_14 conv_i_c119_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_14 (conv_q_src_c119_0_14 0 conv_bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_0_14 (conv_q_src_c119_0_14 conv_q_c119_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_0_15 (conv_i_src_c119_0_15 0 conv_bpf_c119_0 0) vcvs gain=9.807852804032e-01
SCONVI_c119_0_15 (conv_i_src_c119_0_15 conv_i_c119_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_0_15 (conv_q_src_c119_0_15 0 conv_bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_0_15 (conv_q_src_c119_0_15 conv_q_c119_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c119_0 (conv_i_c119_0 0) resistor r=1G
RCONVQ_c119_0 (conv_q_c119_0 0) resistor r=1G
RCONVINTI_c119_0 (conv_i_c119_0 ConvIcar_c119_0) resistor r=1k
CCONVINTI_c119_0 (ConvIcar_c119_0 0) capacitor c=80p
RCONVINTQ_c119_0 (conv_q_c119_0 ConvQcar_c119_0) resistor r=1k
CCONVINTQ_c119_0 (ConvQcar_c119_0 0) capacitor c=80p
save conv_bpf_c119_0 ConvIcar_c119_0 ConvQcar_c119_0

// conventional mixed baseline bl119, carrier_1: 500000000 Hz
CCONVBPF_c119_1 (bl119 n_conv_cbpf_c119_1) capacitor c=1.013211836423e-13
LCONVBPF_c119_1 (n_conv_cbpf_c119_1 conv_bpf_c119_1) inductor l=1.000000000000e-06
RCONVBPF_c119_1 (conv_bpf_c119_1 0) resistor r=1.570796326795e+02
ECONVI_c119_1_00 (conv_i_src_c119_1_00 0 conv_bpf_c119_1 0) vcvs gain=9.807852804032e-01
SCONVI_c119_1_00 (conv_i_src_c119_1_00 conv_i_c119_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_00 (conv_q_src_c119_1_00 0 conv_bpf_c119_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_1_00 (conv_q_src_c119_1_00 conv_q_c119_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_01 (conv_i_src_c119_1_01 0 conv_bpf_c119_1 0) vcvs gain=8.314696123025e-01
SCONVI_c119_1_01 (conv_i_src_c119_1_01 conv_i_c119_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_01 (conv_q_src_c119_1_01 0 conv_bpf_c119_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_1_01 (conv_q_src_c119_1_01 conv_q_c119_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_02 (conv_i_src_c119_1_02 0 conv_bpf_c119_1 0) vcvs gain=5.555702330196e-01
SCONVI_c119_1_02 (conv_i_src_c119_1_02 conv_i_c119_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_02 (conv_q_src_c119_1_02 0 conv_bpf_c119_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_1_02 (conv_q_src_c119_1_02 conv_q_c119_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_03 (conv_i_src_c119_1_03 0 conv_bpf_c119_1 0) vcvs gain=1.950903220161e-01
SCONVI_c119_1_03 (conv_i_src_c119_1_03 conv_i_c119_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_03 (conv_q_src_c119_1_03 0 conv_bpf_c119_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_1_03 (conv_q_src_c119_1_03 conv_q_c119_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_04 (conv_i_src_c119_1_04 0 conv_bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_1_04 (conv_i_src_c119_1_04 conv_i_c119_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_04 (conv_q_src_c119_1_04 0 conv_bpf_c119_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_1_04 (conv_q_src_c119_1_04 conv_q_c119_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_05 (conv_i_src_c119_1_05 0 conv_bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_1_05 (conv_i_src_c119_1_05 conv_i_c119_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_05 (conv_q_src_c119_1_05 0 conv_bpf_c119_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_1_05 (conv_q_src_c119_1_05 conv_q_c119_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_06 (conv_i_src_c119_1_06 0 conv_bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_1_06 (conv_i_src_c119_1_06 conv_i_c119_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_06 (conv_q_src_c119_1_06 0 conv_bpf_c119_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_1_06 (conv_q_src_c119_1_06 conv_q_c119_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_07 (conv_i_src_c119_1_07 0 conv_bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_1_07 (conv_i_src_c119_1_07 conv_i_c119_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_07 (conv_q_src_c119_1_07 0 conv_bpf_c119_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_1_07 (conv_q_src_c119_1_07 conv_q_c119_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_08 (conv_i_src_c119_1_08 0 conv_bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_1_08 (conv_i_src_c119_1_08 conv_i_c119_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_08 (conv_q_src_c119_1_08 0 conv_bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_1_08 (conv_q_src_c119_1_08 conv_q_c119_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_09 (conv_i_src_c119_1_09 0 conv_bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_1_09 (conv_i_src_c119_1_09 conv_i_c119_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_09 (conv_q_src_c119_1_09 0 conv_bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_1_09 (conv_q_src_c119_1_09 conv_q_c119_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_10 (conv_i_src_c119_1_10 0 conv_bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_1_10 (conv_i_src_c119_1_10 conv_i_c119_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_10 (conv_q_src_c119_1_10 0 conv_bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_1_10 (conv_q_src_c119_1_10 conv_q_c119_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_11 (conv_i_src_c119_1_11 0 conv_bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_1_11 (conv_i_src_c119_1_11 conv_i_c119_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_11 (conv_q_src_c119_1_11 0 conv_bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_1_11 (conv_q_src_c119_1_11 conv_q_c119_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_12 (conv_i_src_c119_1_12 0 conv_bpf_c119_1 0) vcvs gain=1.950903220161e-01
SCONVI_c119_1_12 (conv_i_src_c119_1_12 conv_i_c119_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_12 (conv_q_src_c119_1_12 0 conv_bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_1_12 (conv_q_src_c119_1_12 conv_q_c119_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_13 (conv_i_src_c119_1_13 0 conv_bpf_c119_1 0) vcvs gain=5.555702330196e-01
SCONVI_c119_1_13 (conv_i_src_c119_1_13 conv_i_c119_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_13 (conv_q_src_c119_1_13 0 conv_bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_1_13 (conv_q_src_c119_1_13 conv_q_c119_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_14 (conv_i_src_c119_1_14 0 conv_bpf_c119_1 0) vcvs gain=8.314696123025e-01
SCONVI_c119_1_14 (conv_i_src_c119_1_14 conv_i_c119_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_14 (conv_q_src_c119_1_14 0 conv_bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_1_14 (conv_q_src_c119_1_14 conv_q_c119_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_1_15 (conv_i_src_c119_1_15 0 conv_bpf_c119_1 0) vcvs gain=9.807852804032e-01
SCONVI_c119_1_15 (conv_i_src_c119_1_15 conv_i_c119_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_1_15 (conv_q_src_c119_1_15 0 conv_bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_1_15 (conv_q_src_c119_1_15 conv_q_c119_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c119_1 (conv_i_c119_1 0) resistor r=1G
RCONVQ_c119_1 (conv_q_c119_1 0) resistor r=1G
RCONVINTI_c119_1 (conv_i_c119_1 ConvIcar_c119_1) resistor r=1k
CCONVINTI_c119_1 (ConvIcar_c119_1 0) capacitor c=80p
RCONVINTQ_c119_1 (conv_q_c119_1 ConvQcar_c119_1) resistor r=1k
CCONVINTQ_c119_1 (ConvQcar_c119_1 0) capacitor c=80p
save conv_bpf_c119_1 ConvIcar_c119_1 ConvQcar_c119_1

// conventional mixed baseline bl119, carrier_2: 750000000 Hz
CCONVBPF_c119_2 (bl119 n_conv_cbpf_c119_2) capacitor c=4.503163717437e-14
LCONVBPF_c119_2 (n_conv_cbpf_c119_2 conv_bpf_c119_2) inductor l=1.000000000000e-06
RCONVBPF_c119_2 (conv_bpf_c119_2 0) resistor r=2.356194490192e+02
ECONVI_c119_2_00 (conv_i_src_c119_2_00 0 conv_bpf_c119_2 0) vcvs gain=9.807852804032e-01
SCONVI_c119_2_00 (conv_i_src_c119_2_00 conv_i_c119_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_00 (conv_q_src_c119_2_00 0 conv_bpf_c119_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_2_00 (conv_q_src_c119_2_00 conv_q_c119_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_01 (conv_i_src_c119_2_01 0 conv_bpf_c119_2 0) vcvs gain=8.314696123025e-01
SCONVI_c119_2_01 (conv_i_src_c119_2_01 conv_i_c119_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_01 (conv_q_src_c119_2_01 0 conv_bpf_c119_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_2_01 (conv_q_src_c119_2_01 conv_q_c119_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_02 (conv_i_src_c119_2_02 0 conv_bpf_c119_2 0) vcvs gain=5.555702330196e-01
SCONVI_c119_2_02 (conv_i_src_c119_2_02 conv_i_c119_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_02 (conv_q_src_c119_2_02 0 conv_bpf_c119_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_2_02 (conv_q_src_c119_2_02 conv_q_c119_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_03 (conv_i_src_c119_2_03 0 conv_bpf_c119_2 0) vcvs gain=1.950903220161e-01
SCONVI_c119_2_03 (conv_i_src_c119_2_03 conv_i_c119_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_03 (conv_q_src_c119_2_03 0 conv_bpf_c119_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_2_03 (conv_q_src_c119_2_03 conv_q_c119_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_04 (conv_i_src_c119_2_04 0 conv_bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_2_04 (conv_i_src_c119_2_04 conv_i_c119_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_04 (conv_q_src_c119_2_04 0 conv_bpf_c119_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_2_04 (conv_q_src_c119_2_04 conv_q_c119_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_05 (conv_i_src_c119_2_05 0 conv_bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_2_05 (conv_i_src_c119_2_05 conv_i_c119_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_05 (conv_q_src_c119_2_05 0 conv_bpf_c119_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_2_05 (conv_q_src_c119_2_05 conv_q_c119_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_06 (conv_i_src_c119_2_06 0 conv_bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_2_06 (conv_i_src_c119_2_06 conv_i_c119_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_06 (conv_q_src_c119_2_06 0 conv_bpf_c119_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_2_06 (conv_q_src_c119_2_06 conv_q_c119_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_07 (conv_i_src_c119_2_07 0 conv_bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_2_07 (conv_i_src_c119_2_07 conv_i_c119_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_07 (conv_q_src_c119_2_07 0 conv_bpf_c119_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_2_07 (conv_q_src_c119_2_07 conv_q_c119_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_08 (conv_i_src_c119_2_08 0 conv_bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_2_08 (conv_i_src_c119_2_08 conv_i_c119_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_08 (conv_q_src_c119_2_08 0 conv_bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_2_08 (conv_q_src_c119_2_08 conv_q_c119_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_09 (conv_i_src_c119_2_09 0 conv_bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_2_09 (conv_i_src_c119_2_09 conv_i_c119_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_09 (conv_q_src_c119_2_09 0 conv_bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_2_09 (conv_q_src_c119_2_09 conv_q_c119_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_10 (conv_i_src_c119_2_10 0 conv_bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_2_10 (conv_i_src_c119_2_10 conv_i_c119_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_10 (conv_q_src_c119_2_10 0 conv_bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_2_10 (conv_q_src_c119_2_10 conv_q_c119_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_11 (conv_i_src_c119_2_11 0 conv_bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_2_11 (conv_i_src_c119_2_11 conv_i_c119_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_11 (conv_q_src_c119_2_11 0 conv_bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_2_11 (conv_q_src_c119_2_11 conv_q_c119_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_12 (conv_i_src_c119_2_12 0 conv_bpf_c119_2 0) vcvs gain=1.950903220161e-01
SCONVI_c119_2_12 (conv_i_src_c119_2_12 conv_i_c119_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_12 (conv_q_src_c119_2_12 0 conv_bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_2_12 (conv_q_src_c119_2_12 conv_q_c119_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_13 (conv_i_src_c119_2_13 0 conv_bpf_c119_2 0) vcvs gain=5.555702330196e-01
SCONVI_c119_2_13 (conv_i_src_c119_2_13 conv_i_c119_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_13 (conv_q_src_c119_2_13 0 conv_bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_2_13 (conv_q_src_c119_2_13 conv_q_c119_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_14 (conv_i_src_c119_2_14 0 conv_bpf_c119_2 0) vcvs gain=8.314696123025e-01
SCONVI_c119_2_14 (conv_i_src_c119_2_14 conv_i_c119_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_14 (conv_q_src_c119_2_14 0 conv_bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_2_14 (conv_q_src_c119_2_14 conv_q_c119_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_2_15 (conv_i_src_c119_2_15 0 conv_bpf_c119_2 0) vcvs gain=9.807852804032e-01
SCONVI_c119_2_15 (conv_i_src_c119_2_15 conv_i_c119_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_2_15 (conv_q_src_c119_2_15 0 conv_bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_2_15 (conv_q_src_c119_2_15 conv_q_c119_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c119_2 (conv_i_c119_2 0) resistor r=1G
RCONVQ_c119_2 (conv_q_c119_2 0) resistor r=1G
RCONVINTI_c119_2 (conv_i_c119_2 ConvIcar_c119_2) resistor r=1k
CCONVINTI_c119_2 (ConvIcar_c119_2 0) capacitor c=80p
RCONVINTQ_c119_2 (conv_q_c119_2 ConvQcar_c119_2) resistor r=1k
CCONVINTQ_c119_2 (ConvQcar_c119_2 0) capacitor c=80p
save conv_bpf_c119_2 ConvIcar_c119_2 ConvQcar_c119_2

// conventional mixed baseline bl119, carrier_3: 1000000000 Hz
CCONVBPF_c119_3 (bl119 n_conv_cbpf_c119_3) capacitor c=2.533029591058e-14
LCONVBPF_c119_3 (n_conv_cbpf_c119_3 conv_bpf_c119_3) inductor l=1.000000000000e-06
RCONVBPF_c119_3 (conv_bpf_c119_3 0) resistor r=3.141592653590e+02
ECONVI_c119_3_00 (conv_i_src_c119_3_00 0 conv_bpf_c119_3 0) vcvs gain=9.807852804032e-01
SCONVI_c119_3_00 (conv_i_src_c119_3_00 conv_i_c119_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_00 (conv_q_src_c119_3_00 0 conv_bpf_c119_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_3_00 (conv_q_src_c119_3_00 conv_q_c119_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_01 (conv_i_src_c119_3_01 0 conv_bpf_c119_3 0) vcvs gain=8.314696123025e-01
SCONVI_c119_3_01 (conv_i_src_c119_3_01 conv_i_c119_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_01 (conv_q_src_c119_3_01 0 conv_bpf_c119_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_3_01 (conv_q_src_c119_3_01 conv_q_c119_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_02 (conv_i_src_c119_3_02 0 conv_bpf_c119_3 0) vcvs gain=5.555702330196e-01
SCONVI_c119_3_02 (conv_i_src_c119_3_02 conv_i_c119_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_02 (conv_q_src_c119_3_02 0 conv_bpf_c119_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_3_02 (conv_q_src_c119_3_02 conv_q_c119_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_03 (conv_i_src_c119_3_03 0 conv_bpf_c119_3 0) vcvs gain=1.950903220161e-01
SCONVI_c119_3_03 (conv_i_src_c119_3_03 conv_i_c119_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_03 (conv_q_src_c119_3_03 0 conv_bpf_c119_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_3_03 (conv_q_src_c119_3_03 conv_q_c119_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_04 (conv_i_src_c119_3_04 0 conv_bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_3_04 (conv_i_src_c119_3_04 conv_i_c119_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_04 (conv_q_src_c119_3_04 0 conv_bpf_c119_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c119_3_04 (conv_q_src_c119_3_04 conv_q_c119_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_05 (conv_i_src_c119_3_05 0 conv_bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_3_05 (conv_i_src_c119_3_05 conv_i_c119_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_05 (conv_q_src_c119_3_05 0 conv_bpf_c119_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c119_3_05 (conv_q_src_c119_3_05 conv_q_c119_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_06 (conv_i_src_c119_3_06 0 conv_bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_3_06 (conv_i_src_c119_3_06 conv_i_c119_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_06 (conv_q_src_c119_3_06 0 conv_bpf_c119_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c119_3_06 (conv_q_src_c119_3_06 conv_q_c119_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_07 (conv_i_src_c119_3_07 0 conv_bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_3_07 (conv_i_src_c119_3_07 conv_i_c119_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_07 (conv_q_src_c119_3_07 0 conv_bpf_c119_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c119_3_07 (conv_q_src_c119_3_07 conv_q_c119_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_08 (conv_i_src_c119_3_08 0 conv_bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c119_3_08 (conv_i_src_c119_3_08 conv_i_c119_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_08 (conv_q_src_c119_3_08 0 conv_bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_3_08 (conv_q_src_c119_3_08 conv_q_c119_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_09 (conv_i_src_c119_3_09 0 conv_bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c119_3_09 (conv_i_src_c119_3_09 conv_i_c119_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_09 (conv_q_src_c119_3_09 0 conv_bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_3_09 (conv_q_src_c119_3_09 conv_q_c119_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_10 (conv_i_src_c119_3_10 0 conv_bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c119_3_10 (conv_i_src_c119_3_10 conv_i_c119_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_10 (conv_q_src_c119_3_10 0 conv_bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_3_10 (conv_q_src_c119_3_10 conv_q_c119_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_11 (conv_i_src_c119_3_11 0 conv_bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c119_3_11 (conv_i_src_c119_3_11 conv_i_c119_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_11 (conv_q_src_c119_3_11 0 conv_bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_3_11 (conv_q_src_c119_3_11 conv_q_c119_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_12 (conv_i_src_c119_3_12 0 conv_bpf_c119_3 0) vcvs gain=1.950903220161e-01
SCONVI_c119_3_12 (conv_i_src_c119_3_12 conv_i_c119_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_12 (conv_q_src_c119_3_12 0 conv_bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c119_3_12 (conv_q_src_c119_3_12 conv_q_c119_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_13 (conv_i_src_c119_3_13 0 conv_bpf_c119_3 0) vcvs gain=5.555702330196e-01
SCONVI_c119_3_13 (conv_i_src_c119_3_13 conv_i_c119_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_13 (conv_q_src_c119_3_13 0 conv_bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c119_3_13 (conv_q_src_c119_3_13 conv_q_c119_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_14 (conv_i_src_c119_3_14 0 conv_bpf_c119_3 0) vcvs gain=8.314696123025e-01
SCONVI_c119_3_14 (conv_i_src_c119_3_14 conv_i_c119_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_14 (conv_q_src_c119_3_14 0 conv_bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c119_3_14 (conv_q_src_c119_3_14 conv_q_c119_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c119_3_15 (conv_i_src_c119_3_15 0 conv_bpf_c119_3 0) vcvs gain=9.807852804032e-01
SCONVI_c119_3_15 (conv_i_src_c119_3_15 conv_i_c119_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c119_3_15 (conv_q_src_c119_3_15 0 conv_bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c119_3_15 (conv_q_src_c119_3_15 conv_q_c119_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c119_3 (conv_i_c119_3 0) resistor r=1G
RCONVQ_c119_3 (conv_q_c119_3 0) resistor r=1G
RCONVINTI_c119_3 (conv_i_c119_3 ConvIcar_c119_3) resistor r=1k
CCONVINTI_c119_3 (ConvIcar_c119_3 0) capacitor c=80p
RCONVINTQ_c119_3 (conv_q_c119_3 ConvQcar_c119_3) resistor r=1k
CCONVINTQ_c119_3 (ConvQcar_c119_3 0) capacitor c=80p
save conv_bpf_c119_3 ConvIcar_c119_3 ConvQcar_c119_3

// conventional mixed baseline bl120, carrier_0: 250000000 Hz
CCONVBPF_c120_0 (bl120 n_conv_cbpf_c120_0) capacitor c=4.052847345694e-13
LCONVBPF_c120_0 (n_conv_cbpf_c120_0 conv_bpf_c120_0) inductor l=1.000000000000e-06
RCONVBPF_c120_0 (conv_bpf_c120_0 0) resistor r=7.853981633974e+01
ECONVI_c120_0_00 (conv_i_src_c120_0_00 0 conv_bpf_c120_0 0) vcvs gain=9.807852804032e-01
SCONVI_c120_0_00 (conv_i_src_c120_0_00 conv_i_c120_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_00 (conv_q_src_c120_0_00 0 conv_bpf_c120_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_0_00 (conv_q_src_c120_0_00 conv_q_c120_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_01 (conv_i_src_c120_0_01 0 conv_bpf_c120_0 0) vcvs gain=8.314696123025e-01
SCONVI_c120_0_01 (conv_i_src_c120_0_01 conv_i_c120_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_01 (conv_q_src_c120_0_01 0 conv_bpf_c120_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_0_01 (conv_q_src_c120_0_01 conv_q_c120_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_02 (conv_i_src_c120_0_02 0 conv_bpf_c120_0 0) vcvs gain=5.555702330196e-01
SCONVI_c120_0_02 (conv_i_src_c120_0_02 conv_i_c120_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_02 (conv_q_src_c120_0_02 0 conv_bpf_c120_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_0_02 (conv_q_src_c120_0_02 conv_q_c120_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_03 (conv_i_src_c120_0_03 0 conv_bpf_c120_0 0) vcvs gain=1.950903220161e-01
SCONVI_c120_0_03 (conv_i_src_c120_0_03 conv_i_c120_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_03 (conv_q_src_c120_0_03 0 conv_bpf_c120_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_0_03 (conv_q_src_c120_0_03 conv_q_c120_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_04 (conv_i_src_c120_0_04 0 conv_bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_0_04 (conv_i_src_c120_0_04 conv_i_c120_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_04 (conv_q_src_c120_0_04 0 conv_bpf_c120_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_0_04 (conv_q_src_c120_0_04 conv_q_c120_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_05 (conv_i_src_c120_0_05 0 conv_bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_0_05 (conv_i_src_c120_0_05 conv_i_c120_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_05 (conv_q_src_c120_0_05 0 conv_bpf_c120_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_0_05 (conv_q_src_c120_0_05 conv_q_c120_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_06 (conv_i_src_c120_0_06 0 conv_bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_0_06 (conv_i_src_c120_0_06 conv_i_c120_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_06 (conv_q_src_c120_0_06 0 conv_bpf_c120_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_0_06 (conv_q_src_c120_0_06 conv_q_c120_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_07 (conv_i_src_c120_0_07 0 conv_bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_0_07 (conv_i_src_c120_0_07 conv_i_c120_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_07 (conv_q_src_c120_0_07 0 conv_bpf_c120_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_0_07 (conv_q_src_c120_0_07 conv_q_c120_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_08 (conv_i_src_c120_0_08 0 conv_bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_0_08 (conv_i_src_c120_0_08 conv_i_c120_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_08 (conv_q_src_c120_0_08 0 conv_bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_0_08 (conv_q_src_c120_0_08 conv_q_c120_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_09 (conv_i_src_c120_0_09 0 conv_bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_0_09 (conv_i_src_c120_0_09 conv_i_c120_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_09 (conv_q_src_c120_0_09 0 conv_bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_0_09 (conv_q_src_c120_0_09 conv_q_c120_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_10 (conv_i_src_c120_0_10 0 conv_bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_0_10 (conv_i_src_c120_0_10 conv_i_c120_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_10 (conv_q_src_c120_0_10 0 conv_bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_0_10 (conv_q_src_c120_0_10 conv_q_c120_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_11 (conv_i_src_c120_0_11 0 conv_bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_0_11 (conv_i_src_c120_0_11 conv_i_c120_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_11 (conv_q_src_c120_0_11 0 conv_bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_0_11 (conv_q_src_c120_0_11 conv_q_c120_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_12 (conv_i_src_c120_0_12 0 conv_bpf_c120_0 0) vcvs gain=1.950903220161e-01
SCONVI_c120_0_12 (conv_i_src_c120_0_12 conv_i_c120_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_12 (conv_q_src_c120_0_12 0 conv_bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_0_12 (conv_q_src_c120_0_12 conv_q_c120_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_13 (conv_i_src_c120_0_13 0 conv_bpf_c120_0 0) vcvs gain=5.555702330196e-01
SCONVI_c120_0_13 (conv_i_src_c120_0_13 conv_i_c120_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_13 (conv_q_src_c120_0_13 0 conv_bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_0_13 (conv_q_src_c120_0_13 conv_q_c120_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_14 (conv_i_src_c120_0_14 0 conv_bpf_c120_0 0) vcvs gain=8.314696123025e-01
SCONVI_c120_0_14 (conv_i_src_c120_0_14 conv_i_c120_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_14 (conv_q_src_c120_0_14 0 conv_bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_0_14 (conv_q_src_c120_0_14 conv_q_c120_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_0_15 (conv_i_src_c120_0_15 0 conv_bpf_c120_0 0) vcvs gain=9.807852804032e-01
SCONVI_c120_0_15 (conv_i_src_c120_0_15 conv_i_c120_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_0_15 (conv_q_src_c120_0_15 0 conv_bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_0_15 (conv_q_src_c120_0_15 conv_q_c120_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c120_0 (conv_i_c120_0 0) resistor r=1G
RCONVQ_c120_0 (conv_q_c120_0 0) resistor r=1G
RCONVINTI_c120_0 (conv_i_c120_0 ConvIcar_c120_0) resistor r=1k
CCONVINTI_c120_0 (ConvIcar_c120_0 0) capacitor c=80p
RCONVINTQ_c120_0 (conv_q_c120_0 ConvQcar_c120_0) resistor r=1k
CCONVINTQ_c120_0 (ConvQcar_c120_0 0) capacitor c=80p
save conv_bpf_c120_0 ConvIcar_c120_0 ConvQcar_c120_0

// conventional mixed baseline bl120, carrier_1: 500000000 Hz
CCONVBPF_c120_1 (bl120 n_conv_cbpf_c120_1) capacitor c=1.013211836423e-13
LCONVBPF_c120_1 (n_conv_cbpf_c120_1 conv_bpf_c120_1) inductor l=1.000000000000e-06
RCONVBPF_c120_1 (conv_bpf_c120_1 0) resistor r=1.570796326795e+02
ECONVI_c120_1_00 (conv_i_src_c120_1_00 0 conv_bpf_c120_1 0) vcvs gain=9.807852804032e-01
SCONVI_c120_1_00 (conv_i_src_c120_1_00 conv_i_c120_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_00 (conv_q_src_c120_1_00 0 conv_bpf_c120_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_1_00 (conv_q_src_c120_1_00 conv_q_c120_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_01 (conv_i_src_c120_1_01 0 conv_bpf_c120_1 0) vcvs gain=8.314696123025e-01
SCONVI_c120_1_01 (conv_i_src_c120_1_01 conv_i_c120_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_01 (conv_q_src_c120_1_01 0 conv_bpf_c120_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_1_01 (conv_q_src_c120_1_01 conv_q_c120_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_02 (conv_i_src_c120_1_02 0 conv_bpf_c120_1 0) vcvs gain=5.555702330196e-01
SCONVI_c120_1_02 (conv_i_src_c120_1_02 conv_i_c120_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_02 (conv_q_src_c120_1_02 0 conv_bpf_c120_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_1_02 (conv_q_src_c120_1_02 conv_q_c120_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_03 (conv_i_src_c120_1_03 0 conv_bpf_c120_1 0) vcvs gain=1.950903220161e-01
SCONVI_c120_1_03 (conv_i_src_c120_1_03 conv_i_c120_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_03 (conv_q_src_c120_1_03 0 conv_bpf_c120_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_1_03 (conv_q_src_c120_1_03 conv_q_c120_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_04 (conv_i_src_c120_1_04 0 conv_bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_1_04 (conv_i_src_c120_1_04 conv_i_c120_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_04 (conv_q_src_c120_1_04 0 conv_bpf_c120_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_1_04 (conv_q_src_c120_1_04 conv_q_c120_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_05 (conv_i_src_c120_1_05 0 conv_bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_1_05 (conv_i_src_c120_1_05 conv_i_c120_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_05 (conv_q_src_c120_1_05 0 conv_bpf_c120_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_1_05 (conv_q_src_c120_1_05 conv_q_c120_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_06 (conv_i_src_c120_1_06 0 conv_bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_1_06 (conv_i_src_c120_1_06 conv_i_c120_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_06 (conv_q_src_c120_1_06 0 conv_bpf_c120_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_1_06 (conv_q_src_c120_1_06 conv_q_c120_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_07 (conv_i_src_c120_1_07 0 conv_bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_1_07 (conv_i_src_c120_1_07 conv_i_c120_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_07 (conv_q_src_c120_1_07 0 conv_bpf_c120_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_1_07 (conv_q_src_c120_1_07 conv_q_c120_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_08 (conv_i_src_c120_1_08 0 conv_bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_1_08 (conv_i_src_c120_1_08 conv_i_c120_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_08 (conv_q_src_c120_1_08 0 conv_bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_1_08 (conv_q_src_c120_1_08 conv_q_c120_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_09 (conv_i_src_c120_1_09 0 conv_bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_1_09 (conv_i_src_c120_1_09 conv_i_c120_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_09 (conv_q_src_c120_1_09 0 conv_bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_1_09 (conv_q_src_c120_1_09 conv_q_c120_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_10 (conv_i_src_c120_1_10 0 conv_bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_1_10 (conv_i_src_c120_1_10 conv_i_c120_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_10 (conv_q_src_c120_1_10 0 conv_bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_1_10 (conv_q_src_c120_1_10 conv_q_c120_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_11 (conv_i_src_c120_1_11 0 conv_bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_1_11 (conv_i_src_c120_1_11 conv_i_c120_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_11 (conv_q_src_c120_1_11 0 conv_bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_1_11 (conv_q_src_c120_1_11 conv_q_c120_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_12 (conv_i_src_c120_1_12 0 conv_bpf_c120_1 0) vcvs gain=1.950903220161e-01
SCONVI_c120_1_12 (conv_i_src_c120_1_12 conv_i_c120_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_12 (conv_q_src_c120_1_12 0 conv_bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_1_12 (conv_q_src_c120_1_12 conv_q_c120_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_13 (conv_i_src_c120_1_13 0 conv_bpf_c120_1 0) vcvs gain=5.555702330196e-01
SCONVI_c120_1_13 (conv_i_src_c120_1_13 conv_i_c120_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_13 (conv_q_src_c120_1_13 0 conv_bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_1_13 (conv_q_src_c120_1_13 conv_q_c120_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_14 (conv_i_src_c120_1_14 0 conv_bpf_c120_1 0) vcvs gain=8.314696123025e-01
SCONVI_c120_1_14 (conv_i_src_c120_1_14 conv_i_c120_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_14 (conv_q_src_c120_1_14 0 conv_bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_1_14 (conv_q_src_c120_1_14 conv_q_c120_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_1_15 (conv_i_src_c120_1_15 0 conv_bpf_c120_1 0) vcvs gain=9.807852804032e-01
SCONVI_c120_1_15 (conv_i_src_c120_1_15 conv_i_c120_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_1_15 (conv_q_src_c120_1_15 0 conv_bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_1_15 (conv_q_src_c120_1_15 conv_q_c120_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c120_1 (conv_i_c120_1 0) resistor r=1G
RCONVQ_c120_1 (conv_q_c120_1 0) resistor r=1G
RCONVINTI_c120_1 (conv_i_c120_1 ConvIcar_c120_1) resistor r=1k
CCONVINTI_c120_1 (ConvIcar_c120_1 0) capacitor c=80p
RCONVINTQ_c120_1 (conv_q_c120_1 ConvQcar_c120_1) resistor r=1k
CCONVINTQ_c120_1 (ConvQcar_c120_1 0) capacitor c=80p
save conv_bpf_c120_1 ConvIcar_c120_1 ConvQcar_c120_1

// conventional mixed baseline bl120, carrier_2: 750000000 Hz
CCONVBPF_c120_2 (bl120 n_conv_cbpf_c120_2) capacitor c=4.503163717437e-14
LCONVBPF_c120_2 (n_conv_cbpf_c120_2 conv_bpf_c120_2) inductor l=1.000000000000e-06
RCONVBPF_c120_2 (conv_bpf_c120_2 0) resistor r=2.356194490192e+02
ECONVI_c120_2_00 (conv_i_src_c120_2_00 0 conv_bpf_c120_2 0) vcvs gain=9.807852804032e-01
SCONVI_c120_2_00 (conv_i_src_c120_2_00 conv_i_c120_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_00 (conv_q_src_c120_2_00 0 conv_bpf_c120_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_2_00 (conv_q_src_c120_2_00 conv_q_c120_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_01 (conv_i_src_c120_2_01 0 conv_bpf_c120_2 0) vcvs gain=8.314696123025e-01
SCONVI_c120_2_01 (conv_i_src_c120_2_01 conv_i_c120_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_01 (conv_q_src_c120_2_01 0 conv_bpf_c120_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_2_01 (conv_q_src_c120_2_01 conv_q_c120_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_02 (conv_i_src_c120_2_02 0 conv_bpf_c120_2 0) vcvs gain=5.555702330196e-01
SCONVI_c120_2_02 (conv_i_src_c120_2_02 conv_i_c120_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_02 (conv_q_src_c120_2_02 0 conv_bpf_c120_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_2_02 (conv_q_src_c120_2_02 conv_q_c120_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_03 (conv_i_src_c120_2_03 0 conv_bpf_c120_2 0) vcvs gain=1.950903220161e-01
SCONVI_c120_2_03 (conv_i_src_c120_2_03 conv_i_c120_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_03 (conv_q_src_c120_2_03 0 conv_bpf_c120_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_2_03 (conv_q_src_c120_2_03 conv_q_c120_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_04 (conv_i_src_c120_2_04 0 conv_bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_2_04 (conv_i_src_c120_2_04 conv_i_c120_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_04 (conv_q_src_c120_2_04 0 conv_bpf_c120_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_2_04 (conv_q_src_c120_2_04 conv_q_c120_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_05 (conv_i_src_c120_2_05 0 conv_bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_2_05 (conv_i_src_c120_2_05 conv_i_c120_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_05 (conv_q_src_c120_2_05 0 conv_bpf_c120_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_2_05 (conv_q_src_c120_2_05 conv_q_c120_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_06 (conv_i_src_c120_2_06 0 conv_bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_2_06 (conv_i_src_c120_2_06 conv_i_c120_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_06 (conv_q_src_c120_2_06 0 conv_bpf_c120_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_2_06 (conv_q_src_c120_2_06 conv_q_c120_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_07 (conv_i_src_c120_2_07 0 conv_bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_2_07 (conv_i_src_c120_2_07 conv_i_c120_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_07 (conv_q_src_c120_2_07 0 conv_bpf_c120_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_2_07 (conv_q_src_c120_2_07 conv_q_c120_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_08 (conv_i_src_c120_2_08 0 conv_bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_2_08 (conv_i_src_c120_2_08 conv_i_c120_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_08 (conv_q_src_c120_2_08 0 conv_bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_2_08 (conv_q_src_c120_2_08 conv_q_c120_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_09 (conv_i_src_c120_2_09 0 conv_bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_2_09 (conv_i_src_c120_2_09 conv_i_c120_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_09 (conv_q_src_c120_2_09 0 conv_bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_2_09 (conv_q_src_c120_2_09 conv_q_c120_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_10 (conv_i_src_c120_2_10 0 conv_bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_2_10 (conv_i_src_c120_2_10 conv_i_c120_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_10 (conv_q_src_c120_2_10 0 conv_bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_2_10 (conv_q_src_c120_2_10 conv_q_c120_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_11 (conv_i_src_c120_2_11 0 conv_bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_2_11 (conv_i_src_c120_2_11 conv_i_c120_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_11 (conv_q_src_c120_2_11 0 conv_bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_2_11 (conv_q_src_c120_2_11 conv_q_c120_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_12 (conv_i_src_c120_2_12 0 conv_bpf_c120_2 0) vcvs gain=1.950903220161e-01
SCONVI_c120_2_12 (conv_i_src_c120_2_12 conv_i_c120_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_12 (conv_q_src_c120_2_12 0 conv_bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_2_12 (conv_q_src_c120_2_12 conv_q_c120_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_13 (conv_i_src_c120_2_13 0 conv_bpf_c120_2 0) vcvs gain=5.555702330196e-01
SCONVI_c120_2_13 (conv_i_src_c120_2_13 conv_i_c120_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_13 (conv_q_src_c120_2_13 0 conv_bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_2_13 (conv_q_src_c120_2_13 conv_q_c120_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_14 (conv_i_src_c120_2_14 0 conv_bpf_c120_2 0) vcvs gain=8.314696123025e-01
SCONVI_c120_2_14 (conv_i_src_c120_2_14 conv_i_c120_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_14 (conv_q_src_c120_2_14 0 conv_bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_2_14 (conv_q_src_c120_2_14 conv_q_c120_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_2_15 (conv_i_src_c120_2_15 0 conv_bpf_c120_2 0) vcvs gain=9.807852804032e-01
SCONVI_c120_2_15 (conv_i_src_c120_2_15 conv_i_c120_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_2_15 (conv_q_src_c120_2_15 0 conv_bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_2_15 (conv_q_src_c120_2_15 conv_q_c120_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c120_2 (conv_i_c120_2 0) resistor r=1G
RCONVQ_c120_2 (conv_q_c120_2 0) resistor r=1G
RCONVINTI_c120_2 (conv_i_c120_2 ConvIcar_c120_2) resistor r=1k
CCONVINTI_c120_2 (ConvIcar_c120_2 0) capacitor c=80p
RCONVINTQ_c120_2 (conv_q_c120_2 ConvQcar_c120_2) resistor r=1k
CCONVINTQ_c120_2 (ConvQcar_c120_2 0) capacitor c=80p
save conv_bpf_c120_2 ConvIcar_c120_2 ConvQcar_c120_2

// conventional mixed baseline bl120, carrier_3: 1000000000 Hz
CCONVBPF_c120_3 (bl120 n_conv_cbpf_c120_3) capacitor c=2.533029591058e-14
LCONVBPF_c120_3 (n_conv_cbpf_c120_3 conv_bpf_c120_3) inductor l=1.000000000000e-06
RCONVBPF_c120_3 (conv_bpf_c120_3 0) resistor r=3.141592653590e+02
ECONVI_c120_3_00 (conv_i_src_c120_3_00 0 conv_bpf_c120_3 0) vcvs gain=9.807852804032e-01
SCONVI_c120_3_00 (conv_i_src_c120_3_00 conv_i_c120_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_00 (conv_q_src_c120_3_00 0 conv_bpf_c120_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_3_00 (conv_q_src_c120_3_00 conv_q_c120_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_01 (conv_i_src_c120_3_01 0 conv_bpf_c120_3 0) vcvs gain=8.314696123025e-01
SCONVI_c120_3_01 (conv_i_src_c120_3_01 conv_i_c120_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_01 (conv_q_src_c120_3_01 0 conv_bpf_c120_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_3_01 (conv_q_src_c120_3_01 conv_q_c120_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_02 (conv_i_src_c120_3_02 0 conv_bpf_c120_3 0) vcvs gain=5.555702330196e-01
SCONVI_c120_3_02 (conv_i_src_c120_3_02 conv_i_c120_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_02 (conv_q_src_c120_3_02 0 conv_bpf_c120_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_3_02 (conv_q_src_c120_3_02 conv_q_c120_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_03 (conv_i_src_c120_3_03 0 conv_bpf_c120_3 0) vcvs gain=1.950903220161e-01
SCONVI_c120_3_03 (conv_i_src_c120_3_03 conv_i_c120_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_03 (conv_q_src_c120_3_03 0 conv_bpf_c120_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_3_03 (conv_q_src_c120_3_03 conv_q_c120_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_04 (conv_i_src_c120_3_04 0 conv_bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_3_04 (conv_i_src_c120_3_04 conv_i_c120_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_04 (conv_q_src_c120_3_04 0 conv_bpf_c120_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c120_3_04 (conv_q_src_c120_3_04 conv_q_c120_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_05 (conv_i_src_c120_3_05 0 conv_bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_3_05 (conv_i_src_c120_3_05 conv_i_c120_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_05 (conv_q_src_c120_3_05 0 conv_bpf_c120_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c120_3_05 (conv_q_src_c120_3_05 conv_q_c120_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_06 (conv_i_src_c120_3_06 0 conv_bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_3_06 (conv_i_src_c120_3_06 conv_i_c120_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_06 (conv_q_src_c120_3_06 0 conv_bpf_c120_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c120_3_06 (conv_q_src_c120_3_06 conv_q_c120_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_07 (conv_i_src_c120_3_07 0 conv_bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_3_07 (conv_i_src_c120_3_07 conv_i_c120_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_07 (conv_q_src_c120_3_07 0 conv_bpf_c120_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c120_3_07 (conv_q_src_c120_3_07 conv_q_c120_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_08 (conv_i_src_c120_3_08 0 conv_bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c120_3_08 (conv_i_src_c120_3_08 conv_i_c120_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_08 (conv_q_src_c120_3_08 0 conv_bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_3_08 (conv_q_src_c120_3_08 conv_q_c120_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_09 (conv_i_src_c120_3_09 0 conv_bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c120_3_09 (conv_i_src_c120_3_09 conv_i_c120_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_09 (conv_q_src_c120_3_09 0 conv_bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_3_09 (conv_q_src_c120_3_09 conv_q_c120_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_10 (conv_i_src_c120_3_10 0 conv_bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c120_3_10 (conv_i_src_c120_3_10 conv_i_c120_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_10 (conv_q_src_c120_3_10 0 conv_bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_3_10 (conv_q_src_c120_3_10 conv_q_c120_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_11 (conv_i_src_c120_3_11 0 conv_bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c120_3_11 (conv_i_src_c120_3_11 conv_i_c120_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_11 (conv_q_src_c120_3_11 0 conv_bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_3_11 (conv_q_src_c120_3_11 conv_q_c120_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_12 (conv_i_src_c120_3_12 0 conv_bpf_c120_3 0) vcvs gain=1.950903220161e-01
SCONVI_c120_3_12 (conv_i_src_c120_3_12 conv_i_c120_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_12 (conv_q_src_c120_3_12 0 conv_bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c120_3_12 (conv_q_src_c120_3_12 conv_q_c120_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_13 (conv_i_src_c120_3_13 0 conv_bpf_c120_3 0) vcvs gain=5.555702330196e-01
SCONVI_c120_3_13 (conv_i_src_c120_3_13 conv_i_c120_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_13 (conv_q_src_c120_3_13 0 conv_bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c120_3_13 (conv_q_src_c120_3_13 conv_q_c120_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_14 (conv_i_src_c120_3_14 0 conv_bpf_c120_3 0) vcvs gain=8.314696123025e-01
SCONVI_c120_3_14 (conv_i_src_c120_3_14 conv_i_c120_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_14 (conv_q_src_c120_3_14 0 conv_bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c120_3_14 (conv_q_src_c120_3_14 conv_q_c120_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c120_3_15 (conv_i_src_c120_3_15 0 conv_bpf_c120_3 0) vcvs gain=9.807852804032e-01
SCONVI_c120_3_15 (conv_i_src_c120_3_15 conv_i_c120_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c120_3_15 (conv_q_src_c120_3_15 0 conv_bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c120_3_15 (conv_q_src_c120_3_15 conv_q_c120_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c120_3 (conv_i_c120_3 0) resistor r=1G
RCONVQ_c120_3 (conv_q_c120_3 0) resistor r=1G
RCONVINTI_c120_3 (conv_i_c120_3 ConvIcar_c120_3) resistor r=1k
CCONVINTI_c120_3 (ConvIcar_c120_3 0) capacitor c=80p
RCONVINTQ_c120_3 (conv_q_c120_3 ConvQcar_c120_3) resistor r=1k
CCONVINTQ_c120_3 (ConvQcar_c120_3 0) capacitor c=80p
save conv_bpf_c120_3 ConvIcar_c120_3 ConvQcar_c120_3

// conventional mixed baseline bl121, carrier_0: 250000000 Hz
CCONVBPF_c121_0 (bl121 n_conv_cbpf_c121_0) capacitor c=4.052847345694e-13
LCONVBPF_c121_0 (n_conv_cbpf_c121_0 conv_bpf_c121_0) inductor l=1.000000000000e-06
RCONVBPF_c121_0 (conv_bpf_c121_0 0) resistor r=7.853981633974e+01
ECONVI_c121_0_00 (conv_i_src_c121_0_00 0 conv_bpf_c121_0 0) vcvs gain=9.807852804032e-01
SCONVI_c121_0_00 (conv_i_src_c121_0_00 conv_i_c121_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_00 (conv_q_src_c121_0_00 0 conv_bpf_c121_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_0_00 (conv_q_src_c121_0_00 conv_q_c121_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_01 (conv_i_src_c121_0_01 0 conv_bpf_c121_0 0) vcvs gain=8.314696123025e-01
SCONVI_c121_0_01 (conv_i_src_c121_0_01 conv_i_c121_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_01 (conv_q_src_c121_0_01 0 conv_bpf_c121_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_0_01 (conv_q_src_c121_0_01 conv_q_c121_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_02 (conv_i_src_c121_0_02 0 conv_bpf_c121_0 0) vcvs gain=5.555702330196e-01
SCONVI_c121_0_02 (conv_i_src_c121_0_02 conv_i_c121_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_02 (conv_q_src_c121_0_02 0 conv_bpf_c121_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_0_02 (conv_q_src_c121_0_02 conv_q_c121_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_03 (conv_i_src_c121_0_03 0 conv_bpf_c121_0 0) vcvs gain=1.950903220161e-01
SCONVI_c121_0_03 (conv_i_src_c121_0_03 conv_i_c121_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_03 (conv_q_src_c121_0_03 0 conv_bpf_c121_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_0_03 (conv_q_src_c121_0_03 conv_q_c121_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_04 (conv_i_src_c121_0_04 0 conv_bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_0_04 (conv_i_src_c121_0_04 conv_i_c121_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_04 (conv_q_src_c121_0_04 0 conv_bpf_c121_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_0_04 (conv_q_src_c121_0_04 conv_q_c121_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_05 (conv_i_src_c121_0_05 0 conv_bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_0_05 (conv_i_src_c121_0_05 conv_i_c121_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_05 (conv_q_src_c121_0_05 0 conv_bpf_c121_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_0_05 (conv_q_src_c121_0_05 conv_q_c121_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_06 (conv_i_src_c121_0_06 0 conv_bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_0_06 (conv_i_src_c121_0_06 conv_i_c121_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_06 (conv_q_src_c121_0_06 0 conv_bpf_c121_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_0_06 (conv_q_src_c121_0_06 conv_q_c121_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_07 (conv_i_src_c121_0_07 0 conv_bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_0_07 (conv_i_src_c121_0_07 conv_i_c121_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_07 (conv_q_src_c121_0_07 0 conv_bpf_c121_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_0_07 (conv_q_src_c121_0_07 conv_q_c121_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_08 (conv_i_src_c121_0_08 0 conv_bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_0_08 (conv_i_src_c121_0_08 conv_i_c121_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_08 (conv_q_src_c121_0_08 0 conv_bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_0_08 (conv_q_src_c121_0_08 conv_q_c121_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_09 (conv_i_src_c121_0_09 0 conv_bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_0_09 (conv_i_src_c121_0_09 conv_i_c121_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_09 (conv_q_src_c121_0_09 0 conv_bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_0_09 (conv_q_src_c121_0_09 conv_q_c121_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_10 (conv_i_src_c121_0_10 0 conv_bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_0_10 (conv_i_src_c121_0_10 conv_i_c121_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_10 (conv_q_src_c121_0_10 0 conv_bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_0_10 (conv_q_src_c121_0_10 conv_q_c121_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_11 (conv_i_src_c121_0_11 0 conv_bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_0_11 (conv_i_src_c121_0_11 conv_i_c121_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_11 (conv_q_src_c121_0_11 0 conv_bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_0_11 (conv_q_src_c121_0_11 conv_q_c121_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_12 (conv_i_src_c121_0_12 0 conv_bpf_c121_0 0) vcvs gain=1.950903220161e-01
SCONVI_c121_0_12 (conv_i_src_c121_0_12 conv_i_c121_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_12 (conv_q_src_c121_0_12 0 conv_bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_0_12 (conv_q_src_c121_0_12 conv_q_c121_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_13 (conv_i_src_c121_0_13 0 conv_bpf_c121_0 0) vcvs gain=5.555702330196e-01
SCONVI_c121_0_13 (conv_i_src_c121_0_13 conv_i_c121_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_13 (conv_q_src_c121_0_13 0 conv_bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_0_13 (conv_q_src_c121_0_13 conv_q_c121_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_14 (conv_i_src_c121_0_14 0 conv_bpf_c121_0 0) vcvs gain=8.314696123025e-01
SCONVI_c121_0_14 (conv_i_src_c121_0_14 conv_i_c121_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_14 (conv_q_src_c121_0_14 0 conv_bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_0_14 (conv_q_src_c121_0_14 conv_q_c121_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_0_15 (conv_i_src_c121_0_15 0 conv_bpf_c121_0 0) vcvs gain=9.807852804032e-01
SCONVI_c121_0_15 (conv_i_src_c121_0_15 conv_i_c121_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_0_15 (conv_q_src_c121_0_15 0 conv_bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_0_15 (conv_q_src_c121_0_15 conv_q_c121_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c121_0 (conv_i_c121_0 0) resistor r=1G
RCONVQ_c121_0 (conv_q_c121_0 0) resistor r=1G
RCONVINTI_c121_0 (conv_i_c121_0 ConvIcar_c121_0) resistor r=1k
CCONVINTI_c121_0 (ConvIcar_c121_0 0) capacitor c=80p
RCONVINTQ_c121_0 (conv_q_c121_0 ConvQcar_c121_0) resistor r=1k
CCONVINTQ_c121_0 (ConvQcar_c121_0 0) capacitor c=80p
save conv_bpf_c121_0 ConvIcar_c121_0 ConvQcar_c121_0

// conventional mixed baseline bl121, carrier_1: 500000000 Hz
CCONVBPF_c121_1 (bl121 n_conv_cbpf_c121_1) capacitor c=1.013211836423e-13
LCONVBPF_c121_1 (n_conv_cbpf_c121_1 conv_bpf_c121_1) inductor l=1.000000000000e-06
RCONVBPF_c121_1 (conv_bpf_c121_1 0) resistor r=1.570796326795e+02
ECONVI_c121_1_00 (conv_i_src_c121_1_00 0 conv_bpf_c121_1 0) vcvs gain=9.807852804032e-01
SCONVI_c121_1_00 (conv_i_src_c121_1_00 conv_i_c121_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_00 (conv_q_src_c121_1_00 0 conv_bpf_c121_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_1_00 (conv_q_src_c121_1_00 conv_q_c121_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_01 (conv_i_src_c121_1_01 0 conv_bpf_c121_1 0) vcvs gain=8.314696123025e-01
SCONVI_c121_1_01 (conv_i_src_c121_1_01 conv_i_c121_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_01 (conv_q_src_c121_1_01 0 conv_bpf_c121_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_1_01 (conv_q_src_c121_1_01 conv_q_c121_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_02 (conv_i_src_c121_1_02 0 conv_bpf_c121_1 0) vcvs gain=5.555702330196e-01
SCONVI_c121_1_02 (conv_i_src_c121_1_02 conv_i_c121_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_02 (conv_q_src_c121_1_02 0 conv_bpf_c121_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_1_02 (conv_q_src_c121_1_02 conv_q_c121_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_03 (conv_i_src_c121_1_03 0 conv_bpf_c121_1 0) vcvs gain=1.950903220161e-01
SCONVI_c121_1_03 (conv_i_src_c121_1_03 conv_i_c121_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_03 (conv_q_src_c121_1_03 0 conv_bpf_c121_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_1_03 (conv_q_src_c121_1_03 conv_q_c121_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_04 (conv_i_src_c121_1_04 0 conv_bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_1_04 (conv_i_src_c121_1_04 conv_i_c121_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_04 (conv_q_src_c121_1_04 0 conv_bpf_c121_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_1_04 (conv_q_src_c121_1_04 conv_q_c121_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_05 (conv_i_src_c121_1_05 0 conv_bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_1_05 (conv_i_src_c121_1_05 conv_i_c121_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_05 (conv_q_src_c121_1_05 0 conv_bpf_c121_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_1_05 (conv_q_src_c121_1_05 conv_q_c121_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_06 (conv_i_src_c121_1_06 0 conv_bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_1_06 (conv_i_src_c121_1_06 conv_i_c121_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_06 (conv_q_src_c121_1_06 0 conv_bpf_c121_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_1_06 (conv_q_src_c121_1_06 conv_q_c121_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_07 (conv_i_src_c121_1_07 0 conv_bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_1_07 (conv_i_src_c121_1_07 conv_i_c121_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_07 (conv_q_src_c121_1_07 0 conv_bpf_c121_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_1_07 (conv_q_src_c121_1_07 conv_q_c121_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_08 (conv_i_src_c121_1_08 0 conv_bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_1_08 (conv_i_src_c121_1_08 conv_i_c121_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_08 (conv_q_src_c121_1_08 0 conv_bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_1_08 (conv_q_src_c121_1_08 conv_q_c121_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_09 (conv_i_src_c121_1_09 0 conv_bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_1_09 (conv_i_src_c121_1_09 conv_i_c121_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_09 (conv_q_src_c121_1_09 0 conv_bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_1_09 (conv_q_src_c121_1_09 conv_q_c121_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_10 (conv_i_src_c121_1_10 0 conv_bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_1_10 (conv_i_src_c121_1_10 conv_i_c121_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_10 (conv_q_src_c121_1_10 0 conv_bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_1_10 (conv_q_src_c121_1_10 conv_q_c121_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_11 (conv_i_src_c121_1_11 0 conv_bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_1_11 (conv_i_src_c121_1_11 conv_i_c121_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_11 (conv_q_src_c121_1_11 0 conv_bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_1_11 (conv_q_src_c121_1_11 conv_q_c121_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_12 (conv_i_src_c121_1_12 0 conv_bpf_c121_1 0) vcvs gain=1.950903220161e-01
SCONVI_c121_1_12 (conv_i_src_c121_1_12 conv_i_c121_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_12 (conv_q_src_c121_1_12 0 conv_bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_1_12 (conv_q_src_c121_1_12 conv_q_c121_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_13 (conv_i_src_c121_1_13 0 conv_bpf_c121_1 0) vcvs gain=5.555702330196e-01
SCONVI_c121_1_13 (conv_i_src_c121_1_13 conv_i_c121_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_13 (conv_q_src_c121_1_13 0 conv_bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_1_13 (conv_q_src_c121_1_13 conv_q_c121_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_14 (conv_i_src_c121_1_14 0 conv_bpf_c121_1 0) vcvs gain=8.314696123025e-01
SCONVI_c121_1_14 (conv_i_src_c121_1_14 conv_i_c121_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_14 (conv_q_src_c121_1_14 0 conv_bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_1_14 (conv_q_src_c121_1_14 conv_q_c121_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_1_15 (conv_i_src_c121_1_15 0 conv_bpf_c121_1 0) vcvs gain=9.807852804032e-01
SCONVI_c121_1_15 (conv_i_src_c121_1_15 conv_i_c121_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_1_15 (conv_q_src_c121_1_15 0 conv_bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_1_15 (conv_q_src_c121_1_15 conv_q_c121_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c121_1 (conv_i_c121_1 0) resistor r=1G
RCONVQ_c121_1 (conv_q_c121_1 0) resistor r=1G
RCONVINTI_c121_1 (conv_i_c121_1 ConvIcar_c121_1) resistor r=1k
CCONVINTI_c121_1 (ConvIcar_c121_1 0) capacitor c=80p
RCONVINTQ_c121_1 (conv_q_c121_1 ConvQcar_c121_1) resistor r=1k
CCONVINTQ_c121_1 (ConvQcar_c121_1 0) capacitor c=80p
save conv_bpf_c121_1 ConvIcar_c121_1 ConvQcar_c121_1

// conventional mixed baseline bl121, carrier_2: 750000000 Hz
CCONVBPF_c121_2 (bl121 n_conv_cbpf_c121_2) capacitor c=4.503163717437e-14
LCONVBPF_c121_2 (n_conv_cbpf_c121_2 conv_bpf_c121_2) inductor l=1.000000000000e-06
RCONVBPF_c121_2 (conv_bpf_c121_2 0) resistor r=2.356194490192e+02
ECONVI_c121_2_00 (conv_i_src_c121_2_00 0 conv_bpf_c121_2 0) vcvs gain=9.807852804032e-01
SCONVI_c121_2_00 (conv_i_src_c121_2_00 conv_i_c121_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_00 (conv_q_src_c121_2_00 0 conv_bpf_c121_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_2_00 (conv_q_src_c121_2_00 conv_q_c121_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_01 (conv_i_src_c121_2_01 0 conv_bpf_c121_2 0) vcvs gain=8.314696123025e-01
SCONVI_c121_2_01 (conv_i_src_c121_2_01 conv_i_c121_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_01 (conv_q_src_c121_2_01 0 conv_bpf_c121_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_2_01 (conv_q_src_c121_2_01 conv_q_c121_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_02 (conv_i_src_c121_2_02 0 conv_bpf_c121_2 0) vcvs gain=5.555702330196e-01
SCONVI_c121_2_02 (conv_i_src_c121_2_02 conv_i_c121_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_02 (conv_q_src_c121_2_02 0 conv_bpf_c121_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_2_02 (conv_q_src_c121_2_02 conv_q_c121_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_03 (conv_i_src_c121_2_03 0 conv_bpf_c121_2 0) vcvs gain=1.950903220161e-01
SCONVI_c121_2_03 (conv_i_src_c121_2_03 conv_i_c121_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_03 (conv_q_src_c121_2_03 0 conv_bpf_c121_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_2_03 (conv_q_src_c121_2_03 conv_q_c121_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_04 (conv_i_src_c121_2_04 0 conv_bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_2_04 (conv_i_src_c121_2_04 conv_i_c121_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_04 (conv_q_src_c121_2_04 0 conv_bpf_c121_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_2_04 (conv_q_src_c121_2_04 conv_q_c121_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_05 (conv_i_src_c121_2_05 0 conv_bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_2_05 (conv_i_src_c121_2_05 conv_i_c121_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_05 (conv_q_src_c121_2_05 0 conv_bpf_c121_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_2_05 (conv_q_src_c121_2_05 conv_q_c121_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_06 (conv_i_src_c121_2_06 0 conv_bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_2_06 (conv_i_src_c121_2_06 conv_i_c121_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_06 (conv_q_src_c121_2_06 0 conv_bpf_c121_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_2_06 (conv_q_src_c121_2_06 conv_q_c121_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_07 (conv_i_src_c121_2_07 0 conv_bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_2_07 (conv_i_src_c121_2_07 conv_i_c121_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_07 (conv_q_src_c121_2_07 0 conv_bpf_c121_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_2_07 (conv_q_src_c121_2_07 conv_q_c121_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_08 (conv_i_src_c121_2_08 0 conv_bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_2_08 (conv_i_src_c121_2_08 conv_i_c121_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_08 (conv_q_src_c121_2_08 0 conv_bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_2_08 (conv_q_src_c121_2_08 conv_q_c121_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_09 (conv_i_src_c121_2_09 0 conv_bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_2_09 (conv_i_src_c121_2_09 conv_i_c121_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_09 (conv_q_src_c121_2_09 0 conv_bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_2_09 (conv_q_src_c121_2_09 conv_q_c121_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_10 (conv_i_src_c121_2_10 0 conv_bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_2_10 (conv_i_src_c121_2_10 conv_i_c121_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_10 (conv_q_src_c121_2_10 0 conv_bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_2_10 (conv_q_src_c121_2_10 conv_q_c121_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_11 (conv_i_src_c121_2_11 0 conv_bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_2_11 (conv_i_src_c121_2_11 conv_i_c121_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_11 (conv_q_src_c121_2_11 0 conv_bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_2_11 (conv_q_src_c121_2_11 conv_q_c121_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_12 (conv_i_src_c121_2_12 0 conv_bpf_c121_2 0) vcvs gain=1.950903220161e-01
SCONVI_c121_2_12 (conv_i_src_c121_2_12 conv_i_c121_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_12 (conv_q_src_c121_2_12 0 conv_bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_2_12 (conv_q_src_c121_2_12 conv_q_c121_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_13 (conv_i_src_c121_2_13 0 conv_bpf_c121_2 0) vcvs gain=5.555702330196e-01
SCONVI_c121_2_13 (conv_i_src_c121_2_13 conv_i_c121_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_13 (conv_q_src_c121_2_13 0 conv_bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_2_13 (conv_q_src_c121_2_13 conv_q_c121_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_14 (conv_i_src_c121_2_14 0 conv_bpf_c121_2 0) vcvs gain=8.314696123025e-01
SCONVI_c121_2_14 (conv_i_src_c121_2_14 conv_i_c121_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_14 (conv_q_src_c121_2_14 0 conv_bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_2_14 (conv_q_src_c121_2_14 conv_q_c121_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_2_15 (conv_i_src_c121_2_15 0 conv_bpf_c121_2 0) vcvs gain=9.807852804032e-01
SCONVI_c121_2_15 (conv_i_src_c121_2_15 conv_i_c121_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_2_15 (conv_q_src_c121_2_15 0 conv_bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_2_15 (conv_q_src_c121_2_15 conv_q_c121_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c121_2 (conv_i_c121_2 0) resistor r=1G
RCONVQ_c121_2 (conv_q_c121_2 0) resistor r=1G
RCONVINTI_c121_2 (conv_i_c121_2 ConvIcar_c121_2) resistor r=1k
CCONVINTI_c121_2 (ConvIcar_c121_2 0) capacitor c=80p
RCONVINTQ_c121_2 (conv_q_c121_2 ConvQcar_c121_2) resistor r=1k
CCONVINTQ_c121_2 (ConvQcar_c121_2 0) capacitor c=80p
save conv_bpf_c121_2 ConvIcar_c121_2 ConvQcar_c121_2

// conventional mixed baseline bl121, carrier_3: 1000000000 Hz
CCONVBPF_c121_3 (bl121 n_conv_cbpf_c121_3) capacitor c=2.533029591058e-14
LCONVBPF_c121_3 (n_conv_cbpf_c121_3 conv_bpf_c121_3) inductor l=1.000000000000e-06
RCONVBPF_c121_3 (conv_bpf_c121_3 0) resistor r=3.141592653590e+02
ECONVI_c121_3_00 (conv_i_src_c121_3_00 0 conv_bpf_c121_3 0) vcvs gain=9.807852804032e-01
SCONVI_c121_3_00 (conv_i_src_c121_3_00 conv_i_c121_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_00 (conv_q_src_c121_3_00 0 conv_bpf_c121_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_3_00 (conv_q_src_c121_3_00 conv_q_c121_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_01 (conv_i_src_c121_3_01 0 conv_bpf_c121_3 0) vcvs gain=8.314696123025e-01
SCONVI_c121_3_01 (conv_i_src_c121_3_01 conv_i_c121_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_01 (conv_q_src_c121_3_01 0 conv_bpf_c121_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_3_01 (conv_q_src_c121_3_01 conv_q_c121_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_02 (conv_i_src_c121_3_02 0 conv_bpf_c121_3 0) vcvs gain=5.555702330196e-01
SCONVI_c121_3_02 (conv_i_src_c121_3_02 conv_i_c121_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_02 (conv_q_src_c121_3_02 0 conv_bpf_c121_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_3_02 (conv_q_src_c121_3_02 conv_q_c121_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_03 (conv_i_src_c121_3_03 0 conv_bpf_c121_3 0) vcvs gain=1.950903220161e-01
SCONVI_c121_3_03 (conv_i_src_c121_3_03 conv_i_c121_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_03 (conv_q_src_c121_3_03 0 conv_bpf_c121_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_3_03 (conv_q_src_c121_3_03 conv_q_c121_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_04 (conv_i_src_c121_3_04 0 conv_bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_3_04 (conv_i_src_c121_3_04 conv_i_c121_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_04 (conv_q_src_c121_3_04 0 conv_bpf_c121_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c121_3_04 (conv_q_src_c121_3_04 conv_q_c121_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_05 (conv_i_src_c121_3_05 0 conv_bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_3_05 (conv_i_src_c121_3_05 conv_i_c121_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_05 (conv_q_src_c121_3_05 0 conv_bpf_c121_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c121_3_05 (conv_q_src_c121_3_05 conv_q_c121_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_06 (conv_i_src_c121_3_06 0 conv_bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_3_06 (conv_i_src_c121_3_06 conv_i_c121_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_06 (conv_q_src_c121_3_06 0 conv_bpf_c121_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c121_3_06 (conv_q_src_c121_3_06 conv_q_c121_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_07 (conv_i_src_c121_3_07 0 conv_bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_3_07 (conv_i_src_c121_3_07 conv_i_c121_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_07 (conv_q_src_c121_3_07 0 conv_bpf_c121_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c121_3_07 (conv_q_src_c121_3_07 conv_q_c121_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_08 (conv_i_src_c121_3_08 0 conv_bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c121_3_08 (conv_i_src_c121_3_08 conv_i_c121_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_08 (conv_q_src_c121_3_08 0 conv_bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_3_08 (conv_q_src_c121_3_08 conv_q_c121_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_09 (conv_i_src_c121_3_09 0 conv_bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c121_3_09 (conv_i_src_c121_3_09 conv_i_c121_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_09 (conv_q_src_c121_3_09 0 conv_bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_3_09 (conv_q_src_c121_3_09 conv_q_c121_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_10 (conv_i_src_c121_3_10 0 conv_bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c121_3_10 (conv_i_src_c121_3_10 conv_i_c121_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_10 (conv_q_src_c121_3_10 0 conv_bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_3_10 (conv_q_src_c121_3_10 conv_q_c121_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_11 (conv_i_src_c121_3_11 0 conv_bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c121_3_11 (conv_i_src_c121_3_11 conv_i_c121_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_11 (conv_q_src_c121_3_11 0 conv_bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_3_11 (conv_q_src_c121_3_11 conv_q_c121_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_12 (conv_i_src_c121_3_12 0 conv_bpf_c121_3 0) vcvs gain=1.950903220161e-01
SCONVI_c121_3_12 (conv_i_src_c121_3_12 conv_i_c121_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_12 (conv_q_src_c121_3_12 0 conv_bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c121_3_12 (conv_q_src_c121_3_12 conv_q_c121_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_13 (conv_i_src_c121_3_13 0 conv_bpf_c121_3 0) vcvs gain=5.555702330196e-01
SCONVI_c121_3_13 (conv_i_src_c121_3_13 conv_i_c121_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_13 (conv_q_src_c121_3_13 0 conv_bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c121_3_13 (conv_q_src_c121_3_13 conv_q_c121_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_14 (conv_i_src_c121_3_14 0 conv_bpf_c121_3 0) vcvs gain=8.314696123025e-01
SCONVI_c121_3_14 (conv_i_src_c121_3_14 conv_i_c121_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_14 (conv_q_src_c121_3_14 0 conv_bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c121_3_14 (conv_q_src_c121_3_14 conv_q_c121_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c121_3_15 (conv_i_src_c121_3_15 0 conv_bpf_c121_3 0) vcvs gain=9.807852804032e-01
SCONVI_c121_3_15 (conv_i_src_c121_3_15 conv_i_c121_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c121_3_15 (conv_q_src_c121_3_15 0 conv_bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c121_3_15 (conv_q_src_c121_3_15 conv_q_c121_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c121_3 (conv_i_c121_3 0) resistor r=1G
RCONVQ_c121_3 (conv_q_c121_3 0) resistor r=1G
RCONVINTI_c121_3 (conv_i_c121_3 ConvIcar_c121_3) resistor r=1k
CCONVINTI_c121_3 (ConvIcar_c121_3 0) capacitor c=80p
RCONVINTQ_c121_3 (conv_q_c121_3 ConvQcar_c121_3) resistor r=1k
CCONVINTQ_c121_3 (ConvQcar_c121_3 0) capacitor c=80p
save conv_bpf_c121_3 ConvIcar_c121_3 ConvQcar_c121_3

// conventional mixed baseline bl122, carrier_0: 250000000 Hz
CCONVBPF_c122_0 (bl122 n_conv_cbpf_c122_0) capacitor c=4.052847345694e-13
LCONVBPF_c122_0 (n_conv_cbpf_c122_0 conv_bpf_c122_0) inductor l=1.000000000000e-06
RCONVBPF_c122_0 (conv_bpf_c122_0 0) resistor r=7.853981633974e+01
ECONVI_c122_0_00 (conv_i_src_c122_0_00 0 conv_bpf_c122_0 0) vcvs gain=9.807852804032e-01
SCONVI_c122_0_00 (conv_i_src_c122_0_00 conv_i_c122_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_00 (conv_q_src_c122_0_00 0 conv_bpf_c122_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_0_00 (conv_q_src_c122_0_00 conv_q_c122_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_01 (conv_i_src_c122_0_01 0 conv_bpf_c122_0 0) vcvs gain=8.314696123025e-01
SCONVI_c122_0_01 (conv_i_src_c122_0_01 conv_i_c122_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_01 (conv_q_src_c122_0_01 0 conv_bpf_c122_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_0_01 (conv_q_src_c122_0_01 conv_q_c122_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_02 (conv_i_src_c122_0_02 0 conv_bpf_c122_0 0) vcvs gain=5.555702330196e-01
SCONVI_c122_0_02 (conv_i_src_c122_0_02 conv_i_c122_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_02 (conv_q_src_c122_0_02 0 conv_bpf_c122_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_0_02 (conv_q_src_c122_0_02 conv_q_c122_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_03 (conv_i_src_c122_0_03 0 conv_bpf_c122_0 0) vcvs gain=1.950903220161e-01
SCONVI_c122_0_03 (conv_i_src_c122_0_03 conv_i_c122_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_03 (conv_q_src_c122_0_03 0 conv_bpf_c122_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_0_03 (conv_q_src_c122_0_03 conv_q_c122_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_04 (conv_i_src_c122_0_04 0 conv_bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_0_04 (conv_i_src_c122_0_04 conv_i_c122_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_04 (conv_q_src_c122_0_04 0 conv_bpf_c122_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_0_04 (conv_q_src_c122_0_04 conv_q_c122_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_05 (conv_i_src_c122_0_05 0 conv_bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_0_05 (conv_i_src_c122_0_05 conv_i_c122_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_05 (conv_q_src_c122_0_05 0 conv_bpf_c122_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_0_05 (conv_q_src_c122_0_05 conv_q_c122_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_06 (conv_i_src_c122_0_06 0 conv_bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_0_06 (conv_i_src_c122_0_06 conv_i_c122_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_06 (conv_q_src_c122_0_06 0 conv_bpf_c122_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_0_06 (conv_q_src_c122_0_06 conv_q_c122_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_07 (conv_i_src_c122_0_07 0 conv_bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_0_07 (conv_i_src_c122_0_07 conv_i_c122_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_07 (conv_q_src_c122_0_07 0 conv_bpf_c122_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_0_07 (conv_q_src_c122_0_07 conv_q_c122_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_08 (conv_i_src_c122_0_08 0 conv_bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_0_08 (conv_i_src_c122_0_08 conv_i_c122_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_08 (conv_q_src_c122_0_08 0 conv_bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_0_08 (conv_q_src_c122_0_08 conv_q_c122_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_09 (conv_i_src_c122_0_09 0 conv_bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_0_09 (conv_i_src_c122_0_09 conv_i_c122_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_09 (conv_q_src_c122_0_09 0 conv_bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_0_09 (conv_q_src_c122_0_09 conv_q_c122_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_10 (conv_i_src_c122_0_10 0 conv_bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_0_10 (conv_i_src_c122_0_10 conv_i_c122_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_10 (conv_q_src_c122_0_10 0 conv_bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_0_10 (conv_q_src_c122_0_10 conv_q_c122_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_11 (conv_i_src_c122_0_11 0 conv_bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_0_11 (conv_i_src_c122_0_11 conv_i_c122_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_11 (conv_q_src_c122_0_11 0 conv_bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_0_11 (conv_q_src_c122_0_11 conv_q_c122_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_12 (conv_i_src_c122_0_12 0 conv_bpf_c122_0 0) vcvs gain=1.950903220161e-01
SCONVI_c122_0_12 (conv_i_src_c122_0_12 conv_i_c122_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_12 (conv_q_src_c122_0_12 0 conv_bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_0_12 (conv_q_src_c122_0_12 conv_q_c122_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_13 (conv_i_src_c122_0_13 0 conv_bpf_c122_0 0) vcvs gain=5.555702330196e-01
SCONVI_c122_0_13 (conv_i_src_c122_0_13 conv_i_c122_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_13 (conv_q_src_c122_0_13 0 conv_bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_0_13 (conv_q_src_c122_0_13 conv_q_c122_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_14 (conv_i_src_c122_0_14 0 conv_bpf_c122_0 0) vcvs gain=8.314696123025e-01
SCONVI_c122_0_14 (conv_i_src_c122_0_14 conv_i_c122_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_14 (conv_q_src_c122_0_14 0 conv_bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_0_14 (conv_q_src_c122_0_14 conv_q_c122_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_0_15 (conv_i_src_c122_0_15 0 conv_bpf_c122_0 0) vcvs gain=9.807852804032e-01
SCONVI_c122_0_15 (conv_i_src_c122_0_15 conv_i_c122_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_0_15 (conv_q_src_c122_0_15 0 conv_bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_0_15 (conv_q_src_c122_0_15 conv_q_c122_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c122_0 (conv_i_c122_0 0) resistor r=1G
RCONVQ_c122_0 (conv_q_c122_0 0) resistor r=1G
RCONVINTI_c122_0 (conv_i_c122_0 ConvIcar_c122_0) resistor r=1k
CCONVINTI_c122_0 (ConvIcar_c122_0 0) capacitor c=80p
RCONVINTQ_c122_0 (conv_q_c122_0 ConvQcar_c122_0) resistor r=1k
CCONVINTQ_c122_0 (ConvQcar_c122_0 0) capacitor c=80p
save conv_bpf_c122_0 ConvIcar_c122_0 ConvQcar_c122_0

// conventional mixed baseline bl122, carrier_1: 500000000 Hz
CCONVBPF_c122_1 (bl122 n_conv_cbpf_c122_1) capacitor c=1.013211836423e-13
LCONVBPF_c122_1 (n_conv_cbpf_c122_1 conv_bpf_c122_1) inductor l=1.000000000000e-06
RCONVBPF_c122_1 (conv_bpf_c122_1 0) resistor r=1.570796326795e+02
ECONVI_c122_1_00 (conv_i_src_c122_1_00 0 conv_bpf_c122_1 0) vcvs gain=9.807852804032e-01
SCONVI_c122_1_00 (conv_i_src_c122_1_00 conv_i_c122_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_00 (conv_q_src_c122_1_00 0 conv_bpf_c122_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_1_00 (conv_q_src_c122_1_00 conv_q_c122_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_01 (conv_i_src_c122_1_01 0 conv_bpf_c122_1 0) vcvs gain=8.314696123025e-01
SCONVI_c122_1_01 (conv_i_src_c122_1_01 conv_i_c122_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_01 (conv_q_src_c122_1_01 0 conv_bpf_c122_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_1_01 (conv_q_src_c122_1_01 conv_q_c122_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_02 (conv_i_src_c122_1_02 0 conv_bpf_c122_1 0) vcvs gain=5.555702330196e-01
SCONVI_c122_1_02 (conv_i_src_c122_1_02 conv_i_c122_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_02 (conv_q_src_c122_1_02 0 conv_bpf_c122_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_1_02 (conv_q_src_c122_1_02 conv_q_c122_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_03 (conv_i_src_c122_1_03 0 conv_bpf_c122_1 0) vcvs gain=1.950903220161e-01
SCONVI_c122_1_03 (conv_i_src_c122_1_03 conv_i_c122_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_03 (conv_q_src_c122_1_03 0 conv_bpf_c122_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_1_03 (conv_q_src_c122_1_03 conv_q_c122_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_04 (conv_i_src_c122_1_04 0 conv_bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_1_04 (conv_i_src_c122_1_04 conv_i_c122_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_04 (conv_q_src_c122_1_04 0 conv_bpf_c122_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_1_04 (conv_q_src_c122_1_04 conv_q_c122_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_05 (conv_i_src_c122_1_05 0 conv_bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_1_05 (conv_i_src_c122_1_05 conv_i_c122_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_05 (conv_q_src_c122_1_05 0 conv_bpf_c122_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_1_05 (conv_q_src_c122_1_05 conv_q_c122_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_06 (conv_i_src_c122_1_06 0 conv_bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_1_06 (conv_i_src_c122_1_06 conv_i_c122_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_06 (conv_q_src_c122_1_06 0 conv_bpf_c122_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_1_06 (conv_q_src_c122_1_06 conv_q_c122_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_07 (conv_i_src_c122_1_07 0 conv_bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_1_07 (conv_i_src_c122_1_07 conv_i_c122_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_07 (conv_q_src_c122_1_07 0 conv_bpf_c122_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_1_07 (conv_q_src_c122_1_07 conv_q_c122_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_08 (conv_i_src_c122_1_08 0 conv_bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_1_08 (conv_i_src_c122_1_08 conv_i_c122_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_08 (conv_q_src_c122_1_08 0 conv_bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_1_08 (conv_q_src_c122_1_08 conv_q_c122_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_09 (conv_i_src_c122_1_09 0 conv_bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_1_09 (conv_i_src_c122_1_09 conv_i_c122_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_09 (conv_q_src_c122_1_09 0 conv_bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_1_09 (conv_q_src_c122_1_09 conv_q_c122_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_10 (conv_i_src_c122_1_10 0 conv_bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_1_10 (conv_i_src_c122_1_10 conv_i_c122_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_10 (conv_q_src_c122_1_10 0 conv_bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_1_10 (conv_q_src_c122_1_10 conv_q_c122_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_11 (conv_i_src_c122_1_11 0 conv_bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_1_11 (conv_i_src_c122_1_11 conv_i_c122_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_11 (conv_q_src_c122_1_11 0 conv_bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_1_11 (conv_q_src_c122_1_11 conv_q_c122_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_12 (conv_i_src_c122_1_12 0 conv_bpf_c122_1 0) vcvs gain=1.950903220161e-01
SCONVI_c122_1_12 (conv_i_src_c122_1_12 conv_i_c122_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_12 (conv_q_src_c122_1_12 0 conv_bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_1_12 (conv_q_src_c122_1_12 conv_q_c122_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_13 (conv_i_src_c122_1_13 0 conv_bpf_c122_1 0) vcvs gain=5.555702330196e-01
SCONVI_c122_1_13 (conv_i_src_c122_1_13 conv_i_c122_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_13 (conv_q_src_c122_1_13 0 conv_bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_1_13 (conv_q_src_c122_1_13 conv_q_c122_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_14 (conv_i_src_c122_1_14 0 conv_bpf_c122_1 0) vcvs gain=8.314696123025e-01
SCONVI_c122_1_14 (conv_i_src_c122_1_14 conv_i_c122_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_14 (conv_q_src_c122_1_14 0 conv_bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_1_14 (conv_q_src_c122_1_14 conv_q_c122_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_1_15 (conv_i_src_c122_1_15 0 conv_bpf_c122_1 0) vcvs gain=9.807852804032e-01
SCONVI_c122_1_15 (conv_i_src_c122_1_15 conv_i_c122_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_1_15 (conv_q_src_c122_1_15 0 conv_bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_1_15 (conv_q_src_c122_1_15 conv_q_c122_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c122_1 (conv_i_c122_1 0) resistor r=1G
RCONVQ_c122_1 (conv_q_c122_1 0) resistor r=1G
RCONVINTI_c122_1 (conv_i_c122_1 ConvIcar_c122_1) resistor r=1k
CCONVINTI_c122_1 (ConvIcar_c122_1 0) capacitor c=80p
RCONVINTQ_c122_1 (conv_q_c122_1 ConvQcar_c122_1) resistor r=1k
CCONVINTQ_c122_1 (ConvQcar_c122_1 0) capacitor c=80p
save conv_bpf_c122_1 ConvIcar_c122_1 ConvQcar_c122_1

// conventional mixed baseline bl122, carrier_2: 750000000 Hz
CCONVBPF_c122_2 (bl122 n_conv_cbpf_c122_2) capacitor c=4.503163717437e-14
LCONVBPF_c122_2 (n_conv_cbpf_c122_2 conv_bpf_c122_2) inductor l=1.000000000000e-06
RCONVBPF_c122_2 (conv_bpf_c122_2 0) resistor r=2.356194490192e+02
ECONVI_c122_2_00 (conv_i_src_c122_2_00 0 conv_bpf_c122_2 0) vcvs gain=9.807852804032e-01
SCONVI_c122_2_00 (conv_i_src_c122_2_00 conv_i_c122_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_00 (conv_q_src_c122_2_00 0 conv_bpf_c122_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_2_00 (conv_q_src_c122_2_00 conv_q_c122_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_01 (conv_i_src_c122_2_01 0 conv_bpf_c122_2 0) vcvs gain=8.314696123025e-01
SCONVI_c122_2_01 (conv_i_src_c122_2_01 conv_i_c122_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_01 (conv_q_src_c122_2_01 0 conv_bpf_c122_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_2_01 (conv_q_src_c122_2_01 conv_q_c122_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_02 (conv_i_src_c122_2_02 0 conv_bpf_c122_2 0) vcvs gain=5.555702330196e-01
SCONVI_c122_2_02 (conv_i_src_c122_2_02 conv_i_c122_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_02 (conv_q_src_c122_2_02 0 conv_bpf_c122_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_2_02 (conv_q_src_c122_2_02 conv_q_c122_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_03 (conv_i_src_c122_2_03 0 conv_bpf_c122_2 0) vcvs gain=1.950903220161e-01
SCONVI_c122_2_03 (conv_i_src_c122_2_03 conv_i_c122_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_03 (conv_q_src_c122_2_03 0 conv_bpf_c122_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_2_03 (conv_q_src_c122_2_03 conv_q_c122_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_04 (conv_i_src_c122_2_04 0 conv_bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_2_04 (conv_i_src_c122_2_04 conv_i_c122_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_04 (conv_q_src_c122_2_04 0 conv_bpf_c122_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_2_04 (conv_q_src_c122_2_04 conv_q_c122_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_05 (conv_i_src_c122_2_05 0 conv_bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_2_05 (conv_i_src_c122_2_05 conv_i_c122_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_05 (conv_q_src_c122_2_05 0 conv_bpf_c122_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_2_05 (conv_q_src_c122_2_05 conv_q_c122_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_06 (conv_i_src_c122_2_06 0 conv_bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_2_06 (conv_i_src_c122_2_06 conv_i_c122_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_06 (conv_q_src_c122_2_06 0 conv_bpf_c122_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_2_06 (conv_q_src_c122_2_06 conv_q_c122_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_07 (conv_i_src_c122_2_07 0 conv_bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_2_07 (conv_i_src_c122_2_07 conv_i_c122_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_07 (conv_q_src_c122_2_07 0 conv_bpf_c122_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_2_07 (conv_q_src_c122_2_07 conv_q_c122_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_08 (conv_i_src_c122_2_08 0 conv_bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_2_08 (conv_i_src_c122_2_08 conv_i_c122_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_08 (conv_q_src_c122_2_08 0 conv_bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_2_08 (conv_q_src_c122_2_08 conv_q_c122_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_09 (conv_i_src_c122_2_09 0 conv_bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_2_09 (conv_i_src_c122_2_09 conv_i_c122_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_09 (conv_q_src_c122_2_09 0 conv_bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_2_09 (conv_q_src_c122_2_09 conv_q_c122_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_10 (conv_i_src_c122_2_10 0 conv_bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_2_10 (conv_i_src_c122_2_10 conv_i_c122_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_10 (conv_q_src_c122_2_10 0 conv_bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_2_10 (conv_q_src_c122_2_10 conv_q_c122_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_11 (conv_i_src_c122_2_11 0 conv_bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_2_11 (conv_i_src_c122_2_11 conv_i_c122_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_11 (conv_q_src_c122_2_11 0 conv_bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_2_11 (conv_q_src_c122_2_11 conv_q_c122_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_12 (conv_i_src_c122_2_12 0 conv_bpf_c122_2 0) vcvs gain=1.950903220161e-01
SCONVI_c122_2_12 (conv_i_src_c122_2_12 conv_i_c122_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_12 (conv_q_src_c122_2_12 0 conv_bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_2_12 (conv_q_src_c122_2_12 conv_q_c122_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_13 (conv_i_src_c122_2_13 0 conv_bpf_c122_2 0) vcvs gain=5.555702330196e-01
SCONVI_c122_2_13 (conv_i_src_c122_2_13 conv_i_c122_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_13 (conv_q_src_c122_2_13 0 conv_bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_2_13 (conv_q_src_c122_2_13 conv_q_c122_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_14 (conv_i_src_c122_2_14 0 conv_bpf_c122_2 0) vcvs gain=8.314696123025e-01
SCONVI_c122_2_14 (conv_i_src_c122_2_14 conv_i_c122_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_14 (conv_q_src_c122_2_14 0 conv_bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_2_14 (conv_q_src_c122_2_14 conv_q_c122_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_2_15 (conv_i_src_c122_2_15 0 conv_bpf_c122_2 0) vcvs gain=9.807852804032e-01
SCONVI_c122_2_15 (conv_i_src_c122_2_15 conv_i_c122_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_2_15 (conv_q_src_c122_2_15 0 conv_bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_2_15 (conv_q_src_c122_2_15 conv_q_c122_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c122_2 (conv_i_c122_2 0) resistor r=1G
RCONVQ_c122_2 (conv_q_c122_2 0) resistor r=1G
RCONVINTI_c122_2 (conv_i_c122_2 ConvIcar_c122_2) resistor r=1k
CCONVINTI_c122_2 (ConvIcar_c122_2 0) capacitor c=80p
RCONVINTQ_c122_2 (conv_q_c122_2 ConvQcar_c122_2) resistor r=1k
CCONVINTQ_c122_2 (ConvQcar_c122_2 0) capacitor c=80p
save conv_bpf_c122_2 ConvIcar_c122_2 ConvQcar_c122_2

// conventional mixed baseline bl122, carrier_3: 1000000000 Hz
CCONVBPF_c122_3 (bl122 n_conv_cbpf_c122_3) capacitor c=2.533029591058e-14
LCONVBPF_c122_3 (n_conv_cbpf_c122_3 conv_bpf_c122_3) inductor l=1.000000000000e-06
RCONVBPF_c122_3 (conv_bpf_c122_3 0) resistor r=3.141592653590e+02
ECONVI_c122_3_00 (conv_i_src_c122_3_00 0 conv_bpf_c122_3 0) vcvs gain=9.807852804032e-01
SCONVI_c122_3_00 (conv_i_src_c122_3_00 conv_i_c122_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_00 (conv_q_src_c122_3_00 0 conv_bpf_c122_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_3_00 (conv_q_src_c122_3_00 conv_q_c122_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_01 (conv_i_src_c122_3_01 0 conv_bpf_c122_3 0) vcvs gain=8.314696123025e-01
SCONVI_c122_3_01 (conv_i_src_c122_3_01 conv_i_c122_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_01 (conv_q_src_c122_3_01 0 conv_bpf_c122_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_3_01 (conv_q_src_c122_3_01 conv_q_c122_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_02 (conv_i_src_c122_3_02 0 conv_bpf_c122_3 0) vcvs gain=5.555702330196e-01
SCONVI_c122_3_02 (conv_i_src_c122_3_02 conv_i_c122_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_02 (conv_q_src_c122_3_02 0 conv_bpf_c122_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_3_02 (conv_q_src_c122_3_02 conv_q_c122_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_03 (conv_i_src_c122_3_03 0 conv_bpf_c122_3 0) vcvs gain=1.950903220161e-01
SCONVI_c122_3_03 (conv_i_src_c122_3_03 conv_i_c122_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_03 (conv_q_src_c122_3_03 0 conv_bpf_c122_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_3_03 (conv_q_src_c122_3_03 conv_q_c122_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_04 (conv_i_src_c122_3_04 0 conv_bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_3_04 (conv_i_src_c122_3_04 conv_i_c122_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_04 (conv_q_src_c122_3_04 0 conv_bpf_c122_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c122_3_04 (conv_q_src_c122_3_04 conv_q_c122_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_05 (conv_i_src_c122_3_05 0 conv_bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_3_05 (conv_i_src_c122_3_05 conv_i_c122_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_05 (conv_q_src_c122_3_05 0 conv_bpf_c122_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c122_3_05 (conv_q_src_c122_3_05 conv_q_c122_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_06 (conv_i_src_c122_3_06 0 conv_bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_3_06 (conv_i_src_c122_3_06 conv_i_c122_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_06 (conv_q_src_c122_3_06 0 conv_bpf_c122_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c122_3_06 (conv_q_src_c122_3_06 conv_q_c122_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_07 (conv_i_src_c122_3_07 0 conv_bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_3_07 (conv_i_src_c122_3_07 conv_i_c122_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_07 (conv_q_src_c122_3_07 0 conv_bpf_c122_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c122_3_07 (conv_q_src_c122_3_07 conv_q_c122_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_08 (conv_i_src_c122_3_08 0 conv_bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c122_3_08 (conv_i_src_c122_3_08 conv_i_c122_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_08 (conv_q_src_c122_3_08 0 conv_bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_3_08 (conv_q_src_c122_3_08 conv_q_c122_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_09 (conv_i_src_c122_3_09 0 conv_bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c122_3_09 (conv_i_src_c122_3_09 conv_i_c122_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_09 (conv_q_src_c122_3_09 0 conv_bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_3_09 (conv_q_src_c122_3_09 conv_q_c122_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_10 (conv_i_src_c122_3_10 0 conv_bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c122_3_10 (conv_i_src_c122_3_10 conv_i_c122_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_10 (conv_q_src_c122_3_10 0 conv_bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_3_10 (conv_q_src_c122_3_10 conv_q_c122_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_11 (conv_i_src_c122_3_11 0 conv_bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c122_3_11 (conv_i_src_c122_3_11 conv_i_c122_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_11 (conv_q_src_c122_3_11 0 conv_bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_3_11 (conv_q_src_c122_3_11 conv_q_c122_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_12 (conv_i_src_c122_3_12 0 conv_bpf_c122_3 0) vcvs gain=1.950903220161e-01
SCONVI_c122_3_12 (conv_i_src_c122_3_12 conv_i_c122_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_12 (conv_q_src_c122_3_12 0 conv_bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c122_3_12 (conv_q_src_c122_3_12 conv_q_c122_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_13 (conv_i_src_c122_3_13 0 conv_bpf_c122_3 0) vcvs gain=5.555702330196e-01
SCONVI_c122_3_13 (conv_i_src_c122_3_13 conv_i_c122_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_13 (conv_q_src_c122_3_13 0 conv_bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c122_3_13 (conv_q_src_c122_3_13 conv_q_c122_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_14 (conv_i_src_c122_3_14 0 conv_bpf_c122_3 0) vcvs gain=8.314696123025e-01
SCONVI_c122_3_14 (conv_i_src_c122_3_14 conv_i_c122_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_14 (conv_q_src_c122_3_14 0 conv_bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c122_3_14 (conv_q_src_c122_3_14 conv_q_c122_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c122_3_15 (conv_i_src_c122_3_15 0 conv_bpf_c122_3 0) vcvs gain=9.807852804032e-01
SCONVI_c122_3_15 (conv_i_src_c122_3_15 conv_i_c122_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c122_3_15 (conv_q_src_c122_3_15 0 conv_bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c122_3_15 (conv_q_src_c122_3_15 conv_q_c122_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c122_3 (conv_i_c122_3 0) resistor r=1G
RCONVQ_c122_3 (conv_q_c122_3 0) resistor r=1G
RCONVINTI_c122_3 (conv_i_c122_3 ConvIcar_c122_3) resistor r=1k
CCONVINTI_c122_3 (ConvIcar_c122_3 0) capacitor c=80p
RCONVINTQ_c122_3 (conv_q_c122_3 ConvQcar_c122_3) resistor r=1k
CCONVINTQ_c122_3 (ConvQcar_c122_3 0) capacitor c=80p
save conv_bpf_c122_3 ConvIcar_c122_3 ConvQcar_c122_3

// conventional mixed baseline bl123, carrier_0: 250000000 Hz
CCONVBPF_c123_0 (bl123 n_conv_cbpf_c123_0) capacitor c=4.052847345694e-13
LCONVBPF_c123_0 (n_conv_cbpf_c123_0 conv_bpf_c123_0) inductor l=1.000000000000e-06
RCONVBPF_c123_0 (conv_bpf_c123_0 0) resistor r=7.853981633974e+01
ECONVI_c123_0_00 (conv_i_src_c123_0_00 0 conv_bpf_c123_0 0) vcvs gain=9.807852804032e-01
SCONVI_c123_0_00 (conv_i_src_c123_0_00 conv_i_c123_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_00 (conv_q_src_c123_0_00 0 conv_bpf_c123_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_0_00 (conv_q_src_c123_0_00 conv_q_c123_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_01 (conv_i_src_c123_0_01 0 conv_bpf_c123_0 0) vcvs gain=8.314696123025e-01
SCONVI_c123_0_01 (conv_i_src_c123_0_01 conv_i_c123_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_01 (conv_q_src_c123_0_01 0 conv_bpf_c123_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_0_01 (conv_q_src_c123_0_01 conv_q_c123_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_02 (conv_i_src_c123_0_02 0 conv_bpf_c123_0 0) vcvs gain=5.555702330196e-01
SCONVI_c123_0_02 (conv_i_src_c123_0_02 conv_i_c123_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_02 (conv_q_src_c123_0_02 0 conv_bpf_c123_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_0_02 (conv_q_src_c123_0_02 conv_q_c123_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_03 (conv_i_src_c123_0_03 0 conv_bpf_c123_0 0) vcvs gain=1.950903220161e-01
SCONVI_c123_0_03 (conv_i_src_c123_0_03 conv_i_c123_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_03 (conv_q_src_c123_0_03 0 conv_bpf_c123_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_0_03 (conv_q_src_c123_0_03 conv_q_c123_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_04 (conv_i_src_c123_0_04 0 conv_bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_0_04 (conv_i_src_c123_0_04 conv_i_c123_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_04 (conv_q_src_c123_0_04 0 conv_bpf_c123_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_0_04 (conv_q_src_c123_0_04 conv_q_c123_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_05 (conv_i_src_c123_0_05 0 conv_bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_0_05 (conv_i_src_c123_0_05 conv_i_c123_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_05 (conv_q_src_c123_0_05 0 conv_bpf_c123_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_0_05 (conv_q_src_c123_0_05 conv_q_c123_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_06 (conv_i_src_c123_0_06 0 conv_bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_0_06 (conv_i_src_c123_0_06 conv_i_c123_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_06 (conv_q_src_c123_0_06 0 conv_bpf_c123_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_0_06 (conv_q_src_c123_0_06 conv_q_c123_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_07 (conv_i_src_c123_0_07 0 conv_bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_0_07 (conv_i_src_c123_0_07 conv_i_c123_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_07 (conv_q_src_c123_0_07 0 conv_bpf_c123_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_0_07 (conv_q_src_c123_0_07 conv_q_c123_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_08 (conv_i_src_c123_0_08 0 conv_bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_0_08 (conv_i_src_c123_0_08 conv_i_c123_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_08 (conv_q_src_c123_0_08 0 conv_bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_0_08 (conv_q_src_c123_0_08 conv_q_c123_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_09 (conv_i_src_c123_0_09 0 conv_bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_0_09 (conv_i_src_c123_0_09 conv_i_c123_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_09 (conv_q_src_c123_0_09 0 conv_bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_0_09 (conv_q_src_c123_0_09 conv_q_c123_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_10 (conv_i_src_c123_0_10 0 conv_bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_0_10 (conv_i_src_c123_0_10 conv_i_c123_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_10 (conv_q_src_c123_0_10 0 conv_bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_0_10 (conv_q_src_c123_0_10 conv_q_c123_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_11 (conv_i_src_c123_0_11 0 conv_bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_0_11 (conv_i_src_c123_0_11 conv_i_c123_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_11 (conv_q_src_c123_0_11 0 conv_bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_0_11 (conv_q_src_c123_0_11 conv_q_c123_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_12 (conv_i_src_c123_0_12 0 conv_bpf_c123_0 0) vcvs gain=1.950903220161e-01
SCONVI_c123_0_12 (conv_i_src_c123_0_12 conv_i_c123_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_12 (conv_q_src_c123_0_12 0 conv_bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_0_12 (conv_q_src_c123_0_12 conv_q_c123_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_13 (conv_i_src_c123_0_13 0 conv_bpf_c123_0 0) vcvs gain=5.555702330196e-01
SCONVI_c123_0_13 (conv_i_src_c123_0_13 conv_i_c123_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_13 (conv_q_src_c123_0_13 0 conv_bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_0_13 (conv_q_src_c123_0_13 conv_q_c123_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_14 (conv_i_src_c123_0_14 0 conv_bpf_c123_0 0) vcvs gain=8.314696123025e-01
SCONVI_c123_0_14 (conv_i_src_c123_0_14 conv_i_c123_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_14 (conv_q_src_c123_0_14 0 conv_bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_0_14 (conv_q_src_c123_0_14 conv_q_c123_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_0_15 (conv_i_src_c123_0_15 0 conv_bpf_c123_0 0) vcvs gain=9.807852804032e-01
SCONVI_c123_0_15 (conv_i_src_c123_0_15 conv_i_c123_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_0_15 (conv_q_src_c123_0_15 0 conv_bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_0_15 (conv_q_src_c123_0_15 conv_q_c123_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c123_0 (conv_i_c123_0 0) resistor r=1G
RCONVQ_c123_0 (conv_q_c123_0 0) resistor r=1G
RCONVINTI_c123_0 (conv_i_c123_0 ConvIcar_c123_0) resistor r=1k
CCONVINTI_c123_0 (ConvIcar_c123_0 0) capacitor c=80p
RCONVINTQ_c123_0 (conv_q_c123_0 ConvQcar_c123_0) resistor r=1k
CCONVINTQ_c123_0 (ConvQcar_c123_0 0) capacitor c=80p
save conv_bpf_c123_0 ConvIcar_c123_0 ConvQcar_c123_0

// conventional mixed baseline bl123, carrier_1: 500000000 Hz
CCONVBPF_c123_1 (bl123 n_conv_cbpf_c123_1) capacitor c=1.013211836423e-13
LCONVBPF_c123_1 (n_conv_cbpf_c123_1 conv_bpf_c123_1) inductor l=1.000000000000e-06
RCONVBPF_c123_1 (conv_bpf_c123_1 0) resistor r=1.570796326795e+02
ECONVI_c123_1_00 (conv_i_src_c123_1_00 0 conv_bpf_c123_1 0) vcvs gain=9.807852804032e-01
SCONVI_c123_1_00 (conv_i_src_c123_1_00 conv_i_c123_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_00 (conv_q_src_c123_1_00 0 conv_bpf_c123_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_1_00 (conv_q_src_c123_1_00 conv_q_c123_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_01 (conv_i_src_c123_1_01 0 conv_bpf_c123_1 0) vcvs gain=8.314696123025e-01
SCONVI_c123_1_01 (conv_i_src_c123_1_01 conv_i_c123_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_01 (conv_q_src_c123_1_01 0 conv_bpf_c123_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_1_01 (conv_q_src_c123_1_01 conv_q_c123_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_02 (conv_i_src_c123_1_02 0 conv_bpf_c123_1 0) vcvs gain=5.555702330196e-01
SCONVI_c123_1_02 (conv_i_src_c123_1_02 conv_i_c123_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_02 (conv_q_src_c123_1_02 0 conv_bpf_c123_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_1_02 (conv_q_src_c123_1_02 conv_q_c123_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_03 (conv_i_src_c123_1_03 0 conv_bpf_c123_1 0) vcvs gain=1.950903220161e-01
SCONVI_c123_1_03 (conv_i_src_c123_1_03 conv_i_c123_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_03 (conv_q_src_c123_1_03 0 conv_bpf_c123_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_1_03 (conv_q_src_c123_1_03 conv_q_c123_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_04 (conv_i_src_c123_1_04 0 conv_bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_1_04 (conv_i_src_c123_1_04 conv_i_c123_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_04 (conv_q_src_c123_1_04 0 conv_bpf_c123_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_1_04 (conv_q_src_c123_1_04 conv_q_c123_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_05 (conv_i_src_c123_1_05 0 conv_bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_1_05 (conv_i_src_c123_1_05 conv_i_c123_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_05 (conv_q_src_c123_1_05 0 conv_bpf_c123_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_1_05 (conv_q_src_c123_1_05 conv_q_c123_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_06 (conv_i_src_c123_1_06 0 conv_bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_1_06 (conv_i_src_c123_1_06 conv_i_c123_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_06 (conv_q_src_c123_1_06 0 conv_bpf_c123_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_1_06 (conv_q_src_c123_1_06 conv_q_c123_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_07 (conv_i_src_c123_1_07 0 conv_bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_1_07 (conv_i_src_c123_1_07 conv_i_c123_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_07 (conv_q_src_c123_1_07 0 conv_bpf_c123_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_1_07 (conv_q_src_c123_1_07 conv_q_c123_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_08 (conv_i_src_c123_1_08 0 conv_bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_1_08 (conv_i_src_c123_1_08 conv_i_c123_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_08 (conv_q_src_c123_1_08 0 conv_bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_1_08 (conv_q_src_c123_1_08 conv_q_c123_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_09 (conv_i_src_c123_1_09 0 conv_bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_1_09 (conv_i_src_c123_1_09 conv_i_c123_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_09 (conv_q_src_c123_1_09 0 conv_bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_1_09 (conv_q_src_c123_1_09 conv_q_c123_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_10 (conv_i_src_c123_1_10 0 conv_bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_1_10 (conv_i_src_c123_1_10 conv_i_c123_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_10 (conv_q_src_c123_1_10 0 conv_bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_1_10 (conv_q_src_c123_1_10 conv_q_c123_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_11 (conv_i_src_c123_1_11 0 conv_bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_1_11 (conv_i_src_c123_1_11 conv_i_c123_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_11 (conv_q_src_c123_1_11 0 conv_bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_1_11 (conv_q_src_c123_1_11 conv_q_c123_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_12 (conv_i_src_c123_1_12 0 conv_bpf_c123_1 0) vcvs gain=1.950903220161e-01
SCONVI_c123_1_12 (conv_i_src_c123_1_12 conv_i_c123_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_12 (conv_q_src_c123_1_12 0 conv_bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_1_12 (conv_q_src_c123_1_12 conv_q_c123_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_13 (conv_i_src_c123_1_13 0 conv_bpf_c123_1 0) vcvs gain=5.555702330196e-01
SCONVI_c123_1_13 (conv_i_src_c123_1_13 conv_i_c123_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_13 (conv_q_src_c123_1_13 0 conv_bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_1_13 (conv_q_src_c123_1_13 conv_q_c123_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_14 (conv_i_src_c123_1_14 0 conv_bpf_c123_1 0) vcvs gain=8.314696123025e-01
SCONVI_c123_1_14 (conv_i_src_c123_1_14 conv_i_c123_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_14 (conv_q_src_c123_1_14 0 conv_bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_1_14 (conv_q_src_c123_1_14 conv_q_c123_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_1_15 (conv_i_src_c123_1_15 0 conv_bpf_c123_1 0) vcvs gain=9.807852804032e-01
SCONVI_c123_1_15 (conv_i_src_c123_1_15 conv_i_c123_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_1_15 (conv_q_src_c123_1_15 0 conv_bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_1_15 (conv_q_src_c123_1_15 conv_q_c123_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c123_1 (conv_i_c123_1 0) resistor r=1G
RCONVQ_c123_1 (conv_q_c123_1 0) resistor r=1G
RCONVINTI_c123_1 (conv_i_c123_1 ConvIcar_c123_1) resistor r=1k
CCONVINTI_c123_1 (ConvIcar_c123_1 0) capacitor c=80p
RCONVINTQ_c123_1 (conv_q_c123_1 ConvQcar_c123_1) resistor r=1k
CCONVINTQ_c123_1 (ConvQcar_c123_1 0) capacitor c=80p
save conv_bpf_c123_1 ConvIcar_c123_1 ConvQcar_c123_1

// conventional mixed baseline bl123, carrier_2: 750000000 Hz
CCONVBPF_c123_2 (bl123 n_conv_cbpf_c123_2) capacitor c=4.503163717437e-14
LCONVBPF_c123_2 (n_conv_cbpf_c123_2 conv_bpf_c123_2) inductor l=1.000000000000e-06
RCONVBPF_c123_2 (conv_bpf_c123_2 0) resistor r=2.356194490192e+02
ECONVI_c123_2_00 (conv_i_src_c123_2_00 0 conv_bpf_c123_2 0) vcvs gain=9.807852804032e-01
SCONVI_c123_2_00 (conv_i_src_c123_2_00 conv_i_c123_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_00 (conv_q_src_c123_2_00 0 conv_bpf_c123_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_2_00 (conv_q_src_c123_2_00 conv_q_c123_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_01 (conv_i_src_c123_2_01 0 conv_bpf_c123_2 0) vcvs gain=8.314696123025e-01
SCONVI_c123_2_01 (conv_i_src_c123_2_01 conv_i_c123_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_01 (conv_q_src_c123_2_01 0 conv_bpf_c123_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_2_01 (conv_q_src_c123_2_01 conv_q_c123_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_02 (conv_i_src_c123_2_02 0 conv_bpf_c123_2 0) vcvs gain=5.555702330196e-01
SCONVI_c123_2_02 (conv_i_src_c123_2_02 conv_i_c123_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_02 (conv_q_src_c123_2_02 0 conv_bpf_c123_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_2_02 (conv_q_src_c123_2_02 conv_q_c123_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_03 (conv_i_src_c123_2_03 0 conv_bpf_c123_2 0) vcvs gain=1.950903220161e-01
SCONVI_c123_2_03 (conv_i_src_c123_2_03 conv_i_c123_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_03 (conv_q_src_c123_2_03 0 conv_bpf_c123_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_2_03 (conv_q_src_c123_2_03 conv_q_c123_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_04 (conv_i_src_c123_2_04 0 conv_bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_2_04 (conv_i_src_c123_2_04 conv_i_c123_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_04 (conv_q_src_c123_2_04 0 conv_bpf_c123_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_2_04 (conv_q_src_c123_2_04 conv_q_c123_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_05 (conv_i_src_c123_2_05 0 conv_bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_2_05 (conv_i_src_c123_2_05 conv_i_c123_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_05 (conv_q_src_c123_2_05 0 conv_bpf_c123_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_2_05 (conv_q_src_c123_2_05 conv_q_c123_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_06 (conv_i_src_c123_2_06 0 conv_bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_2_06 (conv_i_src_c123_2_06 conv_i_c123_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_06 (conv_q_src_c123_2_06 0 conv_bpf_c123_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_2_06 (conv_q_src_c123_2_06 conv_q_c123_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_07 (conv_i_src_c123_2_07 0 conv_bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_2_07 (conv_i_src_c123_2_07 conv_i_c123_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_07 (conv_q_src_c123_2_07 0 conv_bpf_c123_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_2_07 (conv_q_src_c123_2_07 conv_q_c123_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_08 (conv_i_src_c123_2_08 0 conv_bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_2_08 (conv_i_src_c123_2_08 conv_i_c123_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_08 (conv_q_src_c123_2_08 0 conv_bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_2_08 (conv_q_src_c123_2_08 conv_q_c123_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_09 (conv_i_src_c123_2_09 0 conv_bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_2_09 (conv_i_src_c123_2_09 conv_i_c123_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_09 (conv_q_src_c123_2_09 0 conv_bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_2_09 (conv_q_src_c123_2_09 conv_q_c123_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_10 (conv_i_src_c123_2_10 0 conv_bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_2_10 (conv_i_src_c123_2_10 conv_i_c123_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_10 (conv_q_src_c123_2_10 0 conv_bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_2_10 (conv_q_src_c123_2_10 conv_q_c123_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_11 (conv_i_src_c123_2_11 0 conv_bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_2_11 (conv_i_src_c123_2_11 conv_i_c123_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_11 (conv_q_src_c123_2_11 0 conv_bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_2_11 (conv_q_src_c123_2_11 conv_q_c123_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_12 (conv_i_src_c123_2_12 0 conv_bpf_c123_2 0) vcvs gain=1.950903220161e-01
SCONVI_c123_2_12 (conv_i_src_c123_2_12 conv_i_c123_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_12 (conv_q_src_c123_2_12 0 conv_bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_2_12 (conv_q_src_c123_2_12 conv_q_c123_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_13 (conv_i_src_c123_2_13 0 conv_bpf_c123_2 0) vcvs gain=5.555702330196e-01
SCONVI_c123_2_13 (conv_i_src_c123_2_13 conv_i_c123_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_13 (conv_q_src_c123_2_13 0 conv_bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_2_13 (conv_q_src_c123_2_13 conv_q_c123_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_14 (conv_i_src_c123_2_14 0 conv_bpf_c123_2 0) vcvs gain=8.314696123025e-01
SCONVI_c123_2_14 (conv_i_src_c123_2_14 conv_i_c123_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_14 (conv_q_src_c123_2_14 0 conv_bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_2_14 (conv_q_src_c123_2_14 conv_q_c123_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_2_15 (conv_i_src_c123_2_15 0 conv_bpf_c123_2 0) vcvs gain=9.807852804032e-01
SCONVI_c123_2_15 (conv_i_src_c123_2_15 conv_i_c123_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_2_15 (conv_q_src_c123_2_15 0 conv_bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_2_15 (conv_q_src_c123_2_15 conv_q_c123_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c123_2 (conv_i_c123_2 0) resistor r=1G
RCONVQ_c123_2 (conv_q_c123_2 0) resistor r=1G
RCONVINTI_c123_2 (conv_i_c123_2 ConvIcar_c123_2) resistor r=1k
CCONVINTI_c123_2 (ConvIcar_c123_2 0) capacitor c=80p
RCONVINTQ_c123_2 (conv_q_c123_2 ConvQcar_c123_2) resistor r=1k
CCONVINTQ_c123_2 (ConvQcar_c123_2 0) capacitor c=80p
save conv_bpf_c123_2 ConvIcar_c123_2 ConvQcar_c123_2

// conventional mixed baseline bl123, carrier_3: 1000000000 Hz
CCONVBPF_c123_3 (bl123 n_conv_cbpf_c123_3) capacitor c=2.533029591058e-14
LCONVBPF_c123_3 (n_conv_cbpf_c123_3 conv_bpf_c123_3) inductor l=1.000000000000e-06
RCONVBPF_c123_3 (conv_bpf_c123_3 0) resistor r=3.141592653590e+02
ECONVI_c123_3_00 (conv_i_src_c123_3_00 0 conv_bpf_c123_3 0) vcvs gain=9.807852804032e-01
SCONVI_c123_3_00 (conv_i_src_c123_3_00 conv_i_c123_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_00 (conv_q_src_c123_3_00 0 conv_bpf_c123_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_3_00 (conv_q_src_c123_3_00 conv_q_c123_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_01 (conv_i_src_c123_3_01 0 conv_bpf_c123_3 0) vcvs gain=8.314696123025e-01
SCONVI_c123_3_01 (conv_i_src_c123_3_01 conv_i_c123_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_01 (conv_q_src_c123_3_01 0 conv_bpf_c123_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_3_01 (conv_q_src_c123_3_01 conv_q_c123_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_02 (conv_i_src_c123_3_02 0 conv_bpf_c123_3 0) vcvs gain=5.555702330196e-01
SCONVI_c123_3_02 (conv_i_src_c123_3_02 conv_i_c123_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_02 (conv_q_src_c123_3_02 0 conv_bpf_c123_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_3_02 (conv_q_src_c123_3_02 conv_q_c123_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_03 (conv_i_src_c123_3_03 0 conv_bpf_c123_3 0) vcvs gain=1.950903220161e-01
SCONVI_c123_3_03 (conv_i_src_c123_3_03 conv_i_c123_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_03 (conv_q_src_c123_3_03 0 conv_bpf_c123_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_3_03 (conv_q_src_c123_3_03 conv_q_c123_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_04 (conv_i_src_c123_3_04 0 conv_bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_3_04 (conv_i_src_c123_3_04 conv_i_c123_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_04 (conv_q_src_c123_3_04 0 conv_bpf_c123_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c123_3_04 (conv_q_src_c123_3_04 conv_q_c123_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_05 (conv_i_src_c123_3_05 0 conv_bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_3_05 (conv_i_src_c123_3_05 conv_i_c123_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_05 (conv_q_src_c123_3_05 0 conv_bpf_c123_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c123_3_05 (conv_q_src_c123_3_05 conv_q_c123_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_06 (conv_i_src_c123_3_06 0 conv_bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_3_06 (conv_i_src_c123_3_06 conv_i_c123_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_06 (conv_q_src_c123_3_06 0 conv_bpf_c123_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c123_3_06 (conv_q_src_c123_3_06 conv_q_c123_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_07 (conv_i_src_c123_3_07 0 conv_bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_3_07 (conv_i_src_c123_3_07 conv_i_c123_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_07 (conv_q_src_c123_3_07 0 conv_bpf_c123_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c123_3_07 (conv_q_src_c123_3_07 conv_q_c123_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_08 (conv_i_src_c123_3_08 0 conv_bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c123_3_08 (conv_i_src_c123_3_08 conv_i_c123_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_08 (conv_q_src_c123_3_08 0 conv_bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_3_08 (conv_q_src_c123_3_08 conv_q_c123_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_09 (conv_i_src_c123_3_09 0 conv_bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c123_3_09 (conv_i_src_c123_3_09 conv_i_c123_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_09 (conv_q_src_c123_3_09 0 conv_bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_3_09 (conv_q_src_c123_3_09 conv_q_c123_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_10 (conv_i_src_c123_3_10 0 conv_bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c123_3_10 (conv_i_src_c123_3_10 conv_i_c123_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_10 (conv_q_src_c123_3_10 0 conv_bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_3_10 (conv_q_src_c123_3_10 conv_q_c123_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_11 (conv_i_src_c123_3_11 0 conv_bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c123_3_11 (conv_i_src_c123_3_11 conv_i_c123_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_11 (conv_q_src_c123_3_11 0 conv_bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_3_11 (conv_q_src_c123_3_11 conv_q_c123_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_12 (conv_i_src_c123_3_12 0 conv_bpf_c123_3 0) vcvs gain=1.950903220161e-01
SCONVI_c123_3_12 (conv_i_src_c123_3_12 conv_i_c123_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_12 (conv_q_src_c123_3_12 0 conv_bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c123_3_12 (conv_q_src_c123_3_12 conv_q_c123_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_13 (conv_i_src_c123_3_13 0 conv_bpf_c123_3 0) vcvs gain=5.555702330196e-01
SCONVI_c123_3_13 (conv_i_src_c123_3_13 conv_i_c123_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_13 (conv_q_src_c123_3_13 0 conv_bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c123_3_13 (conv_q_src_c123_3_13 conv_q_c123_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_14 (conv_i_src_c123_3_14 0 conv_bpf_c123_3 0) vcvs gain=8.314696123025e-01
SCONVI_c123_3_14 (conv_i_src_c123_3_14 conv_i_c123_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_14 (conv_q_src_c123_3_14 0 conv_bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c123_3_14 (conv_q_src_c123_3_14 conv_q_c123_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c123_3_15 (conv_i_src_c123_3_15 0 conv_bpf_c123_3 0) vcvs gain=9.807852804032e-01
SCONVI_c123_3_15 (conv_i_src_c123_3_15 conv_i_c123_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c123_3_15 (conv_q_src_c123_3_15 0 conv_bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c123_3_15 (conv_q_src_c123_3_15 conv_q_c123_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c123_3 (conv_i_c123_3 0) resistor r=1G
RCONVQ_c123_3 (conv_q_c123_3 0) resistor r=1G
RCONVINTI_c123_3 (conv_i_c123_3 ConvIcar_c123_3) resistor r=1k
CCONVINTI_c123_3 (ConvIcar_c123_3 0) capacitor c=80p
RCONVINTQ_c123_3 (conv_q_c123_3 ConvQcar_c123_3) resistor r=1k
CCONVINTQ_c123_3 (ConvQcar_c123_3 0) capacitor c=80p
save conv_bpf_c123_3 ConvIcar_c123_3 ConvQcar_c123_3

// conventional mixed baseline bl124, carrier_0: 250000000 Hz
CCONVBPF_c124_0 (bl124 n_conv_cbpf_c124_0) capacitor c=4.052847345694e-13
LCONVBPF_c124_0 (n_conv_cbpf_c124_0 conv_bpf_c124_0) inductor l=1.000000000000e-06
RCONVBPF_c124_0 (conv_bpf_c124_0 0) resistor r=7.853981633974e+01
ECONVI_c124_0_00 (conv_i_src_c124_0_00 0 conv_bpf_c124_0 0) vcvs gain=9.807852804032e-01
SCONVI_c124_0_00 (conv_i_src_c124_0_00 conv_i_c124_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_00 (conv_q_src_c124_0_00 0 conv_bpf_c124_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_0_00 (conv_q_src_c124_0_00 conv_q_c124_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_01 (conv_i_src_c124_0_01 0 conv_bpf_c124_0 0) vcvs gain=8.314696123025e-01
SCONVI_c124_0_01 (conv_i_src_c124_0_01 conv_i_c124_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_01 (conv_q_src_c124_0_01 0 conv_bpf_c124_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_0_01 (conv_q_src_c124_0_01 conv_q_c124_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_02 (conv_i_src_c124_0_02 0 conv_bpf_c124_0 0) vcvs gain=5.555702330196e-01
SCONVI_c124_0_02 (conv_i_src_c124_0_02 conv_i_c124_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_02 (conv_q_src_c124_0_02 0 conv_bpf_c124_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_0_02 (conv_q_src_c124_0_02 conv_q_c124_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_03 (conv_i_src_c124_0_03 0 conv_bpf_c124_0 0) vcvs gain=1.950903220161e-01
SCONVI_c124_0_03 (conv_i_src_c124_0_03 conv_i_c124_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_03 (conv_q_src_c124_0_03 0 conv_bpf_c124_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_0_03 (conv_q_src_c124_0_03 conv_q_c124_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_04 (conv_i_src_c124_0_04 0 conv_bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_0_04 (conv_i_src_c124_0_04 conv_i_c124_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_04 (conv_q_src_c124_0_04 0 conv_bpf_c124_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_0_04 (conv_q_src_c124_0_04 conv_q_c124_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_05 (conv_i_src_c124_0_05 0 conv_bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_0_05 (conv_i_src_c124_0_05 conv_i_c124_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_05 (conv_q_src_c124_0_05 0 conv_bpf_c124_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_0_05 (conv_q_src_c124_0_05 conv_q_c124_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_06 (conv_i_src_c124_0_06 0 conv_bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_0_06 (conv_i_src_c124_0_06 conv_i_c124_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_06 (conv_q_src_c124_0_06 0 conv_bpf_c124_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_0_06 (conv_q_src_c124_0_06 conv_q_c124_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_07 (conv_i_src_c124_0_07 0 conv_bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_0_07 (conv_i_src_c124_0_07 conv_i_c124_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_07 (conv_q_src_c124_0_07 0 conv_bpf_c124_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_0_07 (conv_q_src_c124_0_07 conv_q_c124_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_08 (conv_i_src_c124_0_08 0 conv_bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_0_08 (conv_i_src_c124_0_08 conv_i_c124_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_08 (conv_q_src_c124_0_08 0 conv_bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_0_08 (conv_q_src_c124_0_08 conv_q_c124_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_09 (conv_i_src_c124_0_09 0 conv_bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_0_09 (conv_i_src_c124_0_09 conv_i_c124_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_09 (conv_q_src_c124_0_09 0 conv_bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_0_09 (conv_q_src_c124_0_09 conv_q_c124_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_10 (conv_i_src_c124_0_10 0 conv_bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_0_10 (conv_i_src_c124_0_10 conv_i_c124_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_10 (conv_q_src_c124_0_10 0 conv_bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_0_10 (conv_q_src_c124_0_10 conv_q_c124_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_11 (conv_i_src_c124_0_11 0 conv_bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_0_11 (conv_i_src_c124_0_11 conv_i_c124_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_11 (conv_q_src_c124_0_11 0 conv_bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_0_11 (conv_q_src_c124_0_11 conv_q_c124_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_12 (conv_i_src_c124_0_12 0 conv_bpf_c124_0 0) vcvs gain=1.950903220161e-01
SCONVI_c124_0_12 (conv_i_src_c124_0_12 conv_i_c124_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_12 (conv_q_src_c124_0_12 0 conv_bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_0_12 (conv_q_src_c124_0_12 conv_q_c124_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_13 (conv_i_src_c124_0_13 0 conv_bpf_c124_0 0) vcvs gain=5.555702330196e-01
SCONVI_c124_0_13 (conv_i_src_c124_0_13 conv_i_c124_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_13 (conv_q_src_c124_0_13 0 conv_bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_0_13 (conv_q_src_c124_0_13 conv_q_c124_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_14 (conv_i_src_c124_0_14 0 conv_bpf_c124_0 0) vcvs gain=8.314696123025e-01
SCONVI_c124_0_14 (conv_i_src_c124_0_14 conv_i_c124_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_14 (conv_q_src_c124_0_14 0 conv_bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_0_14 (conv_q_src_c124_0_14 conv_q_c124_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_0_15 (conv_i_src_c124_0_15 0 conv_bpf_c124_0 0) vcvs gain=9.807852804032e-01
SCONVI_c124_0_15 (conv_i_src_c124_0_15 conv_i_c124_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_0_15 (conv_q_src_c124_0_15 0 conv_bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_0_15 (conv_q_src_c124_0_15 conv_q_c124_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c124_0 (conv_i_c124_0 0) resistor r=1G
RCONVQ_c124_0 (conv_q_c124_0 0) resistor r=1G
RCONVINTI_c124_0 (conv_i_c124_0 ConvIcar_c124_0) resistor r=1k
CCONVINTI_c124_0 (ConvIcar_c124_0 0) capacitor c=80p
RCONVINTQ_c124_0 (conv_q_c124_0 ConvQcar_c124_0) resistor r=1k
CCONVINTQ_c124_0 (ConvQcar_c124_0 0) capacitor c=80p
save conv_bpf_c124_0 ConvIcar_c124_0 ConvQcar_c124_0

// conventional mixed baseline bl124, carrier_1: 500000000 Hz
CCONVBPF_c124_1 (bl124 n_conv_cbpf_c124_1) capacitor c=1.013211836423e-13
LCONVBPF_c124_1 (n_conv_cbpf_c124_1 conv_bpf_c124_1) inductor l=1.000000000000e-06
RCONVBPF_c124_1 (conv_bpf_c124_1 0) resistor r=1.570796326795e+02
ECONVI_c124_1_00 (conv_i_src_c124_1_00 0 conv_bpf_c124_1 0) vcvs gain=9.807852804032e-01
SCONVI_c124_1_00 (conv_i_src_c124_1_00 conv_i_c124_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_00 (conv_q_src_c124_1_00 0 conv_bpf_c124_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_1_00 (conv_q_src_c124_1_00 conv_q_c124_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_01 (conv_i_src_c124_1_01 0 conv_bpf_c124_1 0) vcvs gain=8.314696123025e-01
SCONVI_c124_1_01 (conv_i_src_c124_1_01 conv_i_c124_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_01 (conv_q_src_c124_1_01 0 conv_bpf_c124_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_1_01 (conv_q_src_c124_1_01 conv_q_c124_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_02 (conv_i_src_c124_1_02 0 conv_bpf_c124_1 0) vcvs gain=5.555702330196e-01
SCONVI_c124_1_02 (conv_i_src_c124_1_02 conv_i_c124_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_02 (conv_q_src_c124_1_02 0 conv_bpf_c124_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_1_02 (conv_q_src_c124_1_02 conv_q_c124_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_03 (conv_i_src_c124_1_03 0 conv_bpf_c124_1 0) vcvs gain=1.950903220161e-01
SCONVI_c124_1_03 (conv_i_src_c124_1_03 conv_i_c124_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_03 (conv_q_src_c124_1_03 0 conv_bpf_c124_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_1_03 (conv_q_src_c124_1_03 conv_q_c124_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_04 (conv_i_src_c124_1_04 0 conv_bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_1_04 (conv_i_src_c124_1_04 conv_i_c124_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_04 (conv_q_src_c124_1_04 0 conv_bpf_c124_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_1_04 (conv_q_src_c124_1_04 conv_q_c124_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_05 (conv_i_src_c124_1_05 0 conv_bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_1_05 (conv_i_src_c124_1_05 conv_i_c124_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_05 (conv_q_src_c124_1_05 0 conv_bpf_c124_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_1_05 (conv_q_src_c124_1_05 conv_q_c124_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_06 (conv_i_src_c124_1_06 0 conv_bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_1_06 (conv_i_src_c124_1_06 conv_i_c124_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_06 (conv_q_src_c124_1_06 0 conv_bpf_c124_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_1_06 (conv_q_src_c124_1_06 conv_q_c124_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_07 (conv_i_src_c124_1_07 0 conv_bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_1_07 (conv_i_src_c124_1_07 conv_i_c124_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_07 (conv_q_src_c124_1_07 0 conv_bpf_c124_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_1_07 (conv_q_src_c124_1_07 conv_q_c124_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_08 (conv_i_src_c124_1_08 0 conv_bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_1_08 (conv_i_src_c124_1_08 conv_i_c124_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_08 (conv_q_src_c124_1_08 0 conv_bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_1_08 (conv_q_src_c124_1_08 conv_q_c124_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_09 (conv_i_src_c124_1_09 0 conv_bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_1_09 (conv_i_src_c124_1_09 conv_i_c124_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_09 (conv_q_src_c124_1_09 0 conv_bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_1_09 (conv_q_src_c124_1_09 conv_q_c124_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_10 (conv_i_src_c124_1_10 0 conv_bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_1_10 (conv_i_src_c124_1_10 conv_i_c124_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_10 (conv_q_src_c124_1_10 0 conv_bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_1_10 (conv_q_src_c124_1_10 conv_q_c124_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_11 (conv_i_src_c124_1_11 0 conv_bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_1_11 (conv_i_src_c124_1_11 conv_i_c124_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_11 (conv_q_src_c124_1_11 0 conv_bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_1_11 (conv_q_src_c124_1_11 conv_q_c124_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_12 (conv_i_src_c124_1_12 0 conv_bpf_c124_1 0) vcvs gain=1.950903220161e-01
SCONVI_c124_1_12 (conv_i_src_c124_1_12 conv_i_c124_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_12 (conv_q_src_c124_1_12 0 conv_bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_1_12 (conv_q_src_c124_1_12 conv_q_c124_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_13 (conv_i_src_c124_1_13 0 conv_bpf_c124_1 0) vcvs gain=5.555702330196e-01
SCONVI_c124_1_13 (conv_i_src_c124_1_13 conv_i_c124_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_13 (conv_q_src_c124_1_13 0 conv_bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_1_13 (conv_q_src_c124_1_13 conv_q_c124_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_14 (conv_i_src_c124_1_14 0 conv_bpf_c124_1 0) vcvs gain=8.314696123025e-01
SCONVI_c124_1_14 (conv_i_src_c124_1_14 conv_i_c124_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_14 (conv_q_src_c124_1_14 0 conv_bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_1_14 (conv_q_src_c124_1_14 conv_q_c124_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_1_15 (conv_i_src_c124_1_15 0 conv_bpf_c124_1 0) vcvs gain=9.807852804032e-01
SCONVI_c124_1_15 (conv_i_src_c124_1_15 conv_i_c124_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_1_15 (conv_q_src_c124_1_15 0 conv_bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_1_15 (conv_q_src_c124_1_15 conv_q_c124_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c124_1 (conv_i_c124_1 0) resistor r=1G
RCONVQ_c124_1 (conv_q_c124_1 0) resistor r=1G
RCONVINTI_c124_1 (conv_i_c124_1 ConvIcar_c124_1) resistor r=1k
CCONVINTI_c124_1 (ConvIcar_c124_1 0) capacitor c=80p
RCONVINTQ_c124_1 (conv_q_c124_1 ConvQcar_c124_1) resistor r=1k
CCONVINTQ_c124_1 (ConvQcar_c124_1 0) capacitor c=80p
save conv_bpf_c124_1 ConvIcar_c124_1 ConvQcar_c124_1

// conventional mixed baseline bl124, carrier_2: 750000000 Hz
CCONVBPF_c124_2 (bl124 n_conv_cbpf_c124_2) capacitor c=4.503163717437e-14
LCONVBPF_c124_2 (n_conv_cbpf_c124_2 conv_bpf_c124_2) inductor l=1.000000000000e-06
RCONVBPF_c124_2 (conv_bpf_c124_2 0) resistor r=2.356194490192e+02
ECONVI_c124_2_00 (conv_i_src_c124_2_00 0 conv_bpf_c124_2 0) vcvs gain=9.807852804032e-01
SCONVI_c124_2_00 (conv_i_src_c124_2_00 conv_i_c124_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_00 (conv_q_src_c124_2_00 0 conv_bpf_c124_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_2_00 (conv_q_src_c124_2_00 conv_q_c124_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_01 (conv_i_src_c124_2_01 0 conv_bpf_c124_2 0) vcvs gain=8.314696123025e-01
SCONVI_c124_2_01 (conv_i_src_c124_2_01 conv_i_c124_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_01 (conv_q_src_c124_2_01 0 conv_bpf_c124_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_2_01 (conv_q_src_c124_2_01 conv_q_c124_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_02 (conv_i_src_c124_2_02 0 conv_bpf_c124_2 0) vcvs gain=5.555702330196e-01
SCONVI_c124_2_02 (conv_i_src_c124_2_02 conv_i_c124_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_02 (conv_q_src_c124_2_02 0 conv_bpf_c124_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_2_02 (conv_q_src_c124_2_02 conv_q_c124_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_03 (conv_i_src_c124_2_03 0 conv_bpf_c124_2 0) vcvs gain=1.950903220161e-01
SCONVI_c124_2_03 (conv_i_src_c124_2_03 conv_i_c124_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_03 (conv_q_src_c124_2_03 0 conv_bpf_c124_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_2_03 (conv_q_src_c124_2_03 conv_q_c124_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_04 (conv_i_src_c124_2_04 0 conv_bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_2_04 (conv_i_src_c124_2_04 conv_i_c124_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_04 (conv_q_src_c124_2_04 0 conv_bpf_c124_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_2_04 (conv_q_src_c124_2_04 conv_q_c124_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_05 (conv_i_src_c124_2_05 0 conv_bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_2_05 (conv_i_src_c124_2_05 conv_i_c124_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_05 (conv_q_src_c124_2_05 0 conv_bpf_c124_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_2_05 (conv_q_src_c124_2_05 conv_q_c124_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_06 (conv_i_src_c124_2_06 0 conv_bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_2_06 (conv_i_src_c124_2_06 conv_i_c124_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_06 (conv_q_src_c124_2_06 0 conv_bpf_c124_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_2_06 (conv_q_src_c124_2_06 conv_q_c124_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_07 (conv_i_src_c124_2_07 0 conv_bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_2_07 (conv_i_src_c124_2_07 conv_i_c124_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_07 (conv_q_src_c124_2_07 0 conv_bpf_c124_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_2_07 (conv_q_src_c124_2_07 conv_q_c124_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_08 (conv_i_src_c124_2_08 0 conv_bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_2_08 (conv_i_src_c124_2_08 conv_i_c124_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_08 (conv_q_src_c124_2_08 0 conv_bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_2_08 (conv_q_src_c124_2_08 conv_q_c124_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_09 (conv_i_src_c124_2_09 0 conv_bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_2_09 (conv_i_src_c124_2_09 conv_i_c124_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_09 (conv_q_src_c124_2_09 0 conv_bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_2_09 (conv_q_src_c124_2_09 conv_q_c124_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_10 (conv_i_src_c124_2_10 0 conv_bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_2_10 (conv_i_src_c124_2_10 conv_i_c124_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_10 (conv_q_src_c124_2_10 0 conv_bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_2_10 (conv_q_src_c124_2_10 conv_q_c124_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_11 (conv_i_src_c124_2_11 0 conv_bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_2_11 (conv_i_src_c124_2_11 conv_i_c124_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_11 (conv_q_src_c124_2_11 0 conv_bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_2_11 (conv_q_src_c124_2_11 conv_q_c124_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_12 (conv_i_src_c124_2_12 0 conv_bpf_c124_2 0) vcvs gain=1.950903220161e-01
SCONVI_c124_2_12 (conv_i_src_c124_2_12 conv_i_c124_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_12 (conv_q_src_c124_2_12 0 conv_bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_2_12 (conv_q_src_c124_2_12 conv_q_c124_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_13 (conv_i_src_c124_2_13 0 conv_bpf_c124_2 0) vcvs gain=5.555702330196e-01
SCONVI_c124_2_13 (conv_i_src_c124_2_13 conv_i_c124_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_13 (conv_q_src_c124_2_13 0 conv_bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_2_13 (conv_q_src_c124_2_13 conv_q_c124_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_14 (conv_i_src_c124_2_14 0 conv_bpf_c124_2 0) vcvs gain=8.314696123025e-01
SCONVI_c124_2_14 (conv_i_src_c124_2_14 conv_i_c124_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_14 (conv_q_src_c124_2_14 0 conv_bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_2_14 (conv_q_src_c124_2_14 conv_q_c124_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_2_15 (conv_i_src_c124_2_15 0 conv_bpf_c124_2 0) vcvs gain=9.807852804032e-01
SCONVI_c124_2_15 (conv_i_src_c124_2_15 conv_i_c124_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_2_15 (conv_q_src_c124_2_15 0 conv_bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_2_15 (conv_q_src_c124_2_15 conv_q_c124_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c124_2 (conv_i_c124_2 0) resistor r=1G
RCONVQ_c124_2 (conv_q_c124_2 0) resistor r=1G
RCONVINTI_c124_2 (conv_i_c124_2 ConvIcar_c124_2) resistor r=1k
CCONVINTI_c124_2 (ConvIcar_c124_2 0) capacitor c=80p
RCONVINTQ_c124_2 (conv_q_c124_2 ConvQcar_c124_2) resistor r=1k
CCONVINTQ_c124_2 (ConvQcar_c124_2 0) capacitor c=80p
save conv_bpf_c124_2 ConvIcar_c124_2 ConvQcar_c124_2

// conventional mixed baseline bl124, carrier_3: 1000000000 Hz
CCONVBPF_c124_3 (bl124 n_conv_cbpf_c124_3) capacitor c=2.533029591058e-14
LCONVBPF_c124_3 (n_conv_cbpf_c124_3 conv_bpf_c124_3) inductor l=1.000000000000e-06
RCONVBPF_c124_3 (conv_bpf_c124_3 0) resistor r=3.141592653590e+02
ECONVI_c124_3_00 (conv_i_src_c124_3_00 0 conv_bpf_c124_3 0) vcvs gain=9.807852804032e-01
SCONVI_c124_3_00 (conv_i_src_c124_3_00 conv_i_c124_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_00 (conv_q_src_c124_3_00 0 conv_bpf_c124_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_3_00 (conv_q_src_c124_3_00 conv_q_c124_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_01 (conv_i_src_c124_3_01 0 conv_bpf_c124_3 0) vcvs gain=8.314696123025e-01
SCONVI_c124_3_01 (conv_i_src_c124_3_01 conv_i_c124_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_01 (conv_q_src_c124_3_01 0 conv_bpf_c124_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_3_01 (conv_q_src_c124_3_01 conv_q_c124_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_02 (conv_i_src_c124_3_02 0 conv_bpf_c124_3 0) vcvs gain=5.555702330196e-01
SCONVI_c124_3_02 (conv_i_src_c124_3_02 conv_i_c124_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_02 (conv_q_src_c124_3_02 0 conv_bpf_c124_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_3_02 (conv_q_src_c124_3_02 conv_q_c124_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_03 (conv_i_src_c124_3_03 0 conv_bpf_c124_3 0) vcvs gain=1.950903220161e-01
SCONVI_c124_3_03 (conv_i_src_c124_3_03 conv_i_c124_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_03 (conv_q_src_c124_3_03 0 conv_bpf_c124_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_3_03 (conv_q_src_c124_3_03 conv_q_c124_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_04 (conv_i_src_c124_3_04 0 conv_bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_3_04 (conv_i_src_c124_3_04 conv_i_c124_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_04 (conv_q_src_c124_3_04 0 conv_bpf_c124_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c124_3_04 (conv_q_src_c124_3_04 conv_q_c124_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_05 (conv_i_src_c124_3_05 0 conv_bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_3_05 (conv_i_src_c124_3_05 conv_i_c124_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_05 (conv_q_src_c124_3_05 0 conv_bpf_c124_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c124_3_05 (conv_q_src_c124_3_05 conv_q_c124_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_06 (conv_i_src_c124_3_06 0 conv_bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_3_06 (conv_i_src_c124_3_06 conv_i_c124_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_06 (conv_q_src_c124_3_06 0 conv_bpf_c124_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c124_3_06 (conv_q_src_c124_3_06 conv_q_c124_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_07 (conv_i_src_c124_3_07 0 conv_bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_3_07 (conv_i_src_c124_3_07 conv_i_c124_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_07 (conv_q_src_c124_3_07 0 conv_bpf_c124_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c124_3_07 (conv_q_src_c124_3_07 conv_q_c124_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_08 (conv_i_src_c124_3_08 0 conv_bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c124_3_08 (conv_i_src_c124_3_08 conv_i_c124_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_08 (conv_q_src_c124_3_08 0 conv_bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_3_08 (conv_q_src_c124_3_08 conv_q_c124_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_09 (conv_i_src_c124_3_09 0 conv_bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c124_3_09 (conv_i_src_c124_3_09 conv_i_c124_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_09 (conv_q_src_c124_3_09 0 conv_bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_3_09 (conv_q_src_c124_3_09 conv_q_c124_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_10 (conv_i_src_c124_3_10 0 conv_bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c124_3_10 (conv_i_src_c124_3_10 conv_i_c124_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_10 (conv_q_src_c124_3_10 0 conv_bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_3_10 (conv_q_src_c124_3_10 conv_q_c124_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_11 (conv_i_src_c124_3_11 0 conv_bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c124_3_11 (conv_i_src_c124_3_11 conv_i_c124_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_11 (conv_q_src_c124_3_11 0 conv_bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_3_11 (conv_q_src_c124_3_11 conv_q_c124_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_12 (conv_i_src_c124_3_12 0 conv_bpf_c124_3 0) vcvs gain=1.950903220161e-01
SCONVI_c124_3_12 (conv_i_src_c124_3_12 conv_i_c124_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_12 (conv_q_src_c124_3_12 0 conv_bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c124_3_12 (conv_q_src_c124_3_12 conv_q_c124_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_13 (conv_i_src_c124_3_13 0 conv_bpf_c124_3 0) vcvs gain=5.555702330196e-01
SCONVI_c124_3_13 (conv_i_src_c124_3_13 conv_i_c124_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_13 (conv_q_src_c124_3_13 0 conv_bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c124_3_13 (conv_q_src_c124_3_13 conv_q_c124_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_14 (conv_i_src_c124_3_14 0 conv_bpf_c124_3 0) vcvs gain=8.314696123025e-01
SCONVI_c124_3_14 (conv_i_src_c124_3_14 conv_i_c124_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_14 (conv_q_src_c124_3_14 0 conv_bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c124_3_14 (conv_q_src_c124_3_14 conv_q_c124_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c124_3_15 (conv_i_src_c124_3_15 0 conv_bpf_c124_3 0) vcvs gain=9.807852804032e-01
SCONVI_c124_3_15 (conv_i_src_c124_3_15 conv_i_c124_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c124_3_15 (conv_q_src_c124_3_15 0 conv_bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c124_3_15 (conv_q_src_c124_3_15 conv_q_c124_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c124_3 (conv_i_c124_3 0) resistor r=1G
RCONVQ_c124_3 (conv_q_c124_3 0) resistor r=1G
RCONVINTI_c124_3 (conv_i_c124_3 ConvIcar_c124_3) resistor r=1k
CCONVINTI_c124_3 (ConvIcar_c124_3 0) capacitor c=80p
RCONVINTQ_c124_3 (conv_q_c124_3 ConvQcar_c124_3) resistor r=1k
CCONVINTQ_c124_3 (ConvQcar_c124_3 0) capacitor c=80p
save conv_bpf_c124_3 ConvIcar_c124_3 ConvQcar_c124_3

// conventional mixed baseline bl125, carrier_0: 250000000 Hz
CCONVBPF_c125_0 (bl125 n_conv_cbpf_c125_0) capacitor c=4.052847345694e-13
LCONVBPF_c125_0 (n_conv_cbpf_c125_0 conv_bpf_c125_0) inductor l=1.000000000000e-06
RCONVBPF_c125_0 (conv_bpf_c125_0 0) resistor r=7.853981633974e+01
ECONVI_c125_0_00 (conv_i_src_c125_0_00 0 conv_bpf_c125_0 0) vcvs gain=9.807852804032e-01
SCONVI_c125_0_00 (conv_i_src_c125_0_00 conv_i_c125_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_00 (conv_q_src_c125_0_00 0 conv_bpf_c125_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_0_00 (conv_q_src_c125_0_00 conv_q_c125_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_01 (conv_i_src_c125_0_01 0 conv_bpf_c125_0 0) vcvs gain=8.314696123025e-01
SCONVI_c125_0_01 (conv_i_src_c125_0_01 conv_i_c125_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_01 (conv_q_src_c125_0_01 0 conv_bpf_c125_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_0_01 (conv_q_src_c125_0_01 conv_q_c125_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_02 (conv_i_src_c125_0_02 0 conv_bpf_c125_0 0) vcvs gain=5.555702330196e-01
SCONVI_c125_0_02 (conv_i_src_c125_0_02 conv_i_c125_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_02 (conv_q_src_c125_0_02 0 conv_bpf_c125_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_0_02 (conv_q_src_c125_0_02 conv_q_c125_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_03 (conv_i_src_c125_0_03 0 conv_bpf_c125_0 0) vcvs gain=1.950903220161e-01
SCONVI_c125_0_03 (conv_i_src_c125_0_03 conv_i_c125_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_03 (conv_q_src_c125_0_03 0 conv_bpf_c125_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_0_03 (conv_q_src_c125_0_03 conv_q_c125_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_04 (conv_i_src_c125_0_04 0 conv_bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_0_04 (conv_i_src_c125_0_04 conv_i_c125_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_04 (conv_q_src_c125_0_04 0 conv_bpf_c125_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_0_04 (conv_q_src_c125_0_04 conv_q_c125_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_05 (conv_i_src_c125_0_05 0 conv_bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_0_05 (conv_i_src_c125_0_05 conv_i_c125_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_05 (conv_q_src_c125_0_05 0 conv_bpf_c125_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_0_05 (conv_q_src_c125_0_05 conv_q_c125_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_06 (conv_i_src_c125_0_06 0 conv_bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_0_06 (conv_i_src_c125_0_06 conv_i_c125_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_06 (conv_q_src_c125_0_06 0 conv_bpf_c125_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_0_06 (conv_q_src_c125_0_06 conv_q_c125_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_07 (conv_i_src_c125_0_07 0 conv_bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_0_07 (conv_i_src_c125_0_07 conv_i_c125_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_07 (conv_q_src_c125_0_07 0 conv_bpf_c125_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_0_07 (conv_q_src_c125_0_07 conv_q_c125_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_08 (conv_i_src_c125_0_08 0 conv_bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_0_08 (conv_i_src_c125_0_08 conv_i_c125_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_08 (conv_q_src_c125_0_08 0 conv_bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_0_08 (conv_q_src_c125_0_08 conv_q_c125_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_09 (conv_i_src_c125_0_09 0 conv_bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_0_09 (conv_i_src_c125_0_09 conv_i_c125_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_09 (conv_q_src_c125_0_09 0 conv_bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_0_09 (conv_q_src_c125_0_09 conv_q_c125_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_10 (conv_i_src_c125_0_10 0 conv_bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_0_10 (conv_i_src_c125_0_10 conv_i_c125_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_10 (conv_q_src_c125_0_10 0 conv_bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_0_10 (conv_q_src_c125_0_10 conv_q_c125_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_11 (conv_i_src_c125_0_11 0 conv_bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_0_11 (conv_i_src_c125_0_11 conv_i_c125_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_11 (conv_q_src_c125_0_11 0 conv_bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_0_11 (conv_q_src_c125_0_11 conv_q_c125_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_12 (conv_i_src_c125_0_12 0 conv_bpf_c125_0 0) vcvs gain=1.950903220161e-01
SCONVI_c125_0_12 (conv_i_src_c125_0_12 conv_i_c125_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_12 (conv_q_src_c125_0_12 0 conv_bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_0_12 (conv_q_src_c125_0_12 conv_q_c125_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_13 (conv_i_src_c125_0_13 0 conv_bpf_c125_0 0) vcvs gain=5.555702330196e-01
SCONVI_c125_0_13 (conv_i_src_c125_0_13 conv_i_c125_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_13 (conv_q_src_c125_0_13 0 conv_bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_0_13 (conv_q_src_c125_0_13 conv_q_c125_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_14 (conv_i_src_c125_0_14 0 conv_bpf_c125_0 0) vcvs gain=8.314696123025e-01
SCONVI_c125_0_14 (conv_i_src_c125_0_14 conv_i_c125_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_14 (conv_q_src_c125_0_14 0 conv_bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_0_14 (conv_q_src_c125_0_14 conv_q_c125_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_0_15 (conv_i_src_c125_0_15 0 conv_bpf_c125_0 0) vcvs gain=9.807852804032e-01
SCONVI_c125_0_15 (conv_i_src_c125_0_15 conv_i_c125_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_0_15 (conv_q_src_c125_0_15 0 conv_bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_0_15 (conv_q_src_c125_0_15 conv_q_c125_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c125_0 (conv_i_c125_0 0) resistor r=1G
RCONVQ_c125_0 (conv_q_c125_0 0) resistor r=1G
RCONVINTI_c125_0 (conv_i_c125_0 ConvIcar_c125_0) resistor r=1k
CCONVINTI_c125_0 (ConvIcar_c125_0 0) capacitor c=80p
RCONVINTQ_c125_0 (conv_q_c125_0 ConvQcar_c125_0) resistor r=1k
CCONVINTQ_c125_0 (ConvQcar_c125_0 0) capacitor c=80p
save conv_bpf_c125_0 ConvIcar_c125_0 ConvQcar_c125_0

// conventional mixed baseline bl125, carrier_1: 500000000 Hz
CCONVBPF_c125_1 (bl125 n_conv_cbpf_c125_1) capacitor c=1.013211836423e-13
LCONVBPF_c125_1 (n_conv_cbpf_c125_1 conv_bpf_c125_1) inductor l=1.000000000000e-06
RCONVBPF_c125_1 (conv_bpf_c125_1 0) resistor r=1.570796326795e+02
ECONVI_c125_1_00 (conv_i_src_c125_1_00 0 conv_bpf_c125_1 0) vcvs gain=9.807852804032e-01
SCONVI_c125_1_00 (conv_i_src_c125_1_00 conv_i_c125_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_00 (conv_q_src_c125_1_00 0 conv_bpf_c125_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_1_00 (conv_q_src_c125_1_00 conv_q_c125_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_01 (conv_i_src_c125_1_01 0 conv_bpf_c125_1 0) vcvs gain=8.314696123025e-01
SCONVI_c125_1_01 (conv_i_src_c125_1_01 conv_i_c125_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_01 (conv_q_src_c125_1_01 0 conv_bpf_c125_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_1_01 (conv_q_src_c125_1_01 conv_q_c125_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_02 (conv_i_src_c125_1_02 0 conv_bpf_c125_1 0) vcvs gain=5.555702330196e-01
SCONVI_c125_1_02 (conv_i_src_c125_1_02 conv_i_c125_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_02 (conv_q_src_c125_1_02 0 conv_bpf_c125_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_1_02 (conv_q_src_c125_1_02 conv_q_c125_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_03 (conv_i_src_c125_1_03 0 conv_bpf_c125_1 0) vcvs gain=1.950903220161e-01
SCONVI_c125_1_03 (conv_i_src_c125_1_03 conv_i_c125_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_03 (conv_q_src_c125_1_03 0 conv_bpf_c125_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_1_03 (conv_q_src_c125_1_03 conv_q_c125_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_04 (conv_i_src_c125_1_04 0 conv_bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_1_04 (conv_i_src_c125_1_04 conv_i_c125_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_04 (conv_q_src_c125_1_04 0 conv_bpf_c125_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_1_04 (conv_q_src_c125_1_04 conv_q_c125_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_05 (conv_i_src_c125_1_05 0 conv_bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_1_05 (conv_i_src_c125_1_05 conv_i_c125_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_05 (conv_q_src_c125_1_05 0 conv_bpf_c125_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_1_05 (conv_q_src_c125_1_05 conv_q_c125_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_06 (conv_i_src_c125_1_06 0 conv_bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_1_06 (conv_i_src_c125_1_06 conv_i_c125_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_06 (conv_q_src_c125_1_06 0 conv_bpf_c125_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_1_06 (conv_q_src_c125_1_06 conv_q_c125_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_07 (conv_i_src_c125_1_07 0 conv_bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_1_07 (conv_i_src_c125_1_07 conv_i_c125_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_07 (conv_q_src_c125_1_07 0 conv_bpf_c125_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_1_07 (conv_q_src_c125_1_07 conv_q_c125_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_08 (conv_i_src_c125_1_08 0 conv_bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_1_08 (conv_i_src_c125_1_08 conv_i_c125_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_08 (conv_q_src_c125_1_08 0 conv_bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_1_08 (conv_q_src_c125_1_08 conv_q_c125_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_09 (conv_i_src_c125_1_09 0 conv_bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_1_09 (conv_i_src_c125_1_09 conv_i_c125_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_09 (conv_q_src_c125_1_09 0 conv_bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_1_09 (conv_q_src_c125_1_09 conv_q_c125_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_10 (conv_i_src_c125_1_10 0 conv_bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_1_10 (conv_i_src_c125_1_10 conv_i_c125_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_10 (conv_q_src_c125_1_10 0 conv_bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_1_10 (conv_q_src_c125_1_10 conv_q_c125_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_11 (conv_i_src_c125_1_11 0 conv_bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_1_11 (conv_i_src_c125_1_11 conv_i_c125_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_11 (conv_q_src_c125_1_11 0 conv_bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_1_11 (conv_q_src_c125_1_11 conv_q_c125_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_12 (conv_i_src_c125_1_12 0 conv_bpf_c125_1 0) vcvs gain=1.950903220161e-01
SCONVI_c125_1_12 (conv_i_src_c125_1_12 conv_i_c125_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_12 (conv_q_src_c125_1_12 0 conv_bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_1_12 (conv_q_src_c125_1_12 conv_q_c125_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_13 (conv_i_src_c125_1_13 0 conv_bpf_c125_1 0) vcvs gain=5.555702330196e-01
SCONVI_c125_1_13 (conv_i_src_c125_1_13 conv_i_c125_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_13 (conv_q_src_c125_1_13 0 conv_bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_1_13 (conv_q_src_c125_1_13 conv_q_c125_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_14 (conv_i_src_c125_1_14 0 conv_bpf_c125_1 0) vcvs gain=8.314696123025e-01
SCONVI_c125_1_14 (conv_i_src_c125_1_14 conv_i_c125_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_14 (conv_q_src_c125_1_14 0 conv_bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_1_14 (conv_q_src_c125_1_14 conv_q_c125_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_1_15 (conv_i_src_c125_1_15 0 conv_bpf_c125_1 0) vcvs gain=9.807852804032e-01
SCONVI_c125_1_15 (conv_i_src_c125_1_15 conv_i_c125_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_1_15 (conv_q_src_c125_1_15 0 conv_bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_1_15 (conv_q_src_c125_1_15 conv_q_c125_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c125_1 (conv_i_c125_1 0) resistor r=1G
RCONVQ_c125_1 (conv_q_c125_1 0) resistor r=1G
RCONVINTI_c125_1 (conv_i_c125_1 ConvIcar_c125_1) resistor r=1k
CCONVINTI_c125_1 (ConvIcar_c125_1 0) capacitor c=80p
RCONVINTQ_c125_1 (conv_q_c125_1 ConvQcar_c125_1) resistor r=1k
CCONVINTQ_c125_1 (ConvQcar_c125_1 0) capacitor c=80p
save conv_bpf_c125_1 ConvIcar_c125_1 ConvQcar_c125_1

// conventional mixed baseline bl125, carrier_2: 750000000 Hz
CCONVBPF_c125_2 (bl125 n_conv_cbpf_c125_2) capacitor c=4.503163717437e-14
LCONVBPF_c125_2 (n_conv_cbpf_c125_2 conv_bpf_c125_2) inductor l=1.000000000000e-06
RCONVBPF_c125_2 (conv_bpf_c125_2 0) resistor r=2.356194490192e+02
ECONVI_c125_2_00 (conv_i_src_c125_2_00 0 conv_bpf_c125_2 0) vcvs gain=9.807852804032e-01
SCONVI_c125_2_00 (conv_i_src_c125_2_00 conv_i_c125_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_00 (conv_q_src_c125_2_00 0 conv_bpf_c125_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_2_00 (conv_q_src_c125_2_00 conv_q_c125_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_01 (conv_i_src_c125_2_01 0 conv_bpf_c125_2 0) vcvs gain=8.314696123025e-01
SCONVI_c125_2_01 (conv_i_src_c125_2_01 conv_i_c125_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_01 (conv_q_src_c125_2_01 0 conv_bpf_c125_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_2_01 (conv_q_src_c125_2_01 conv_q_c125_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_02 (conv_i_src_c125_2_02 0 conv_bpf_c125_2 0) vcvs gain=5.555702330196e-01
SCONVI_c125_2_02 (conv_i_src_c125_2_02 conv_i_c125_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_02 (conv_q_src_c125_2_02 0 conv_bpf_c125_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_2_02 (conv_q_src_c125_2_02 conv_q_c125_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_03 (conv_i_src_c125_2_03 0 conv_bpf_c125_2 0) vcvs gain=1.950903220161e-01
SCONVI_c125_2_03 (conv_i_src_c125_2_03 conv_i_c125_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_03 (conv_q_src_c125_2_03 0 conv_bpf_c125_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_2_03 (conv_q_src_c125_2_03 conv_q_c125_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_04 (conv_i_src_c125_2_04 0 conv_bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_2_04 (conv_i_src_c125_2_04 conv_i_c125_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_04 (conv_q_src_c125_2_04 0 conv_bpf_c125_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_2_04 (conv_q_src_c125_2_04 conv_q_c125_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_05 (conv_i_src_c125_2_05 0 conv_bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_2_05 (conv_i_src_c125_2_05 conv_i_c125_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_05 (conv_q_src_c125_2_05 0 conv_bpf_c125_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_2_05 (conv_q_src_c125_2_05 conv_q_c125_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_06 (conv_i_src_c125_2_06 0 conv_bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_2_06 (conv_i_src_c125_2_06 conv_i_c125_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_06 (conv_q_src_c125_2_06 0 conv_bpf_c125_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_2_06 (conv_q_src_c125_2_06 conv_q_c125_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_07 (conv_i_src_c125_2_07 0 conv_bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_2_07 (conv_i_src_c125_2_07 conv_i_c125_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_07 (conv_q_src_c125_2_07 0 conv_bpf_c125_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_2_07 (conv_q_src_c125_2_07 conv_q_c125_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_08 (conv_i_src_c125_2_08 0 conv_bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_2_08 (conv_i_src_c125_2_08 conv_i_c125_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_08 (conv_q_src_c125_2_08 0 conv_bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_2_08 (conv_q_src_c125_2_08 conv_q_c125_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_09 (conv_i_src_c125_2_09 0 conv_bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_2_09 (conv_i_src_c125_2_09 conv_i_c125_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_09 (conv_q_src_c125_2_09 0 conv_bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_2_09 (conv_q_src_c125_2_09 conv_q_c125_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_10 (conv_i_src_c125_2_10 0 conv_bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_2_10 (conv_i_src_c125_2_10 conv_i_c125_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_10 (conv_q_src_c125_2_10 0 conv_bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_2_10 (conv_q_src_c125_2_10 conv_q_c125_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_11 (conv_i_src_c125_2_11 0 conv_bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_2_11 (conv_i_src_c125_2_11 conv_i_c125_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_11 (conv_q_src_c125_2_11 0 conv_bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_2_11 (conv_q_src_c125_2_11 conv_q_c125_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_12 (conv_i_src_c125_2_12 0 conv_bpf_c125_2 0) vcvs gain=1.950903220161e-01
SCONVI_c125_2_12 (conv_i_src_c125_2_12 conv_i_c125_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_12 (conv_q_src_c125_2_12 0 conv_bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_2_12 (conv_q_src_c125_2_12 conv_q_c125_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_13 (conv_i_src_c125_2_13 0 conv_bpf_c125_2 0) vcvs gain=5.555702330196e-01
SCONVI_c125_2_13 (conv_i_src_c125_2_13 conv_i_c125_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_13 (conv_q_src_c125_2_13 0 conv_bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_2_13 (conv_q_src_c125_2_13 conv_q_c125_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_14 (conv_i_src_c125_2_14 0 conv_bpf_c125_2 0) vcvs gain=8.314696123025e-01
SCONVI_c125_2_14 (conv_i_src_c125_2_14 conv_i_c125_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_14 (conv_q_src_c125_2_14 0 conv_bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_2_14 (conv_q_src_c125_2_14 conv_q_c125_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_2_15 (conv_i_src_c125_2_15 0 conv_bpf_c125_2 0) vcvs gain=9.807852804032e-01
SCONVI_c125_2_15 (conv_i_src_c125_2_15 conv_i_c125_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_2_15 (conv_q_src_c125_2_15 0 conv_bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_2_15 (conv_q_src_c125_2_15 conv_q_c125_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c125_2 (conv_i_c125_2 0) resistor r=1G
RCONVQ_c125_2 (conv_q_c125_2 0) resistor r=1G
RCONVINTI_c125_2 (conv_i_c125_2 ConvIcar_c125_2) resistor r=1k
CCONVINTI_c125_2 (ConvIcar_c125_2 0) capacitor c=80p
RCONVINTQ_c125_2 (conv_q_c125_2 ConvQcar_c125_2) resistor r=1k
CCONVINTQ_c125_2 (ConvQcar_c125_2 0) capacitor c=80p
save conv_bpf_c125_2 ConvIcar_c125_2 ConvQcar_c125_2

// conventional mixed baseline bl125, carrier_3: 1000000000 Hz
CCONVBPF_c125_3 (bl125 n_conv_cbpf_c125_3) capacitor c=2.533029591058e-14
LCONVBPF_c125_3 (n_conv_cbpf_c125_3 conv_bpf_c125_3) inductor l=1.000000000000e-06
RCONVBPF_c125_3 (conv_bpf_c125_3 0) resistor r=3.141592653590e+02
ECONVI_c125_3_00 (conv_i_src_c125_3_00 0 conv_bpf_c125_3 0) vcvs gain=9.807852804032e-01
SCONVI_c125_3_00 (conv_i_src_c125_3_00 conv_i_c125_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_00 (conv_q_src_c125_3_00 0 conv_bpf_c125_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_3_00 (conv_q_src_c125_3_00 conv_q_c125_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_01 (conv_i_src_c125_3_01 0 conv_bpf_c125_3 0) vcvs gain=8.314696123025e-01
SCONVI_c125_3_01 (conv_i_src_c125_3_01 conv_i_c125_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_01 (conv_q_src_c125_3_01 0 conv_bpf_c125_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_3_01 (conv_q_src_c125_3_01 conv_q_c125_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_02 (conv_i_src_c125_3_02 0 conv_bpf_c125_3 0) vcvs gain=5.555702330196e-01
SCONVI_c125_3_02 (conv_i_src_c125_3_02 conv_i_c125_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_02 (conv_q_src_c125_3_02 0 conv_bpf_c125_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_3_02 (conv_q_src_c125_3_02 conv_q_c125_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_03 (conv_i_src_c125_3_03 0 conv_bpf_c125_3 0) vcvs gain=1.950903220161e-01
SCONVI_c125_3_03 (conv_i_src_c125_3_03 conv_i_c125_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_03 (conv_q_src_c125_3_03 0 conv_bpf_c125_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_3_03 (conv_q_src_c125_3_03 conv_q_c125_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_04 (conv_i_src_c125_3_04 0 conv_bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_3_04 (conv_i_src_c125_3_04 conv_i_c125_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_04 (conv_q_src_c125_3_04 0 conv_bpf_c125_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c125_3_04 (conv_q_src_c125_3_04 conv_q_c125_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_05 (conv_i_src_c125_3_05 0 conv_bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_3_05 (conv_i_src_c125_3_05 conv_i_c125_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_05 (conv_q_src_c125_3_05 0 conv_bpf_c125_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c125_3_05 (conv_q_src_c125_3_05 conv_q_c125_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_06 (conv_i_src_c125_3_06 0 conv_bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_3_06 (conv_i_src_c125_3_06 conv_i_c125_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_06 (conv_q_src_c125_3_06 0 conv_bpf_c125_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c125_3_06 (conv_q_src_c125_3_06 conv_q_c125_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_07 (conv_i_src_c125_3_07 0 conv_bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_3_07 (conv_i_src_c125_3_07 conv_i_c125_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_07 (conv_q_src_c125_3_07 0 conv_bpf_c125_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c125_3_07 (conv_q_src_c125_3_07 conv_q_c125_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_08 (conv_i_src_c125_3_08 0 conv_bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c125_3_08 (conv_i_src_c125_3_08 conv_i_c125_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_08 (conv_q_src_c125_3_08 0 conv_bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_3_08 (conv_q_src_c125_3_08 conv_q_c125_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_09 (conv_i_src_c125_3_09 0 conv_bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c125_3_09 (conv_i_src_c125_3_09 conv_i_c125_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_09 (conv_q_src_c125_3_09 0 conv_bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_3_09 (conv_q_src_c125_3_09 conv_q_c125_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_10 (conv_i_src_c125_3_10 0 conv_bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c125_3_10 (conv_i_src_c125_3_10 conv_i_c125_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_10 (conv_q_src_c125_3_10 0 conv_bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_3_10 (conv_q_src_c125_3_10 conv_q_c125_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_11 (conv_i_src_c125_3_11 0 conv_bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c125_3_11 (conv_i_src_c125_3_11 conv_i_c125_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_11 (conv_q_src_c125_3_11 0 conv_bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_3_11 (conv_q_src_c125_3_11 conv_q_c125_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_12 (conv_i_src_c125_3_12 0 conv_bpf_c125_3 0) vcvs gain=1.950903220161e-01
SCONVI_c125_3_12 (conv_i_src_c125_3_12 conv_i_c125_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_12 (conv_q_src_c125_3_12 0 conv_bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c125_3_12 (conv_q_src_c125_3_12 conv_q_c125_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_13 (conv_i_src_c125_3_13 0 conv_bpf_c125_3 0) vcvs gain=5.555702330196e-01
SCONVI_c125_3_13 (conv_i_src_c125_3_13 conv_i_c125_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_13 (conv_q_src_c125_3_13 0 conv_bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c125_3_13 (conv_q_src_c125_3_13 conv_q_c125_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_14 (conv_i_src_c125_3_14 0 conv_bpf_c125_3 0) vcvs gain=8.314696123025e-01
SCONVI_c125_3_14 (conv_i_src_c125_3_14 conv_i_c125_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_14 (conv_q_src_c125_3_14 0 conv_bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c125_3_14 (conv_q_src_c125_3_14 conv_q_c125_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c125_3_15 (conv_i_src_c125_3_15 0 conv_bpf_c125_3 0) vcvs gain=9.807852804032e-01
SCONVI_c125_3_15 (conv_i_src_c125_3_15 conv_i_c125_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c125_3_15 (conv_q_src_c125_3_15 0 conv_bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c125_3_15 (conv_q_src_c125_3_15 conv_q_c125_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c125_3 (conv_i_c125_3 0) resistor r=1G
RCONVQ_c125_3 (conv_q_c125_3 0) resistor r=1G
RCONVINTI_c125_3 (conv_i_c125_3 ConvIcar_c125_3) resistor r=1k
CCONVINTI_c125_3 (ConvIcar_c125_3 0) capacitor c=80p
RCONVINTQ_c125_3 (conv_q_c125_3 ConvQcar_c125_3) resistor r=1k
CCONVINTQ_c125_3 (ConvQcar_c125_3 0) capacitor c=80p
save conv_bpf_c125_3 ConvIcar_c125_3 ConvQcar_c125_3

// conventional mixed baseline bl126, carrier_0: 250000000 Hz
CCONVBPF_c126_0 (bl126 n_conv_cbpf_c126_0) capacitor c=4.052847345694e-13
LCONVBPF_c126_0 (n_conv_cbpf_c126_0 conv_bpf_c126_0) inductor l=1.000000000000e-06
RCONVBPF_c126_0 (conv_bpf_c126_0 0) resistor r=7.853981633974e+01
ECONVI_c126_0_00 (conv_i_src_c126_0_00 0 conv_bpf_c126_0 0) vcvs gain=9.807852804032e-01
SCONVI_c126_0_00 (conv_i_src_c126_0_00 conv_i_c126_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_00 (conv_q_src_c126_0_00 0 conv_bpf_c126_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_0_00 (conv_q_src_c126_0_00 conv_q_c126_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_01 (conv_i_src_c126_0_01 0 conv_bpf_c126_0 0) vcvs gain=8.314696123025e-01
SCONVI_c126_0_01 (conv_i_src_c126_0_01 conv_i_c126_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_01 (conv_q_src_c126_0_01 0 conv_bpf_c126_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_0_01 (conv_q_src_c126_0_01 conv_q_c126_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_02 (conv_i_src_c126_0_02 0 conv_bpf_c126_0 0) vcvs gain=5.555702330196e-01
SCONVI_c126_0_02 (conv_i_src_c126_0_02 conv_i_c126_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_02 (conv_q_src_c126_0_02 0 conv_bpf_c126_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_0_02 (conv_q_src_c126_0_02 conv_q_c126_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_03 (conv_i_src_c126_0_03 0 conv_bpf_c126_0 0) vcvs gain=1.950903220161e-01
SCONVI_c126_0_03 (conv_i_src_c126_0_03 conv_i_c126_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_03 (conv_q_src_c126_0_03 0 conv_bpf_c126_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_0_03 (conv_q_src_c126_0_03 conv_q_c126_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_04 (conv_i_src_c126_0_04 0 conv_bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_0_04 (conv_i_src_c126_0_04 conv_i_c126_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_04 (conv_q_src_c126_0_04 0 conv_bpf_c126_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_0_04 (conv_q_src_c126_0_04 conv_q_c126_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_05 (conv_i_src_c126_0_05 0 conv_bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_0_05 (conv_i_src_c126_0_05 conv_i_c126_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_05 (conv_q_src_c126_0_05 0 conv_bpf_c126_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_0_05 (conv_q_src_c126_0_05 conv_q_c126_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_06 (conv_i_src_c126_0_06 0 conv_bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_0_06 (conv_i_src_c126_0_06 conv_i_c126_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_06 (conv_q_src_c126_0_06 0 conv_bpf_c126_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_0_06 (conv_q_src_c126_0_06 conv_q_c126_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_07 (conv_i_src_c126_0_07 0 conv_bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_0_07 (conv_i_src_c126_0_07 conv_i_c126_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_07 (conv_q_src_c126_0_07 0 conv_bpf_c126_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_0_07 (conv_q_src_c126_0_07 conv_q_c126_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_08 (conv_i_src_c126_0_08 0 conv_bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_0_08 (conv_i_src_c126_0_08 conv_i_c126_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_08 (conv_q_src_c126_0_08 0 conv_bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_0_08 (conv_q_src_c126_0_08 conv_q_c126_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_09 (conv_i_src_c126_0_09 0 conv_bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_0_09 (conv_i_src_c126_0_09 conv_i_c126_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_09 (conv_q_src_c126_0_09 0 conv_bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_0_09 (conv_q_src_c126_0_09 conv_q_c126_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_10 (conv_i_src_c126_0_10 0 conv_bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_0_10 (conv_i_src_c126_0_10 conv_i_c126_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_10 (conv_q_src_c126_0_10 0 conv_bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_0_10 (conv_q_src_c126_0_10 conv_q_c126_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_11 (conv_i_src_c126_0_11 0 conv_bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_0_11 (conv_i_src_c126_0_11 conv_i_c126_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_11 (conv_q_src_c126_0_11 0 conv_bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_0_11 (conv_q_src_c126_0_11 conv_q_c126_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_12 (conv_i_src_c126_0_12 0 conv_bpf_c126_0 0) vcvs gain=1.950903220161e-01
SCONVI_c126_0_12 (conv_i_src_c126_0_12 conv_i_c126_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_12 (conv_q_src_c126_0_12 0 conv_bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_0_12 (conv_q_src_c126_0_12 conv_q_c126_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_13 (conv_i_src_c126_0_13 0 conv_bpf_c126_0 0) vcvs gain=5.555702330196e-01
SCONVI_c126_0_13 (conv_i_src_c126_0_13 conv_i_c126_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_13 (conv_q_src_c126_0_13 0 conv_bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_0_13 (conv_q_src_c126_0_13 conv_q_c126_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_14 (conv_i_src_c126_0_14 0 conv_bpf_c126_0 0) vcvs gain=8.314696123025e-01
SCONVI_c126_0_14 (conv_i_src_c126_0_14 conv_i_c126_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_14 (conv_q_src_c126_0_14 0 conv_bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_0_14 (conv_q_src_c126_0_14 conv_q_c126_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_0_15 (conv_i_src_c126_0_15 0 conv_bpf_c126_0 0) vcvs gain=9.807852804032e-01
SCONVI_c126_0_15 (conv_i_src_c126_0_15 conv_i_c126_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_0_15 (conv_q_src_c126_0_15 0 conv_bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_0_15 (conv_q_src_c126_0_15 conv_q_c126_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c126_0 (conv_i_c126_0 0) resistor r=1G
RCONVQ_c126_0 (conv_q_c126_0 0) resistor r=1G
RCONVINTI_c126_0 (conv_i_c126_0 ConvIcar_c126_0) resistor r=1k
CCONVINTI_c126_0 (ConvIcar_c126_0 0) capacitor c=80p
RCONVINTQ_c126_0 (conv_q_c126_0 ConvQcar_c126_0) resistor r=1k
CCONVINTQ_c126_0 (ConvQcar_c126_0 0) capacitor c=80p
save conv_bpf_c126_0 ConvIcar_c126_0 ConvQcar_c126_0

// conventional mixed baseline bl126, carrier_1: 500000000 Hz
CCONVBPF_c126_1 (bl126 n_conv_cbpf_c126_1) capacitor c=1.013211836423e-13
LCONVBPF_c126_1 (n_conv_cbpf_c126_1 conv_bpf_c126_1) inductor l=1.000000000000e-06
RCONVBPF_c126_1 (conv_bpf_c126_1 0) resistor r=1.570796326795e+02
ECONVI_c126_1_00 (conv_i_src_c126_1_00 0 conv_bpf_c126_1 0) vcvs gain=9.807852804032e-01
SCONVI_c126_1_00 (conv_i_src_c126_1_00 conv_i_c126_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_00 (conv_q_src_c126_1_00 0 conv_bpf_c126_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_1_00 (conv_q_src_c126_1_00 conv_q_c126_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_01 (conv_i_src_c126_1_01 0 conv_bpf_c126_1 0) vcvs gain=8.314696123025e-01
SCONVI_c126_1_01 (conv_i_src_c126_1_01 conv_i_c126_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_01 (conv_q_src_c126_1_01 0 conv_bpf_c126_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_1_01 (conv_q_src_c126_1_01 conv_q_c126_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_02 (conv_i_src_c126_1_02 0 conv_bpf_c126_1 0) vcvs gain=5.555702330196e-01
SCONVI_c126_1_02 (conv_i_src_c126_1_02 conv_i_c126_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_02 (conv_q_src_c126_1_02 0 conv_bpf_c126_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_1_02 (conv_q_src_c126_1_02 conv_q_c126_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_03 (conv_i_src_c126_1_03 0 conv_bpf_c126_1 0) vcvs gain=1.950903220161e-01
SCONVI_c126_1_03 (conv_i_src_c126_1_03 conv_i_c126_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_03 (conv_q_src_c126_1_03 0 conv_bpf_c126_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_1_03 (conv_q_src_c126_1_03 conv_q_c126_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_04 (conv_i_src_c126_1_04 0 conv_bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_1_04 (conv_i_src_c126_1_04 conv_i_c126_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_04 (conv_q_src_c126_1_04 0 conv_bpf_c126_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_1_04 (conv_q_src_c126_1_04 conv_q_c126_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_05 (conv_i_src_c126_1_05 0 conv_bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_1_05 (conv_i_src_c126_1_05 conv_i_c126_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_05 (conv_q_src_c126_1_05 0 conv_bpf_c126_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_1_05 (conv_q_src_c126_1_05 conv_q_c126_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_06 (conv_i_src_c126_1_06 0 conv_bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_1_06 (conv_i_src_c126_1_06 conv_i_c126_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_06 (conv_q_src_c126_1_06 0 conv_bpf_c126_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_1_06 (conv_q_src_c126_1_06 conv_q_c126_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_07 (conv_i_src_c126_1_07 0 conv_bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_1_07 (conv_i_src_c126_1_07 conv_i_c126_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_07 (conv_q_src_c126_1_07 0 conv_bpf_c126_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_1_07 (conv_q_src_c126_1_07 conv_q_c126_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_08 (conv_i_src_c126_1_08 0 conv_bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_1_08 (conv_i_src_c126_1_08 conv_i_c126_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_08 (conv_q_src_c126_1_08 0 conv_bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_1_08 (conv_q_src_c126_1_08 conv_q_c126_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_09 (conv_i_src_c126_1_09 0 conv_bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_1_09 (conv_i_src_c126_1_09 conv_i_c126_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_09 (conv_q_src_c126_1_09 0 conv_bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_1_09 (conv_q_src_c126_1_09 conv_q_c126_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_10 (conv_i_src_c126_1_10 0 conv_bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_1_10 (conv_i_src_c126_1_10 conv_i_c126_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_10 (conv_q_src_c126_1_10 0 conv_bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_1_10 (conv_q_src_c126_1_10 conv_q_c126_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_11 (conv_i_src_c126_1_11 0 conv_bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_1_11 (conv_i_src_c126_1_11 conv_i_c126_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_11 (conv_q_src_c126_1_11 0 conv_bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_1_11 (conv_q_src_c126_1_11 conv_q_c126_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_12 (conv_i_src_c126_1_12 0 conv_bpf_c126_1 0) vcvs gain=1.950903220161e-01
SCONVI_c126_1_12 (conv_i_src_c126_1_12 conv_i_c126_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_12 (conv_q_src_c126_1_12 0 conv_bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_1_12 (conv_q_src_c126_1_12 conv_q_c126_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_13 (conv_i_src_c126_1_13 0 conv_bpf_c126_1 0) vcvs gain=5.555702330196e-01
SCONVI_c126_1_13 (conv_i_src_c126_1_13 conv_i_c126_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_13 (conv_q_src_c126_1_13 0 conv_bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_1_13 (conv_q_src_c126_1_13 conv_q_c126_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_14 (conv_i_src_c126_1_14 0 conv_bpf_c126_1 0) vcvs gain=8.314696123025e-01
SCONVI_c126_1_14 (conv_i_src_c126_1_14 conv_i_c126_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_14 (conv_q_src_c126_1_14 0 conv_bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_1_14 (conv_q_src_c126_1_14 conv_q_c126_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_1_15 (conv_i_src_c126_1_15 0 conv_bpf_c126_1 0) vcvs gain=9.807852804032e-01
SCONVI_c126_1_15 (conv_i_src_c126_1_15 conv_i_c126_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_1_15 (conv_q_src_c126_1_15 0 conv_bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_1_15 (conv_q_src_c126_1_15 conv_q_c126_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c126_1 (conv_i_c126_1 0) resistor r=1G
RCONVQ_c126_1 (conv_q_c126_1 0) resistor r=1G
RCONVINTI_c126_1 (conv_i_c126_1 ConvIcar_c126_1) resistor r=1k
CCONVINTI_c126_1 (ConvIcar_c126_1 0) capacitor c=80p
RCONVINTQ_c126_1 (conv_q_c126_1 ConvQcar_c126_1) resistor r=1k
CCONVINTQ_c126_1 (ConvQcar_c126_1 0) capacitor c=80p
save conv_bpf_c126_1 ConvIcar_c126_1 ConvQcar_c126_1

// conventional mixed baseline bl126, carrier_2: 750000000 Hz
CCONVBPF_c126_2 (bl126 n_conv_cbpf_c126_2) capacitor c=4.503163717437e-14
LCONVBPF_c126_2 (n_conv_cbpf_c126_2 conv_bpf_c126_2) inductor l=1.000000000000e-06
RCONVBPF_c126_2 (conv_bpf_c126_2 0) resistor r=2.356194490192e+02
ECONVI_c126_2_00 (conv_i_src_c126_2_00 0 conv_bpf_c126_2 0) vcvs gain=9.807852804032e-01
SCONVI_c126_2_00 (conv_i_src_c126_2_00 conv_i_c126_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_00 (conv_q_src_c126_2_00 0 conv_bpf_c126_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_2_00 (conv_q_src_c126_2_00 conv_q_c126_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_01 (conv_i_src_c126_2_01 0 conv_bpf_c126_2 0) vcvs gain=8.314696123025e-01
SCONVI_c126_2_01 (conv_i_src_c126_2_01 conv_i_c126_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_01 (conv_q_src_c126_2_01 0 conv_bpf_c126_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_2_01 (conv_q_src_c126_2_01 conv_q_c126_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_02 (conv_i_src_c126_2_02 0 conv_bpf_c126_2 0) vcvs gain=5.555702330196e-01
SCONVI_c126_2_02 (conv_i_src_c126_2_02 conv_i_c126_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_02 (conv_q_src_c126_2_02 0 conv_bpf_c126_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_2_02 (conv_q_src_c126_2_02 conv_q_c126_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_03 (conv_i_src_c126_2_03 0 conv_bpf_c126_2 0) vcvs gain=1.950903220161e-01
SCONVI_c126_2_03 (conv_i_src_c126_2_03 conv_i_c126_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_03 (conv_q_src_c126_2_03 0 conv_bpf_c126_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_2_03 (conv_q_src_c126_2_03 conv_q_c126_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_04 (conv_i_src_c126_2_04 0 conv_bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_2_04 (conv_i_src_c126_2_04 conv_i_c126_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_04 (conv_q_src_c126_2_04 0 conv_bpf_c126_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_2_04 (conv_q_src_c126_2_04 conv_q_c126_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_05 (conv_i_src_c126_2_05 0 conv_bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_2_05 (conv_i_src_c126_2_05 conv_i_c126_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_05 (conv_q_src_c126_2_05 0 conv_bpf_c126_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_2_05 (conv_q_src_c126_2_05 conv_q_c126_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_06 (conv_i_src_c126_2_06 0 conv_bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_2_06 (conv_i_src_c126_2_06 conv_i_c126_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_06 (conv_q_src_c126_2_06 0 conv_bpf_c126_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_2_06 (conv_q_src_c126_2_06 conv_q_c126_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_07 (conv_i_src_c126_2_07 0 conv_bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_2_07 (conv_i_src_c126_2_07 conv_i_c126_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_07 (conv_q_src_c126_2_07 0 conv_bpf_c126_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_2_07 (conv_q_src_c126_2_07 conv_q_c126_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_08 (conv_i_src_c126_2_08 0 conv_bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_2_08 (conv_i_src_c126_2_08 conv_i_c126_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_08 (conv_q_src_c126_2_08 0 conv_bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_2_08 (conv_q_src_c126_2_08 conv_q_c126_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_09 (conv_i_src_c126_2_09 0 conv_bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_2_09 (conv_i_src_c126_2_09 conv_i_c126_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_09 (conv_q_src_c126_2_09 0 conv_bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_2_09 (conv_q_src_c126_2_09 conv_q_c126_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_10 (conv_i_src_c126_2_10 0 conv_bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_2_10 (conv_i_src_c126_2_10 conv_i_c126_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_10 (conv_q_src_c126_2_10 0 conv_bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_2_10 (conv_q_src_c126_2_10 conv_q_c126_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_11 (conv_i_src_c126_2_11 0 conv_bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_2_11 (conv_i_src_c126_2_11 conv_i_c126_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_11 (conv_q_src_c126_2_11 0 conv_bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_2_11 (conv_q_src_c126_2_11 conv_q_c126_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_12 (conv_i_src_c126_2_12 0 conv_bpf_c126_2 0) vcvs gain=1.950903220161e-01
SCONVI_c126_2_12 (conv_i_src_c126_2_12 conv_i_c126_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_12 (conv_q_src_c126_2_12 0 conv_bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_2_12 (conv_q_src_c126_2_12 conv_q_c126_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_13 (conv_i_src_c126_2_13 0 conv_bpf_c126_2 0) vcvs gain=5.555702330196e-01
SCONVI_c126_2_13 (conv_i_src_c126_2_13 conv_i_c126_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_13 (conv_q_src_c126_2_13 0 conv_bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_2_13 (conv_q_src_c126_2_13 conv_q_c126_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_14 (conv_i_src_c126_2_14 0 conv_bpf_c126_2 0) vcvs gain=8.314696123025e-01
SCONVI_c126_2_14 (conv_i_src_c126_2_14 conv_i_c126_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_14 (conv_q_src_c126_2_14 0 conv_bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_2_14 (conv_q_src_c126_2_14 conv_q_c126_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_2_15 (conv_i_src_c126_2_15 0 conv_bpf_c126_2 0) vcvs gain=9.807852804032e-01
SCONVI_c126_2_15 (conv_i_src_c126_2_15 conv_i_c126_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_2_15 (conv_q_src_c126_2_15 0 conv_bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_2_15 (conv_q_src_c126_2_15 conv_q_c126_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c126_2 (conv_i_c126_2 0) resistor r=1G
RCONVQ_c126_2 (conv_q_c126_2 0) resistor r=1G
RCONVINTI_c126_2 (conv_i_c126_2 ConvIcar_c126_2) resistor r=1k
CCONVINTI_c126_2 (ConvIcar_c126_2 0) capacitor c=80p
RCONVINTQ_c126_2 (conv_q_c126_2 ConvQcar_c126_2) resistor r=1k
CCONVINTQ_c126_2 (ConvQcar_c126_2 0) capacitor c=80p
save conv_bpf_c126_2 ConvIcar_c126_2 ConvQcar_c126_2

// conventional mixed baseline bl126, carrier_3: 1000000000 Hz
CCONVBPF_c126_3 (bl126 n_conv_cbpf_c126_3) capacitor c=2.533029591058e-14
LCONVBPF_c126_3 (n_conv_cbpf_c126_3 conv_bpf_c126_3) inductor l=1.000000000000e-06
RCONVBPF_c126_3 (conv_bpf_c126_3 0) resistor r=3.141592653590e+02
ECONVI_c126_3_00 (conv_i_src_c126_3_00 0 conv_bpf_c126_3 0) vcvs gain=9.807852804032e-01
SCONVI_c126_3_00 (conv_i_src_c126_3_00 conv_i_c126_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_00 (conv_q_src_c126_3_00 0 conv_bpf_c126_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_3_00 (conv_q_src_c126_3_00 conv_q_c126_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_01 (conv_i_src_c126_3_01 0 conv_bpf_c126_3 0) vcvs gain=8.314696123025e-01
SCONVI_c126_3_01 (conv_i_src_c126_3_01 conv_i_c126_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_01 (conv_q_src_c126_3_01 0 conv_bpf_c126_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_3_01 (conv_q_src_c126_3_01 conv_q_c126_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_02 (conv_i_src_c126_3_02 0 conv_bpf_c126_3 0) vcvs gain=5.555702330196e-01
SCONVI_c126_3_02 (conv_i_src_c126_3_02 conv_i_c126_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_02 (conv_q_src_c126_3_02 0 conv_bpf_c126_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_3_02 (conv_q_src_c126_3_02 conv_q_c126_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_03 (conv_i_src_c126_3_03 0 conv_bpf_c126_3 0) vcvs gain=1.950903220161e-01
SCONVI_c126_3_03 (conv_i_src_c126_3_03 conv_i_c126_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_03 (conv_q_src_c126_3_03 0 conv_bpf_c126_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_3_03 (conv_q_src_c126_3_03 conv_q_c126_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_04 (conv_i_src_c126_3_04 0 conv_bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_3_04 (conv_i_src_c126_3_04 conv_i_c126_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_04 (conv_q_src_c126_3_04 0 conv_bpf_c126_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c126_3_04 (conv_q_src_c126_3_04 conv_q_c126_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_05 (conv_i_src_c126_3_05 0 conv_bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_3_05 (conv_i_src_c126_3_05 conv_i_c126_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_05 (conv_q_src_c126_3_05 0 conv_bpf_c126_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c126_3_05 (conv_q_src_c126_3_05 conv_q_c126_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_06 (conv_i_src_c126_3_06 0 conv_bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_3_06 (conv_i_src_c126_3_06 conv_i_c126_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_06 (conv_q_src_c126_3_06 0 conv_bpf_c126_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c126_3_06 (conv_q_src_c126_3_06 conv_q_c126_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_07 (conv_i_src_c126_3_07 0 conv_bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_3_07 (conv_i_src_c126_3_07 conv_i_c126_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_07 (conv_q_src_c126_3_07 0 conv_bpf_c126_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c126_3_07 (conv_q_src_c126_3_07 conv_q_c126_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_08 (conv_i_src_c126_3_08 0 conv_bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c126_3_08 (conv_i_src_c126_3_08 conv_i_c126_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_08 (conv_q_src_c126_3_08 0 conv_bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_3_08 (conv_q_src_c126_3_08 conv_q_c126_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_09 (conv_i_src_c126_3_09 0 conv_bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c126_3_09 (conv_i_src_c126_3_09 conv_i_c126_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_09 (conv_q_src_c126_3_09 0 conv_bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_3_09 (conv_q_src_c126_3_09 conv_q_c126_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_10 (conv_i_src_c126_3_10 0 conv_bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c126_3_10 (conv_i_src_c126_3_10 conv_i_c126_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_10 (conv_q_src_c126_3_10 0 conv_bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_3_10 (conv_q_src_c126_3_10 conv_q_c126_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_11 (conv_i_src_c126_3_11 0 conv_bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c126_3_11 (conv_i_src_c126_3_11 conv_i_c126_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_11 (conv_q_src_c126_3_11 0 conv_bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_3_11 (conv_q_src_c126_3_11 conv_q_c126_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_12 (conv_i_src_c126_3_12 0 conv_bpf_c126_3 0) vcvs gain=1.950903220161e-01
SCONVI_c126_3_12 (conv_i_src_c126_3_12 conv_i_c126_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_12 (conv_q_src_c126_3_12 0 conv_bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c126_3_12 (conv_q_src_c126_3_12 conv_q_c126_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_13 (conv_i_src_c126_3_13 0 conv_bpf_c126_3 0) vcvs gain=5.555702330196e-01
SCONVI_c126_3_13 (conv_i_src_c126_3_13 conv_i_c126_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_13 (conv_q_src_c126_3_13 0 conv_bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c126_3_13 (conv_q_src_c126_3_13 conv_q_c126_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_14 (conv_i_src_c126_3_14 0 conv_bpf_c126_3 0) vcvs gain=8.314696123025e-01
SCONVI_c126_3_14 (conv_i_src_c126_3_14 conv_i_c126_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_14 (conv_q_src_c126_3_14 0 conv_bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c126_3_14 (conv_q_src_c126_3_14 conv_q_c126_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c126_3_15 (conv_i_src_c126_3_15 0 conv_bpf_c126_3 0) vcvs gain=9.807852804032e-01
SCONVI_c126_3_15 (conv_i_src_c126_3_15 conv_i_c126_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c126_3_15 (conv_q_src_c126_3_15 0 conv_bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c126_3_15 (conv_q_src_c126_3_15 conv_q_c126_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c126_3 (conv_i_c126_3 0) resistor r=1G
RCONVQ_c126_3 (conv_q_c126_3 0) resistor r=1G
RCONVINTI_c126_3 (conv_i_c126_3 ConvIcar_c126_3) resistor r=1k
CCONVINTI_c126_3 (ConvIcar_c126_3 0) capacitor c=80p
RCONVINTQ_c126_3 (conv_q_c126_3 ConvQcar_c126_3) resistor r=1k
CCONVINTQ_c126_3 (ConvQcar_c126_3 0) capacitor c=80p
save conv_bpf_c126_3 ConvIcar_c126_3 ConvQcar_c126_3

// conventional mixed baseline bl127, carrier_0: 250000000 Hz
CCONVBPF_c127_0 (bl127 n_conv_cbpf_c127_0) capacitor c=4.052847345694e-13
LCONVBPF_c127_0 (n_conv_cbpf_c127_0 conv_bpf_c127_0) inductor l=1.000000000000e-06
RCONVBPF_c127_0 (conv_bpf_c127_0 0) resistor r=7.853981633974e+01
ECONVI_c127_0_00 (conv_i_src_c127_0_00 0 conv_bpf_c127_0 0) vcvs gain=9.807852804032e-01
SCONVI_c127_0_00 (conv_i_src_c127_0_00 conv_i_c127_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_00 (conv_q_src_c127_0_00 0 conv_bpf_c127_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_0_00 (conv_q_src_c127_0_00 conv_q_c127_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_01 (conv_i_src_c127_0_01 0 conv_bpf_c127_0 0) vcvs gain=8.314696123025e-01
SCONVI_c127_0_01 (conv_i_src_c127_0_01 conv_i_c127_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_01 (conv_q_src_c127_0_01 0 conv_bpf_c127_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_0_01 (conv_q_src_c127_0_01 conv_q_c127_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_02 (conv_i_src_c127_0_02 0 conv_bpf_c127_0 0) vcvs gain=5.555702330196e-01
SCONVI_c127_0_02 (conv_i_src_c127_0_02 conv_i_c127_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_02 (conv_q_src_c127_0_02 0 conv_bpf_c127_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_0_02 (conv_q_src_c127_0_02 conv_q_c127_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_03 (conv_i_src_c127_0_03 0 conv_bpf_c127_0 0) vcvs gain=1.950903220161e-01
SCONVI_c127_0_03 (conv_i_src_c127_0_03 conv_i_c127_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_03 (conv_q_src_c127_0_03 0 conv_bpf_c127_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_0_03 (conv_q_src_c127_0_03 conv_q_c127_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_04 (conv_i_src_c127_0_04 0 conv_bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_0_04 (conv_i_src_c127_0_04 conv_i_c127_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_04 (conv_q_src_c127_0_04 0 conv_bpf_c127_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_0_04 (conv_q_src_c127_0_04 conv_q_c127_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_05 (conv_i_src_c127_0_05 0 conv_bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_0_05 (conv_i_src_c127_0_05 conv_i_c127_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_05 (conv_q_src_c127_0_05 0 conv_bpf_c127_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_0_05 (conv_q_src_c127_0_05 conv_q_c127_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_06 (conv_i_src_c127_0_06 0 conv_bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_0_06 (conv_i_src_c127_0_06 conv_i_c127_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_06 (conv_q_src_c127_0_06 0 conv_bpf_c127_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_0_06 (conv_q_src_c127_0_06 conv_q_c127_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_07 (conv_i_src_c127_0_07 0 conv_bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_0_07 (conv_i_src_c127_0_07 conv_i_c127_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_07 (conv_q_src_c127_0_07 0 conv_bpf_c127_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_0_07 (conv_q_src_c127_0_07 conv_q_c127_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_08 (conv_i_src_c127_0_08 0 conv_bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_0_08 (conv_i_src_c127_0_08 conv_i_c127_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_08 (conv_q_src_c127_0_08 0 conv_bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_0_08 (conv_q_src_c127_0_08 conv_q_c127_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_09 (conv_i_src_c127_0_09 0 conv_bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_0_09 (conv_i_src_c127_0_09 conv_i_c127_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_09 (conv_q_src_c127_0_09 0 conv_bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_0_09 (conv_q_src_c127_0_09 conv_q_c127_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_10 (conv_i_src_c127_0_10 0 conv_bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_0_10 (conv_i_src_c127_0_10 conv_i_c127_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_10 (conv_q_src_c127_0_10 0 conv_bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_0_10 (conv_q_src_c127_0_10 conv_q_c127_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_11 (conv_i_src_c127_0_11 0 conv_bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_0_11 (conv_i_src_c127_0_11 conv_i_c127_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_11 (conv_q_src_c127_0_11 0 conv_bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_0_11 (conv_q_src_c127_0_11 conv_q_c127_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_12 (conv_i_src_c127_0_12 0 conv_bpf_c127_0 0) vcvs gain=1.950903220161e-01
SCONVI_c127_0_12 (conv_i_src_c127_0_12 conv_i_c127_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_12 (conv_q_src_c127_0_12 0 conv_bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_0_12 (conv_q_src_c127_0_12 conv_q_c127_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_13 (conv_i_src_c127_0_13 0 conv_bpf_c127_0 0) vcvs gain=5.555702330196e-01
SCONVI_c127_0_13 (conv_i_src_c127_0_13 conv_i_c127_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_13 (conv_q_src_c127_0_13 0 conv_bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_0_13 (conv_q_src_c127_0_13 conv_q_c127_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_14 (conv_i_src_c127_0_14 0 conv_bpf_c127_0 0) vcvs gain=8.314696123025e-01
SCONVI_c127_0_14 (conv_i_src_c127_0_14 conv_i_c127_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_14 (conv_q_src_c127_0_14 0 conv_bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_0_14 (conv_q_src_c127_0_14 conv_q_c127_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_0_15 (conv_i_src_c127_0_15 0 conv_bpf_c127_0 0) vcvs gain=9.807852804032e-01
SCONVI_c127_0_15 (conv_i_src_c127_0_15 conv_i_c127_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_0_15 (conv_q_src_c127_0_15 0 conv_bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_0_15 (conv_q_src_c127_0_15 conv_q_c127_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c127_0 (conv_i_c127_0 0) resistor r=1G
RCONVQ_c127_0 (conv_q_c127_0 0) resistor r=1G
RCONVINTI_c127_0 (conv_i_c127_0 ConvIcar_c127_0) resistor r=1k
CCONVINTI_c127_0 (ConvIcar_c127_0 0) capacitor c=80p
RCONVINTQ_c127_0 (conv_q_c127_0 ConvQcar_c127_0) resistor r=1k
CCONVINTQ_c127_0 (ConvQcar_c127_0 0) capacitor c=80p
save conv_bpf_c127_0 ConvIcar_c127_0 ConvQcar_c127_0

// conventional mixed baseline bl127, carrier_1: 500000000 Hz
CCONVBPF_c127_1 (bl127 n_conv_cbpf_c127_1) capacitor c=1.013211836423e-13
LCONVBPF_c127_1 (n_conv_cbpf_c127_1 conv_bpf_c127_1) inductor l=1.000000000000e-06
RCONVBPF_c127_1 (conv_bpf_c127_1 0) resistor r=1.570796326795e+02
ECONVI_c127_1_00 (conv_i_src_c127_1_00 0 conv_bpf_c127_1 0) vcvs gain=9.807852804032e-01
SCONVI_c127_1_00 (conv_i_src_c127_1_00 conv_i_c127_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_00 (conv_q_src_c127_1_00 0 conv_bpf_c127_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_1_00 (conv_q_src_c127_1_00 conv_q_c127_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_01 (conv_i_src_c127_1_01 0 conv_bpf_c127_1 0) vcvs gain=8.314696123025e-01
SCONVI_c127_1_01 (conv_i_src_c127_1_01 conv_i_c127_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_01 (conv_q_src_c127_1_01 0 conv_bpf_c127_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_1_01 (conv_q_src_c127_1_01 conv_q_c127_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_02 (conv_i_src_c127_1_02 0 conv_bpf_c127_1 0) vcvs gain=5.555702330196e-01
SCONVI_c127_1_02 (conv_i_src_c127_1_02 conv_i_c127_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_02 (conv_q_src_c127_1_02 0 conv_bpf_c127_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_1_02 (conv_q_src_c127_1_02 conv_q_c127_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_03 (conv_i_src_c127_1_03 0 conv_bpf_c127_1 0) vcvs gain=1.950903220161e-01
SCONVI_c127_1_03 (conv_i_src_c127_1_03 conv_i_c127_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_03 (conv_q_src_c127_1_03 0 conv_bpf_c127_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_1_03 (conv_q_src_c127_1_03 conv_q_c127_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_04 (conv_i_src_c127_1_04 0 conv_bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_1_04 (conv_i_src_c127_1_04 conv_i_c127_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_04 (conv_q_src_c127_1_04 0 conv_bpf_c127_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_1_04 (conv_q_src_c127_1_04 conv_q_c127_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_05 (conv_i_src_c127_1_05 0 conv_bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_1_05 (conv_i_src_c127_1_05 conv_i_c127_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_05 (conv_q_src_c127_1_05 0 conv_bpf_c127_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_1_05 (conv_q_src_c127_1_05 conv_q_c127_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_06 (conv_i_src_c127_1_06 0 conv_bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_1_06 (conv_i_src_c127_1_06 conv_i_c127_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_06 (conv_q_src_c127_1_06 0 conv_bpf_c127_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_1_06 (conv_q_src_c127_1_06 conv_q_c127_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_07 (conv_i_src_c127_1_07 0 conv_bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_1_07 (conv_i_src_c127_1_07 conv_i_c127_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_07 (conv_q_src_c127_1_07 0 conv_bpf_c127_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_1_07 (conv_q_src_c127_1_07 conv_q_c127_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_08 (conv_i_src_c127_1_08 0 conv_bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_1_08 (conv_i_src_c127_1_08 conv_i_c127_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_08 (conv_q_src_c127_1_08 0 conv_bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_1_08 (conv_q_src_c127_1_08 conv_q_c127_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_09 (conv_i_src_c127_1_09 0 conv_bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_1_09 (conv_i_src_c127_1_09 conv_i_c127_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_09 (conv_q_src_c127_1_09 0 conv_bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_1_09 (conv_q_src_c127_1_09 conv_q_c127_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_10 (conv_i_src_c127_1_10 0 conv_bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_1_10 (conv_i_src_c127_1_10 conv_i_c127_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_10 (conv_q_src_c127_1_10 0 conv_bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_1_10 (conv_q_src_c127_1_10 conv_q_c127_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_11 (conv_i_src_c127_1_11 0 conv_bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_1_11 (conv_i_src_c127_1_11 conv_i_c127_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_11 (conv_q_src_c127_1_11 0 conv_bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_1_11 (conv_q_src_c127_1_11 conv_q_c127_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_12 (conv_i_src_c127_1_12 0 conv_bpf_c127_1 0) vcvs gain=1.950903220161e-01
SCONVI_c127_1_12 (conv_i_src_c127_1_12 conv_i_c127_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_12 (conv_q_src_c127_1_12 0 conv_bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_1_12 (conv_q_src_c127_1_12 conv_q_c127_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_13 (conv_i_src_c127_1_13 0 conv_bpf_c127_1 0) vcvs gain=5.555702330196e-01
SCONVI_c127_1_13 (conv_i_src_c127_1_13 conv_i_c127_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_13 (conv_q_src_c127_1_13 0 conv_bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_1_13 (conv_q_src_c127_1_13 conv_q_c127_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_14 (conv_i_src_c127_1_14 0 conv_bpf_c127_1 0) vcvs gain=8.314696123025e-01
SCONVI_c127_1_14 (conv_i_src_c127_1_14 conv_i_c127_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_14 (conv_q_src_c127_1_14 0 conv_bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_1_14 (conv_q_src_c127_1_14 conv_q_c127_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_1_15 (conv_i_src_c127_1_15 0 conv_bpf_c127_1 0) vcvs gain=9.807852804032e-01
SCONVI_c127_1_15 (conv_i_src_c127_1_15 conv_i_c127_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_1_15 (conv_q_src_c127_1_15 0 conv_bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_1_15 (conv_q_src_c127_1_15 conv_q_c127_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c127_1 (conv_i_c127_1 0) resistor r=1G
RCONVQ_c127_1 (conv_q_c127_1 0) resistor r=1G
RCONVINTI_c127_1 (conv_i_c127_1 ConvIcar_c127_1) resistor r=1k
CCONVINTI_c127_1 (ConvIcar_c127_1 0) capacitor c=80p
RCONVINTQ_c127_1 (conv_q_c127_1 ConvQcar_c127_1) resistor r=1k
CCONVINTQ_c127_1 (ConvQcar_c127_1 0) capacitor c=80p
save conv_bpf_c127_1 ConvIcar_c127_1 ConvQcar_c127_1

// conventional mixed baseline bl127, carrier_2: 750000000 Hz
CCONVBPF_c127_2 (bl127 n_conv_cbpf_c127_2) capacitor c=4.503163717437e-14
LCONVBPF_c127_2 (n_conv_cbpf_c127_2 conv_bpf_c127_2) inductor l=1.000000000000e-06
RCONVBPF_c127_2 (conv_bpf_c127_2 0) resistor r=2.356194490192e+02
ECONVI_c127_2_00 (conv_i_src_c127_2_00 0 conv_bpf_c127_2 0) vcvs gain=9.807852804032e-01
SCONVI_c127_2_00 (conv_i_src_c127_2_00 conv_i_c127_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_00 (conv_q_src_c127_2_00 0 conv_bpf_c127_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_2_00 (conv_q_src_c127_2_00 conv_q_c127_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_01 (conv_i_src_c127_2_01 0 conv_bpf_c127_2 0) vcvs gain=8.314696123025e-01
SCONVI_c127_2_01 (conv_i_src_c127_2_01 conv_i_c127_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_01 (conv_q_src_c127_2_01 0 conv_bpf_c127_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_2_01 (conv_q_src_c127_2_01 conv_q_c127_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_02 (conv_i_src_c127_2_02 0 conv_bpf_c127_2 0) vcvs gain=5.555702330196e-01
SCONVI_c127_2_02 (conv_i_src_c127_2_02 conv_i_c127_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_02 (conv_q_src_c127_2_02 0 conv_bpf_c127_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_2_02 (conv_q_src_c127_2_02 conv_q_c127_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_03 (conv_i_src_c127_2_03 0 conv_bpf_c127_2 0) vcvs gain=1.950903220161e-01
SCONVI_c127_2_03 (conv_i_src_c127_2_03 conv_i_c127_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_03 (conv_q_src_c127_2_03 0 conv_bpf_c127_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_2_03 (conv_q_src_c127_2_03 conv_q_c127_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_04 (conv_i_src_c127_2_04 0 conv_bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_2_04 (conv_i_src_c127_2_04 conv_i_c127_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_04 (conv_q_src_c127_2_04 0 conv_bpf_c127_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_2_04 (conv_q_src_c127_2_04 conv_q_c127_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_05 (conv_i_src_c127_2_05 0 conv_bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_2_05 (conv_i_src_c127_2_05 conv_i_c127_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_05 (conv_q_src_c127_2_05 0 conv_bpf_c127_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_2_05 (conv_q_src_c127_2_05 conv_q_c127_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_06 (conv_i_src_c127_2_06 0 conv_bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_2_06 (conv_i_src_c127_2_06 conv_i_c127_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_06 (conv_q_src_c127_2_06 0 conv_bpf_c127_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_2_06 (conv_q_src_c127_2_06 conv_q_c127_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_07 (conv_i_src_c127_2_07 0 conv_bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_2_07 (conv_i_src_c127_2_07 conv_i_c127_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_07 (conv_q_src_c127_2_07 0 conv_bpf_c127_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_2_07 (conv_q_src_c127_2_07 conv_q_c127_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_08 (conv_i_src_c127_2_08 0 conv_bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_2_08 (conv_i_src_c127_2_08 conv_i_c127_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_08 (conv_q_src_c127_2_08 0 conv_bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_2_08 (conv_q_src_c127_2_08 conv_q_c127_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_09 (conv_i_src_c127_2_09 0 conv_bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_2_09 (conv_i_src_c127_2_09 conv_i_c127_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_09 (conv_q_src_c127_2_09 0 conv_bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_2_09 (conv_q_src_c127_2_09 conv_q_c127_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_10 (conv_i_src_c127_2_10 0 conv_bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_2_10 (conv_i_src_c127_2_10 conv_i_c127_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_10 (conv_q_src_c127_2_10 0 conv_bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_2_10 (conv_q_src_c127_2_10 conv_q_c127_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_11 (conv_i_src_c127_2_11 0 conv_bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_2_11 (conv_i_src_c127_2_11 conv_i_c127_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_11 (conv_q_src_c127_2_11 0 conv_bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_2_11 (conv_q_src_c127_2_11 conv_q_c127_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_12 (conv_i_src_c127_2_12 0 conv_bpf_c127_2 0) vcvs gain=1.950903220161e-01
SCONVI_c127_2_12 (conv_i_src_c127_2_12 conv_i_c127_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_12 (conv_q_src_c127_2_12 0 conv_bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_2_12 (conv_q_src_c127_2_12 conv_q_c127_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_13 (conv_i_src_c127_2_13 0 conv_bpf_c127_2 0) vcvs gain=5.555702330196e-01
SCONVI_c127_2_13 (conv_i_src_c127_2_13 conv_i_c127_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_13 (conv_q_src_c127_2_13 0 conv_bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_2_13 (conv_q_src_c127_2_13 conv_q_c127_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_14 (conv_i_src_c127_2_14 0 conv_bpf_c127_2 0) vcvs gain=8.314696123025e-01
SCONVI_c127_2_14 (conv_i_src_c127_2_14 conv_i_c127_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_14 (conv_q_src_c127_2_14 0 conv_bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_2_14 (conv_q_src_c127_2_14 conv_q_c127_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_2_15 (conv_i_src_c127_2_15 0 conv_bpf_c127_2 0) vcvs gain=9.807852804032e-01
SCONVI_c127_2_15 (conv_i_src_c127_2_15 conv_i_c127_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_2_15 (conv_q_src_c127_2_15 0 conv_bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_2_15 (conv_q_src_c127_2_15 conv_q_c127_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c127_2 (conv_i_c127_2 0) resistor r=1G
RCONVQ_c127_2 (conv_q_c127_2 0) resistor r=1G
RCONVINTI_c127_2 (conv_i_c127_2 ConvIcar_c127_2) resistor r=1k
CCONVINTI_c127_2 (ConvIcar_c127_2 0) capacitor c=80p
RCONVINTQ_c127_2 (conv_q_c127_2 ConvQcar_c127_2) resistor r=1k
CCONVINTQ_c127_2 (ConvQcar_c127_2 0) capacitor c=80p
save conv_bpf_c127_2 ConvIcar_c127_2 ConvQcar_c127_2

// conventional mixed baseline bl127, carrier_3: 1000000000 Hz
CCONVBPF_c127_3 (bl127 n_conv_cbpf_c127_3) capacitor c=2.533029591058e-14
LCONVBPF_c127_3 (n_conv_cbpf_c127_3 conv_bpf_c127_3) inductor l=1.000000000000e-06
RCONVBPF_c127_3 (conv_bpf_c127_3 0) resistor r=3.141592653590e+02
ECONVI_c127_3_00 (conv_i_src_c127_3_00 0 conv_bpf_c127_3 0) vcvs gain=9.807852804032e-01
SCONVI_c127_3_00 (conv_i_src_c127_3_00 conv_i_c127_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_00 (conv_q_src_c127_3_00 0 conv_bpf_c127_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_3_00 (conv_q_src_c127_3_00 conv_q_c127_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_01 (conv_i_src_c127_3_01 0 conv_bpf_c127_3 0) vcvs gain=8.314696123025e-01
SCONVI_c127_3_01 (conv_i_src_c127_3_01 conv_i_c127_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_01 (conv_q_src_c127_3_01 0 conv_bpf_c127_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_3_01 (conv_q_src_c127_3_01 conv_q_c127_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_02 (conv_i_src_c127_3_02 0 conv_bpf_c127_3 0) vcvs gain=5.555702330196e-01
SCONVI_c127_3_02 (conv_i_src_c127_3_02 conv_i_c127_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_02 (conv_q_src_c127_3_02 0 conv_bpf_c127_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_3_02 (conv_q_src_c127_3_02 conv_q_c127_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_03 (conv_i_src_c127_3_03 0 conv_bpf_c127_3 0) vcvs gain=1.950903220161e-01
SCONVI_c127_3_03 (conv_i_src_c127_3_03 conv_i_c127_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_03 (conv_q_src_c127_3_03 0 conv_bpf_c127_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_3_03 (conv_q_src_c127_3_03 conv_q_c127_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_04 (conv_i_src_c127_3_04 0 conv_bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_3_04 (conv_i_src_c127_3_04 conv_i_c127_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_04 (conv_q_src_c127_3_04 0 conv_bpf_c127_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c127_3_04 (conv_q_src_c127_3_04 conv_q_c127_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_05 (conv_i_src_c127_3_05 0 conv_bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_3_05 (conv_i_src_c127_3_05 conv_i_c127_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_05 (conv_q_src_c127_3_05 0 conv_bpf_c127_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c127_3_05 (conv_q_src_c127_3_05 conv_q_c127_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_06 (conv_i_src_c127_3_06 0 conv_bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_3_06 (conv_i_src_c127_3_06 conv_i_c127_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_06 (conv_q_src_c127_3_06 0 conv_bpf_c127_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c127_3_06 (conv_q_src_c127_3_06 conv_q_c127_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_07 (conv_i_src_c127_3_07 0 conv_bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_3_07 (conv_i_src_c127_3_07 conv_i_c127_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_07 (conv_q_src_c127_3_07 0 conv_bpf_c127_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c127_3_07 (conv_q_src_c127_3_07 conv_q_c127_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_08 (conv_i_src_c127_3_08 0 conv_bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c127_3_08 (conv_i_src_c127_3_08 conv_i_c127_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_08 (conv_q_src_c127_3_08 0 conv_bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_3_08 (conv_q_src_c127_3_08 conv_q_c127_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_09 (conv_i_src_c127_3_09 0 conv_bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c127_3_09 (conv_i_src_c127_3_09 conv_i_c127_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_09 (conv_q_src_c127_3_09 0 conv_bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_3_09 (conv_q_src_c127_3_09 conv_q_c127_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_10 (conv_i_src_c127_3_10 0 conv_bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c127_3_10 (conv_i_src_c127_3_10 conv_i_c127_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_10 (conv_q_src_c127_3_10 0 conv_bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_3_10 (conv_q_src_c127_3_10 conv_q_c127_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_11 (conv_i_src_c127_3_11 0 conv_bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c127_3_11 (conv_i_src_c127_3_11 conv_i_c127_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_11 (conv_q_src_c127_3_11 0 conv_bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_3_11 (conv_q_src_c127_3_11 conv_q_c127_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_12 (conv_i_src_c127_3_12 0 conv_bpf_c127_3 0) vcvs gain=1.950903220161e-01
SCONVI_c127_3_12 (conv_i_src_c127_3_12 conv_i_c127_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_12 (conv_q_src_c127_3_12 0 conv_bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c127_3_12 (conv_q_src_c127_3_12 conv_q_c127_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_13 (conv_i_src_c127_3_13 0 conv_bpf_c127_3 0) vcvs gain=5.555702330196e-01
SCONVI_c127_3_13 (conv_i_src_c127_3_13 conv_i_c127_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_13 (conv_q_src_c127_3_13 0 conv_bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c127_3_13 (conv_q_src_c127_3_13 conv_q_c127_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_14 (conv_i_src_c127_3_14 0 conv_bpf_c127_3 0) vcvs gain=8.314696123025e-01
SCONVI_c127_3_14 (conv_i_src_c127_3_14 conv_i_c127_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_14 (conv_q_src_c127_3_14 0 conv_bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c127_3_14 (conv_q_src_c127_3_14 conv_q_c127_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c127_3_15 (conv_i_src_c127_3_15 0 conv_bpf_c127_3 0) vcvs gain=9.807852804032e-01
SCONVI_c127_3_15 (conv_i_src_c127_3_15 conv_i_c127_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c127_3_15 (conv_q_src_c127_3_15 0 conv_bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c127_3_15 (conv_q_src_c127_3_15 conv_q_c127_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c127_3 (conv_i_c127_3 0) resistor r=1G
RCONVQ_c127_3 (conv_q_c127_3 0) resistor r=1G
RCONVINTI_c127_3 (conv_i_c127_3 ConvIcar_c127_3) resistor r=1k
CCONVINTI_c127_3 (ConvIcar_c127_3 0) capacitor c=80p
RCONVINTQ_c127_3 (conv_q_c127_3 ConvQcar_c127_3) resistor r=1k
CCONVINTQ_c127_3 (ConvQcar_c127_3 0) capacitor c=80p
save conv_bpf_c127_3 ConvIcar_c127_3 ConvQcar_c127_3

tbtran tran stop=80n maxstep=5p
