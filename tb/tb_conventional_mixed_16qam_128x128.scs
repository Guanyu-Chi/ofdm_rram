SCONVQ_c065_1_15 (conv_q_src_c065_1_15 conv_q_c065_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c065_1 (conv_i_c065_1 0) resistor r=1G
RCONVQ_c065_1 (conv_q_c065_1 0) resistor r=1G
RCONVINTI_c065_1 (conv_i_c065_1 ConvIcar_c065_1) resistor r=1k
CCONVINTI_c065_1 (ConvIcar_c065_1 0) capacitor c=80p
RCONVINTQ_c065_1 (conv_q_c065_1 ConvQcar_c065_1) resistor r=1k
CCONVINTQ_c065_1 (ConvQcar_c065_1 0) capacitor c=80p
save conv_bpf_c065_1 ConvIcar_c065_1 ConvQcar_c065_1

// conventional mixed baseline bl065, carrier_2: 750000000 Hz
CCONVBPF_c065_2 (bl065 n_conv_cbpf_c065_2) capacitor c=4.503163717437e-14
LCONVBPF_c065_2 (n_conv_cbpf_c065_2 conv_bpf_c065_2) inductor l=1.000000000000e-06
RCONVBPF_c065_2 (conv_bpf_c065_2 0) resistor r=2.356194490192e+02
ECONVI_c065_2_00 (conv_i_src_c065_2_00 0 conv_bpf_c065_2 0) vcvs gain=9.807852804032e-01
SCONVI_c065_2_00 (conv_i_src_c065_2_00 conv_i_c065_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_00 (conv_q_src_c065_2_00 0 conv_bpf_c065_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_2_00 (conv_q_src_c065_2_00 conv_q_c065_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_01 (conv_i_src_c065_2_01 0 conv_bpf_c065_2 0) vcvs gain=8.314696123025e-01
SCONVI_c065_2_01 (conv_i_src_c065_2_01 conv_i_c065_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_01 (conv_q_src_c065_2_01 0 conv_bpf_c065_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_2_01 (conv_q_src_c065_2_01 conv_q_c065_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_02 (conv_i_src_c065_2_02 0 conv_bpf_c065_2 0) vcvs gain=5.555702330196e-01
SCONVI_c065_2_02 (conv_i_src_c065_2_02 conv_i_c065_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_02 (conv_q_src_c065_2_02 0 conv_bpf_c065_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_2_02 (conv_q_src_c065_2_02 conv_q_c065_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_03 (conv_i_src_c065_2_03 0 conv_bpf_c065_2 0) vcvs gain=1.950903220161e-01
SCONVI_c065_2_03 (conv_i_src_c065_2_03 conv_i_c065_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_03 (conv_q_src_c065_2_03 0 conv_bpf_c065_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_2_03 (conv_q_src_c065_2_03 conv_q_c065_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_04 (conv_i_src_c065_2_04 0 conv_bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_2_04 (conv_i_src_c065_2_04 conv_i_c065_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_04 (conv_q_src_c065_2_04 0 conv_bpf_c065_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_2_04 (conv_q_src_c065_2_04 conv_q_c065_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_05 (conv_i_src_c065_2_05 0 conv_bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_2_05 (conv_i_src_c065_2_05 conv_i_c065_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_05 (conv_q_src_c065_2_05 0 conv_bpf_c065_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_2_05 (conv_q_src_c065_2_05 conv_q_c065_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_06 (conv_i_src_c065_2_06 0 conv_bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_2_06 (conv_i_src_c065_2_06 conv_i_c065_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_06 (conv_q_src_c065_2_06 0 conv_bpf_c065_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_2_06 (conv_q_src_c065_2_06 conv_q_c065_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_07 (conv_i_src_c065_2_07 0 conv_bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_2_07 (conv_i_src_c065_2_07 conv_i_c065_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_07 (conv_q_src_c065_2_07 0 conv_bpf_c065_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_2_07 (conv_q_src_c065_2_07 conv_q_c065_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_08 (conv_i_src_c065_2_08 0 conv_bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_2_08 (conv_i_src_c065_2_08 conv_i_c065_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_08 (conv_q_src_c065_2_08 0 conv_bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c065_2_08 (conv_q_src_c065_2_08 conv_q_c065_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_09 (conv_i_src_c065_2_09 0 conv_bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_2_09 (conv_i_src_c065_2_09 conv_i_c065_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_09 (conv_q_src_c065_2_09 0 conv_bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_2_09 (conv_q_src_c065_2_09 conv_q_c065_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_10 (conv_i_src_c065_2_10 0 conv_bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_2_10 (conv_i_src_c065_2_10 conv_i_c065_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_10 (conv_q_src_c065_2_10 0 conv_bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_2_10 (conv_q_src_c065_2_10 conv_q_c065_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_11 (conv_i_src_c065_2_11 0 conv_bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_2_11 (conv_i_src_c065_2_11 conv_i_c065_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_11 (conv_q_src_c065_2_11 0 conv_bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_2_11 (conv_q_src_c065_2_11 conv_q_c065_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_12 (conv_i_src_c065_2_12 0 conv_bpf_c065_2 0) vcvs gain=1.950903220161e-01
SCONVI_c065_2_12 (conv_i_src_c065_2_12 conv_i_c065_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_12 (conv_q_src_c065_2_12 0 conv_bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_2_12 (conv_q_src_c065_2_12 conv_q_c065_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_13 (conv_i_src_c065_2_13 0 conv_bpf_c065_2 0) vcvs gain=5.555702330196e-01
SCONVI_c065_2_13 (conv_i_src_c065_2_13 conv_i_c065_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_13 (conv_q_src_c065_2_13 0 conv_bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_2_13 (conv_q_src_c065_2_13 conv_q_c065_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_14 (conv_i_src_c065_2_14 0 conv_bpf_c065_2 0) vcvs gain=8.314696123025e-01
SCONVI_c065_2_14 (conv_i_src_c065_2_14 conv_i_c065_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_14 (conv_q_src_c065_2_14 0 conv_bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_2_14 (conv_q_src_c065_2_14 conv_q_c065_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_2_15 (conv_i_src_c065_2_15 0 conv_bpf_c065_2 0) vcvs gain=9.807852804032e-01
SCONVI_c065_2_15 (conv_i_src_c065_2_15 conv_i_c065_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_2_15 (conv_q_src_c065_2_15 0 conv_bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c065_2_15 (conv_q_src_c065_2_15 conv_q_c065_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c065_2 (conv_i_c065_2 0) resistor r=1G
RCONVQ_c065_2 (conv_q_c065_2 0) resistor r=1G
RCONVINTI_c065_2 (conv_i_c065_2 ConvIcar_c065_2) resistor r=1k
CCONVINTI_c065_2 (ConvIcar_c065_2 0) capacitor c=80p
RCONVINTQ_c065_2 (conv_q_c065_2 ConvQcar_c065_2) resistor r=1k
CCONVINTQ_c065_2 (ConvQcar_c065_2 0) capacitor c=80p
save conv_bpf_c065_2 ConvIcar_c065_2 ConvQcar_c065_2

// conventional mixed baseline bl065, carrier_3: 1000000000 Hz
CCONVBPF_c065_3 (bl065 n_conv_cbpf_c065_3) capacitor c=2.533029591058e-14
LCONVBPF_c065_3 (n_conv_cbpf_c065_3 conv_bpf_c065_3) inductor l=1.000000000000e-06
RCONVBPF_c065_3 (conv_bpf_c065_3 0) resistor r=3.141592653590e+02
ECONVI_c065_3_00 (conv_i_src_c065_3_00 0 conv_bpf_c065_3 0) vcvs gain=9.807852804032e-01
SCONVI_c065_3_00 (conv_i_src_c065_3_00 conv_i_c065_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_00 (conv_q_src_c065_3_00 0 conv_bpf_c065_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_3_00 (conv_q_src_c065_3_00 conv_q_c065_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_01 (conv_i_src_c065_3_01 0 conv_bpf_c065_3 0) vcvs gain=8.314696123025e-01
SCONVI_c065_3_01 (conv_i_src_c065_3_01 conv_i_c065_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_01 (conv_q_src_c065_3_01 0 conv_bpf_c065_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_3_01 (conv_q_src_c065_3_01 conv_q_c065_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_02 (conv_i_src_c065_3_02 0 conv_bpf_c065_3 0) vcvs gain=5.555702330196e-01
SCONVI_c065_3_02 (conv_i_src_c065_3_02 conv_i_c065_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_02 (conv_q_src_c065_3_02 0 conv_bpf_c065_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_3_02 (conv_q_src_c065_3_02 conv_q_c065_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_03 (conv_i_src_c065_3_03 0 conv_bpf_c065_3 0) vcvs gain=1.950903220161e-01
SCONVI_c065_3_03 (conv_i_src_c065_3_03 conv_i_c065_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_03 (conv_q_src_c065_3_03 0 conv_bpf_c065_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_3_03 (conv_q_src_c065_3_03 conv_q_c065_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_04 (conv_i_src_c065_3_04 0 conv_bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_3_04 (conv_i_src_c065_3_04 conv_i_c065_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_04 (conv_q_src_c065_3_04 0 conv_bpf_c065_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c065_3_04 (conv_q_src_c065_3_04 conv_q_c065_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_05 (conv_i_src_c065_3_05 0 conv_bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_3_05 (conv_i_src_c065_3_05 conv_i_c065_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_05 (conv_q_src_c065_3_05 0 conv_bpf_c065_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c065_3_05 (conv_q_src_c065_3_05 conv_q_c065_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_06 (conv_i_src_c065_3_06 0 conv_bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_3_06 (conv_i_src_c065_3_06 conv_i_c065_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_06 (conv_q_src_c065_3_06 0 conv_bpf_c065_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c065_3_06 (conv_q_src_c065_3_06 conv_q_c065_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_07 (conv_i_src_c065_3_07 0 conv_bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_3_07 (conv_i_src_c065_3_07 conv_i_c065_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_07 (conv_q_src_c065_3_07 0 conv_bpf_c065_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c065_3_07 (conv_q_src_c065_3_07 conv_q_c065_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_08 (conv_i_src_c065_3_08 0 conv_bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c065_3_08 (conv_i_src_c065_3_08 conv_i_c065_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_08 (conv_q_src_c065_3_08 0 conv_bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c065_3_08 (conv_q_src_c065_3_08 conv_q_c065_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_09 (conv_i_src_c065_3_09 0 conv_bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c065_3_09 (conv_i_src_c065_3_09 conv_i_c065_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_09 (conv_q_src_c065_3_09 0 conv_bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_3_09 (conv_q_src_c065_3_09 conv_q_c065_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_10 (conv_i_src_c065_3_10 0 conv_bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c065_3_10 (conv_i_src_c065_3_10 conv_i_c065_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_10 (conv_q_src_c065_3_10 0 conv_bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_3_10 (conv_q_src_c065_3_10 conv_q_c065_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_11 (conv_i_src_c065_3_11 0 conv_bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c065_3_11 (conv_i_src_c065_3_11 conv_i_c065_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_11 (conv_q_src_c065_3_11 0 conv_bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_3_11 (conv_q_src_c065_3_11 conv_q_c065_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_12 (conv_i_src_c065_3_12 0 conv_bpf_c065_3 0) vcvs gain=1.950903220161e-01
SCONVI_c065_3_12 (conv_i_src_c065_3_12 conv_i_c065_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_12 (conv_q_src_c065_3_12 0 conv_bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c065_3_12 (conv_q_src_c065_3_12 conv_q_c065_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_13 (conv_i_src_c065_3_13 0 conv_bpf_c065_3 0) vcvs gain=5.555702330196e-01
SCONVI_c065_3_13 (conv_i_src_c065_3_13 conv_i_c065_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_13 (conv_q_src_c065_3_13 0 conv_bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c065_3_13 (conv_q_src_c065_3_13 conv_q_c065_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_14 (conv_i_src_c065_3_14 0 conv_bpf_c065_3 0) vcvs gain=8.314696123025e-01
SCONVI_c065_3_14 (conv_i_src_c065_3_14 conv_i_c065_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_14 (conv_q_src_c065_3_14 0 conv_bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c065_3_14 (conv_q_src_c065_3_14 conv_q_c065_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c065_3_15 (conv_i_src_c065_3_15 0 conv_bpf_c065_3 0) vcvs gain=9.807852804032e-01
SCONVI_c065_3_15 (conv_i_src_c065_3_15 conv_i_c065_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c065_3_15 (conv_q_src_c065_3_15 0 conv_bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c065_3_15 (conv_q_src_c065_3_15 conv_q_c065_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c065_3 (conv_i_c065_3 0) resistor r=1G
RCONVQ_c065_3 (conv_q_c065_3 0) resistor r=1G
RCONVINTI_c065_3 (conv_i_c065_3 ConvIcar_c065_3) resistor r=1k
CCONVINTI_c065_3 (ConvIcar_c065_3 0) capacitor c=80p
RCONVINTQ_c065_3 (conv_q_c065_3 ConvQcar_c065_3) resistor r=1k
CCONVINTQ_c065_3 (ConvQcar_c065_3 0) capacitor c=80p
save conv_bpf_c065_3 ConvIcar_c065_3 ConvQcar_c065_3

// conventional mixed baseline bl066, carrier_0: 250000000 Hz
CCONVBPF_c066_0 (bl066 n_conv_cbpf_c066_0) capacitor c=4.052847345694e-13
LCONVBPF_c066_0 (n_conv_cbpf_c066_0 conv_bpf_c066_0) inductor l=1.000000000000e-06
RCONVBPF_c066_0 (conv_bpf_c066_0 0) resistor r=7.853981633974e+01
ECONVI_c066_0_00 (conv_i_src_c066_0_00 0 conv_bpf_c066_0 0) vcvs gain=9.807852804032e-01
SCONVI_c066_0_00 (conv_i_src_c066_0_00 conv_i_c066_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_00 (conv_q_src_c066_0_00 0 conv_bpf_c066_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_0_00 (conv_q_src_c066_0_00 conv_q_c066_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_01 (conv_i_src_c066_0_01 0 conv_bpf_c066_0 0) vcvs gain=8.314696123025e-01
SCONVI_c066_0_01 (conv_i_src_c066_0_01 conv_i_c066_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_01 (conv_q_src_c066_0_01 0 conv_bpf_c066_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_0_01 (conv_q_src_c066_0_01 conv_q_c066_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_02 (conv_i_src_c066_0_02 0 conv_bpf_c066_0 0) vcvs gain=5.555702330196e-01
SCONVI_c066_0_02 (conv_i_src_c066_0_02 conv_i_c066_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_02 (conv_q_src_c066_0_02 0 conv_bpf_c066_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_0_02 (conv_q_src_c066_0_02 conv_q_c066_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_03 (conv_i_src_c066_0_03 0 conv_bpf_c066_0 0) vcvs gain=1.950903220161e-01
SCONVI_c066_0_03 (conv_i_src_c066_0_03 conv_i_c066_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_03 (conv_q_src_c066_0_03 0 conv_bpf_c066_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_0_03 (conv_q_src_c066_0_03 conv_q_c066_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_04 (conv_i_src_c066_0_04 0 conv_bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_0_04 (conv_i_src_c066_0_04 conv_i_c066_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_04 (conv_q_src_c066_0_04 0 conv_bpf_c066_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_0_04 (conv_q_src_c066_0_04 conv_q_c066_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_05 (conv_i_src_c066_0_05 0 conv_bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_0_05 (conv_i_src_c066_0_05 conv_i_c066_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_05 (conv_q_src_c066_0_05 0 conv_bpf_c066_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_0_05 (conv_q_src_c066_0_05 conv_q_c066_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_06 (conv_i_src_c066_0_06 0 conv_bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_0_06 (conv_i_src_c066_0_06 conv_i_c066_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_06 (conv_q_src_c066_0_06 0 conv_bpf_c066_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_0_06 (conv_q_src_c066_0_06 conv_q_c066_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_07 (conv_i_src_c066_0_07 0 conv_bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_0_07 (conv_i_src_c066_0_07 conv_i_c066_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_07 (conv_q_src_c066_0_07 0 conv_bpf_c066_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_0_07 (conv_q_src_c066_0_07 conv_q_c066_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_08 (conv_i_src_c066_0_08 0 conv_bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_0_08 (conv_i_src_c066_0_08 conv_i_c066_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_08 (conv_q_src_c066_0_08 0 conv_bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_0_08 (conv_q_src_c066_0_08 conv_q_c066_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_09 (conv_i_src_c066_0_09 0 conv_bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_0_09 (conv_i_src_c066_0_09 conv_i_c066_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_09 (conv_q_src_c066_0_09 0 conv_bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_0_09 (conv_q_src_c066_0_09 conv_q_c066_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_10 (conv_i_src_c066_0_10 0 conv_bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_0_10 (conv_i_src_c066_0_10 conv_i_c066_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_10 (conv_q_src_c066_0_10 0 conv_bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_0_10 (conv_q_src_c066_0_10 conv_q_c066_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_11 (conv_i_src_c066_0_11 0 conv_bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_0_11 (conv_i_src_c066_0_11 conv_i_c066_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_11 (conv_q_src_c066_0_11 0 conv_bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_0_11 (conv_q_src_c066_0_11 conv_q_c066_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_12 (conv_i_src_c066_0_12 0 conv_bpf_c066_0 0) vcvs gain=1.950903220161e-01
SCONVI_c066_0_12 (conv_i_src_c066_0_12 conv_i_c066_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_12 (conv_q_src_c066_0_12 0 conv_bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_0_12 (conv_q_src_c066_0_12 conv_q_c066_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_13 (conv_i_src_c066_0_13 0 conv_bpf_c066_0 0) vcvs gain=5.555702330196e-01
SCONVI_c066_0_13 (conv_i_src_c066_0_13 conv_i_c066_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_13 (conv_q_src_c066_0_13 0 conv_bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_0_13 (conv_q_src_c066_0_13 conv_q_c066_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_14 (conv_i_src_c066_0_14 0 conv_bpf_c066_0 0) vcvs gain=8.314696123025e-01
SCONVI_c066_0_14 (conv_i_src_c066_0_14 conv_i_c066_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_14 (conv_q_src_c066_0_14 0 conv_bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_0_14 (conv_q_src_c066_0_14 conv_q_c066_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_0_15 (conv_i_src_c066_0_15 0 conv_bpf_c066_0 0) vcvs gain=9.807852804032e-01
SCONVI_c066_0_15 (conv_i_src_c066_0_15 conv_i_c066_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_0_15 (conv_q_src_c066_0_15 0 conv_bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_0_15 (conv_q_src_c066_0_15 conv_q_c066_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c066_0 (conv_i_c066_0 0) resistor r=1G
RCONVQ_c066_0 (conv_q_c066_0 0) resistor r=1G
RCONVINTI_c066_0 (conv_i_c066_0 ConvIcar_c066_0) resistor r=1k
CCONVINTI_c066_0 (ConvIcar_c066_0 0) capacitor c=80p
RCONVINTQ_c066_0 (conv_q_c066_0 ConvQcar_c066_0) resistor r=1k
CCONVINTQ_c066_0 (ConvQcar_c066_0 0) capacitor c=80p
save conv_bpf_c066_0 ConvIcar_c066_0 ConvQcar_c066_0

// conventional mixed baseline bl066, carrier_1: 500000000 Hz
CCONVBPF_c066_1 (bl066 n_conv_cbpf_c066_1) capacitor c=1.013211836423e-13
LCONVBPF_c066_1 (n_conv_cbpf_c066_1 conv_bpf_c066_1) inductor l=1.000000000000e-06
RCONVBPF_c066_1 (conv_bpf_c066_1 0) resistor r=1.570796326795e+02
ECONVI_c066_1_00 (conv_i_src_c066_1_00 0 conv_bpf_c066_1 0) vcvs gain=9.807852804032e-01
SCONVI_c066_1_00 (conv_i_src_c066_1_00 conv_i_c066_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_00 (conv_q_src_c066_1_00 0 conv_bpf_c066_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_1_00 (conv_q_src_c066_1_00 conv_q_c066_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_01 (conv_i_src_c066_1_01 0 conv_bpf_c066_1 0) vcvs gain=8.314696123025e-01
SCONVI_c066_1_01 (conv_i_src_c066_1_01 conv_i_c066_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_01 (conv_q_src_c066_1_01 0 conv_bpf_c066_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_1_01 (conv_q_src_c066_1_01 conv_q_c066_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_02 (conv_i_src_c066_1_02 0 conv_bpf_c066_1 0) vcvs gain=5.555702330196e-01
SCONVI_c066_1_02 (conv_i_src_c066_1_02 conv_i_c066_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_02 (conv_q_src_c066_1_02 0 conv_bpf_c066_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_1_02 (conv_q_src_c066_1_02 conv_q_c066_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_03 (conv_i_src_c066_1_03 0 conv_bpf_c066_1 0) vcvs gain=1.950903220161e-01
SCONVI_c066_1_03 (conv_i_src_c066_1_03 conv_i_c066_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_03 (conv_q_src_c066_1_03 0 conv_bpf_c066_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_1_03 (conv_q_src_c066_1_03 conv_q_c066_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_04 (conv_i_src_c066_1_04 0 conv_bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_1_04 (conv_i_src_c066_1_04 conv_i_c066_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_04 (conv_q_src_c066_1_04 0 conv_bpf_c066_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_1_04 (conv_q_src_c066_1_04 conv_q_c066_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_05 (conv_i_src_c066_1_05 0 conv_bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_1_05 (conv_i_src_c066_1_05 conv_i_c066_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_05 (conv_q_src_c066_1_05 0 conv_bpf_c066_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_1_05 (conv_q_src_c066_1_05 conv_q_c066_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_06 (conv_i_src_c066_1_06 0 conv_bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_1_06 (conv_i_src_c066_1_06 conv_i_c066_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_06 (conv_q_src_c066_1_06 0 conv_bpf_c066_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_1_06 (conv_q_src_c066_1_06 conv_q_c066_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_07 (conv_i_src_c066_1_07 0 conv_bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_1_07 (conv_i_src_c066_1_07 conv_i_c066_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_07 (conv_q_src_c066_1_07 0 conv_bpf_c066_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_1_07 (conv_q_src_c066_1_07 conv_q_c066_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_08 (conv_i_src_c066_1_08 0 conv_bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_1_08 (conv_i_src_c066_1_08 conv_i_c066_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_08 (conv_q_src_c066_1_08 0 conv_bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_1_08 (conv_q_src_c066_1_08 conv_q_c066_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_09 (conv_i_src_c066_1_09 0 conv_bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_1_09 (conv_i_src_c066_1_09 conv_i_c066_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_09 (conv_q_src_c066_1_09 0 conv_bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_1_09 (conv_q_src_c066_1_09 conv_q_c066_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_10 (conv_i_src_c066_1_10 0 conv_bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_1_10 (conv_i_src_c066_1_10 conv_i_c066_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_10 (conv_q_src_c066_1_10 0 conv_bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_1_10 (conv_q_src_c066_1_10 conv_q_c066_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_11 (conv_i_src_c066_1_11 0 conv_bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_1_11 (conv_i_src_c066_1_11 conv_i_c066_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_11 (conv_q_src_c066_1_11 0 conv_bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_1_11 (conv_q_src_c066_1_11 conv_q_c066_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_12 (conv_i_src_c066_1_12 0 conv_bpf_c066_1 0) vcvs gain=1.950903220161e-01
SCONVI_c066_1_12 (conv_i_src_c066_1_12 conv_i_c066_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_12 (conv_q_src_c066_1_12 0 conv_bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_1_12 (conv_q_src_c066_1_12 conv_q_c066_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_13 (conv_i_src_c066_1_13 0 conv_bpf_c066_1 0) vcvs gain=5.555702330196e-01
SCONVI_c066_1_13 (conv_i_src_c066_1_13 conv_i_c066_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_13 (conv_q_src_c066_1_13 0 conv_bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_1_13 (conv_q_src_c066_1_13 conv_q_c066_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_14 (conv_i_src_c066_1_14 0 conv_bpf_c066_1 0) vcvs gain=8.314696123025e-01
SCONVI_c066_1_14 (conv_i_src_c066_1_14 conv_i_c066_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_14 (conv_q_src_c066_1_14 0 conv_bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_1_14 (conv_q_src_c066_1_14 conv_q_c066_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_1_15 (conv_i_src_c066_1_15 0 conv_bpf_c066_1 0) vcvs gain=9.807852804032e-01
SCONVI_c066_1_15 (conv_i_src_c066_1_15 conv_i_c066_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_1_15 (conv_q_src_c066_1_15 0 conv_bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_1_15 (conv_q_src_c066_1_15 conv_q_c066_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c066_1 (conv_i_c066_1 0) resistor r=1G
RCONVQ_c066_1 (conv_q_c066_1 0) resistor r=1G
RCONVINTI_c066_1 (conv_i_c066_1 ConvIcar_c066_1) resistor r=1k
CCONVINTI_c066_1 (ConvIcar_c066_1 0) capacitor c=80p
RCONVINTQ_c066_1 (conv_q_c066_1 ConvQcar_c066_1) resistor r=1k
CCONVINTQ_c066_1 (ConvQcar_c066_1 0) capacitor c=80p
save conv_bpf_c066_1 ConvIcar_c066_1 ConvQcar_c066_1

// conventional mixed baseline bl066, carrier_2: 750000000 Hz
CCONVBPF_c066_2 (bl066 n_conv_cbpf_c066_2) capacitor c=4.503163717437e-14
LCONVBPF_c066_2 (n_conv_cbpf_c066_2 conv_bpf_c066_2) inductor l=1.000000000000e-06
RCONVBPF_c066_2 (conv_bpf_c066_2 0) resistor r=2.356194490192e+02
ECONVI_c066_2_00 (conv_i_src_c066_2_00 0 conv_bpf_c066_2 0) vcvs gain=9.807852804032e-01
SCONVI_c066_2_00 (conv_i_src_c066_2_00 conv_i_c066_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_00 (conv_q_src_c066_2_00 0 conv_bpf_c066_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_2_00 (conv_q_src_c066_2_00 conv_q_c066_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_01 (conv_i_src_c066_2_01 0 conv_bpf_c066_2 0) vcvs gain=8.314696123025e-01
SCONVI_c066_2_01 (conv_i_src_c066_2_01 conv_i_c066_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_01 (conv_q_src_c066_2_01 0 conv_bpf_c066_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_2_01 (conv_q_src_c066_2_01 conv_q_c066_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_02 (conv_i_src_c066_2_02 0 conv_bpf_c066_2 0) vcvs gain=5.555702330196e-01
SCONVI_c066_2_02 (conv_i_src_c066_2_02 conv_i_c066_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_02 (conv_q_src_c066_2_02 0 conv_bpf_c066_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_2_02 (conv_q_src_c066_2_02 conv_q_c066_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_03 (conv_i_src_c066_2_03 0 conv_bpf_c066_2 0) vcvs gain=1.950903220161e-01
SCONVI_c066_2_03 (conv_i_src_c066_2_03 conv_i_c066_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_03 (conv_q_src_c066_2_03 0 conv_bpf_c066_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_2_03 (conv_q_src_c066_2_03 conv_q_c066_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_04 (conv_i_src_c066_2_04 0 conv_bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_2_04 (conv_i_src_c066_2_04 conv_i_c066_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_04 (conv_q_src_c066_2_04 0 conv_bpf_c066_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_2_04 (conv_q_src_c066_2_04 conv_q_c066_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_05 (conv_i_src_c066_2_05 0 conv_bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_2_05 (conv_i_src_c066_2_05 conv_i_c066_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_05 (conv_q_src_c066_2_05 0 conv_bpf_c066_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_2_05 (conv_q_src_c066_2_05 conv_q_c066_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_06 (conv_i_src_c066_2_06 0 conv_bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_2_06 (conv_i_src_c066_2_06 conv_i_c066_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_06 (conv_q_src_c066_2_06 0 conv_bpf_c066_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_2_06 (conv_q_src_c066_2_06 conv_q_c066_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_07 (conv_i_src_c066_2_07 0 conv_bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_2_07 (conv_i_src_c066_2_07 conv_i_c066_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_07 (conv_q_src_c066_2_07 0 conv_bpf_c066_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_2_07 (conv_q_src_c066_2_07 conv_q_c066_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_08 (conv_i_src_c066_2_08 0 conv_bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_2_08 (conv_i_src_c066_2_08 conv_i_c066_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_08 (conv_q_src_c066_2_08 0 conv_bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_2_08 (conv_q_src_c066_2_08 conv_q_c066_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_09 (conv_i_src_c066_2_09 0 conv_bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_2_09 (conv_i_src_c066_2_09 conv_i_c066_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_09 (conv_q_src_c066_2_09 0 conv_bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_2_09 (conv_q_src_c066_2_09 conv_q_c066_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_10 (conv_i_src_c066_2_10 0 conv_bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_2_10 (conv_i_src_c066_2_10 conv_i_c066_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_10 (conv_q_src_c066_2_10 0 conv_bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_2_10 (conv_q_src_c066_2_10 conv_q_c066_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_11 (conv_i_src_c066_2_11 0 conv_bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_2_11 (conv_i_src_c066_2_11 conv_i_c066_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_11 (conv_q_src_c066_2_11 0 conv_bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_2_11 (conv_q_src_c066_2_11 conv_q_c066_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_12 (conv_i_src_c066_2_12 0 conv_bpf_c066_2 0) vcvs gain=1.950903220161e-01
SCONVI_c066_2_12 (conv_i_src_c066_2_12 conv_i_c066_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_12 (conv_q_src_c066_2_12 0 conv_bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_2_12 (conv_q_src_c066_2_12 conv_q_c066_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_13 (conv_i_src_c066_2_13 0 conv_bpf_c066_2 0) vcvs gain=5.555702330196e-01
SCONVI_c066_2_13 (conv_i_src_c066_2_13 conv_i_c066_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_13 (conv_q_src_c066_2_13 0 conv_bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_2_13 (conv_q_src_c066_2_13 conv_q_c066_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_14 (conv_i_src_c066_2_14 0 conv_bpf_c066_2 0) vcvs gain=8.314696123025e-01
SCONVI_c066_2_14 (conv_i_src_c066_2_14 conv_i_c066_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_14 (conv_q_src_c066_2_14 0 conv_bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_2_14 (conv_q_src_c066_2_14 conv_q_c066_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_2_15 (conv_i_src_c066_2_15 0 conv_bpf_c066_2 0) vcvs gain=9.807852804032e-01
SCONVI_c066_2_15 (conv_i_src_c066_2_15 conv_i_c066_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_2_15 (conv_q_src_c066_2_15 0 conv_bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_2_15 (conv_q_src_c066_2_15 conv_q_c066_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c066_2 (conv_i_c066_2 0) resistor r=1G
RCONVQ_c066_2 (conv_q_c066_2 0) resistor r=1G
RCONVINTI_c066_2 (conv_i_c066_2 ConvIcar_c066_2) resistor r=1k
CCONVINTI_c066_2 (ConvIcar_c066_2 0) capacitor c=80p
RCONVINTQ_c066_2 (conv_q_c066_2 ConvQcar_c066_2) resistor r=1k
CCONVINTQ_c066_2 (ConvQcar_c066_2 0) capacitor c=80p
save conv_bpf_c066_2 ConvIcar_c066_2 ConvQcar_c066_2

// conventional mixed baseline bl066, carrier_3: 1000000000 Hz
CCONVBPF_c066_3 (bl066 n_conv_cbpf_c066_3) capacitor c=2.533029591058e-14
LCONVBPF_c066_3 (n_conv_cbpf_c066_3 conv_bpf_c066_3) inductor l=1.000000000000e-06
RCONVBPF_c066_3 (conv_bpf_c066_3 0) resistor r=3.141592653590e+02
ECONVI_c066_3_00 (conv_i_src_c066_3_00 0 conv_bpf_c066_3 0) vcvs gain=9.807852804032e-01
SCONVI_c066_3_00 (conv_i_src_c066_3_00 conv_i_c066_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_00 (conv_q_src_c066_3_00 0 conv_bpf_c066_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_3_00 (conv_q_src_c066_3_00 conv_q_c066_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_01 (conv_i_src_c066_3_01 0 conv_bpf_c066_3 0) vcvs gain=8.314696123025e-01
SCONVI_c066_3_01 (conv_i_src_c066_3_01 conv_i_c066_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_01 (conv_q_src_c066_3_01 0 conv_bpf_c066_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_3_01 (conv_q_src_c066_3_01 conv_q_c066_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_02 (conv_i_src_c066_3_02 0 conv_bpf_c066_3 0) vcvs gain=5.555702330196e-01
SCONVI_c066_3_02 (conv_i_src_c066_3_02 conv_i_c066_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_02 (conv_q_src_c066_3_02 0 conv_bpf_c066_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_3_02 (conv_q_src_c066_3_02 conv_q_c066_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_03 (conv_i_src_c066_3_03 0 conv_bpf_c066_3 0) vcvs gain=1.950903220161e-01
SCONVI_c066_3_03 (conv_i_src_c066_3_03 conv_i_c066_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_03 (conv_q_src_c066_3_03 0 conv_bpf_c066_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_3_03 (conv_q_src_c066_3_03 conv_q_c066_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_04 (conv_i_src_c066_3_04 0 conv_bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_3_04 (conv_i_src_c066_3_04 conv_i_c066_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_04 (conv_q_src_c066_3_04 0 conv_bpf_c066_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c066_3_04 (conv_q_src_c066_3_04 conv_q_c066_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_05 (conv_i_src_c066_3_05 0 conv_bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_3_05 (conv_i_src_c066_3_05 conv_i_c066_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_05 (conv_q_src_c066_3_05 0 conv_bpf_c066_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c066_3_05 (conv_q_src_c066_3_05 conv_q_c066_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_06 (conv_i_src_c066_3_06 0 conv_bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_3_06 (conv_i_src_c066_3_06 conv_i_c066_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_06 (conv_q_src_c066_3_06 0 conv_bpf_c066_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c066_3_06 (conv_q_src_c066_3_06 conv_q_c066_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_07 (conv_i_src_c066_3_07 0 conv_bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_3_07 (conv_i_src_c066_3_07 conv_i_c066_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_07 (conv_q_src_c066_3_07 0 conv_bpf_c066_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c066_3_07 (conv_q_src_c066_3_07 conv_q_c066_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_08 (conv_i_src_c066_3_08 0 conv_bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c066_3_08 (conv_i_src_c066_3_08 conv_i_c066_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_08 (conv_q_src_c066_3_08 0 conv_bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_3_08 (conv_q_src_c066_3_08 conv_q_c066_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_09 (conv_i_src_c066_3_09 0 conv_bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c066_3_09 (conv_i_src_c066_3_09 conv_i_c066_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_09 (conv_q_src_c066_3_09 0 conv_bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_3_09 (conv_q_src_c066_3_09 conv_q_c066_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_10 (conv_i_src_c066_3_10 0 conv_bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c066_3_10 (conv_i_src_c066_3_10 conv_i_c066_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_10 (conv_q_src_c066_3_10 0 conv_bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_3_10 (conv_q_src_c066_3_10 conv_q_c066_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_11 (conv_i_src_c066_3_11 0 conv_bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c066_3_11 (conv_i_src_c066_3_11 conv_i_c066_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_11 (conv_q_src_c066_3_11 0 conv_bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_3_11 (conv_q_src_c066_3_11 conv_q_c066_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_12 (conv_i_src_c066_3_12 0 conv_bpf_c066_3 0) vcvs gain=1.950903220161e-01
SCONVI_c066_3_12 (conv_i_src_c066_3_12 conv_i_c066_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_12 (conv_q_src_c066_3_12 0 conv_bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c066_3_12 (conv_q_src_c066_3_12 conv_q_c066_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_13 (conv_i_src_c066_3_13 0 conv_bpf_c066_3 0) vcvs gain=5.555702330196e-01
SCONVI_c066_3_13 (conv_i_src_c066_3_13 conv_i_c066_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_13 (conv_q_src_c066_3_13 0 conv_bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c066_3_13 (conv_q_src_c066_3_13 conv_q_c066_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_14 (conv_i_src_c066_3_14 0 conv_bpf_c066_3 0) vcvs gain=8.314696123025e-01
SCONVI_c066_3_14 (conv_i_src_c066_3_14 conv_i_c066_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_14 (conv_q_src_c066_3_14 0 conv_bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c066_3_14 (conv_q_src_c066_3_14 conv_q_c066_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c066_3_15 (conv_i_src_c066_3_15 0 conv_bpf_c066_3 0) vcvs gain=9.807852804032e-01
SCONVI_c066_3_15 (conv_i_src_c066_3_15 conv_i_c066_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c066_3_15 (conv_q_src_c066_3_15 0 conv_bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c066_3_15 (conv_q_src_c066_3_15 conv_q_c066_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c066_3 (conv_i_c066_3 0) resistor r=1G
RCONVQ_c066_3 (conv_q_c066_3 0) resistor r=1G
RCONVINTI_c066_3 (conv_i_c066_3 ConvIcar_c066_3) resistor r=1k
CCONVINTI_c066_3 (ConvIcar_c066_3 0) capacitor c=80p
RCONVINTQ_c066_3 (conv_q_c066_3 ConvQcar_c066_3) resistor r=1k
CCONVINTQ_c066_3 (ConvQcar_c066_3 0) capacitor c=80p
save conv_bpf_c066_3 ConvIcar_c066_3 ConvQcar_c066_3

// conventional mixed baseline bl067, carrier_0: 250000000 Hz
CCONVBPF_c067_0 (bl067 n_conv_cbpf_c067_0) capacitor c=4.052847345694e-13
LCONVBPF_c067_0 (n_conv_cbpf_c067_0 conv_bpf_c067_0) inductor l=1.000000000000e-06
RCONVBPF_c067_0 (conv_bpf_c067_0 0) resistor r=7.853981633974e+01
ECONVI_c067_0_00 (conv_i_src_c067_0_00 0 conv_bpf_c067_0 0) vcvs gain=9.807852804032e-01
SCONVI_c067_0_00 (conv_i_src_c067_0_00 conv_i_c067_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_00 (conv_q_src_c067_0_00 0 conv_bpf_c067_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_0_00 (conv_q_src_c067_0_00 conv_q_c067_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_01 (conv_i_src_c067_0_01 0 conv_bpf_c067_0 0) vcvs gain=8.314696123025e-01
SCONVI_c067_0_01 (conv_i_src_c067_0_01 conv_i_c067_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_01 (conv_q_src_c067_0_01 0 conv_bpf_c067_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_0_01 (conv_q_src_c067_0_01 conv_q_c067_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_02 (conv_i_src_c067_0_02 0 conv_bpf_c067_0 0) vcvs gain=5.555702330196e-01
SCONVI_c067_0_02 (conv_i_src_c067_0_02 conv_i_c067_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_02 (conv_q_src_c067_0_02 0 conv_bpf_c067_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_0_02 (conv_q_src_c067_0_02 conv_q_c067_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_03 (conv_i_src_c067_0_03 0 conv_bpf_c067_0 0) vcvs gain=1.950903220161e-01
SCONVI_c067_0_03 (conv_i_src_c067_0_03 conv_i_c067_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_03 (conv_q_src_c067_0_03 0 conv_bpf_c067_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_0_03 (conv_q_src_c067_0_03 conv_q_c067_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_04 (conv_i_src_c067_0_04 0 conv_bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_0_04 (conv_i_src_c067_0_04 conv_i_c067_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_04 (conv_q_src_c067_0_04 0 conv_bpf_c067_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_0_04 (conv_q_src_c067_0_04 conv_q_c067_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_05 (conv_i_src_c067_0_05 0 conv_bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_0_05 (conv_i_src_c067_0_05 conv_i_c067_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_05 (conv_q_src_c067_0_05 0 conv_bpf_c067_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_0_05 (conv_q_src_c067_0_05 conv_q_c067_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_06 (conv_i_src_c067_0_06 0 conv_bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_0_06 (conv_i_src_c067_0_06 conv_i_c067_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_06 (conv_q_src_c067_0_06 0 conv_bpf_c067_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_0_06 (conv_q_src_c067_0_06 conv_q_c067_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_07 (conv_i_src_c067_0_07 0 conv_bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_0_07 (conv_i_src_c067_0_07 conv_i_c067_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_07 (conv_q_src_c067_0_07 0 conv_bpf_c067_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_0_07 (conv_q_src_c067_0_07 conv_q_c067_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_08 (conv_i_src_c067_0_08 0 conv_bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_0_08 (conv_i_src_c067_0_08 conv_i_c067_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_08 (conv_q_src_c067_0_08 0 conv_bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_0_08 (conv_q_src_c067_0_08 conv_q_c067_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_09 (conv_i_src_c067_0_09 0 conv_bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_0_09 (conv_i_src_c067_0_09 conv_i_c067_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_09 (conv_q_src_c067_0_09 0 conv_bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_0_09 (conv_q_src_c067_0_09 conv_q_c067_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_10 (conv_i_src_c067_0_10 0 conv_bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_0_10 (conv_i_src_c067_0_10 conv_i_c067_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_10 (conv_q_src_c067_0_10 0 conv_bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_0_10 (conv_q_src_c067_0_10 conv_q_c067_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_11 (conv_i_src_c067_0_11 0 conv_bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_0_11 (conv_i_src_c067_0_11 conv_i_c067_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_11 (conv_q_src_c067_0_11 0 conv_bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_0_11 (conv_q_src_c067_0_11 conv_q_c067_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_12 (conv_i_src_c067_0_12 0 conv_bpf_c067_0 0) vcvs gain=1.950903220161e-01
SCONVI_c067_0_12 (conv_i_src_c067_0_12 conv_i_c067_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_12 (conv_q_src_c067_0_12 0 conv_bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_0_12 (conv_q_src_c067_0_12 conv_q_c067_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_13 (conv_i_src_c067_0_13 0 conv_bpf_c067_0 0) vcvs gain=5.555702330196e-01
SCONVI_c067_0_13 (conv_i_src_c067_0_13 conv_i_c067_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_13 (conv_q_src_c067_0_13 0 conv_bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_0_13 (conv_q_src_c067_0_13 conv_q_c067_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_14 (conv_i_src_c067_0_14 0 conv_bpf_c067_0 0) vcvs gain=8.314696123025e-01
SCONVI_c067_0_14 (conv_i_src_c067_0_14 conv_i_c067_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_14 (conv_q_src_c067_0_14 0 conv_bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_0_14 (conv_q_src_c067_0_14 conv_q_c067_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_0_15 (conv_i_src_c067_0_15 0 conv_bpf_c067_0 0) vcvs gain=9.807852804032e-01
SCONVI_c067_0_15 (conv_i_src_c067_0_15 conv_i_c067_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_0_15 (conv_q_src_c067_0_15 0 conv_bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_0_15 (conv_q_src_c067_0_15 conv_q_c067_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c067_0 (conv_i_c067_0 0) resistor r=1G
RCONVQ_c067_0 (conv_q_c067_0 0) resistor r=1G
RCONVINTI_c067_0 (conv_i_c067_0 ConvIcar_c067_0) resistor r=1k
CCONVINTI_c067_0 (ConvIcar_c067_0 0) capacitor c=80p
RCONVINTQ_c067_0 (conv_q_c067_0 ConvQcar_c067_0) resistor r=1k
CCONVINTQ_c067_0 (ConvQcar_c067_0 0) capacitor c=80p
save conv_bpf_c067_0 ConvIcar_c067_0 ConvQcar_c067_0

// conventional mixed baseline bl067, carrier_1: 500000000 Hz
CCONVBPF_c067_1 (bl067 n_conv_cbpf_c067_1) capacitor c=1.013211836423e-13
LCONVBPF_c067_1 (n_conv_cbpf_c067_1 conv_bpf_c067_1) inductor l=1.000000000000e-06
RCONVBPF_c067_1 (conv_bpf_c067_1 0) resistor r=1.570796326795e+02
ECONVI_c067_1_00 (conv_i_src_c067_1_00 0 conv_bpf_c067_1 0) vcvs gain=9.807852804032e-01
SCONVI_c067_1_00 (conv_i_src_c067_1_00 conv_i_c067_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_00 (conv_q_src_c067_1_00 0 conv_bpf_c067_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_1_00 (conv_q_src_c067_1_00 conv_q_c067_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_01 (conv_i_src_c067_1_01 0 conv_bpf_c067_1 0) vcvs gain=8.314696123025e-01
SCONVI_c067_1_01 (conv_i_src_c067_1_01 conv_i_c067_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_01 (conv_q_src_c067_1_01 0 conv_bpf_c067_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_1_01 (conv_q_src_c067_1_01 conv_q_c067_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_02 (conv_i_src_c067_1_02 0 conv_bpf_c067_1 0) vcvs gain=5.555702330196e-01
SCONVI_c067_1_02 (conv_i_src_c067_1_02 conv_i_c067_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_02 (conv_q_src_c067_1_02 0 conv_bpf_c067_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_1_02 (conv_q_src_c067_1_02 conv_q_c067_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_03 (conv_i_src_c067_1_03 0 conv_bpf_c067_1 0) vcvs gain=1.950903220161e-01
SCONVI_c067_1_03 (conv_i_src_c067_1_03 conv_i_c067_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_03 (conv_q_src_c067_1_03 0 conv_bpf_c067_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_1_03 (conv_q_src_c067_1_03 conv_q_c067_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_04 (conv_i_src_c067_1_04 0 conv_bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_1_04 (conv_i_src_c067_1_04 conv_i_c067_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_04 (conv_q_src_c067_1_04 0 conv_bpf_c067_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_1_04 (conv_q_src_c067_1_04 conv_q_c067_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_05 (conv_i_src_c067_1_05 0 conv_bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_1_05 (conv_i_src_c067_1_05 conv_i_c067_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_05 (conv_q_src_c067_1_05 0 conv_bpf_c067_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_1_05 (conv_q_src_c067_1_05 conv_q_c067_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_06 (conv_i_src_c067_1_06 0 conv_bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_1_06 (conv_i_src_c067_1_06 conv_i_c067_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_06 (conv_q_src_c067_1_06 0 conv_bpf_c067_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_1_06 (conv_q_src_c067_1_06 conv_q_c067_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_07 (conv_i_src_c067_1_07 0 conv_bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_1_07 (conv_i_src_c067_1_07 conv_i_c067_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_07 (conv_q_src_c067_1_07 0 conv_bpf_c067_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_1_07 (conv_q_src_c067_1_07 conv_q_c067_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_08 (conv_i_src_c067_1_08 0 conv_bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_1_08 (conv_i_src_c067_1_08 conv_i_c067_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_08 (conv_q_src_c067_1_08 0 conv_bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_1_08 (conv_q_src_c067_1_08 conv_q_c067_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_09 (conv_i_src_c067_1_09 0 conv_bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_1_09 (conv_i_src_c067_1_09 conv_i_c067_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_09 (conv_q_src_c067_1_09 0 conv_bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_1_09 (conv_q_src_c067_1_09 conv_q_c067_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_10 (conv_i_src_c067_1_10 0 conv_bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_1_10 (conv_i_src_c067_1_10 conv_i_c067_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_10 (conv_q_src_c067_1_10 0 conv_bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_1_10 (conv_q_src_c067_1_10 conv_q_c067_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_11 (conv_i_src_c067_1_11 0 conv_bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_1_11 (conv_i_src_c067_1_11 conv_i_c067_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_11 (conv_q_src_c067_1_11 0 conv_bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_1_11 (conv_q_src_c067_1_11 conv_q_c067_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_12 (conv_i_src_c067_1_12 0 conv_bpf_c067_1 0) vcvs gain=1.950903220161e-01
SCONVI_c067_1_12 (conv_i_src_c067_1_12 conv_i_c067_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_12 (conv_q_src_c067_1_12 0 conv_bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_1_12 (conv_q_src_c067_1_12 conv_q_c067_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_13 (conv_i_src_c067_1_13 0 conv_bpf_c067_1 0) vcvs gain=5.555702330196e-01
SCONVI_c067_1_13 (conv_i_src_c067_1_13 conv_i_c067_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_13 (conv_q_src_c067_1_13 0 conv_bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_1_13 (conv_q_src_c067_1_13 conv_q_c067_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_14 (conv_i_src_c067_1_14 0 conv_bpf_c067_1 0) vcvs gain=8.314696123025e-01
SCONVI_c067_1_14 (conv_i_src_c067_1_14 conv_i_c067_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_14 (conv_q_src_c067_1_14 0 conv_bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_1_14 (conv_q_src_c067_1_14 conv_q_c067_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_1_15 (conv_i_src_c067_1_15 0 conv_bpf_c067_1 0) vcvs gain=9.807852804032e-01
SCONVI_c067_1_15 (conv_i_src_c067_1_15 conv_i_c067_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_1_15 (conv_q_src_c067_1_15 0 conv_bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_1_15 (conv_q_src_c067_1_15 conv_q_c067_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c067_1 (conv_i_c067_1 0) resistor r=1G
RCONVQ_c067_1 (conv_q_c067_1 0) resistor r=1G
RCONVINTI_c067_1 (conv_i_c067_1 ConvIcar_c067_1) resistor r=1k
CCONVINTI_c067_1 (ConvIcar_c067_1 0) capacitor c=80p
RCONVINTQ_c067_1 (conv_q_c067_1 ConvQcar_c067_1) resistor r=1k
CCONVINTQ_c067_1 (ConvQcar_c067_1 0) capacitor c=80p
save conv_bpf_c067_1 ConvIcar_c067_1 ConvQcar_c067_1

// conventional mixed baseline bl067, carrier_2: 750000000 Hz
CCONVBPF_c067_2 (bl067 n_conv_cbpf_c067_2) capacitor c=4.503163717437e-14
LCONVBPF_c067_2 (n_conv_cbpf_c067_2 conv_bpf_c067_2) inductor l=1.000000000000e-06
RCONVBPF_c067_2 (conv_bpf_c067_2 0) resistor r=2.356194490192e+02
ECONVI_c067_2_00 (conv_i_src_c067_2_00 0 conv_bpf_c067_2 0) vcvs gain=9.807852804032e-01
SCONVI_c067_2_00 (conv_i_src_c067_2_00 conv_i_c067_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_00 (conv_q_src_c067_2_00 0 conv_bpf_c067_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_2_00 (conv_q_src_c067_2_00 conv_q_c067_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_01 (conv_i_src_c067_2_01 0 conv_bpf_c067_2 0) vcvs gain=8.314696123025e-01
SCONVI_c067_2_01 (conv_i_src_c067_2_01 conv_i_c067_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_01 (conv_q_src_c067_2_01 0 conv_bpf_c067_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_2_01 (conv_q_src_c067_2_01 conv_q_c067_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_02 (conv_i_src_c067_2_02 0 conv_bpf_c067_2 0) vcvs gain=5.555702330196e-01
SCONVI_c067_2_02 (conv_i_src_c067_2_02 conv_i_c067_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_02 (conv_q_src_c067_2_02 0 conv_bpf_c067_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_2_02 (conv_q_src_c067_2_02 conv_q_c067_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_03 (conv_i_src_c067_2_03 0 conv_bpf_c067_2 0) vcvs gain=1.950903220161e-01
SCONVI_c067_2_03 (conv_i_src_c067_2_03 conv_i_c067_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_03 (conv_q_src_c067_2_03 0 conv_bpf_c067_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_2_03 (conv_q_src_c067_2_03 conv_q_c067_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_04 (conv_i_src_c067_2_04 0 conv_bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_2_04 (conv_i_src_c067_2_04 conv_i_c067_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_04 (conv_q_src_c067_2_04 0 conv_bpf_c067_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_2_04 (conv_q_src_c067_2_04 conv_q_c067_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_05 (conv_i_src_c067_2_05 0 conv_bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_2_05 (conv_i_src_c067_2_05 conv_i_c067_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_05 (conv_q_src_c067_2_05 0 conv_bpf_c067_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_2_05 (conv_q_src_c067_2_05 conv_q_c067_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_06 (conv_i_src_c067_2_06 0 conv_bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_2_06 (conv_i_src_c067_2_06 conv_i_c067_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_06 (conv_q_src_c067_2_06 0 conv_bpf_c067_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_2_06 (conv_q_src_c067_2_06 conv_q_c067_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_07 (conv_i_src_c067_2_07 0 conv_bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_2_07 (conv_i_src_c067_2_07 conv_i_c067_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_07 (conv_q_src_c067_2_07 0 conv_bpf_c067_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_2_07 (conv_q_src_c067_2_07 conv_q_c067_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_08 (conv_i_src_c067_2_08 0 conv_bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_2_08 (conv_i_src_c067_2_08 conv_i_c067_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_08 (conv_q_src_c067_2_08 0 conv_bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_2_08 (conv_q_src_c067_2_08 conv_q_c067_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_09 (conv_i_src_c067_2_09 0 conv_bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_2_09 (conv_i_src_c067_2_09 conv_i_c067_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_09 (conv_q_src_c067_2_09 0 conv_bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_2_09 (conv_q_src_c067_2_09 conv_q_c067_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_10 (conv_i_src_c067_2_10 0 conv_bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_2_10 (conv_i_src_c067_2_10 conv_i_c067_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_10 (conv_q_src_c067_2_10 0 conv_bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_2_10 (conv_q_src_c067_2_10 conv_q_c067_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_11 (conv_i_src_c067_2_11 0 conv_bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_2_11 (conv_i_src_c067_2_11 conv_i_c067_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_11 (conv_q_src_c067_2_11 0 conv_bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_2_11 (conv_q_src_c067_2_11 conv_q_c067_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_12 (conv_i_src_c067_2_12 0 conv_bpf_c067_2 0) vcvs gain=1.950903220161e-01
SCONVI_c067_2_12 (conv_i_src_c067_2_12 conv_i_c067_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_12 (conv_q_src_c067_2_12 0 conv_bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_2_12 (conv_q_src_c067_2_12 conv_q_c067_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_13 (conv_i_src_c067_2_13 0 conv_bpf_c067_2 0) vcvs gain=5.555702330196e-01
SCONVI_c067_2_13 (conv_i_src_c067_2_13 conv_i_c067_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_13 (conv_q_src_c067_2_13 0 conv_bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_2_13 (conv_q_src_c067_2_13 conv_q_c067_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_14 (conv_i_src_c067_2_14 0 conv_bpf_c067_2 0) vcvs gain=8.314696123025e-01
SCONVI_c067_2_14 (conv_i_src_c067_2_14 conv_i_c067_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_14 (conv_q_src_c067_2_14 0 conv_bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_2_14 (conv_q_src_c067_2_14 conv_q_c067_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_2_15 (conv_i_src_c067_2_15 0 conv_bpf_c067_2 0) vcvs gain=9.807852804032e-01
SCONVI_c067_2_15 (conv_i_src_c067_2_15 conv_i_c067_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_2_15 (conv_q_src_c067_2_15 0 conv_bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_2_15 (conv_q_src_c067_2_15 conv_q_c067_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c067_2 (conv_i_c067_2 0) resistor r=1G
RCONVQ_c067_2 (conv_q_c067_2 0) resistor r=1G
RCONVINTI_c067_2 (conv_i_c067_2 ConvIcar_c067_2) resistor r=1k
CCONVINTI_c067_2 (ConvIcar_c067_2 0) capacitor c=80p
RCONVINTQ_c067_2 (conv_q_c067_2 ConvQcar_c067_2) resistor r=1k
CCONVINTQ_c067_2 (ConvQcar_c067_2 0) capacitor c=80p
save conv_bpf_c067_2 ConvIcar_c067_2 ConvQcar_c067_2

// conventional mixed baseline bl067, carrier_3: 1000000000 Hz
CCONVBPF_c067_3 (bl067 n_conv_cbpf_c067_3) capacitor c=2.533029591058e-14
LCONVBPF_c067_3 (n_conv_cbpf_c067_3 conv_bpf_c067_3) inductor l=1.000000000000e-06
RCONVBPF_c067_3 (conv_bpf_c067_3 0) resistor r=3.141592653590e+02
ECONVI_c067_3_00 (conv_i_src_c067_3_00 0 conv_bpf_c067_3 0) vcvs gain=9.807852804032e-01
SCONVI_c067_3_00 (conv_i_src_c067_3_00 conv_i_c067_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_00 (conv_q_src_c067_3_00 0 conv_bpf_c067_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_3_00 (conv_q_src_c067_3_00 conv_q_c067_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_01 (conv_i_src_c067_3_01 0 conv_bpf_c067_3 0) vcvs gain=8.314696123025e-01
SCONVI_c067_3_01 (conv_i_src_c067_3_01 conv_i_c067_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_01 (conv_q_src_c067_3_01 0 conv_bpf_c067_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_3_01 (conv_q_src_c067_3_01 conv_q_c067_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_02 (conv_i_src_c067_3_02 0 conv_bpf_c067_3 0) vcvs gain=5.555702330196e-01
SCONVI_c067_3_02 (conv_i_src_c067_3_02 conv_i_c067_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_02 (conv_q_src_c067_3_02 0 conv_bpf_c067_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_3_02 (conv_q_src_c067_3_02 conv_q_c067_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_03 (conv_i_src_c067_3_03 0 conv_bpf_c067_3 0) vcvs gain=1.950903220161e-01
SCONVI_c067_3_03 (conv_i_src_c067_3_03 conv_i_c067_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_03 (conv_q_src_c067_3_03 0 conv_bpf_c067_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_3_03 (conv_q_src_c067_3_03 conv_q_c067_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_04 (conv_i_src_c067_3_04 0 conv_bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_3_04 (conv_i_src_c067_3_04 conv_i_c067_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_04 (conv_q_src_c067_3_04 0 conv_bpf_c067_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c067_3_04 (conv_q_src_c067_3_04 conv_q_c067_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_05 (conv_i_src_c067_3_05 0 conv_bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_3_05 (conv_i_src_c067_3_05 conv_i_c067_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_05 (conv_q_src_c067_3_05 0 conv_bpf_c067_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c067_3_05 (conv_q_src_c067_3_05 conv_q_c067_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_06 (conv_i_src_c067_3_06 0 conv_bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_3_06 (conv_i_src_c067_3_06 conv_i_c067_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_06 (conv_q_src_c067_3_06 0 conv_bpf_c067_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c067_3_06 (conv_q_src_c067_3_06 conv_q_c067_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_07 (conv_i_src_c067_3_07 0 conv_bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_3_07 (conv_i_src_c067_3_07 conv_i_c067_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_07 (conv_q_src_c067_3_07 0 conv_bpf_c067_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c067_3_07 (conv_q_src_c067_3_07 conv_q_c067_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_08 (conv_i_src_c067_3_08 0 conv_bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c067_3_08 (conv_i_src_c067_3_08 conv_i_c067_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_08 (conv_q_src_c067_3_08 0 conv_bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_3_08 (conv_q_src_c067_3_08 conv_q_c067_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_09 (conv_i_src_c067_3_09 0 conv_bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c067_3_09 (conv_i_src_c067_3_09 conv_i_c067_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_09 (conv_q_src_c067_3_09 0 conv_bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_3_09 (conv_q_src_c067_3_09 conv_q_c067_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_10 (conv_i_src_c067_3_10 0 conv_bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c067_3_10 (conv_i_src_c067_3_10 conv_i_c067_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_10 (conv_q_src_c067_3_10 0 conv_bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_3_10 (conv_q_src_c067_3_10 conv_q_c067_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_11 (conv_i_src_c067_3_11 0 conv_bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c067_3_11 (conv_i_src_c067_3_11 conv_i_c067_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_11 (conv_q_src_c067_3_11 0 conv_bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_3_11 (conv_q_src_c067_3_11 conv_q_c067_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_12 (conv_i_src_c067_3_12 0 conv_bpf_c067_3 0) vcvs gain=1.950903220161e-01
SCONVI_c067_3_12 (conv_i_src_c067_3_12 conv_i_c067_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_12 (conv_q_src_c067_3_12 0 conv_bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c067_3_12 (conv_q_src_c067_3_12 conv_q_c067_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_13 (conv_i_src_c067_3_13 0 conv_bpf_c067_3 0) vcvs gain=5.555702330196e-01
SCONVI_c067_3_13 (conv_i_src_c067_3_13 conv_i_c067_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_13 (conv_q_src_c067_3_13 0 conv_bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c067_3_13 (conv_q_src_c067_3_13 conv_q_c067_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_14 (conv_i_src_c067_3_14 0 conv_bpf_c067_3 0) vcvs gain=8.314696123025e-01
SCONVI_c067_3_14 (conv_i_src_c067_3_14 conv_i_c067_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_14 (conv_q_src_c067_3_14 0 conv_bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c067_3_14 (conv_q_src_c067_3_14 conv_q_c067_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c067_3_15 (conv_i_src_c067_3_15 0 conv_bpf_c067_3 0) vcvs gain=9.807852804032e-01
SCONVI_c067_3_15 (conv_i_src_c067_3_15 conv_i_c067_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c067_3_15 (conv_q_src_c067_3_15 0 conv_bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c067_3_15 (conv_q_src_c067_3_15 conv_q_c067_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c067_3 (conv_i_c067_3 0) resistor r=1G
RCONVQ_c067_3 (conv_q_c067_3 0) resistor r=1G
RCONVINTI_c067_3 (conv_i_c067_3 ConvIcar_c067_3) resistor r=1k
CCONVINTI_c067_3 (ConvIcar_c067_3 0) capacitor c=80p
RCONVINTQ_c067_3 (conv_q_c067_3 ConvQcar_c067_3) resistor r=1k
CCONVINTQ_c067_3 (ConvQcar_c067_3 0) capacitor c=80p
save conv_bpf_c067_3 ConvIcar_c067_3 ConvQcar_c067_3

// conventional mixed baseline bl068, carrier_0: 250000000 Hz
CCONVBPF_c068_0 (bl068 n_conv_cbpf_c068_0) capacitor c=4.052847345694e-13
LCONVBPF_c068_0 (n_conv_cbpf_c068_0 conv_bpf_c068_0) inductor l=1.000000000000e-06
RCONVBPF_c068_0 (conv_bpf_c068_0 0) resistor r=7.853981633974e+01
ECONVI_c068_0_00 (conv_i_src_c068_0_00 0 conv_bpf_c068_0 0) vcvs gain=9.807852804032e-01
SCONVI_c068_0_00 (conv_i_src_c068_0_00 conv_i_c068_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_00 (conv_q_src_c068_0_00 0 conv_bpf_c068_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_0_00 (conv_q_src_c068_0_00 conv_q_c068_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_01 (conv_i_src_c068_0_01 0 conv_bpf_c068_0 0) vcvs gain=8.314696123025e-01
SCONVI_c068_0_01 (conv_i_src_c068_0_01 conv_i_c068_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_01 (conv_q_src_c068_0_01 0 conv_bpf_c068_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_0_01 (conv_q_src_c068_0_01 conv_q_c068_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_02 (conv_i_src_c068_0_02 0 conv_bpf_c068_0 0) vcvs gain=5.555702330196e-01
SCONVI_c068_0_02 (conv_i_src_c068_0_02 conv_i_c068_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_02 (conv_q_src_c068_0_02 0 conv_bpf_c068_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_0_02 (conv_q_src_c068_0_02 conv_q_c068_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_03 (conv_i_src_c068_0_03 0 conv_bpf_c068_0 0) vcvs gain=1.950903220161e-01
SCONVI_c068_0_03 (conv_i_src_c068_0_03 conv_i_c068_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_03 (conv_q_src_c068_0_03 0 conv_bpf_c068_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_0_03 (conv_q_src_c068_0_03 conv_q_c068_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_04 (conv_i_src_c068_0_04 0 conv_bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_0_04 (conv_i_src_c068_0_04 conv_i_c068_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_04 (conv_q_src_c068_0_04 0 conv_bpf_c068_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_0_04 (conv_q_src_c068_0_04 conv_q_c068_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_05 (conv_i_src_c068_0_05 0 conv_bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_0_05 (conv_i_src_c068_0_05 conv_i_c068_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_05 (conv_q_src_c068_0_05 0 conv_bpf_c068_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_0_05 (conv_q_src_c068_0_05 conv_q_c068_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_06 (conv_i_src_c068_0_06 0 conv_bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_0_06 (conv_i_src_c068_0_06 conv_i_c068_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_06 (conv_q_src_c068_0_06 0 conv_bpf_c068_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_0_06 (conv_q_src_c068_0_06 conv_q_c068_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_07 (conv_i_src_c068_0_07 0 conv_bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_0_07 (conv_i_src_c068_0_07 conv_i_c068_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_07 (conv_q_src_c068_0_07 0 conv_bpf_c068_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_0_07 (conv_q_src_c068_0_07 conv_q_c068_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_08 (conv_i_src_c068_0_08 0 conv_bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_0_08 (conv_i_src_c068_0_08 conv_i_c068_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_08 (conv_q_src_c068_0_08 0 conv_bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_0_08 (conv_q_src_c068_0_08 conv_q_c068_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_09 (conv_i_src_c068_0_09 0 conv_bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_0_09 (conv_i_src_c068_0_09 conv_i_c068_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_09 (conv_q_src_c068_0_09 0 conv_bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_0_09 (conv_q_src_c068_0_09 conv_q_c068_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_10 (conv_i_src_c068_0_10 0 conv_bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_0_10 (conv_i_src_c068_0_10 conv_i_c068_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_10 (conv_q_src_c068_0_10 0 conv_bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_0_10 (conv_q_src_c068_0_10 conv_q_c068_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_11 (conv_i_src_c068_0_11 0 conv_bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_0_11 (conv_i_src_c068_0_11 conv_i_c068_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_11 (conv_q_src_c068_0_11 0 conv_bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_0_11 (conv_q_src_c068_0_11 conv_q_c068_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_12 (conv_i_src_c068_0_12 0 conv_bpf_c068_0 0) vcvs gain=1.950903220161e-01
SCONVI_c068_0_12 (conv_i_src_c068_0_12 conv_i_c068_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_12 (conv_q_src_c068_0_12 0 conv_bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_0_12 (conv_q_src_c068_0_12 conv_q_c068_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_13 (conv_i_src_c068_0_13 0 conv_bpf_c068_0 0) vcvs gain=5.555702330196e-01
SCONVI_c068_0_13 (conv_i_src_c068_0_13 conv_i_c068_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_13 (conv_q_src_c068_0_13 0 conv_bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_0_13 (conv_q_src_c068_0_13 conv_q_c068_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_14 (conv_i_src_c068_0_14 0 conv_bpf_c068_0 0) vcvs gain=8.314696123025e-01
SCONVI_c068_0_14 (conv_i_src_c068_0_14 conv_i_c068_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_14 (conv_q_src_c068_0_14 0 conv_bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_0_14 (conv_q_src_c068_0_14 conv_q_c068_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_0_15 (conv_i_src_c068_0_15 0 conv_bpf_c068_0 0) vcvs gain=9.807852804032e-01
SCONVI_c068_0_15 (conv_i_src_c068_0_15 conv_i_c068_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_0_15 (conv_q_src_c068_0_15 0 conv_bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_0_15 (conv_q_src_c068_0_15 conv_q_c068_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c068_0 (conv_i_c068_0 0) resistor r=1G
RCONVQ_c068_0 (conv_q_c068_0 0) resistor r=1G
RCONVINTI_c068_0 (conv_i_c068_0 ConvIcar_c068_0) resistor r=1k
CCONVINTI_c068_0 (ConvIcar_c068_0 0) capacitor c=80p
RCONVINTQ_c068_0 (conv_q_c068_0 ConvQcar_c068_0) resistor r=1k
CCONVINTQ_c068_0 (ConvQcar_c068_0 0) capacitor c=80p
save conv_bpf_c068_0 ConvIcar_c068_0 ConvQcar_c068_0

// conventional mixed baseline bl068, carrier_1: 500000000 Hz
CCONVBPF_c068_1 (bl068 n_conv_cbpf_c068_1) capacitor c=1.013211836423e-13
LCONVBPF_c068_1 (n_conv_cbpf_c068_1 conv_bpf_c068_1) inductor l=1.000000000000e-06
RCONVBPF_c068_1 (conv_bpf_c068_1 0) resistor r=1.570796326795e+02
ECONVI_c068_1_00 (conv_i_src_c068_1_00 0 conv_bpf_c068_1 0) vcvs gain=9.807852804032e-01
SCONVI_c068_1_00 (conv_i_src_c068_1_00 conv_i_c068_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_00 (conv_q_src_c068_1_00 0 conv_bpf_c068_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_1_00 (conv_q_src_c068_1_00 conv_q_c068_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_01 (conv_i_src_c068_1_01 0 conv_bpf_c068_1 0) vcvs gain=8.314696123025e-01
SCONVI_c068_1_01 (conv_i_src_c068_1_01 conv_i_c068_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_01 (conv_q_src_c068_1_01 0 conv_bpf_c068_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_1_01 (conv_q_src_c068_1_01 conv_q_c068_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_02 (conv_i_src_c068_1_02 0 conv_bpf_c068_1 0) vcvs gain=5.555702330196e-01
SCONVI_c068_1_02 (conv_i_src_c068_1_02 conv_i_c068_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_02 (conv_q_src_c068_1_02 0 conv_bpf_c068_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_1_02 (conv_q_src_c068_1_02 conv_q_c068_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_03 (conv_i_src_c068_1_03 0 conv_bpf_c068_1 0) vcvs gain=1.950903220161e-01
SCONVI_c068_1_03 (conv_i_src_c068_1_03 conv_i_c068_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_03 (conv_q_src_c068_1_03 0 conv_bpf_c068_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_1_03 (conv_q_src_c068_1_03 conv_q_c068_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_04 (conv_i_src_c068_1_04 0 conv_bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_1_04 (conv_i_src_c068_1_04 conv_i_c068_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_04 (conv_q_src_c068_1_04 0 conv_bpf_c068_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_1_04 (conv_q_src_c068_1_04 conv_q_c068_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_05 (conv_i_src_c068_1_05 0 conv_bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_1_05 (conv_i_src_c068_1_05 conv_i_c068_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_05 (conv_q_src_c068_1_05 0 conv_bpf_c068_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_1_05 (conv_q_src_c068_1_05 conv_q_c068_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_06 (conv_i_src_c068_1_06 0 conv_bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_1_06 (conv_i_src_c068_1_06 conv_i_c068_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_06 (conv_q_src_c068_1_06 0 conv_bpf_c068_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_1_06 (conv_q_src_c068_1_06 conv_q_c068_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_07 (conv_i_src_c068_1_07 0 conv_bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_1_07 (conv_i_src_c068_1_07 conv_i_c068_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_07 (conv_q_src_c068_1_07 0 conv_bpf_c068_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_1_07 (conv_q_src_c068_1_07 conv_q_c068_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_08 (conv_i_src_c068_1_08 0 conv_bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_1_08 (conv_i_src_c068_1_08 conv_i_c068_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_08 (conv_q_src_c068_1_08 0 conv_bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_1_08 (conv_q_src_c068_1_08 conv_q_c068_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_09 (conv_i_src_c068_1_09 0 conv_bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_1_09 (conv_i_src_c068_1_09 conv_i_c068_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_09 (conv_q_src_c068_1_09 0 conv_bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_1_09 (conv_q_src_c068_1_09 conv_q_c068_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_10 (conv_i_src_c068_1_10 0 conv_bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_1_10 (conv_i_src_c068_1_10 conv_i_c068_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_10 (conv_q_src_c068_1_10 0 conv_bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_1_10 (conv_q_src_c068_1_10 conv_q_c068_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_11 (conv_i_src_c068_1_11 0 conv_bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_1_11 (conv_i_src_c068_1_11 conv_i_c068_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_11 (conv_q_src_c068_1_11 0 conv_bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_1_11 (conv_q_src_c068_1_11 conv_q_c068_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_12 (conv_i_src_c068_1_12 0 conv_bpf_c068_1 0) vcvs gain=1.950903220161e-01
SCONVI_c068_1_12 (conv_i_src_c068_1_12 conv_i_c068_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_12 (conv_q_src_c068_1_12 0 conv_bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_1_12 (conv_q_src_c068_1_12 conv_q_c068_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_13 (conv_i_src_c068_1_13 0 conv_bpf_c068_1 0) vcvs gain=5.555702330196e-01
SCONVI_c068_1_13 (conv_i_src_c068_1_13 conv_i_c068_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_13 (conv_q_src_c068_1_13 0 conv_bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_1_13 (conv_q_src_c068_1_13 conv_q_c068_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_14 (conv_i_src_c068_1_14 0 conv_bpf_c068_1 0) vcvs gain=8.314696123025e-01
SCONVI_c068_1_14 (conv_i_src_c068_1_14 conv_i_c068_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_14 (conv_q_src_c068_1_14 0 conv_bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_1_14 (conv_q_src_c068_1_14 conv_q_c068_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_1_15 (conv_i_src_c068_1_15 0 conv_bpf_c068_1 0) vcvs gain=9.807852804032e-01
SCONVI_c068_1_15 (conv_i_src_c068_1_15 conv_i_c068_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_1_15 (conv_q_src_c068_1_15 0 conv_bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_1_15 (conv_q_src_c068_1_15 conv_q_c068_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c068_1 (conv_i_c068_1 0) resistor r=1G
RCONVQ_c068_1 (conv_q_c068_1 0) resistor r=1G
RCONVINTI_c068_1 (conv_i_c068_1 ConvIcar_c068_1) resistor r=1k
CCONVINTI_c068_1 (ConvIcar_c068_1 0) capacitor c=80p
RCONVINTQ_c068_1 (conv_q_c068_1 ConvQcar_c068_1) resistor r=1k
CCONVINTQ_c068_1 (ConvQcar_c068_1 0) capacitor c=80p
save conv_bpf_c068_1 ConvIcar_c068_1 ConvQcar_c068_1

// conventional mixed baseline bl068, carrier_2: 750000000 Hz
CCONVBPF_c068_2 (bl068 n_conv_cbpf_c068_2) capacitor c=4.503163717437e-14
LCONVBPF_c068_2 (n_conv_cbpf_c068_2 conv_bpf_c068_2) inductor l=1.000000000000e-06
RCONVBPF_c068_2 (conv_bpf_c068_2 0) resistor r=2.356194490192e+02
ECONVI_c068_2_00 (conv_i_src_c068_2_00 0 conv_bpf_c068_2 0) vcvs gain=9.807852804032e-01
SCONVI_c068_2_00 (conv_i_src_c068_2_00 conv_i_c068_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_00 (conv_q_src_c068_2_00 0 conv_bpf_c068_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_2_00 (conv_q_src_c068_2_00 conv_q_c068_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_01 (conv_i_src_c068_2_01 0 conv_bpf_c068_2 0) vcvs gain=8.314696123025e-01
SCONVI_c068_2_01 (conv_i_src_c068_2_01 conv_i_c068_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_01 (conv_q_src_c068_2_01 0 conv_bpf_c068_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_2_01 (conv_q_src_c068_2_01 conv_q_c068_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_02 (conv_i_src_c068_2_02 0 conv_bpf_c068_2 0) vcvs gain=5.555702330196e-01
SCONVI_c068_2_02 (conv_i_src_c068_2_02 conv_i_c068_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_02 (conv_q_src_c068_2_02 0 conv_bpf_c068_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_2_02 (conv_q_src_c068_2_02 conv_q_c068_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_03 (conv_i_src_c068_2_03 0 conv_bpf_c068_2 0) vcvs gain=1.950903220161e-01
SCONVI_c068_2_03 (conv_i_src_c068_2_03 conv_i_c068_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_03 (conv_q_src_c068_2_03 0 conv_bpf_c068_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_2_03 (conv_q_src_c068_2_03 conv_q_c068_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_04 (conv_i_src_c068_2_04 0 conv_bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_2_04 (conv_i_src_c068_2_04 conv_i_c068_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_04 (conv_q_src_c068_2_04 0 conv_bpf_c068_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_2_04 (conv_q_src_c068_2_04 conv_q_c068_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_05 (conv_i_src_c068_2_05 0 conv_bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_2_05 (conv_i_src_c068_2_05 conv_i_c068_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_05 (conv_q_src_c068_2_05 0 conv_bpf_c068_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_2_05 (conv_q_src_c068_2_05 conv_q_c068_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_06 (conv_i_src_c068_2_06 0 conv_bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_2_06 (conv_i_src_c068_2_06 conv_i_c068_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_06 (conv_q_src_c068_2_06 0 conv_bpf_c068_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_2_06 (conv_q_src_c068_2_06 conv_q_c068_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_07 (conv_i_src_c068_2_07 0 conv_bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_2_07 (conv_i_src_c068_2_07 conv_i_c068_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_07 (conv_q_src_c068_2_07 0 conv_bpf_c068_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_2_07 (conv_q_src_c068_2_07 conv_q_c068_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_08 (conv_i_src_c068_2_08 0 conv_bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_2_08 (conv_i_src_c068_2_08 conv_i_c068_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_08 (conv_q_src_c068_2_08 0 conv_bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_2_08 (conv_q_src_c068_2_08 conv_q_c068_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_09 (conv_i_src_c068_2_09 0 conv_bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_2_09 (conv_i_src_c068_2_09 conv_i_c068_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_09 (conv_q_src_c068_2_09 0 conv_bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_2_09 (conv_q_src_c068_2_09 conv_q_c068_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_10 (conv_i_src_c068_2_10 0 conv_bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_2_10 (conv_i_src_c068_2_10 conv_i_c068_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_10 (conv_q_src_c068_2_10 0 conv_bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_2_10 (conv_q_src_c068_2_10 conv_q_c068_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_11 (conv_i_src_c068_2_11 0 conv_bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_2_11 (conv_i_src_c068_2_11 conv_i_c068_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_11 (conv_q_src_c068_2_11 0 conv_bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_2_11 (conv_q_src_c068_2_11 conv_q_c068_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_12 (conv_i_src_c068_2_12 0 conv_bpf_c068_2 0) vcvs gain=1.950903220161e-01
SCONVI_c068_2_12 (conv_i_src_c068_2_12 conv_i_c068_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_12 (conv_q_src_c068_2_12 0 conv_bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_2_12 (conv_q_src_c068_2_12 conv_q_c068_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_13 (conv_i_src_c068_2_13 0 conv_bpf_c068_2 0) vcvs gain=5.555702330196e-01
SCONVI_c068_2_13 (conv_i_src_c068_2_13 conv_i_c068_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_13 (conv_q_src_c068_2_13 0 conv_bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_2_13 (conv_q_src_c068_2_13 conv_q_c068_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_14 (conv_i_src_c068_2_14 0 conv_bpf_c068_2 0) vcvs gain=8.314696123025e-01
SCONVI_c068_2_14 (conv_i_src_c068_2_14 conv_i_c068_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_14 (conv_q_src_c068_2_14 0 conv_bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_2_14 (conv_q_src_c068_2_14 conv_q_c068_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_2_15 (conv_i_src_c068_2_15 0 conv_bpf_c068_2 0) vcvs gain=9.807852804032e-01
SCONVI_c068_2_15 (conv_i_src_c068_2_15 conv_i_c068_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_2_15 (conv_q_src_c068_2_15 0 conv_bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_2_15 (conv_q_src_c068_2_15 conv_q_c068_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c068_2 (conv_i_c068_2 0) resistor r=1G
RCONVQ_c068_2 (conv_q_c068_2 0) resistor r=1G
RCONVINTI_c068_2 (conv_i_c068_2 ConvIcar_c068_2) resistor r=1k
CCONVINTI_c068_2 (ConvIcar_c068_2 0) capacitor c=80p
RCONVINTQ_c068_2 (conv_q_c068_2 ConvQcar_c068_2) resistor r=1k
CCONVINTQ_c068_2 (ConvQcar_c068_2 0) capacitor c=80p
save conv_bpf_c068_2 ConvIcar_c068_2 ConvQcar_c068_2

// conventional mixed baseline bl068, carrier_3: 1000000000 Hz
CCONVBPF_c068_3 (bl068 n_conv_cbpf_c068_3) capacitor c=2.533029591058e-14
LCONVBPF_c068_3 (n_conv_cbpf_c068_3 conv_bpf_c068_3) inductor l=1.000000000000e-06
RCONVBPF_c068_3 (conv_bpf_c068_3 0) resistor r=3.141592653590e+02
ECONVI_c068_3_00 (conv_i_src_c068_3_00 0 conv_bpf_c068_3 0) vcvs gain=9.807852804032e-01
SCONVI_c068_3_00 (conv_i_src_c068_3_00 conv_i_c068_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_00 (conv_q_src_c068_3_00 0 conv_bpf_c068_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_3_00 (conv_q_src_c068_3_00 conv_q_c068_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_01 (conv_i_src_c068_3_01 0 conv_bpf_c068_3 0) vcvs gain=8.314696123025e-01
SCONVI_c068_3_01 (conv_i_src_c068_3_01 conv_i_c068_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_01 (conv_q_src_c068_3_01 0 conv_bpf_c068_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_3_01 (conv_q_src_c068_3_01 conv_q_c068_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_02 (conv_i_src_c068_3_02 0 conv_bpf_c068_3 0) vcvs gain=5.555702330196e-01
SCONVI_c068_3_02 (conv_i_src_c068_3_02 conv_i_c068_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_02 (conv_q_src_c068_3_02 0 conv_bpf_c068_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_3_02 (conv_q_src_c068_3_02 conv_q_c068_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_03 (conv_i_src_c068_3_03 0 conv_bpf_c068_3 0) vcvs gain=1.950903220161e-01
SCONVI_c068_3_03 (conv_i_src_c068_3_03 conv_i_c068_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_03 (conv_q_src_c068_3_03 0 conv_bpf_c068_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_3_03 (conv_q_src_c068_3_03 conv_q_c068_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_04 (conv_i_src_c068_3_04 0 conv_bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_3_04 (conv_i_src_c068_3_04 conv_i_c068_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_04 (conv_q_src_c068_3_04 0 conv_bpf_c068_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c068_3_04 (conv_q_src_c068_3_04 conv_q_c068_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_05 (conv_i_src_c068_3_05 0 conv_bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_3_05 (conv_i_src_c068_3_05 conv_i_c068_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_05 (conv_q_src_c068_3_05 0 conv_bpf_c068_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c068_3_05 (conv_q_src_c068_3_05 conv_q_c068_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_06 (conv_i_src_c068_3_06 0 conv_bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_3_06 (conv_i_src_c068_3_06 conv_i_c068_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_06 (conv_q_src_c068_3_06 0 conv_bpf_c068_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c068_3_06 (conv_q_src_c068_3_06 conv_q_c068_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_07 (conv_i_src_c068_3_07 0 conv_bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_3_07 (conv_i_src_c068_3_07 conv_i_c068_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_07 (conv_q_src_c068_3_07 0 conv_bpf_c068_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c068_3_07 (conv_q_src_c068_3_07 conv_q_c068_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_08 (conv_i_src_c068_3_08 0 conv_bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c068_3_08 (conv_i_src_c068_3_08 conv_i_c068_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_08 (conv_q_src_c068_3_08 0 conv_bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_3_08 (conv_q_src_c068_3_08 conv_q_c068_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_09 (conv_i_src_c068_3_09 0 conv_bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c068_3_09 (conv_i_src_c068_3_09 conv_i_c068_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_09 (conv_q_src_c068_3_09 0 conv_bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_3_09 (conv_q_src_c068_3_09 conv_q_c068_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_10 (conv_i_src_c068_3_10 0 conv_bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c068_3_10 (conv_i_src_c068_3_10 conv_i_c068_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_10 (conv_q_src_c068_3_10 0 conv_bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_3_10 (conv_q_src_c068_3_10 conv_q_c068_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_11 (conv_i_src_c068_3_11 0 conv_bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c068_3_11 (conv_i_src_c068_3_11 conv_i_c068_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_11 (conv_q_src_c068_3_11 0 conv_bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_3_11 (conv_q_src_c068_3_11 conv_q_c068_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_12 (conv_i_src_c068_3_12 0 conv_bpf_c068_3 0) vcvs gain=1.950903220161e-01
SCONVI_c068_3_12 (conv_i_src_c068_3_12 conv_i_c068_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_12 (conv_q_src_c068_3_12 0 conv_bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c068_3_12 (conv_q_src_c068_3_12 conv_q_c068_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_13 (conv_i_src_c068_3_13 0 conv_bpf_c068_3 0) vcvs gain=5.555702330196e-01
SCONVI_c068_3_13 (conv_i_src_c068_3_13 conv_i_c068_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_13 (conv_q_src_c068_3_13 0 conv_bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c068_3_13 (conv_q_src_c068_3_13 conv_q_c068_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_14 (conv_i_src_c068_3_14 0 conv_bpf_c068_3 0) vcvs gain=8.314696123025e-01
SCONVI_c068_3_14 (conv_i_src_c068_3_14 conv_i_c068_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_14 (conv_q_src_c068_3_14 0 conv_bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c068_3_14 (conv_q_src_c068_3_14 conv_q_c068_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c068_3_15 (conv_i_src_c068_3_15 0 conv_bpf_c068_3 0) vcvs gain=9.807852804032e-01
SCONVI_c068_3_15 (conv_i_src_c068_3_15 conv_i_c068_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c068_3_15 (conv_q_src_c068_3_15 0 conv_bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c068_3_15 (conv_q_src_c068_3_15 conv_q_c068_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c068_3 (conv_i_c068_3 0) resistor r=1G
RCONVQ_c068_3 (conv_q_c068_3 0) resistor r=1G
RCONVINTI_c068_3 (conv_i_c068_3 ConvIcar_c068_3) resistor r=1k
CCONVINTI_c068_3 (ConvIcar_c068_3 0) capacitor c=80p
RCONVINTQ_c068_3 (conv_q_c068_3 ConvQcar_c068_3) resistor r=1k
CCONVINTQ_c068_3 (ConvQcar_c068_3 0) capacitor c=80p
save conv_bpf_c068_3 ConvIcar_c068_3 ConvQcar_c068_3

// conventional mixed baseline bl069, carrier_0: 250000000 Hz
CCONVBPF_c069_0 (bl069 n_conv_cbpf_c069_0) capacitor c=4.052847345694e-13
LCONVBPF_c069_0 (n_conv_cbpf_c069_0 conv_bpf_c069_0) inductor l=1.000000000000e-06
RCONVBPF_c069_0 (conv_bpf_c069_0 0) resistor r=7.853981633974e+01
ECONVI_c069_0_00 (conv_i_src_c069_0_00 0 conv_bpf_c069_0 0) vcvs gain=9.807852804032e-01
SCONVI_c069_0_00 (conv_i_src_c069_0_00 conv_i_c069_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_00 (conv_q_src_c069_0_00 0 conv_bpf_c069_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_0_00 (conv_q_src_c069_0_00 conv_q_c069_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_01 (conv_i_src_c069_0_01 0 conv_bpf_c069_0 0) vcvs gain=8.314696123025e-01
SCONVI_c069_0_01 (conv_i_src_c069_0_01 conv_i_c069_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_01 (conv_q_src_c069_0_01 0 conv_bpf_c069_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_0_01 (conv_q_src_c069_0_01 conv_q_c069_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_02 (conv_i_src_c069_0_02 0 conv_bpf_c069_0 0) vcvs gain=5.555702330196e-01
SCONVI_c069_0_02 (conv_i_src_c069_0_02 conv_i_c069_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_02 (conv_q_src_c069_0_02 0 conv_bpf_c069_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_0_02 (conv_q_src_c069_0_02 conv_q_c069_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_03 (conv_i_src_c069_0_03 0 conv_bpf_c069_0 0) vcvs gain=1.950903220161e-01
SCONVI_c069_0_03 (conv_i_src_c069_0_03 conv_i_c069_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_03 (conv_q_src_c069_0_03 0 conv_bpf_c069_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_0_03 (conv_q_src_c069_0_03 conv_q_c069_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_04 (conv_i_src_c069_0_04 0 conv_bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_0_04 (conv_i_src_c069_0_04 conv_i_c069_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_04 (conv_q_src_c069_0_04 0 conv_bpf_c069_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_0_04 (conv_q_src_c069_0_04 conv_q_c069_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_05 (conv_i_src_c069_0_05 0 conv_bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_0_05 (conv_i_src_c069_0_05 conv_i_c069_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_05 (conv_q_src_c069_0_05 0 conv_bpf_c069_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_0_05 (conv_q_src_c069_0_05 conv_q_c069_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_06 (conv_i_src_c069_0_06 0 conv_bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_0_06 (conv_i_src_c069_0_06 conv_i_c069_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_06 (conv_q_src_c069_0_06 0 conv_bpf_c069_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_0_06 (conv_q_src_c069_0_06 conv_q_c069_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_07 (conv_i_src_c069_0_07 0 conv_bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_0_07 (conv_i_src_c069_0_07 conv_i_c069_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_07 (conv_q_src_c069_0_07 0 conv_bpf_c069_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_0_07 (conv_q_src_c069_0_07 conv_q_c069_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_08 (conv_i_src_c069_0_08 0 conv_bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_0_08 (conv_i_src_c069_0_08 conv_i_c069_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_08 (conv_q_src_c069_0_08 0 conv_bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_0_08 (conv_q_src_c069_0_08 conv_q_c069_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_09 (conv_i_src_c069_0_09 0 conv_bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_0_09 (conv_i_src_c069_0_09 conv_i_c069_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_09 (conv_q_src_c069_0_09 0 conv_bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_0_09 (conv_q_src_c069_0_09 conv_q_c069_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_10 (conv_i_src_c069_0_10 0 conv_bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_0_10 (conv_i_src_c069_0_10 conv_i_c069_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_10 (conv_q_src_c069_0_10 0 conv_bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_0_10 (conv_q_src_c069_0_10 conv_q_c069_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_11 (conv_i_src_c069_0_11 0 conv_bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_0_11 (conv_i_src_c069_0_11 conv_i_c069_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_11 (conv_q_src_c069_0_11 0 conv_bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_0_11 (conv_q_src_c069_0_11 conv_q_c069_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_12 (conv_i_src_c069_0_12 0 conv_bpf_c069_0 0) vcvs gain=1.950903220161e-01
SCONVI_c069_0_12 (conv_i_src_c069_0_12 conv_i_c069_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_12 (conv_q_src_c069_0_12 0 conv_bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_0_12 (conv_q_src_c069_0_12 conv_q_c069_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_13 (conv_i_src_c069_0_13 0 conv_bpf_c069_0 0) vcvs gain=5.555702330196e-01
SCONVI_c069_0_13 (conv_i_src_c069_0_13 conv_i_c069_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_13 (conv_q_src_c069_0_13 0 conv_bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_0_13 (conv_q_src_c069_0_13 conv_q_c069_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_14 (conv_i_src_c069_0_14 0 conv_bpf_c069_0 0) vcvs gain=8.314696123025e-01
SCONVI_c069_0_14 (conv_i_src_c069_0_14 conv_i_c069_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_14 (conv_q_src_c069_0_14 0 conv_bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_0_14 (conv_q_src_c069_0_14 conv_q_c069_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_0_15 (conv_i_src_c069_0_15 0 conv_bpf_c069_0 0) vcvs gain=9.807852804032e-01
SCONVI_c069_0_15 (conv_i_src_c069_0_15 conv_i_c069_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_0_15 (conv_q_src_c069_0_15 0 conv_bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_0_15 (conv_q_src_c069_0_15 conv_q_c069_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c069_0 (conv_i_c069_0 0) resistor r=1G
RCONVQ_c069_0 (conv_q_c069_0 0) resistor r=1G
RCONVINTI_c069_0 (conv_i_c069_0 ConvIcar_c069_0) resistor r=1k
CCONVINTI_c069_0 (ConvIcar_c069_0 0) capacitor c=80p
RCONVINTQ_c069_0 (conv_q_c069_0 ConvQcar_c069_0) resistor r=1k
CCONVINTQ_c069_0 (ConvQcar_c069_0 0) capacitor c=80p
save conv_bpf_c069_0 ConvIcar_c069_0 ConvQcar_c069_0

// conventional mixed baseline bl069, carrier_1: 500000000 Hz
CCONVBPF_c069_1 (bl069 n_conv_cbpf_c069_1) capacitor c=1.013211836423e-13
LCONVBPF_c069_1 (n_conv_cbpf_c069_1 conv_bpf_c069_1) inductor l=1.000000000000e-06
RCONVBPF_c069_1 (conv_bpf_c069_1 0) resistor r=1.570796326795e+02
ECONVI_c069_1_00 (conv_i_src_c069_1_00 0 conv_bpf_c069_1 0) vcvs gain=9.807852804032e-01
SCONVI_c069_1_00 (conv_i_src_c069_1_00 conv_i_c069_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_00 (conv_q_src_c069_1_00 0 conv_bpf_c069_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_1_00 (conv_q_src_c069_1_00 conv_q_c069_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_01 (conv_i_src_c069_1_01 0 conv_bpf_c069_1 0) vcvs gain=8.314696123025e-01
SCONVI_c069_1_01 (conv_i_src_c069_1_01 conv_i_c069_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_01 (conv_q_src_c069_1_01 0 conv_bpf_c069_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_1_01 (conv_q_src_c069_1_01 conv_q_c069_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_02 (conv_i_src_c069_1_02 0 conv_bpf_c069_1 0) vcvs gain=5.555702330196e-01
SCONVI_c069_1_02 (conv_i_src_c069_1_02 conv_i_c069_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_02 (conv_q_src_c069_1_02 0 conv_bpf_c069_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_1_02 (conv_q_src_c069_1_02 conv_q_c069_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_03 (conv_i_src_c069_1_03 0 conv_bpf_c069_1 0) vcvs gain=1.950903220161e-01
SCONVI_c069_1_03 (conv_i_src_c069_1_03 conv_i_c069_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_03 (conv_q_src_c069_1_03 0 conv_bpf_c069_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_1_03 (conv_q_src_c069_1_03 conv_q_c069_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_04 (conv_i_src_c069_1_04 0 conv_bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_1_04 (conv_i_src_c069_1_04 conv_i_c069_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_04 (conv_q_src_c069_1_04 0 conv_bpf_c069_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_1_04 (conv_q_src_c069_1_04 conv_q_c069_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_05 (conv_i_src_c069_1_05 0 conv_bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_1_05 (conv_i_src_c069_1_05 conv_i_c069_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_05 (conv_q_src_c069_1_05 0 conv_bpf_c069_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_1_05 (conv_q_src_c069_1_05 conv_q_c069_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_06 (conv_i_src_c069_1_06 0 conv_bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_1_06 (conv_i_src_c069_1_06 conv_i_c069_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_06 (conv_q_src_c069_1_06 0 conv_bpf_c069_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_1_06 (conv_q_src_c069_1_06 conv_q_c069_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_07 (conv_i_src_c069_1_07 0 conv_bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_1_07 (conv_i_src_c069_1_07 conv_i_c069_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_07 (conv_q_src_c069_1_07 0 conv_bpf_c069_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_1_07 (conv_q_src_c069_1_07 conv_q_c069_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_08 (conv_i_src_c069_1_08 0 conv_bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_1_08 (conv_i_src_c069_1_08 conv_i_c069_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_08 (conv_q_src_c069_1_08 0 conv_bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_1_08 (conv_q_src_c069_1_08 conv_q_c069_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_09 (conv_i_src_c069_1_09 0 conv_bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_1_09 (conv_i_src_c069_1_09 conv_i_c069_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_09 (conv_q_src_c069_1_09 0 conv_bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_1_09 (conv_q_src_c069_1_09 conv_q_c069_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_10 (conv_i_src_c069_1_10 0 conv_bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_1_10 (conv_i_src_c069_1_10 conv_i_c069_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_10 (conv_q_src_c069_1_10 0 conv_bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_1_10 (conv_q_src_c069_1_10 conv_q_c069_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_11 (conv_i_src_c069_1_11 0 conv_bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_1_11 (conv_i_src_c069_1_11 conv_i_c069_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_11 (conv_q_src_c069_1_11 0 conv_bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_1_11 (conv_q_src_c069_1_11 conv_q_c069_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_12 (conv_i_src_c069_1_12 0 conv_bpf_c069_1 0) vcvs gain=1.950903220161e-01
SCONVI_c069_1_12 (conv_i_src_c069_1_12 conv_i_c069_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_12 (conv_q_src_c069_1_12 0 conv_bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_1_12 (conv_q_src_c069_1_12 conv_q_c069_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_13 (conv_i_src_c069_1_13 0 conv_bpf_c069_1 0) vcvs gain=5.555702330196e-01
SCONVI_c069_1_13 (conv_i_src_c069_1_13 conv_i_c069_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_13 (conv_q_src_c069_1_13 0 conv_bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_1_13 (conv_q_src_c069_1_13 conv_q_c069_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_14 (conv_i_src_c069_1_14 0 conv_bpf_c069_1 0) vcvs gain=8.314696123025e-01
SCONVI_c069_1_14 (conv_i_src_c069_1_14 conv_i_c069_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_14 (conv_q_src_c069_1_14 0 conv_bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_1_14 (conv_q_src_c069_1_14 conv_q_c069_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_1_15 (conv_i_src_c069_1_15 0 conv_bpf_c069_1 0) vcvs gain=9.807852804032e-01
SCONVI_c069_1_15 (conv_i_src_c069_1_15 conv_i_c069_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_1_15 (conv_q_src_c069_1_15 0 conv_bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_1_15 (conv_q_src_c069_1_15 conv_q_c069_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c069_1 (conv_i_c069_1 0) resistor r=1G
RCONVQ_c069_1 (conv_q_c069_1 0) resistor r=1G
RCONVINTI_c069_1 (conv_i_c069_1 ConvIcar_c069_1) resistor r=1k
CCONVINTI_c069_1 (ConvIcar_c069_1 0) capacitor c=80p
RCONVINTQ_c069_1 (conv_q_c069_1 ConvQcar_c069_1) resistor r=1k
CCONVINTQ_c069_1 (ConvQcar_c069_1 0) capacitor c=80p
save conv_bpf_c069_1 ConvIcar_c069_1 ConvQcar_c069_1

// conventional mixed baseline bl069, carrier_2: 750000000 Hz
CCONVBPF_c069_2 (bl069 n_conv_cbpf_c069_2) capacitor c=4.503163717437e-14
LCONVBPF_c069_2 (n_conv_cbpf_c069_2 conv_bpf_c069_2) inductor l=1.000000000000e-06
RCONVBPF_c069_2 (conv_bpf_c069_2 0) resistor r=2.356194490192e+02
ECONVI_c069_2_00 (conv_i_src_c069_2_00 0 conv_bpf_c069_2 0) vcvs gain=9.807852804032e-01
SCONVI_c069_2_00 (conv_i_src_c069_2_00 conv_i_c069_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_00 (conv_q_src_c069_2_00 0 conv_bpf_c069_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_2_00 (conv_q_src_c069_2_00 conv_q_c069_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_01 (conv_i_src_c069_2_01 0 conv_bpf_c069_2 0) vcvs gain=8.314696123025e-01
SCONVI_c069_2_01 (conv_i_src_c069_2_01 conv_i_c069_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_01 (conv_q_src_c069_2_01 0 conv_bpf_c069_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_2_01 (conv_q_src_c069_2_01 conv_q_c069_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_02 (conv_i_src_c069_2_02 0 conv_bpf_c069_2 0) vcvs gain=5.555702330196e-01
SCONVI_c069_2_02 (conv_i_src_c069_2_02 conv_i_c069_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_02 (conv_q_src_c069_2_02 0 conv_bpf_c069_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_2_02 (conv_q_src_c069_2_02 conv_q_c069_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_03 (conv_i_src_c069_2_03 0 conv_bpf_c069_2 0) vcvs gain=1.950903220161e-01
SCONVI_c069_2_03 (conv_i_src_c069_2_03 conv_i_c069_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_03 (conv_q_src_c069_2_03 0 conv_bpf_c069_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_2_03 (conv_q_src_c069_2_03 conv_q_c069_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_04 (conv_i_src_c069_2_04 0 conv_bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_2_04 (conv_i_src_c069_2_04 conv_i_c069_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_04 (conv_q_src_c069_2_04 0 conv_bpf_c069_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_2_04 (conv_q_src_c069_2_04 conv_q_c069_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_05 (conv_i_src_c069_2_05 0 conv_bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_2_05 (conv_i_src_c069_2_05 conv_i_c069_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_05 (conv_q_src_c069_2_05 0 conv_bpf_c069_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_2_05 (conv_q_src_c069_2_05 conv_q_c069_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_06 (conv_i_src_c069_2_06 0 conv_bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_2_06 (conv_i_src_c069_2_06 conv_i_c069_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_06 (conv_q_src_c069_2_06 0 conv_bpf_c069_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_2_06 (conv_q_src_c069_2_06 conv_q_c069_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_07 (conv_i_src_c069_2_07 0 conv_bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_2_07 (conv_i_src_c069_2_07 conv_i_c069_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_07 (conv_q_src_c069_2_07 0 conv_bpf_c069_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_2_07 (conv_q_src_c069_2_07 conv_q_c069_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_08 (conv_i_src_c069_2_08 0 conv_bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_2_08 (conv_i_src_c069_2_08 conv_i_c069_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_08 (conv_q_src_c069_2_08 0 conv_bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_2_08 (conv_q_src_c069_2_08 conv_q_c069_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_09 (conv_i_src_c069_2_09 0 conv_bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_2_09 (conv_i_src_c069_2_09 conv_i_c069_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_09 (conv_q_src_c069_2_09 0 conv_bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_2_09 (conv_q_src_c069_2_09 conv_q_c069_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_10 (conv_i_src_c069_2_10 0 conv_bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_2_10 (conv_i_src_c069_2_10 conv_i_c069_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_10 (conv_q_src_c069_2_10 0 conv_bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_2_10 (conv_q_src_c069_2_10 conv_q_c069_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_11 (conv_i_src_c069_2_11 0 conv_bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_2_11 (conv_i_src_c069_2_11 conv_i_c069_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_11 (conv_q_src_c069_2_11 0 conv_bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_2_11 (conv_q_src_c069_2_11 conv_q_c069_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_12 (conv_i_src_c069_2_12 0 conv_bpf_c069_2 0) vcvs gain=1.950903220161e-01
SCONVI_c069_2_12 (conv_i_src_c069_2_12 conv_i_c069_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_12 (conv_q_src_c069_2_12 0 conv_bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_2_12 (conv_q_src_c069_2_12 conv_q_c069_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_13 (conv_i_src_c069_2_13 0 conv_bpf_c069_2 0) vcvs gain=5.555702330196e-01
SCONVI_c069_2_13 (conv_i_src_c069_2_13 conv_i_c069_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_13 (conv_q_src_c069_2_13 0 conv_bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_2_13 (conv_q_src_c069_2_13 conv_q_c069_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_14 (conv_i_src_c069_2_14 0 conv_bpf_c069_2 0) vcvs gain=8.314696123025e-01
SCONVI_c069_2_14 (conv_i_src_c069_2_14 conv_i_c069_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_14 (conv_q_src_c069_2_14 0 conv_bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_2_14 (conv_q_src_c069_2_14 conv_q_c069_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_2_15 (conv_i_src_c069_2_15 0 conv_bpf_c069_2 0) vcvs gain=9.807852804032e-01
SCONVI_c069_2_15 (conv_i_src_c069_2_15 conv_i_c069_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_2_15 (conv_q_src_c069_2_15 0 conv_bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_2_15 (conv_q_src_c069_2_15 conv_q_c069_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c069_2 (conv_i_c069_2 0) resistor r=1G
RCONVQ_c069_2 (conv_q_c069_2 0) resistor r=1G
RCONVINTI_c069_2 (conv_i_c069_2 ConvIcar_c069_2) resistor r=1k
CCONVINTI_c069_2 (ConvIcar_c069_2 0) capacitor c=80p
RCONVINTQ_c069_2 (conv_q_c069_2 ConvQcar_c069_2) resistor r=1k
CCONVINTQ_c069_2 (ConvQcar_c069_2 0) capacitor c=80p
save conv_bpf_c069_2 ConvIcar_c069_2 ConvQcar_c069_2

// conventional mixed baseline bl069, carrier_3: 1000000000 Hz
CCONVBPF_c069_3 (bl069 n_conv_cbpf_c069_3) capacitor c=2.533029591058e-14
LCONVBPF_c069_3 (n_conv_cbpf_c069_3 conv_bpf_c069_3) inductor l=1.000000000000e-06
RCONVBPF_c069_3 (conv_bpf_c069_3 0) resistor r=3.141592653590e+02
ECONVI_c069_3_00 (conv_i_src_c069_3_00 0 conv_bpf_c069_3 0) vcvs gain=9.807852804032e-01
SCONVI_c069_3_00 (conv_i_src_c069_3_00 conv_i_c069_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_00 (conv_q_src_c069_3_00 0 conv_bpf_c069_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_3_00 (conv_q_src_c069_3_00 conv_q_c069_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_01 (conv_i_src_c069_3_01 0 conv_bpf_c069_3 0) vcvs gain=8.314696123025e-01
SCONVI_c069_3_01 (conv_i_src_c069_3_01 conv_i_c069_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_01 (conv_q_src_c069_3_01 0 conv_bpf_c069_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_3_01 (conv_q_src_c069_3_01 conv_q_c069_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_02 (conv_i_src_c069_3_02 0 conv_bpf_c069_3 0) vcvs gain=5.555702330196e-01
SCONVI_c069_3_02 (conv_i_src_c069_3_02 conv_i_c069_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_02 (conv_q_src_c069_3_02 0 conv_bpf_c069_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_3_02 (conv_q_src_c069_3_02 conv_q_c069_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_03 (conv_i_src_c069_3_03 0 conv_bpf_c069_3 0) vcvs gain=1.950903220161e-01
SCONVI_c069_3_03 (conv_i_src_c069_3_03 conv_i_c069_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_03 (conv_q_src_c069_3_03 0 conv_bpf_c069_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_3_03 (conv_q_src_c069_3_03 conv_q_c069_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_04 (conv_i_src_c069_3_04 0 conv_bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_3_04 (conv_i_src_c069_3_04 conv_i_c069_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_04 (conv_q_src_c069_3_04 0 conv_bpf_c069_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c069_3_04 (conv_q_src_c069_3_04 conv_q_c069_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_05 (conv_i_src_c069_3_05 0 conv_bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_3_05 (conv_i_src_c069_3_05 conv_i_c069_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_05 (conv_q_src_c069_3_05 0 conv_bpf_c069_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c069_3_05 (conv_q_src_c069_3_05 conv_q_c069_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_06 (conv_i_src_c069_3_06 0 conv_bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_3_06 (conv_i_src_c069_3_06 conv_i_c069_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_06 (conv_q_src_c069_3_06 0 conv_bpf_c069_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c069_3_06 (conv_q_src_c069_3_06 conv_q_c069_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_07 (conv_i_src_c069_3_07 0 conv_bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_3_07 (conv_i_src_c069_3_07 conv_i_c069_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_07 (conv_q_src_c069_3_07 0 conv_bpf_c069_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c069_3_07 (conv_q_src_c069_3_07 conv_q_c069_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_08 (conv_i_src_c069_3_08 0 conv_bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c069_3_08 (conv_i_src_c069_3_08 conv_i_c069_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_08 (conv_q_src_c069_3_08 0 conv_bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_3_08 (conv_q_src_c069_3_08 conv_q_c069_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_09 (conv_i_src_c069_3_09 0 conv_bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c069_3_09 (conv_i_src_c069_3_09 conv_i_c069_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_09 (conv_q_src_c069_3_09 0 conv_bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_3_09 (conv_q_src_c069_3_09 conv_q_c069_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_10 (conv_i_src_c069_3_10 0 conv_bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c069_3_10 (conv_i_src_c069_3_10 conv_i_c069_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_10 (conv_q_src_c069_3_10 0 conv_bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_3_10 (conv_q_src_c069_3_10 conv_q_c069_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_11 (conv_i_src_c069_3_11 0 conv_bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c069_3_11 (conv_i_src_c069_3_11 conv_i_c069_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_11 (conv_q_src_c069_3_11 0 conv_bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_3_11 (conv_q_src_c069_3_11 conv_q_c069_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_12 (conv_i_src_c069_3_12 0 conv_bpf_c069_3 0) vcvs gain=1.950903220161e-01
SCONVI_c069_3_12 (conv_i_src_c069_3_12 conv_i_c069_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_12 (conv_q_src_c069_3_12 0 conv_bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c069_3_12 (conv_q_src_c069_3_12 conv_q_c069_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_13 (conv_i_src_c069_3_13 0 conv_bpf_c069_3 0) vcvs gain=5.555702330196e-01
SCONVI_c069_3_13 (conv_i_src_c069_3_13 conv_i_c069_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_13 (conv_q_src_c069_3_13 0 conv_bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c069_3_13 (conv_q_src_c069_3_13 conv_q_c069_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_14 (conv_i_src_c069_3_14 0 conv_bpf_c069_3 0) vcvs gain=8.314696123025e-01
SCONVI_c069_3_14 (conv_i_src_c069_3_14 conv_i_c069_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_14 (conv_q_src_c069_3_14 0 conv_bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c069_3_14 (conv_q_src_c069_3_14 conv_q_c069_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c069_3_15 (conv_i_src_c069_3_15 0 conv_bpf_c069_3 0) vcvs gain=9.807852804032e-01
SCONVI_c069_3_15 (conv_i_src_c069_3_15 conv_i_c069_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c069_3_15 (conv_q_src_c069_3_15 0 conv_bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c069_3_15 (conv_q_src_c069_3_15 conv_q_c069_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c069_3 (conv_i_c069_3 0) resistor r=1G
RCONVQ_c069_3 (conv_q_c069_3 0) resistor r=1G
RCONVINTI_c069_3 (conv_i_c069_3 ConvIcar_c069_3) resistor r=1k
CCONVINTI_c069_3 (ConvIcar_c069_3 0) capacitor c=80p
RCONVINTQ_c069_3 (conv_q_c069_3 ConvQcar_c069_3) resistor r=1k
CCONVINTQ_c069_3 (ConvQcar_c069_3 0) capacitor c=80p
save conv_bpf_c069_3 ConvIcar_c069_3 ConvQcar_c069_3

// conventional mixed baseline bl070, carrier_0: 250000000 Hz
CCONVBPF_c070_0 (bl070 n_conv_cbpf_c070_0) capacitor c=4.052847345694e-13
LCONVBPF_c070_0 (n_conv_cbpf_c070_0 conv_bpf_c070_0) inductor l=1.000000000000e-06
RCONVBPF_c070_0 (conv_bpf_c070_0 0) resistor r=7.853981633974e+01
ECONVI_c070_0_00 (conv_i_src_c070_0_00 0 conv_bpf_c070_0 0) vcvs gain=9.807852804032e-01
SCONVI_c070_0_00 (conv_i_src_c070_0_00 conv_i_c070_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_00 (conv_q_src_c070_0_00 0 conv_bpf_c070_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_0_00 (conv_q_src_c070_0_00 conv_q_c070_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_01 (conv_i_src_c070_0_01 0 conv_bpf_c070_0 0) vcvs gain=8.314696123025e-01
SCONVI_c070_0_01 (conv_i_src_c070_0_01 conv_i_c070_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_01 (conv_q_src_c070_0_01 0 conv_bpf_c070_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_0_01 (conv_q_src_c070_0_01 conv_q_c070_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_02 (conv_i_src_c070_0_02 0 conv_bpf_c070_0 0) vcvs gain=5.555702330196e-01
SCONVI_c070_0_02 (conv_i_src_c070_0_02 conv_i_c070_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_02 (conv_q_src_c070_0_02 0 conv_bpf_c070_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_0_02 (conv_q_src_c070_0_02 conv_q_c070_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_03 (conv_i_src_c070_0_03 0 conv_bpf_c070_0 0) vcvs gain=1.950903220161e-01
SCONVI_c070_0_03 (conv_i_src_c070_0_03 conv_i_c070_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_03 (conv_q_src_c070_0_03 0 conv_bpf_c070_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_0_03 (conv_q_src_c070_0_03 conv_q_c070_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_04 (conv_i_src_c070_0_04 0 conv_bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_0_04 (conv_i_src_c070_0_04 conv_i_c070_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_04 (conv_q_src_c070_0_04 0 conv_bpf_c070_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_0_04 (conv_q_src_c070_0_04 conv_q_c070_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_05 (conv_i_src_c070_0_05 0 conv_bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_0_05 (conv_i_src_c070_0_05 conv_i_c070_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_05 (conv_q_src_c070_0_05 0 conv_bpf_c070_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_0_05 (conv_q_src_c070_0_05 conv_q_c070_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_06 (conv_i_src_c070_0_06 0 conv_bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_0_06 (conv_i_src_c070_0_06 conv_i_c070_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_06 (conv_q_src_c070_0_06 0 conv_bpf_c070_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_0_06 (conv_q_src_c070_0_06 conv_q_c070_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_07 (conv_i_src_c070_0_07 0 conv_bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_0_07 (conv_i_src_c070_0_07 conv_i_c070_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_07 (conv_q_src_c070_0_07 0 conv_bpf_c070_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_0_07 (conv_q_src_c070_0_07 conv_q_c070_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_08 (conv_i_src_c070_0_08 0 conv_bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_0_08 (conv_i_src_c070_0_08 conv_i_c070_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_08 (conv_q_src_c070_0_08 0 conv_bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_0_08 (conv_q_src_c070_0_08 conv_q_c070_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_09 (conv_i_src_c070_0_09 0 conv_bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_0_09 (conv_i_src_c070_0_09 conv_i_c070_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_09 (conv_q_src_c070_0_09 0 conv_bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_0_09 (conv_q_src_c070_0_09 conv_q_c070_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_10 (conv_i_src_c070_0_10 0 conv_bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_0_10 (conv_i_src_c070_0_10 conv_i_c070_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_10 (conv_q_src_c070_0_10 0 conv_bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_0_10 (conv_q_src_c070_0_10 conv_q_c070_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_11 (conv_i_src_c070_0_11 0 conv_bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_0_11 (conv_i_src_c070_0_11 conv_i_c070_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_11 (conv_q_src_c070_0_11 0 conv_bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_0_11 (conv_q_src_c070_0_11 conv_q_c070_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_12 (conv_i_src_c070_0_12 0 conv_bpf_c070_0 0) vcvs gain=1.950903220161e-01
SCONVI_c070_0_12 (conv_i_src_c070_0_12 conv_i_c070_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_12 (conv_q_src_c070_0_12 0 conv_bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_0_12 (conv_q_src_c070_0_12 conv_q_c070_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_13 (conv_i_src_c070_0_13 0 conv_bpf_c070_0 0) vcvs gain=5.555702330196e-01
SCONVI_c070_0_13 (conv_i_src_c070_0_13 conv_i_c070_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_13 (conv_q_src_c070_0_13 0 conv_bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_0_13 (conv_q_src_c070_0_13 conv_q_c070_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_14 (conv_i_src_c070_0_14 0 conv_bpf_c070_0 0) vcvs gain=8.314696123025e-01
SCONVI_c070_0_14 (conv_i_src_c070_0_14 conv_i_c070_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_14 (conv_q_src_c070_0_14 0 conv_bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_0_14 (conv_q_src_c070_0_14 conv_q_c070_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_0_15 (conv_i_src_c070_0_15 0 conv_bpf_c070_0 0) vcvs gain=9.807852804032e-01
SCONVI_c070_0_15 (conv_i_src_c070_0_15 conv_i_c070_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_0_15 (conv_q_src_c070_0_15 0 conv_bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_0_15 (conv_q_src_c070_0_15 conv_q_c070_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c070_0 (conv_i_c070_0 0) resistor r=1G
RCONVQ_c070_0 (conv_q_c070_0 0) resistor r=1G
RCONVINTI_c070_0 (conv_i_c070_0 ConvIcar_c070_0) resistor r=1k
CCONVINTI_c070_0 (ConvIcar_c070_0 0) capacitor c=80p
RCONVINTQ_c070_0 (conv_q_c070_0 ConvQcar_c070_0) resistor r=1k
CCONVINTQ_c070_0 (ConvQcar_c070_0 0) capacitor c=80p
save conv_bpf_c070_0 ConvIcar_c070_0 ConvQcar_c070_0

// conventional mixed baseline bl070, carrier_1: 500000000 Hz
CCONVBPF_c070_1 (bl070 n_conv_cbpf_c070_1) capacitor c=1.013211836423e-13
LCONVBPF_c070_1 (n_conv_cbpf_c070_1 conv_bpf_c070_1) inductor l=1.000000000000e-06
RCONVBPF_c070_1 (conv_bpf_c070_1 0) resistor r=1.570796326795e+02
ECONVI_c070_1_00 (conv_i_src_c070_1_00 0 conv_bpf_c070_1 0) vcvs gain=9.807852804032e-01
SCONVI_c070_1_00 (conv_i_src_c070_1_00 conv_i_c070_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_00 (conv_q_src_c070_1_00 0 conv_bpf_c070_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_1_00 (conv_q_src_c070_1_00 conv_q_c070_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_01 (conv_i_src_c070_1_01 0 conv_bpf_c070_1 0) vcvs gain=8.314696123025e-01
SCONVI_c070_1_01 (conv_i_src_c070_1_01 conv_i_c070_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_01 (conv_q_src_c070_1_01 0 conv_bpf_c070_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_1_01 (conv_q_src_c070_1_01 conv_q_c070_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_02 (conv_i_src_c070_1_02 0 conv_bpf_c070_1 0) vcvs gain=5.555702330196e-01
SCONVI_c070_1_02 (conv_i_src_c070_1_02 conv_i_c070_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_02 (conv_q_src_c070_1_02 0 conv_bpf_c070_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_1_02 (conv_q_src_c070_1_02 conv_q_c070_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_03 (conv_i_src_c070_1_03 0 conv_bpf_c070_1 0) vcvs gain=1.950903220161e-01
SCONVI_c070_1_03 (conv_i_src_c070_1_03 conv_i_c070_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_03 (conv_q_src_c070_1_03 0 conv_bpf_c070_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_1_03 (conv_q_src_c070_1_03 conv_q_c070_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_04 (conv_i_src_c070_1_04 0 conv_bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_1_04 (conv_i_src_c070_1_04 conv_i_c070_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_04 (conv_q_src_c070_1_04 0 conv_bpf_c070_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_1_04 (conv_q_src_c070_1_04 conv_q_c070_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_05 (conv_i_src_c070_1_05 0 conv_bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_1_05 (conv_i_src_c070_1_05 conv_i_c070_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_05 (conv_q_src_c070_1_05 0 conv_bpf_c070_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_1_05 (conv_q_src_c070_1_05 conv_q_c070_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_06 (conv_i_src_c070_1_06 0 conv_bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_1_06 (conv_i_src_c070_1_06 conv_i_c070_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_06 (conv_q_src_c070_1_06 0 conv_bpf_c070_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_1_06 (conv_q_src_c070_1_06 conv_q_c070_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_07 (conv_i_src_c070_1_07 0 conv_bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_1_07 (conv_i_src_c070_1_07 conv_i_c070_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_07 (conv_q_src_c070_1_07 0 conv_bpf_c070_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_1_07 (conv_q_src_c070_1_07 conv_q_c070_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_08 (conv_i_src_c070_1_08 0 conv_bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_1_08 (conv_i_src_c070_1_08 conv_i_c070_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_08 (conv_q_src_c070_1_08 0 conv_bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_1_08 (conv_q_src_c070_1_08 conv_q_c070_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_09 (conv_i_src_c070_1_09 0 conv_bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_1_09 (conv_i_src_c070_1_09 conv_i_c070_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_09 (conv_q_src_c070_1_09 0 conv_bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_1_09 (conv_q_src_c070_1_09 conv_q_c070_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_10 (conv_i_src_c070_1_10 0 conv_bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_1_10 (conv_i_src_c070_1_10 conv_i_c070_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_10 (conv_q_src_c070_1_10 0 conv_bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_1_10 (conv_q_src_c070_1_10 conv_q_c070_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_11 (conv_i_src_c070_1_11 0 conv_bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_1_11 (conv_i_src_c070_1_11 conv_i_c070_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_11 (conv_q_src_c070_1_11 0 conv_bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_1_11 (conv_q_src_c070_1_11 conv_q_c070_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_12 (conv_i_src_c070_1_12 0 conv_bpf_c070_1 0) vcvs gain=1.950903220161e-01
SCONVI_c070_1_12 (conv_i_src_c070_1_12 conv_i_c070_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_12 (conv_q_src_c070_1_12 0 conv_bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_1_12 (conv_q_src_c070_1_12 conv_q_c070_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_13 (conv_i_src_c070_1_13 0 conv_bpf_c070_1 0) vcvs gain=5.555702330196e-01
SCONVI_c070_1_13 (conv_i_src_c070_1_13 conv_i_c070_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_13 (conv_q_src_c070_1_13 0 conv_bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_1_13 (conv_q_src_c070_1_13 conv_q_c070_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_14 (conv_i_src_c070_1_14 0 conv_bpf_c070_1 0) vcvs gain=8.314696123025e-01
SCONVI_c070_1_14 (conv_i_src_c070_1_14 conv_i_c070_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_14 (conv_q_src_c070_1_14 0 conv_bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_1_14 (conv_q_src_c070_1_14 conv_q_c070_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_1_15 (conv_i_src_c070_1_15 0 conv_bpf_c070_1 0) vcvs gain=9.807852804032e-01
SCONVI_c070_1_15 (conv_i_src_c070_1_15 conv_i_c070_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_1_15 (conv_q_src_c070_1_15 0 conv_bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_1_15 (conv_q_src_c070_1_15 conv_q_c070_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c070_1 (conv_i_c070_1 0) resistor r=1G
RCONVQ_c070_1 (conv_q_c070_1 0) resistor r=1G
RCONVINTI_c070_1 (conv_i_c070_1 ConvIcar_c070_1) resistor r=1k
CCONVINTI_c070_1 (ConvIcar_c070_1 0) capacitor c=80p
RCONVINTQ_c070_1 (conv_q_c070_1 ConvQcar_c070_1) resistor r=1k
CCONVINTQ_c070_1 (ConvQcar_c070_1 0) capacitor c=80p
save conv_bpf_c070_1 ConvIcar_c070_1 ConvQcar_c070_1

// conventional mixed baseline bl070, carrier_2: 750000000 Hz
CCONVBPF_c070_2 (bl070 n_conv_cbpf_c070_2) capacitor c=4.503163717437e-14
LCONVBPF_c070_2 (n_conv_cbpf_c070_2 conv_bpf_c070_2) inductor l=1.000000000000e-06
RCONVBPF_c070_2 (conv_bpf_c070_2 0) resistor r=2.356194490192e+02
ECONVI_c070_2_00 (conv_i_src_c070_2_00 0 conv_bpf_c070_2 0) vcvs gain=9.807852804032e-01
SCONVI_c070_2_00 (conv_i_src_c070_2_00 conv_i_c070_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_00 (conv_q_src_c070_2_00 0 conv_bpf_c070_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_2_00 (conv_q_src_c070_2_00 conv_q_c070_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_01 (conv_i_src_c070_2_01 0 conv_bpf_c070_2 0) vcvs gain=8.314696123025e-01
SCONVI_c070_2_01 (conv_i_src_c070_2_01 conv_i_c070_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_01 (conv_q_src_c070_2_01 0 conv_bpf_c070_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_2_01 (conv_q_src_c070_2_01 conv_q_c070_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_02 (conv_i_src_c070_2_02 0 conv_bpf_c070_2 0) vcvs gain=5.555702330196e-01
SCONVI_c070_2_02 (conv_i_src_c070_2_02 conv_i_c070_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_02 (conv_q_src_c070_2_02 0 conv_bpf_c070_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_2_02 (conv_q_src_c070_2_02 conv_q_c070_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_03 (conv_i_src_c070_2_03 0 conv_bpf_c070_2 0) vcvs gain=1.950903220161e-01
SCONVI_c070_2_03 (conv_i_src_c070_2_03 conv_i_c070_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_03 (conv_q_src_c070_2_03 0 conv_bpf_c070_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_2_03 (conv_q_src_c070_2_03 conv_q_c070_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_04 (conv_i_src_c070_2_04 0 conv_bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_2_04 (conv_i_src_c070_2_04 conv_i_c070_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_04 (conv_q_src_c070_2_04 0 conv_bpf_c070_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_2_04 (conv_q_src_c070_2_04 conv_q_c070_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_05 (conv_i_src_c070_2_05 0 conv_bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_2_05 (conv_i_src_c070_2_05 conv_i_c070_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_05 (conv_q_src_c070_2_05 0 conv_bpf_c070_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_2_05 (conv_q_src_c070_2_05 conv_q_c070_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_06 (conv_i_src_c070_2_06 0 conv_bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_2_06 (conv_i_src_c070_2_06 conv_i_c070_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_06 (conv_q_src_c070_2_06 0 conv_bpf_c070_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_2_06 (conv_q_src_c070_2_06 conv_q_c070_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_07 (conv_i_src_c070_2_07 0 conv_bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_2_07 (conv_i_src_c070_2_07 conv_i_c070_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_07 (conv_q_src_c070_2_07 0 conv_bpf_c070_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_2_07 (conv_q_src_c070_2_07 conv_q_c070_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_08 (conv_i_src_c070_2_08 0 conv_bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_2_08 (conv_i_src_c070_2_08 conv_i_c070_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_08 (conv_q_src_c070_2_08 0 conv_bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_2_08 (conv_q_src_c070_2_08 conv_q_c070_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_09 (conv_i_src_c070_2_09 0 conv_bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_2_09 (conv_i_src_c070_2_09 conv_i_c070_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_09 (conv_q_src_c070_2_09 0 conv_bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_2_09 (conv_q_src_c070_2_09 conv_q_c070_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_10 (conv_i_src_c070_2_10 0 conv_bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_2_10 (conv_i_src_c070_2_10 conv_i_c070_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_10 (conv_q_src_c070_2_10 0 conv_bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_2_10 (conv_q_src_c070_2_10 conv_q_c070_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_11 (conv_i_src_c070_2_11 0 conv_bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_2_11 (conv_i_src_c070_2_11 conv_i_c070_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_11 (conv_q_src_c070_2_11 0 conv_bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_2_11 (conv_q_src_c070_2_11 conv_q_c070_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_12 (conv_i_src_c070_2_12 0 conv_bpf_c070_2 0) vcvs gain=1.950903220161e-01
SCONVI_c070_2_12 (conv_i_src_c070_2_12 conv_i_c070_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_12 (conv_q_src_c070_2_12 0 conv_bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_2_12 (conv_q_src_c070_2_12 conv_q_c070_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_13 (conv_i_src_c070_2_13 0 conv_bpf_c070_2 0) vcvs gain=5.555702330196e-01
SCONVI_c070_2_13 (conv_i_src_c070_2_13 conv_i_c070_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_13 (conv_q_src_c070_2_13 0 conv_bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_2_13 (conv_q_src_c070_2_13 conv_q_c070_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_14 (conv_i_src_c070_2_14 0 conv_bpf_c070_2 0) vcvs gain=8.314696123025e-01
SCONVI_c070_2_14 (conv_i_src_c070_2_14 conv_i_c070_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_14 (conv_q_src_c070_2_14 0 conv_bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_2_14 (conv_q_src_c070_2_14 conv_q_c070_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_2_15 (conv_i_src_c070_2_15 0 conv_bpf_c070_2 0) vcvs gain=9.807852804032e-01
SCONVI_c070_2_15 (conv_i_src_c070_2_15 conv_i_c070_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_2_15 (conv_q_src_c070_2_15 0 conv_bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_2_15 (conv_q_src_c070_2_15 conv_q_c070_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c070_2 (conv_i_c070_2 0) resistor r=1G
RCONVQ_c070_2 (conv_q_c070_2 0) resistor r=1G
RCONVINTI_c070_2 (conv_i_c070_2 ConvIcar_c070_2) resistor r=1k
CCONVINTI_c070_2 (ConvIcar_c070_2 0) capacitor c=80p
RCONVINTQ_c070_2 (conv_q_c070_2 ConvQcar_c070_2) resistor r=1k
CCONVINTQ_c070_2 (ConvQcar_c070_2 0) capacitor c=80p
save conv_bpf_c070_2 ConvIcar_c070_2 ConvQcar_c070_2

// conventional mixed baseline bl070, carrier_3: 1000000000 Hz
CCONVBPF_c070_3 (bl070 n_conv_cbpf_c070_3) capacitor c=2.533029591058e-14
LCONVBPF_c070_3 (n_conv_cbpf_c070_3 conv_bpf_c070_3) inductor l=1.000000000000e-06
RCONVBPF_c070_3 (conv_bpf_c070_3 0) resistor r=3.141592653590e+02
ECONVI_c070_3_00 (conv_i_src_c070_3_00 0 conv_bpf_c070_3 0) vcvs gain=9.807852804032e-01
SCONVI_c070_3_00 (conv_i_src_c070_3_00 conv_i_c070_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_00 (conv_q_src_c070_3_00 0 conv_bpf_c070_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_3_00 (conv_q_src_c070_3_00 conv_q_c070_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_01 (conv_i_src_c070_3_01 0 conv_bpf_c070_3 0) vcvs gain=8.314696123025e-01
SCONVI_c070_3_01 (conv_i_src_c070_3_01 conv_i_c070_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_01 (conv_q_src_c070_3_01 0 conv_bpf_c070_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_3_01 (conv_q_src_c070_3_01 conv_q_c070_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_02 (conv_i_src_c070_3_02 0 conv_bpf_c070_3 0) vcvs gain=5.555702330196e-01
SCONVI_c070_3_02 (conv_i_src_c070_3_02 conv_i_c070_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_02 (conv_q_src_c070_3_02 0 conv_bpf_c070_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_3_02 (conv_q_src_c070_3_02 conv_q_c070_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_03 (conv_i_src_c070_3_03 0 conv_bpf_c070_3 0) vcvs gain=1.950903220161e-01
SCONVI_c070_3_03 (conv_i_src_c070_3_03 conv_i_c070_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_03 (conv_q_src_c070_3_03 0 conv_bpf_c070_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_3_03 (conv_q_src_c070_3_03 conv_q_c070_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_04 (conv_i_src_c070_3_04 0 conv_bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_3_04 (conv_i_src_c070_3_04 conv_i_c070_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_04 (conv_q_src_c070_3_04 0 conv_bpf_c070_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c070_3_04 (conv_q_src_c070_3_04 conv_q_c070_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_05 (conv_i_src_c070_3_05 0 conv_bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_3_05 (conv_i_src_c070_3_05 conv_i_c070_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_05 (conv_q_src_c070_3_05 0 conv_bpf_c070_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c070_3_05 (conv_q_src_c070_3_05 conv_q_c070_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_06 (conv_i_src_c070_3_06 0 conv_bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_3_06 (conv_i_src_c070_3_06 conv_i_c070_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_06 (conv_q_src_c070_3_06 0 conv_bpf_c070_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c070_3_06 (conv_q_src_c070_3_06 conv_q_c070_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_07 (conv_i_src_c070_3_07 0 conv_bpf_c070_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_3_07 (conv_i_src_c070_3_07 conv_i_c070_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_07 (conv_q_src_c070_3_07 0 conv_bpf_c070_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c070_3_07 (conv_q_src_c070_3_07 conv_q_c070_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_08 (conv_i_src_c070_3_08 0 conv_bpf_c070_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c070_3_08 (conv_i_src_c070_3_08 conv_i_c070_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_08 (conv_q_src_c070_3_08 0 conv_bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_3_08 (conv_q_src_c070_3_08 conv_q_c070_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_09 (conv_i_src_c070_3_09 0 conv_bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c070_3_09 (conv_i_src_c070_3_09 conv_i_c070_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_09 (conv_q_src_c070_3_09 0 conv_bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_3_09 (conv_q_src_c070_3_09 conv_q_c070_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_10 (conv_i_src_c070_3_10 0 conv_bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c070_3_10 (conv_i_src_c070_3_10 conv_i_c070_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_10 (conv_q_src_c070_3_10 0 conv_bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_3_10 (conv_q_src_c070_3_10 conv_q_c070_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_11 (conv_i_src_c070_3_11 0 conv_bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c070_3_11 (conv_i_src_c070_3_11 conv_i_c070_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_11 (conv_q_src_c070_3_11 0 conv_bpf_c070_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_3_11 (conv_q_src_c070_3_11 conv_q_c070_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_12 (conv_i_src_c070_3_12 0 conv_bpf_c070_3 0) vcvs gain=1.950903220161e-01
SCONVI_c070_3_12 (conv_i_src_c070_3_12 conv_i_c070_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_12 (conv_q_src_c070_3_12 0 conv_bpf_c070_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c070_3_12 (conv_q_src_c070_3_12 conv_q_c070_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_13 (conv_i_src_c070_3_13 0 conv_bpf_c070_3 0) vcvs gain=5.555702330196e-01
SCONVI_c070_3_13 (conv_i_src_c070_3_13 conv_i_c070_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_13 (conv_q_src_c070_3_13 0 conv_bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c070_3_13 (conv_q_src_c070_3_13 conv_q_c070_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_14 (conv_i_src_c070_3_14 0 conv_bpf_c070_3 0) vcvs gain=8.314696123025e-01
SCONVI_c070_3_14 (conv_i_src_c070_3_14 conv_i_c070_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_14 (conv_q_src_c070_3_14 0 conv_bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c070_3_14 (conv_q_src_c070_3_14 conv_q_c070_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c070_3_15 (conv_i_src_c070_3_15 0 conv_bpf_c070_3 0) vcvs gain=9.807852804032e-01
SCONVI_c070_3_15 (conv_i_src_c070_3_15 conv_i_c070_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c070_3_15 (conv_q_src_c070_3_15 0 conv_bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c070_3_15 (conv_q_src_c070_3_15 conv_q_c070_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c070_3 (conv_i_c070_3 0) resistor r=1G
RCONVQ_c070_3 (conv_q_c070_3 0) resistor r=1G
RCONVINTI_c070_3 (conv_i_c070_3 ConvIcar_c070_3) resistor r=1k
CCONVINTI_c070_3 (ConvIcar_c070_3 0) capacitor c=80p
RCONVINTQ_c070_3 (conv_q_c070_3 ConvQcar_c070_3) resistor r=1k
CCONVINTQ_c070_3 (ConvQcar_c070_3 0) capacitor c=80p
save conv_bpf_c070_3 ConvIcar_c070_3 ConvQcar_c070_3

// conventional mixed baseline bl071, carrier_0: 250000000 Hz
CCONVBPF_c071_0 (bl071 n_conv_cbpf_c071_0) capacitor c=4.052847345694e-13
LCONVBPF_c071_0 (n_conv_cbpf_c071_0 conv_bpf_c071_0) inductor l=1.000000000000e-06
RCONVBPF_c071_0 (conv_bpf_c071_0 0) resistor r=7.853981633974e+01
ECONVI_c071_0_00 (conv_i_src_c071_0_00 0 conv_bpf_c071_0 0) vcvs gain=9.807852804032e-01
SCONVI_c071_0_00 (conv_i_src_c071_0_00 conv_i_c071_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_00 (conv_q_src_c071_0_00 0 conv_bpf_c071_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_0_00 (conv_q_src_c071_0_00 conv_q_c071_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_01 (conv_i_src_c071_0_01 0 conv_bpf_c071_0 0) vcvs gain=8.314696123025e-01
SCONVI_c071_0_01 (conv_i_src_c071_0_01 conv_i_c071_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_01 (conv_q_src_c071_0_01 0 conv_bpf_c071_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_0_01 (conv_q_src_c071_0_01 conv_q_c071_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_02 (conv_i_src_c071_0_02 0 conv_bpf_c071_0 0) vcvs gain=5.555702330196e-01
SCONVI_c071_0_02 (conv_i_src_c071_0_02 conv_i_c071_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_02 (conv_q_src_c071_0_02 0 conv_bpf_c071_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_0_02 (conv_q_src_c071_0_02 conv_q_c071_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_03 (conv_i_src_c071_0_03 0 conv_bpf_c071_0 0) vcvs gain=1.950903220161e-01
SCONVI_c071_0_03 (conv_i_src_c071_0_03 conv_i_c071_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_03 (conv_q_src_c071_0_03 0 conv_bpf_c071_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_0_03 (conv_q_src_c071_0_03 conv_q_c071_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_04 (conv_i_src_c071_0_04 0 conv_bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_0_04 (conv_i_src_c071_0_04 conv_i_c071_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_04 (conv_q_src_c071_0_04 0 conv_bpf_c071_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_0_04 (conv_q_src_c071_0_04 conv_q_c071_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_05 (conv_i_src_c071_0_05 0 conv_bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_0_05 (conv_i_src_c071_0_05 conv_i_c071_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_05 (conv_q_src_c071_0_05 0 conv_bpf_c071_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_0_05 (conv_q_src_c071_0_05 conv_q_c071_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_06 (conv_i_src_c071_0_06 0 conv_bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_0_06 (conv_i_src_c071_0_06 conv_i_c071_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_06 (conv_q_src_c071_0_06 0 conv_bpf_c071_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_0_06 (conv_q_src_c071_0_06 conv_q_c071_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_07 (conv_i_src_c071_0_07 0 conv_bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_0_07 (conv_i_src_c071_0_07 conv_i_c071_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_07 (conv_q_src_c071_0_07 0 conv_bpf_c071_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_0_07 (conv_q_src_c071_0_07 conv_q_c071_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_08 (conv_i_src_c071_0_08 0 conv_bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_0_08 (conv_i_src_c071_0_08 conv_i_c071_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_08 (conv_q_src_c071_0_08 0 conv_bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_0_08 (conv_q_src_c071_0_08 conv_q_c071_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_09 (conv_i_src_c071_0_09 0 conv_bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_0_09 (conv_i_src_c071_0_09 conv_i_c071_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_09 (conv_q_src_c071_0_09 0 conv_bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_0_09 (conv_q_src_c071_0_09 conv_q_c071_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_10 (conv_i_src_c071_0_10 0 conv_bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_0_10 (conv_i_src_c071_0_10 conv_i_c071_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_10 (conv_q_src_c071_0_10 0 conv_bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_0_10 (conv_q_src_c071_0_10 conv_q_c071_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_11 (conv_i_src_c071_0_11 0 conv_bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_0_11 (conv_i_src_c071_0_11 conv_i_c071_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_11 (conv_q_src_c071_0_11 0 conv_bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_0_11 (conv_q_src_c071_0_11 conv_q_c071_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_12 (conv_i_src_c071_0_12 0 conv_bpf_c071_0 0) vcvs gain=1.950903220161e-01
SCONVI_c071_0_12 (conv_i_src_c071_0_12 conv_i_c071_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_12 (conv_q_src_c071_0_12 0 conv_bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_0_12 (conv_q_src_c071_0_12 conv_q_c071_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_13 (conv_i_src_c071_0_13 0 conv_bpf_c071_0 0) vcvs gain=5.555702330196e-01
SCONVI_c071_0_13 (conv_i_src_c071_0_13 conv_i_c071_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_13 (conv_q_src_c071_0_13 0 conv_bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_0_13 (conv_q_src_c071_0_13 conv_q_c071_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_14 (conv_i_src_c071_0_14 0 conv_bpf_c071_0 0) vcvs gain=8.314696123025e-01
SCONVI_c071_0_14 (conv_i_src_c071_0_14 conv_i_c071_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_14 (conv_q_src_c071_0_14 0 conv_bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_0_14 (conv_q_src_c071_0_14 conv_q_c071_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_0_15 (conv_i_src_c071_0_15 0 conv_bpf_c071_0 0) vcvs gain=9.807852804032e-01
SCONVI_c071_0_15 (conv_i_src_c071_0_15 conv_i_c071_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_0_15 (conv_q_src_c071_0_15 0 conv_bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_0_15 (conv_q_src_c071_0_15 conv_q_c071_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c071_0 (conv_i_c071_0 0) resistor r=1G
RCONVQ_c071_0 (conv_q_c071_0 0) resistor r=1G
RCONVINTI_c071_0 (conv_i_c071_0 ConvIcar_c071_0) resistor r=1k
CCONVINTI_c071_0 (ConvIcar_c071_0 0) capacitor c=80p
RCONVINTQ_c071_0 (conv_q_c071_0 ConvQcar_c071_0) resistor r=1k
CCONVINTQ_c071_0 (ConvQcar_c071_0 0) capacitor c=80p
save conv_bpf_c071_0 ConvIcar_c071_0 ConvQcar_c071_0

// conventional mixed baseline bl071, carrier_1: 500000000 Hz
CCONVBPF_c071_1 (bl071 n_conv_cbpf_c071_1) capacitor c=1.013211836423e-13
LCONVBPF_c071_1 (n_conv_cbpf_c071_1 conv_bpf_c071_1) inductor l=1.000000000000e-06
RCONVBPF_c071_1 (conv_bpf_c071_1 0) resistor r=1.570796326795e+02
ECONVI_c071_1_00 (conv_i_src_c071_1_00 0 conv_bpf_c071_1 0) vcvs gain=9.807852804032e-01
SCONVI_c071_1_00 (conv_i_src_c071_1_00 conv_i_c071_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_00 (conv_q_src_c071_1_00 0 conv_bpf_c071_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_1_00 (conv_q_src_c071_1_00 conv_q_c071_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_01 (conv_i_src_c071_1_01 0 conv_bpf_c071_1 0) vcvs gain=8.314696123025e-01
SCONVI_c071_1_01 (conv_i_src_c071_1_01 conv_i_c071_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_01 (conv_q_src_c071_1_01 0 conv_bpf_c071_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_1_01 (conv_q_src_c071_1_01 conv_q_c071_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_02 (conv_i_src_c071_1_02 0 conv_bpf_c071_1 0) vcvs gain=5.555702330196e-01
SCONVI_c071_1_02 (conv_i_src_c071_1_02 conv_i_c071_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_02 (conv_q_src_c071_1_02 0 conv_bpf_c071_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_1_02 (conv_q_src_c071_1_02 conv_q_c071_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_03 (conv_i_src_c071_1_03 0 conv_bpf_c071_1 0) vcvs gain=1.950903220161e-01
SCONVI_c071_1_03 (conv_i_src_c071_1_03 conv_i_c071_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_03 (conv_q_src_c071_1_03 0 conv_bpf_c071_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_1_03 (conv_q_src_c071_1_03 conv_q_c071_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_04 (conv_i_src_c071_1_04 0 conv_bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_1_04 (conv_i_src_c071_1_04 conv_i_c071_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_04 (conv_q_src_c071_1_04 0 conv_bpf_c071_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_1_04 (conv_q_src_c071_1_04 conv_q_c071_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_05 (conv_i_src_c071_1_05 0 conv_bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_1_05 (conv_i_src_c071_1_05 conv_i_c071_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_05 (conv_q_src_c071_1_05 0 conv_bpf_c071_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_1_05 (conv_q_src_c071_1_05 conv_q_c071_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_06 (conv_i_src_c071_1_06 0 conv_bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_1_06 (conv_i_src_c071_1_06 conv_i_c071_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_06 (conv_q_src_c071_1_06 0 conv_bpf_c071_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_1_06 (conv_q_src_c071_1_06 conv_q_c071_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_07 (conv_i_src_c071_1_07 0 conv_bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_1_07 (conv_i_src_c071_1_07 conv_i_c071_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_07 (conv_q_src_c071_1_07 0 conv_bpf_c071_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_1_07 (conv_q_src_c071_1_07 conv_q_c071_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_08 (conv_i_src_c071_1_08 0 conv_bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_1_08 (conv_i_src_c071_1_08 conv_i_c071_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_08 (conv_q_src_c071_1_08 0 conv_bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_1_08 (conv_q_src_c071_1_08 conv_q_c071_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_09 (conv_i_src_c071_1_09 0 conv_bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_1_09 (conv_i_src_c071_1_09 conv_i_c071_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_09 (conv_q_src_c071_1_09 0 conv_bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_1_09 (conv_q_src_c071_1_09 conv_q_c071_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_10 (conv_i_src_c071_1_10 0 conv_bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_1_10 (conv_i_src_c071_1_10 conv_i_c071_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_10 (conv_q_src_c071_1_10 0 conv_bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_1_10 (conv_q_src_c071_1_10 conv_q_c071_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_11 (conv_i_src_c071_1_11 0 conv_bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_1_11 (conv_i_src_c071_1_11 conv_i_c071_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_11 (conv_q_src_c071_1_11 0 conv_bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_1_11 (conv_q_src_c071_1_11 conv_q_c071_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_12 (conv_i_src_c071_1_12 0 conv_bpf_c071_1 0) vcvs gain=1.950903220161e-01
SCONVI_c071_1_12 (conv_i_src_c071_1_12 conv_i_c071_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_12 (conv_q_src_c071_1_12 0 conv_bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_1_12 (conv_q_src_c071_1_12 conv_q_c071_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_13 (conv_i_src_c071_1_13 0 conv_bpf_c071_1 0) vcvs gain=5.555702330196e-01
SCONVI_c071_1_13 (conv_i_src_c071_1_13 conv_i_c071_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_13 (conv_q_src_c071_1_13 0 conv_bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_1_13 (conv_q_src_c071_1_13 conv_q_c071_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_14 (conv_i_src_c071_1_14 0 conv_bpf_c071_1 0) vcvs gain=8.314696123025e-01
SCONVI_c071_1_14 (conv_i_src_c071_1_14 conv_i_c071_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_14 (conv_q_src_c071_1_14 0 conv_bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_1_14 (conv_q_src_c071_1_14 conv_q_c071_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_1_15 (conv_i_src_c071_1_15 0 conv_bpf_c071_1 0) vcvs gain=9.807852804032e-01
SCONVI_c071_1_15 (conv_i_src_c071_1_15 conv_i_c071_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_1_15 (conv_q_src_c071_1_15 0 conv_bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_1_15 (conv_q_src_c071_1_15 conv_q_c071_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c071_1 (conv_i_c071_1 0) resistor r=1G
RCONVQ_c071_1 (conv_q_c071_1 0) resistor r=1G
RCONVINTI_c071_1 (conv_i_c071_1 ConvIcar_c071_1) resistor r=1k
CCONVINTI_c071_1 (ConvIcar_c071_1 0) capacitor c=80p
RCONVINTQ_c071_1 (conv_q_c071_1 ConvQcar_c071_1) resistor r=1k
CCONVINTQ_c071_1 (ConvQcar_c071_1 0) capacitor c=80p
save conv_bpf_c071_1 ConvIcar_c071_1 ConvQcar_c071_1

// conventional mixed baseline bl071, carrier_2: 750000000 Hz
CCONVBPF_c071_2 (bl071 n_conv_cbpf_c071_2) capacitor c=4.503163717437e-14
LCONVBPF_c071_2 (n_conv_cbpf_c071_2 conv_bpf_c071_2) inductor l=1.000000000000e-06
RCONVBPF_c071_2 (conv_bpf_c071_2 0) resistor r=2.356194490192e+02
ECONVI_c071_2_00 (conv_i_src_c071_2_00 0 conv_bpf_c071_2 0) vcvs gain=9.807852804032e-01
SCONVI_c071_2_00 (conv_i_src_c071_2_00 conv_i_c071_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_00 (conv_q_src_c071_2_00 0 conv_bpf_c071_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_2_00 (conv_q_src_c071_2_00 conv_q_c071_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_01 (conv_i_src_c071_2_01 0 conv_bpf_c071_2 0) vcvs gain=8.314696123025e-01
SCONVI_c071_2_01 (conv_i_src_c071_2_01 conv_i_c071_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_01 (conv_q_src_c071_2_01 0 conv_bpf_c071_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_2_01 (conv_q_src_c071_2_01 conv_q_c071_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_02 (conv_i_src_c071_2_02 0 conv_bpf_c071_2 0) vcvs gain=5.555702330196e-01
SCONVI_c071_2_02 (conv_i_src_c071_2_02 conv_i_c071_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_02 (conv_q_src_c071_2_02 0 conv_bpf_c071_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_2_02 (conv_q_src_c071_2_02 conv_q_c071_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_03 (conv_i_src_c071_2_03 0 conv_bpf_c071_2 0) vcvs gain=1.950903220161e-01
SCONVI_c071_2_03 (conv_i_src_c071_2_03 conv_i_c071_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_03 (conv_q_src_c071_2_03 0 conv_bpf_c071_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_2_03 (conv_q_src_c071_2_03 conv_q_c071_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_04 (conv_i_src_c071_2_04 0 conv_bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_2_04 (conv_i_src_c071_2_04 conv_i_c071_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_04 (conv_q_src_c071_2_04 0 conv_bpf_c071_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_2_04 (conv_q_src_c071_2_04 conv_q_c071_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_05 (conv_i_src_c071_2_05 0 conv_bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_2_05 (conv_i_src_c071_2_05 conv_i_c071_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_05 (conv_q_src_c071_2_05 0 conv_bpf_c071_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_2_05 (conv_q_src_c071_2_05 conv_q_c071_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_06 (conv_i_src_c071_2_06 0 conv_bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_2_06 (conv_i_src_c071_2_06 conv_i_c071_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_06 (conv_q_src_c071_2_06 0 conv_bpf_c071_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_2_06 (conv_q_src_c071_2_06 conv_q_c071_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_07 (conv_i_src_c071_2_07 0 conv_bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_2_07 (conv_i_src_c071_2_07 conv_i_c071_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_07 (conv_q_src_c071_2_07 0 conv_bpf_c071_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_2_07 (conv_q_src_c071_2_07 conv_q_c071_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_08 (conv_i_src_c071_2_08 0 conv_bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_2_08 (conv_i_src_c071_2_08 conv_i_c071_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_08 (conv_q_src_c071_2_08 0 conv_bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_2_08 (conv_q_src_c071_2_08 conv_q_c071_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_09 (conv_i_src_c071_2_09 0 conv_bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_2_09 (conv_i_src_c071_2_09 conv_i_c071_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_09 (conv_q_src_c071_2_09 0 conv_bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_2_09 (conv_q_src_c071_2_09 conv_q_c071_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_10 (conv_i_src_c071_2_10 0 conv_bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_2_10 (conv_i_src_c071_2_10 conv_i_c071_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_10 (conv_q_src_c071_2_10 0 conv_bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_2_10 (conv_q_src_c071_2_10 conv_q_c071_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_11 (conv_i_src_c071_2_11 0 conv_bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_2_11 (conv_i_src_c071_2_11 conv_i_c071_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_11 (conv_q_src_c071_2_11 0 conv_bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_2_11 (conv_q_src_c071_2_11 conv_q_c071_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_12 (conv_i_src_c071_2_12 0 conv_bpf_c071_2 0) vcvs gain=1.950903220161e-01
SCONVI_c071_2_12 (conv_i_src_c071_2_12 conv_i_c071_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_12 (conv_q_src_c071_2_12 0 conv_bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_2_12 (conv_q_src_c071_2_12 conv_q_c071_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_13 (conv_i_src_c071_2_13 0 conv_bpf_c071_2 0) vcvs gain=5.555702330196e-01
SCONVI_c071_2_13 (conv_i_src_c071_2_13 conv_i_c071_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_13 (conv_q_src_c071_2_13 0 conv_bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_2_13 (conv_q_src_c071_2_13 conv_q_c071_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_14 (conv_i_src_c071_2_14 0 conv_bpf_c071_2 0) vcvs gain=8.314696123025e-01
SCONVI_c071_2_14 (conv_i_src_c071_2_14 conv_i_c071_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_14 (conv_q_src_c071_2_14 0 conv_bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_2_14 (conv_q_src_c071_2_14 conv_q_c071_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_2_15 (conv_i_src_c071_2_15 0 conv_bpf_c071_2 0) vcvs gain=9.807852804032e-01
SCONVI_c071_2_15 (conv_i_src_c071_2_15 conv_i_c071_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_2_15 (conv_q_src_c071_2_15 0 conv_bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_2_15 (conv_q_src_c071_2_15 conv_q_c071_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c071_2 (conv_i_c071_2 0) resistor r=1G
RCONVQ_c071_2 (conv_q_c071_2 0) resistor r=1G
RCONVINTI_c071_2 (conv_i_c071_2 ConvIcar_c071_2) resistor r=1k
CCONVINTI_c071_2 (ConvIcar_c071_2 0) capacitor c=80p
RCONVINTQ_c071_2 (conv_q_c071_2 ConvQcar_c071_2) resistor r=1k
CCONVINTQ_c071_2 (ConvQcar_c071_2 0) capacitor c=80p
save conv_bpf_c071_2 ConvIcar_c071_2 ConvQcar_c071_2

// conventional mixed baseline bl071, carrier_3: 1000000000 Hz
CCONVBPF_c071_3 (bl071 n_conv_cbpf_c071_3) capacitor c=2.533029591058e-14
LCONVBPF_c071_3 (n_conv_cbpf_c071_3 conv_bpf_c071_3) inductor l=1.000000000000e-06
RCONVBPF_c071_3 (conv_bpf_c071_3 0) resistor r=3.141592653590e+02
ECONVI_c071_3_00 (conv_i_src_c071_3_00 0 conv_bpf_c071_3 0) vcvs gain=9.807852804032e-01
SCONVI_c071_3_00 (conv_i_src_c071_3_00 conv_i_c071_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_00 (conv_q_src_c071_3_00 0 conv_bpf_c071_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_3_00 (conv_q_src_c071_3_00 conv_q_c071_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_01 (conv_i_src_c071_3_01 0 conv_bpf_c071_3 0) vcvs gain=8.314696123025e-01
SCONVI_c071_3_01 (conv_i_src_c071_3_01 conv_i_c071_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_01 (conv_q_src_c071_3_01 0 conv_bpf_c071_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_3_01 (conv_q_src_c071_3_01 conv_q_c071_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_02 (conv_i_src_c071_3_02 0 conv_bpf_c071_3 0) vcvs gain=5.555702330196e-01
SCONVI_c071_3_02 (conv_i_src_c071_3_02 conv_i_c071_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_02 (conv_q_src_c071_3_02 0 conv_bpf_c071_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_3_02 (conv_q_src_c071_3_02 conv_q_c071_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_03 (conv_i_src_c071_3_03 0 conv_bpf_c071_3 0) vcvs gain=1.950903220161e-01
SCONVI_c071_3_03 (conv_i_src_c071_3_03 conv_i_c071_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_03 (conv_q_src_c071_3_03 0 conv_bpf_c071_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_3_03 (conv_q_src_c071_3_03 conv_q_c071_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_04 (conv_i_src_c071_3_04 0 conv_bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_3_04 (conv_i_src_c071_3_04 conv_i_c071_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_04 (conv_q_src_c071_3_04 0 conv_bpf_c071_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c071_3_04 (conv_q_src_c071_3_04 conv_q_c071_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_05 (conv_i_src_c071_3_05 0 conv_bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_3_05 (conv_i_src_c071_3_05 conv_i_c071_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_05 (conv_q_src_c071_3_05 0 conv_bpf_c071_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c071_3_05 (conv_q_src_c071_3_05 conv_q_c071_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_06 (conv_i_src_c071_3_06 0 conv_bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_3_06 (conv_i_src_c071_3_06 conv_i_c071_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_06 (conv_q_src_c071_3_06 0 conv_bpf_c071_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c071_3_06 (conv_q_src_c071_3_06 conv_q_c071_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_07 (conv_i_src_c071_3_07 0 conv_bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_3_07 (conv_i_src_c071_3_07 conv_i_c071_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_07 (conv_q_src_c071_3_07 0 conv_bpf_c071_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c071_3_07 (conv_q_src_c071_3_07 conv_q_c071_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_08 (conv_i_src_c071_3_08 0 conv_bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c071_3_08 (conv_i_src_c071_3_08 conv_i_c071_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_08 (conv_q_src_c071_3_08 0 conv_bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_3_08 (conv_q_src_c071_3_08 conv_q_c071_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_09 (conv_i_src_c071_3_09 0 conv_bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c071_3_09 (conv_i_src_c071_3_09 conv_i_c071_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_09 (conv_q_src_c071_3_09 0 conv_bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_3_09 (conv_q_src_c071_3_09 conv_q_c071_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_10 (conv_i_src_c071_3_10 0 conv_bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c071_3_10 (conv_i_src_c071_3_10 conv_i_c071_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_10 (conv_q_src_c071_3_10 0 conv_bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_3_10 (conv_q_src_c071_3_10 conv_q_c071_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_11 (conv_i_src_c071_3_11 0 conv_bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c071_3_11 (conv_i_src_c071_3_11 conv_i_c071_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_11 (conv_q_src_c071_3_11 0 conv_bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_3_11 (conv_q_src_c071_3_11 conv_q_c071_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_12 (conv_i_src_c071_3_12 0 conv_bpf_c071_3 0) vcvs gain=1.950903220161e-01
SCONVI_c071_3_12 (conv_i_src_c071_3_12 conv_i_c071_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_12 (conv_q_src_c071_3_12 0 conv_bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c071_3_12 (conv_q_src_c071_3_12 conv_q_c071_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_13 (conv_i_src_c071_3_13 0 conv_bpf_c071_3 0) vcvs gain=5.555702330196e-01
SCONVI_c071_3_13 (conv_i_src_c071_3_13 conv_i_c071_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_13 (conv_q_src_c071_3_13 0 conv_bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c071_3_13 (conv_q_src_c071_3_13 conv_q_c071_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_14 (conv_i_src_c071_3_14 0 conv_bpf_c071_3 0) vcvs gain=8.314696123025e-01
SCONVI_c071_3_14 (conv_i_src_c071_3_14 conv_i_c071_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_14 (conv_q_src_c071_3_14 0 conv_bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c071_3_14 (conv_q_src_c071_3_14 conv_q_c071_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c071_3_15 (conv_i_src_c071_3_15 0 conv_bpf_c071_3 0) vcvs gain=9.807852804032e-01
SCONVI_c071_3_15 (conv_i_src_c071_3_15 conv_i_c071_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c071_3_15 (conv_q_src_c071_3_15 0 conv_bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c071_3_15 (conv_q_src_c071_3_15 conv_q_c071_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c071_3 (conv_i_c071_3 0) resistor r=1G
RCONVQ_c071_3 (conv_q_c071_3 0) resistor r=1G
RCONVINTI_c071_3 (conv_i_c071_3 ConvIcar_c071_3) resistor r=1k
CCONVINTI_c071_3 (ConvIcar_c071_3 0) capacitor c=80p
RCONVINTQ_c071_3 (conv_q_c071_3 ConvQcar_c071_3) resistor r=1k
CCONVINTQ_c071_3 (ConvQcar_c071_3 0) capacitor c=80p
save conv_bpf_c071_3 ConvIcar_c071_3 ConvQcar_c071_3

// conventional mixed baseline bl072, carrier_0: 250000000 Hz
CCONVBPF_c072_0 (bl072 n_conv_cbpf_c072_0) capacitor c=4.052847345694e-13
LCONVBPF_c072_0 (n_conv_cbpf_c072_0 conv_bpf_c072_0) inductor l=1.000000000000e-06
RCONVBPF_c072_0 (conv_bpf_c072_0 0) resistor r=7.853981633974e+01
ECONVI_c072_0_00 (conv_i_src_c072_0_00 0 conv_bpf_c072_0 0) vcvs gain=9.807852804032e-01
SCONVI_c072_0_00 (conv_i_src_c072_0_00 conv_i_c072_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_00 (conv_q_src_c072_0_00 0 conv_bpf_c072_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_0_00 (conv_q_src_c072_0_00 conv_q_c072_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_01 (conv_i_src_c072_0_01 0 conv_bpf_c072_0 0) vcvs gain=8.314696123025e-01
SCONVI_c072_0_01 (conv_i_src_c072_0_01 conv_i_c072_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_01 (conv_q_src_c072_0_01 0 conv_bpf_c072_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_0_01 (conv_q_src_c072_0_01 conv_q_c072_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_02 (conv_i_src_c072_0_02 0 conv_bpf_c072_0 0) vcvs gain=5.555702330196e-01
SCONVI_c072_0_02 (conv_i_src_c072_0_02 conv_i_c072_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_02 (conv_q_src_c072_0_02 0 conv_bpf_c072_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_0_02 (conv_q_src_c072_0_02 conv_q_c072_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_03 (conv_i_src_c072_0_03 0 conv_bpf_c072_0 0) vcvs gain=1.950903220161e-01
SCONVI_c072_0_03 (conv_i_src_c072_0_03 conv_i_c072_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_03 (conv_q_src_c072_0_03 0 conv_bpf_c072_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_0_03 (conv_q_src_c072_0_03 conv_q_c072_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_04 (conv_i_src_c072_0_04 0 conv_bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_0_04 (conv_i_src_c072_0_04 conv_i_c072_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_04 (conv_q_src_c072_0_04 0 conv_bpf_c072_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_0_04 (conv_q_src_c072_0_04 conv_q_c072_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_05 (conv_i_src_c072_0_05 0 conv_bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_0_05 (conv_i_src_c072_0_05 conv_i_c072_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_05 (conv_q_src_c072_0_05 0 conv_bpf_c072_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_0_05 (conv_q_src_c072_0_05 conv_q_c072_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_06 (conv_i_src_c072_0_06 0 conv_bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_0_06 (conv_i_src_c072_0_06 conv_i_c072_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_06 (conv_q_src_c072_0_06 0 conv_bpf_c072_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_0_06 (conv_q_src_c072_0_06 conv_q_c072_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_07 (conv_i_src_c072_0_07 0 conv_bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_0_07 (conv_i_src_c072_0_07 conv_i_c072_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_07 (conv_q_src_c072_0_07 0 conv_bpf_c072_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_0_07 (conv_q_src_c072_0_07 conv_q_c072_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_08 (conv_i_src_c072_0_08 0 conv_bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_0_08 (conv_i_src_c072_0_08 conv_i_c072_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_08 (conv_q_src_c072_0_08 0 conv_bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_0_08 (conv_q_src_c072_0_08 conv_q_c072_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_09 (conv_i_src_c072_0_09 0 conv_bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_0_09 (conv_i_src_c072_0_09 conv_i_c072_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_09 (conv_q_src_c072_0_09 0 conv_bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_0_09 (conv_q_src_c072_0_09 conv_q_c072_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_10 (conv_i_src_c072_0_10 0 conv_bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_0_10 (conv_i_src_c072_0_10 conv_i_c072_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_10 (conv_q_src_c072_0_10 0 conv_bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_0_10 (conv_q_src_c072_0_10 conv_q_c072_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_11 (conv_i_src_c072_0_11 0 conv_bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_0_11 (conv_i_src_c072_0_11 conv_i_c072_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_11 (conv_q_src_c072_0_11 0 conv_bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_0_11 (conv_q_src_c072_0_11 conv_q_c072_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_12 (conv_i_src_c072_0_12 0 conv_bpf_c072_0 0) vcvs gain=1.950903220161e-01
SCONVI_c072_0_12 (conv_i_src_c072_0_12 conv_i_c072_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_12 (conv_q_src_c072_0_12 0 conv_bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_0_12 (conv_q_src_c072_0_12 conv_q_c072_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_13 (conv_i_src_c072_0_13 0 conv_bpf_c072_0 0) vcvs gain=5.555702330196e-01
SCONVI_c072_0_13 (conv_i_src_c072_0_13 conv_i_c072_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_13 (conv_q_src_c072_0_13 0 conv_bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_0_13 (conv_q_src_c072_0_13 conv_q_c072_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_14 (conv_i_src_c072_0_14 0 conv_bpf_c072_0 0) vcvs gain=8.314696123025e-01
SCONVI_c072_0_14 (conv_i_src_c072_0_14 conv_i_c072_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_14 (conv_q_src_c072_0_14 0 conv_bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_0_14 (conv_q_src_c072_0_14 conv_q_c072_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_0_15 (conv_i_src_c072_0_15 0 conv_bpf_c072_0 0) vcvs gain=9.807852804032e-01
SCONVI_c072_0_15 (conv_i_src_c072_0_15 conv_i_c072_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_0_15 (conv_q_src_c072_0_15 0 conv_bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_0_15 (conv_q_src_c072_0_15 conv_q_c072_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c072_0 (conv_i_c072_0 0) resistor r=1G
RCONVQ_c072_0 (conv_q_c072_0 0) resistor r=1G
RCONVINTI_c072_0 (conv_i_c072_0 ConvIcar_c072_0) resistor r=1k
CCONVINTI_c072_0 (ConvIcar_c072_0 0) capacitor c=80p
RCONVINTQ_c072_0 (conv_q_c072_0 ConvQcar_c072_0) resistor r=1k
CCONVINTQ_c072_0 (ConvQcar_c072_0 0) capacitor c=80p
save conv_bpf_c072_0 ConvIcar_c072_0 ConvQcar_c072_0

// conventional mixed baseline bl072, carrier_1: 500000000 Hz
CCONVBPF_c072_1 (bl072 n_conv_cbpf_c072_1) capacitor c=1.013211836423e-13
LCONVBPF_c072_1 (n_conv_cbpf_c072_1 conv_bpf_c072_1) inductor l=1.000000000000e-06
RCONVBPF_c072_1 (conv_bpf_c072_1 0) resistor r=1.570796326795e+02
ECONVI_c072_1_00 (conv_i_src_c072_1_00 0 conv_bpf_c072_1 0) vcvs gain=9.807852804032e-01
SCONVI_c072_1_00 (conv_i_src_c072_1_00 conv_i_c072_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_00 (conv_q_src_c072_1_00 0 conv_bpf_c072_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_1_00 (conv_q_src_c072_1_00 conv_q_c072_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_01 (conv_i_src_c072_1_01 0 conv_bpf_c072_1 0) vcvs gain=8.314696123025e-01
SCONVI_c072_1_01 (conv_i_src_c072_1_01 conv_i_c072_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_01 (conv_q_src_c072_1_01 0 conv_bpf_c072_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_1_01 (conv_q_src_c072_1_01 conv_q_c072_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_02 (conv_i_src_c072_1_02 0 conv_bpf_c072_1 0) vcvs gain=5.555702330196e-01
SCONVI_c072_1_02 (conv_i_src_c072_1_02 conv_i_c072_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_02 (conv_q_src_c072_1_02 0 conv_bpf_c072_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_1_02 (conv_q_src_c072_1_02 conv_q_c072_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_03 (conv_i_src_c072_1_03 0 conv_bpf_c072_1 0) vcvs gain=1.950903220161e-01
SCONVI_c072_1_03 (conv_i_src_c072_1_03 conv_i_c072_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_03 (conv_q_src_c072_1_03 0 conv_bpf_c072_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_1_03 (conv_q_src_c072_1_03 conv_q_c072_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_04 (conv_i_src_c072_1_04 0 conv_bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_1_04 (conv_i_src_c072_1_04 conv_i_c072_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_04 (conv_q_src_c072_1_04 0 conv_bpf_c072_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_1_04 (conv_q_src_c072_1_04 conv_q_c072_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_05 (conv_i_src_c072_1_05 0 conv_bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_1_05 (conv_i_src_c072_1_05 conv_i_c072_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_05 (conv_q_src_c072_1_05 0 conv_bpf_c072_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_1_05 (conv_q_src_c072_1_05 conv_q_c072_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_06 (conv_i_src_c072_1_06 0 conv_bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_1_06 (conv_i_src_c072_1_06 conv_i_c072_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_06 (conv_q_src_c072_1_06 0 conv_bpf_c072_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_1_06 (conv_q_src_c072_1_06 conv_q_c072_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_07 (conv_i_src_c072_1_07 0 conv_bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_1_07 (conv_i_src_c072_1_07 conv_i_c072_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_07 (conv_q_src_c072_1_07 0 conv_bpf_c072_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_1_07 (conv_q_src_c072_1_07 conv_q_c072_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_08 (conv_i_src_c072_1_08 0 conv_bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_1_08 (conv_i_src_c072_1_08 conv_i_c072_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_08 (conv_q_src_c072_1_08 0 conv_bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_1_08 (conv_q_src_c072_1_08 conv_q_c072_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_09 (conv_i_src_c072_1_09 0 conv_bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_1_09 (conv_i_src_c072_1_09 conv_i_c072_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_09 (conv_q_src_c072_1_09 0 conv_bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_1_09 (conv_q_src_c072_1_09 conv_q_c072_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_10 (conv_i_src_c072_1_10 0 conv_bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_1_10 (conv_i_src_c072_1_10 conv_i_c072_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_10 (conv_q_src_c072_1_10 0 conv_bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_1_10 (conv_q_src_c072_1_10 conv_q_c072_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_11 (conv_i_src_c072_1_11 0 conv_bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_1_11 (conv_i_src_c072_1_11 conv_i_c072_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_11 (conv_q_src_c072_1_11 0 conv_bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_1_11 (conv_q_src_c072_1_11 conv_q_c072_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_12 (conv_i_src_c072_1_12 0 conv_bpf_c072_1 0) vcvs gain=1.950903220161e-01
SCONVI_c072_1_12 (conv_i_src_c072_1_12 conv_i_c072_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_12 (conv_q_src_c072_1_12 0 conv_bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_1_12 (conv_q_src_c072_1_12 conv_q_c072_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_13 (conv_i_src_c072_1_13 0 conv_bpf_c072_1 0) vcvs gain=5.555702330196e-01
SCONVI_c072_1_13 (conv_i_src_c072_1_13 conv_i_c072_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_13 (conv_q_src_c072_1_13 0 conv_bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_1_13 (conv_q_src_c072_1_13 conv_q_c072_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_14 (conv_i_src_c072_1_14 0 conv_bpf_c072_1 0) vcvs gain=8.314696123025e-01
SCONVI_c072_1_14 (conv_i_src_c072_1_14 conv_i_c072_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_14 (conv_q_src_c072_1_14 0 conv_bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_1_14 (conv_q_src_c072_1_14 conv_q_c072_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_1_15 (conv_i_src_c072_1_15 0 conv_bpf_c072_1 0) vcvs gain=9.807852804032e-01
SCONVI_c072_1_15 (conv_i_src_c072_1_15 conv_i_c072_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_1_15 (conv_q_src_c072_1_15 0 conv_bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_1_15 (conv_q_src_c072_1_15 conv_q_c072_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c072_1 (conv_i_c072_1 0) resistor r=1G
RCONVQ_c072_1 (conv_q_c072_1 0) resistor r=1G
RCONVINTI_c072_1 (conv_i_c072_1 ConvIcar_c072_1) resistor r=1k
CCONVINTI_c072_1 (ConvIcar_c072_1 0) capacitor c=80p
RCONVINTQ_c072_1 (conv_q_c072_1 ConvQcar_c072_1) resistor r=1k
CCONVINTQ_c072_1 (ConvQcar_c072_1 0) capacitor c=80p
save conv_bpf_c072_1 ConvIcar_c072_1 ConvQcar_c072_1

// conventional mixed baseline bl072, carrier_2: 750000000 Hz
CCONVBPF_c072_2 (bl072 n_conv_cbpf_c072_2) capacitor c=4.503163717437e-14
LCONVBPF_c072_2 (n_conv_cbpf_c072_2 conv_bpf_c072_2) inductor l=1.000000000000e-06
RCONVBPF_c072_2 (conv_bpf_c072_2 0) resistor r=2.356194490192e+02
ECONVI_c072_2_00 (conv_i_src_c072_2_00 0 conv_bpf_c072_2 0) vcvs gain=9.807852804032e-01
SCONVI_c072_2_00 (conv_i_src_c072_2_00 conv_i_c072_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_00 (conv_q_src_c072_2_00 0 conv_bpf_c072_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_2_00 (conv_q_src_c072_2_00 conv_q_c072_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_01 (conv_i_src_c072_2_01 0 conv_bpf_c072_2 0) vcvs gain=8.314696123025e-01
SCONVI_c072_2_01 (conv_i_src_c072_2_01 conv_i_c072_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_01 (conv_q_src_c072_2_01 0 conv_bpf_c072_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_2_01 (conv_q_src_c072_2_01 conv_q_c072_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_02 (conv_i_src_c072_2_02 0 conv_bpf_c072_2 0) vcvs gain=5.555702330196e-01
SCONVI_c072_2_02 (conv_i_src_c072_2_02 conv_i_c072_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_02 (conv_q_src_c072_2_02 0 conv_bpf_c072_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_2_02 (conv_q_src_c072_2_02 conv_q_c072_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_03 (conv_i_src_c072_2_03 0 conv_bpf_c072_2 0) vcvs gain=1.950903220161e-01
SCONVI_c072_2_03 (conv_i_src_c072_2_03 conv_i_c072_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_03 (conv_q_src_c072_2_03 0 conv_bpf_c072_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_2_03 (conv_q_src_c072_2_03 conv_q_c072_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_04 (conv_i_src_c072_2_04 0 conv_bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_2_04 (conv_i_src_c072_2_04 conv_i_c072_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_04 (conv_q_src_c072_2_04 0 conv_bpf_c072_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_2_04 (conv_q_src_c072_2_04 conv_q_c072_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_05 (conv_i_src_c072_2_05 0 conv_bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_2_05 (conv_i_src_c072_2_05 conv_i_c072_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_05 (conv_q_src_c072_2_05 0 conv_bpf_c072_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_2_05 (conv_q_src_c072_2_05 conv_q_c072_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_06 (conv_i_src_c072_2_06 0 conv_bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_2_06 (conv_i_src_c072_2_06 conv_i_c072_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_06 (conv_q_src_c072_2_06 0 conv_bpf_c072_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_2_06 (conv_q_src_c072_2_06 conv_q_c072_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_07 (conv_i_src_c072_2_07 0 conv_bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_2_07 (conv_i_src_c072_2_07 conv_i_c072_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_07 (conv_q_src_c072_2_07 0 conv_bpf_c072_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_2_07 (conv_q_src_c072_2_07 conv_q_c072_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_08 (conv_i_src_c072_2_08 0 conv_bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_2_08 (conv_i_src_c072_2_08 conv_i_c072_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_08 (conv_q_src_c072_2_08 0 conv_bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_2_08 (conv_q_src_c072_2_08 conv_q_c072_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_09 (conv_i_src_c072_2_09 0 conv_bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_2_09 (conv_i_src_c072_2_09 conv_i_c072_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_09 (conv_q_src_c072_2_09 0 conv_bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_2_09 (conv_q_src_c072_2_09 conv_q_c072_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_10 (conv_i_src_c072_2_10 0 conv_bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_2_10 (conv_i_src_c072_2_10 conv_i_c072_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_10 (conv_q_src_c072_2_10 0 conv_bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_2_10 (conv_q_src_c072_2_10 conv_q_c072_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_11 (conv_i_src_c072_2_11 0 conv_bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_2_11 (conv_i_src_c072_2_11 conv_i_c072_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_11 (conv_q_src_c072_2_11 0 conv_bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_2_11 (conv_q_src_c072_2_11 conv_q_c072_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_12 (conv_i_src_c072_2_12 0 conv_bpf_c072_2 0) vcvs gain=1.950903220161e-01
SCONVI_c072_2_12 (conv_i_src_c072_2_12 conv_i_c072_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_12 (conv_q_src_c072_2_12 0 conv_bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_2_12 (conv_q_src_c072_2_12 conv_q_c072_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_13 (conv_i_src_c072_2_13 0 conv_bpf_c072_2 0) vcvs gain=5.555702330196e-01
SCONVI_c072_2_13 (conv_i_src_c072_2_13 conv_i_c072_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_13 (conv_q_src_c072_2_13 0 conv_bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_2_13 (conv_q_src_c072_2_13 conv_q_c072_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_14 (conv_i_src_c072_2_14 0 conv_bpf_c072_2 0) vcvs gain=8.314696123025e-01
SCONVI_c072_2_14 (conv_i_src_c072_2_14 conv_i_c072_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_14 (conv_q_src_c072_2_14 0 conv_bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_2_14 (conv_q_src_c072_2_14 conv_q_c072_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_2_15 (conv_i_src_c072_2_15 0 conv_bpf_c072_2 0) vcvs gain=9.807852804032e-01
SCONVI_c072_2_15 (conv_i_src_c072_2_15 conv_i_c072_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_2_15 (conv_q_src_c072_2_15 0 conv_bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_2_15 (conv_q_src_c072_2_15 conv_q_c072_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c072_2 (conv_i_c072_2 0) resistor r=1G
RCONVQ_c072_2 (conv_q_c072_2 0) resistor r=1G
RCONVINTI_c072_2 (conv_i_c072_2 ConvIcar_c072_2) resistor r=1k
CCONVINTI_c072_2 (ConvIcar_c072_2 0) capacitor c=80p
RCONVINTQ_c072_2 (conv_q_c072_2 ConvQcar_c072_2) resistor r=1k
CCONVINTQ_c072_2 (ConvQcar_c072_2 0) capacitor c=80p
save conv_bpf_c072_2 ConvIcar_c072_2 ConvQcar_c072_2

// conventional mixed baseline bl072, carrier_3: 1000000000 Hz
CCONVBPF_c072_3 (bl072 n_conv_cbpf_c072_3) capacitor c=2.533029591058e-14
LCONVBPF_c072_3 (n_conv_cbpf_c072_3 conv_bpf_c072_3) inductor l=1.000000000000e-06
RCONVBPF_c072_3 (conv_bpf_c072_3 0) resistor r=3.141592653590e+02
ECONVI_c072_3_00 (conv_i_src_c072_3_00 0 conv_bpf_c072_3 0) vcvs gain=9.807852804032e-01
SCONVI_c072_3_00 (conv_i_src_c072_3_00 conv_i_c072_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_00 (conv_q_src_c072_3_00 0 conv_bpf_c072_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_3_00 (conv_q_src_c072_3_00 conv_q_c072_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_01 (conv_i_src_c072_3_01 0 conv_bpf_c072_3 0) vcvs gain=8.314696123025e-01
SCONVI_c072_3_01 (conv_i_src_c072_3_01 conv_i_c072_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_01 (conv_q_src_c072_3_01 0 conv_bpf_c072_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_3_01 (conv_q_src_c072_3_01 conv_q_c072_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_02 (conv_i_src_c072_3_02 0 conv_bpf_c072_3 0) vcvs gain=5.555702330196e-01
SCONVI_c072_3_02 (conv_i_src_c072_3_02 conv_i_c072_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_02 (conv_q_src_c072_3_02 0 conv_bpf_c072_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_3_02 (conv_q_src_c072_3_02 conv_q_c072_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_03 (conv_i_src_c072_3_03 0 conv_bpf_c072_3 0) vcvs gain=1.950903220161e-01
SCONVI_c072_3_03 (conv_i_src_c072_3_03 conv_i_c072_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_03 (conv_q_src_c072_3_03 0 conv_bpf_c072_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_3_03 (conv_q_src_c072_3_03 conv_q_c072_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_04 (conv_i_src_c072_3_04 0 conv_bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_3_04 (conv_i_src_c072_3_04 conv_i_c072_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_04 (conv_q_src_c072_3_04 0 conv_bpf_c072_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c072_3_04 (conv_q_src_c072_3_04 conv_q_c072_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_05 (conv_i_src_c072_3_05 0 conv_bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_3_05 (conv_i_src_c072_3_05 conv_i_c072_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_05 (conv_q_src_c072_3_05 0 conv_bpf_c072_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c072_3_05 (conv_q_src_c072_3_05 conv_q_c072_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_06 (conv_i_src_c072_3_06 0 conv_bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_3_06 (conv_i_src_c072_3_06 conv_i_c072_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_06 (conv_q_src_c072_3_06 0 conv_bpf_c072_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c072_3_06 (conv_q_src_c072_3_06 conv_q_c072_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_07 (conv_i_src_c072_3_07 0 conv_bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_3_07 (conv_i_src_c072_3_07 conv_i_c072_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_07 (conv_q_src_c072_3_07 0 conv_bpf_c072_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c072_3_07 (conv_q_src_c072_3_07 conv_q_c072_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_08 (conv_i_src_c072_3_08 0 conv_bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c072_3_08 (conv_i_src_c072_3_08 conv_i_c072_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_08 (conv_q_src_c072_3_08 0 conv_bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_3_08 (conv_q_src_c072_3_08 conv_q_c072_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_09 (conv_i_src_c072_3_09 0 conv_bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c072_3_09 (conv_i_src_c072_3_09 conv_i_c072_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_09 (conv_q_src_c072_3_09 0 conv_bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_3_09 (conv_q_src_c072_3_09 conv_q_c072_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_10 (conv_i_src_c072_3_10 0 conv_bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c072_3_10 (conv_i_src_c072_3_10 conv_i_c072_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_10 (conv_q_src_c072_3_10 0 conv_bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_3_10 (conv_q_src_c072_3_10 conv_q_c072_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_11 (conv_i_src_c072_3_11 0 conv_bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c072_3_11 (conv_i_src_c072_3_11 conv_i_c072_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_11 (conv_q_src_c072_3_11 0 conv_bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_3_11 (conv_q_src_c072_3_11 conv_q_c072_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_12 (conv_i_src_c072_3_12 0 conv_bpf_c072_3 0) vcvs gain=1.950903220161e-01
SCONVI_c072_3_12 (conv_i_src_c072_3_12 conv_i_c072_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_12 (conv_q_src_c072_3_12 0 conv_bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c072_3_12 (conv_q_src_c072_3_12 conv_q_c072_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_13 (conv_i_src_c072_3_13 0 conv_bpf_c072_3 0) vcvs gain=5.555702330196e-01
SCONVI_c072_3_13 (conv_i_src_c072_3_13 conv_i_c072_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_13 (conv_q_src_c072_3_13 0 conv_bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c072_3_13 (conv_q_src_c072_3_13 conv_q_c072_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_14 (conv_i_src_c072_3_14 0 conv_bpf_c072_3 0) vcvs gain=8.314696123025e-01
SCONVI_c072_3_14 (conv_i_src_c072_3_14 conv_i_c072_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_14 (conv_q_src_c072_3_14 0 conv_bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c072_3_14 (conv_q_src_c072_3_14 conv_q_c072_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c072_3_15 (conv_i_src_c072_3_15 0 conv_bpf_c072_3 0) vcvs gain=9.807852804032e-01
SCONVI_c072_3_15 (conv_i_src_c072_3_15 conv_i_c072_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c072_3_15 (conv_q_src_c072_3_15 0 conv_bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c072_3_15 (conv_q_src_c072_3_15 conv_q_c072_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c072_3 (conv_i_c072_3 0) resistor r=1G
RCONVQ_c072_3 (conv_q_c072_3 0) resistor r=1G
RCONVINTI_c072_3 (conv_i_c072_3 ConvIcar_c072_3) resistor r=1k
CCONVINTI_c072_3 (ConvIcar_c072_3 0) capacitor c=80p
RCONVINTQ_c072_3 (conv_q_c072_3 ConvQcar_c072_3) resistor r=1k
CCONVINTQ_c072_3 (ConvQcar_c072_3 0) capacitor c=80p
save conv_bpf_c072_3 ConvIcar_c072_3 ConvQcar_c072_3

// conventional mixed baseline bl073, carrier_0: 250000000 Hz
CCONVBPF_c073_0 (bl073 n_conv_cbpf_c073_0) capacitor c=4.052847345694e-13
LCONVBPF_c073_0 (n_conv_cbpf_c073_0 conv_bpf_c073_0) inductor l=1.000000000000e-06
RCONVBPF_c073_0 (conv_bpf_c073_0 0) resistor r=7.853981633974e+01
ECONVI_c073_0_00 (conv_i_src_c073_0_00 0 conv_bpf_c073_0 0) vcvs gain=9.807852804032e-01
SCONVI_c073_0_00 (conv_i_src_c073_0_00 conv_i_c073_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_00 (conv_q_src_c073_0_00 0 conv_bpf_c073_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_0_00 (conv_q_src_c073_0_00 conv_q_c073_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_01 (conv_i_src_c073_0_01 0 conv_bpf_c073_0 0) vcvs gain=8.314696123025e-01
SCONVI_c073_0_01 (conv_i_src_c073_0_01 conv_i_c073_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_01 (conv_q_src_c073_0_01 0 conv_bpf_c073_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_0_01 (conv_q_src_c073_0_01 conv_q_c073_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_02 (conv_i_src_c073_0_02 0 conv_bpf_c073_0 0) vcvs gain=5.555702330196e-01
SCONVI_c073_0_02 (conv_i_src_c073_0_02 conv_i_c073_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_02 (conv_q_src_c073_0_02 0 conv_bpf_c073_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_0_02 (conv_q_src_c073_0_02 conv_q_c073_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_03 (conv_i_src_c073_0_03 0 conv_bpf_c073_0 0) vcvs gain=1.950903220161e-01
SCONVI_c073_0_03 (conv_i_src_c073_0_03 conv_i_c073_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_03 (conv_q_src_c073_0_03 0 conv_bpf_c073_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_0_03 (conv_q_src_c073_0_03 conv_q_c073_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_04 (conv_i_src_c073_0_04 0 conv_bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_0_04 (conv_i_src_c073_0_04 conv_i_c073_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_04 (conv_q_src_c073_0_04 0 conv_bpf_c073_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_0_04 (conv_q_src_c073_0_04 conv_q_c073_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_05 (conv_i_src_c073_0_05 0 conv_bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_0_05 (conv_i_src_c073_0_05 conv_i_c073_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_05 (conv_q_src_c073_0_05 0 conv_bpf_c073_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_0_05 (conv_q_src_c073_0_05 conv_q_c073_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_06 (conv_i_src_c073_0_06 0 conv_bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_0_06 (conv_i_src_c073_0_06 conv_i_c073_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_06 (conv_q_src_c073_0_06 0 conv_bpf_c073_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_0_06 (conv_q_src_c073_0_06 conv_q_c073_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_07 (conv_i_src_c073_0_07 0 conv_bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_0_07 (conv_i_src_c073_0_07 conv_i_c073_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_07 (conv_q_src_c073_0_07 0 conv_bpf_c073_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_0_07 (conv_q_src_c073_0_07 conv_q_c073_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_08 (conv_i_src_c073_0_08 0 conv_bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_0_08 (conv_i_src_c073_0_08 conv_i_c073_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_08 (conv_q_src_c073_0_08 0 conv_bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_0_08 (conv_q_src_c073_0_08 conv_q_c073_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_09 (conv_i_src_c073_0_09 0 conv_bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_0_09 (conv_i_src_c073_0_09 conv_i_c073_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_09 (conv_q_src_c073_0_09 0 conv_bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_0_09 (conv_q_src_c073_0_09 conv_q_c073_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_10 (conv_i_src_c073_0_10 0 conv_bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_0_10 (conv_i_src_c073_0_10 conv_i_c073_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_10 (conv_q_src_c073_0_10 0 conv_bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_0_10 (conv_q_src_c073_0_10 conv_q_c073_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_11 (conv_i_src_c073_0_11 0 conv_bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_0_11 (conv_i_src_c073_0_11 conv_i_c073_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_11 (conv_q_src_c073_0_11 0 conv_bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_0_11 (conv_q_src_c073_0_11 conv_q_c073_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_12 (conv_i_src_c073_0_12 0 conv_bpf_c073_0 0) vcvs gain=1.950903220161e-01
SCONVI_c073_0_12 (conv_i_src_c073_0_12 conv_i_c073_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_12 (conv_q_src_c073_0_12 0 conv_bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_0_12 (conv_q_src_c073_0_12 conv_q_c073_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_13 (conv_i_src_c073_0_13 0 conv_bpf_c073_0 0) vcvs gain=5.555702330196e-01
SCONVI_c073_0_13 (conv_i_src_c073_0_13 conv_i_c073_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_13 (conv_q_src_c073_0_13 0 conv_bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_0_13 (conv_q_src_c073_0_13 conv_q_c073_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_14 (conv_i_src_c073_0_14 0 conv_bpf_c073_0 0) vcvs gain=8.314696123025e-01
SCONVI_c073_0_14 (conv_i_src_c073_0_14 conv_i_c073_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_14 (conv_q_src_c073_0_14 0 conv_bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_0_14 (conv_q_src_c073_0_14 conv_q_c073_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_0_15 (conv_i_src_c073_0_15 0 conv_bpf_c073_0 0) vcvs gain=9.807852804032e-01
SCONVI_c073_0_15 (conv_i_src_c073_0_15 conv_i_c073_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_0_15 (conv_q_src_c073_0_15 0 conv_bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_0_15 (conv_q_src_c073_0_15 conv_q_c073_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c073_0 (conv_i_c073_0 0) resistor r=1G
RCONVQ_c073_0 (conv_q_c073_0 0) resistor r=1G
RCONVINTI_c073_0 (conv_i_c073_0 ConvIcar_c073_0) resistor r=1k
CCONVINTI_c073_0 (ConvIcar_c073_0 0) capacitor c=80p
RCONVINTQ_c073_0 (conv_q_c073_0 ConvQcar_c073_0) resistor r=1k
CCONVINTQ_c073_0 (ConvQcar_c073_0 0) capacitor c=80p
save conv_bpf_c073_0 ConvIcar_c073_0 ConvQcar_c073_0

// conventional mixed baseline bl073, carrier_1: 500000000 Hz
CCONVBPF_c073_1 (bl073 n_conv_cbpf_c073_1) capacitor c=1.013211836423e-13
LCONVBPF_c073_1 (n_conv_cbpf_c073_1 conv_bpf_c073_1) inductor l=1.000000000000e-06
RCONVBPF_c073_1 (conv_bpf_c073_1 0) resistor r=1.570796326795e+02
ECONVI_c073_1_00 (conv_i_src_c073_1_00 0 conv_bpf_c073_1 0) vcvs gain=9.807852804032e-01
SCONVI_c073_1_00 (conv_i_src_c073_1_00 conv_i_c073_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_00 (conv_q_src_c073_1_00 0 conv_bpf_c073_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_1_00 (conv_q_src_c073_1_00 conv_q_c073_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_01 (conv_i_src_c073_1_01 0 conv_bpf_c073_1 0) vcvs gain=8.314696123025e-01
SCONVI_c073_1_01 (conv_i_src_c073_1_01 conv_i_c073_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_01 (conv_q_src_c073_1_01 0 conv_bpf_c073_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_1_01 (conv_q_src_c073_1_01 conv_q_c073_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_02 (conv_i_src_c073_1_02 0 conv_bpf_c073_1 0) vcvs gain=5.555702330196e-01
SCONVI_c073_1_02 (conv_i_src_c073_1_02 conv_i_c073_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_02 (conv_q_src_c073_1_02 0 conv_bpf_c073_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_1_02 (conv_q_src_c073_1_02 conv_q_c073_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_03 (conv_i_src_c073_1_03 0 conv_bpf_c073_1 0) vcvs gain=1.950903220161e-01
SCONVI_c073_1_03 (conv_i_src_c073_1_03 conv_i_c073_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_03 (conv_q_src_c073_1_03 0 conv_bpf_c073_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_1_03 (conv_q_src_c073_1_03 conv_q_c073_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_04 (conv_i_src_c073_1_04 0 conv_bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_1_04 (conv_i_src_c073_1_04 conv_i_c073_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_04 (conv_q_src_c073_1_04 0 conv_bpf_c073_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_1_04 (conv_q_src_c073_1_04 conv_q_c073_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_05 (conv_i_src_c073_1_05 0 conv_bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_1_05 (conv_i_src_c073_1_05 conv_i_c073_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_05 (conv_q_src_c073_1_05 0 conv_bpf_c073_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_1_05 (conv_q_src_c073_1_05 conv_q_c073_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_06 (conv_i_src_c073_1_06 0 conv_bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_1_06 (conv_i_src_c073_1_06 conv_i_c073_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_06 (conv_q_src_c073_1_06 0 conv_bpf_c073_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_1_06 (conv_q_src_c073_1_06 conv_q_c073_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_07 (conv_i_src_c073_1_07 0 conv_bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_1_07 (conv_i_src_c073_1_07 conv_i_c073_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_07 (conv_q_src_c073_1_07 0 conv_bpf_c073_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_1_07 (conv_q_src_c073_1_07 conv_q_c073_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_08 (conv_i_src_c073_1_08 0 conv_bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_1_08 (conv_i_src_c073_1_08 conv_i_c073_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_08 (conv_q_src_c073_1_08 0 conv_bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_1_08 (conv_q_src_c073_1_08 conv_q_c073_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_09 (conv_i_src_c073_1_09 0 conv_bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_1_09 (conv_i_src_c073_1_09 conv_i_c073_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_09 (conv_q_src_c073_1_09 0 conv_bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_1_09 (conv_q_src_c073_1_09 conv_q_c073_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_10 (conv_i_src_c073_1_10 0 conv_bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_1_10 (conv_i_src_c073_1_10 conv_i_c073_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_10 (conv_q_src_c073_1_10 0 conv_bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_1_10 (conv_q_src_c073_1_10 conv_q_c073_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_11 (conv_i_src_c073_1_11 0 conv_bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_1_11 (conv_i_src_c073_1_11 conv_i_c073_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_11 (conv_q_src_c073_1_11 0 conv_bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_1_11 (conv_q_src_c073_1_11 conv_q_c073_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_12 (conv_i_src_c073_1_12 0 conv_bpf_c073_1 0) vcvs gain=1.950903220161e-01
SCONVI_c073_1_12 (conv_i_src_c073_1_12 conv_i_c073_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_12 (conv_q_src_c073_1_12 0 conv_bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_1_12 (conv_q_src_c073_1_12 conv_q_c073_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_13 (conv_i_src_c073_1_13 0 conv_bpf_c073_1 0) vcvs gain=5.555702330196e-01
SCONVI_c073_1_13 (conv_i_src_c073_1_13 conv_i_c073_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_13 (conv_q_src_c073_1_13 0 conv_bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_1_13 (conv_q_src_c073_1_13 conv_q_c073_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_14 (conv_i_src_c073_1_14 0 conv_bpf_c073_1 0) vcvs gain=8.314696123025e-01
SCONVI_c073_1_14 (conv_i_src_c073_1_14 conv_i_c073_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_14 (conv_q_src_c073_1_14 0 conv_bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_1_14 (conv_q_src_c073_1_14 conv_q_c073_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_1_15 (conv_i_src_c073_1_15 0 conv_bpf_c073_1 0) vcvs gain=9.807852804032e-01
SCONVI_c073_1_15 (conv_i_src_c073_1_15 conv_i_c073_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_1_15 (conv_q_src_c073_1_15 0 conv_bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_1_15 (conv_q_src_c073_1_15 conv_q_c073_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c073_1 (conv_i_c073_1 0) resistor r=1G
RCONVQ_c073_1 (conv_q_c073_1 0) resistor r=1G
RCONVINTI_c073_1 (conv_i_c073_1 ConvIcar_c073_1) resistor r=1k
CCONVINTI_c073_1 (ConvIcar_c073_1 0) capacitor c=80p
RCONVINTQ_c073_1 (conv_q_c073_1 ConvQcar_c073_1) resistor r=1k
CCONVINTQ_c073_1 (ConvQcar_c073_1 0) capacitor c=80p
save conv_bpf_c073_1 ConvIcar_c073_1 ConvQcar_c073_1

// conventional mixed baseline bl073, carrier_2: 750000000 Hz
CCONVBPF_c073_2 (bl073 n_conv_cbpf_c073_2) capacitor c=4.503163717437e-14
LCONVBPF_c073_2 (n_conv_cbpf_c073_2 conv_bpf_c073_2) inductor l=1.000000000000e-06
RCONVBPF_c073_2 (conv_bpf_c073_2 0) resistor r=2.356194490192e+02
ECONVI_c073_2_00 (conv_i_src_c073_2_00 0 conv_bpf_c073_2 0) vcvs gain=9.807852804032e-01
SCONVI_c073_2_00 (conv_i_src_c073_2_00 conv_i_c073_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_00 (conv_q_src_c073_2_00 0 conv_bpf_c073_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_2_00 (conv_q_src_c073_2_00 conv_q_c073_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_01 (conv_i_src_c073_2_01 0 conv_bpf_c073_2 0) vcvs gain=8.314696123025e-01
SCONVI_c073_2_01 (conv_i_src_c073_2_01 conv_i_c073_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_01 (conv_q_src_c073_2_01 0 conv_bpf_c073_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_2_01 (conv_q_src_c073_2_01 conv_q_c073_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_02 (conv_i_src_c073_2_02 0 conv_bpf_c073_2 0) vcvs gain=5.555702330196e-01
SCONVI_c073_2_02 (conv_i_src_c073_2_02 conv_i_c073_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_02 (conv_q_src_c073_2_02 0 conv_bpf_c073_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_2_02 (conv_q_src_c073_2_02 conv_q_c073_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_03 (conv_i_src_c073_2_03 0 conv_bpf_c073_2 0) vcvs gain=1.950903220161e-01
SCONVI_c073_2_03 (conv_i_src_c073_2_03 conv_i_c073_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_03 (conv_q_src_c073_2_03 0 conv_bpf_c073_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_2_03 (conv_q_src_c073_2_03 conv_q_c073_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_04 (conv_i_src_c073_2_04 0 conv_bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_2_04 (conv_i_src_c073_2_04 conv_i_c073_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_04 (conv_q_src_c073_2_04 0 conv_bpf_c073_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_2_04 (conv_q_src_c073_2_04 conv_q_c073_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_05 (conv_i_src_c073_2_05 0 conv_bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_2_05 (conv_i_src_c073_2_05 conv_i_c073_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_05 (conv_q_src_c073_2_05 0 conv_bpf_c073_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_2_05 (conv_q_src_c073_2_05 conv_q_c073_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_06 (conv_i_src_c073_2_06 0 conv_bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_2_06 (conv_i_src_c073_2_06 conv_i_c073_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_06 (conv_q_src_c073_2_06 0 conv_bpf_c073_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_2_06 (conv_q_src_c073_2_06 conv_q_c073_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_07 (conv_i_src_c073_2_07 0 conv_bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_2_07 (conv_i_src_c073_2_07 conv_i_c073_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_07 (conv_q_src_c073_2_07 0 conv_bpf_c073_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_2_07 (conv_q_src_c073_2_07 conv_q_c073_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_08 (conv_i_src_c073_2_08 0 conv_bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_2_08 (conv_i_src_c073_2_08 conv_i_c073_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_08 (conv_q_src_c073_2_08 0 conv_bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_2_08 (conv_q_src_c073_2_08 conv_q_c073_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_09 (conv_i_src_c073_2_09 0 conv_bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_2_09 (conv_i_src_c073_2_09 conv_i_c073_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_09 (conv_q_src_c073_2_09 0 conv_bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_2_09 (conv_q_src_c073_2_09 conv_q_c073_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_10 (conv_i_src_c073_2_10 0 conv_bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_2_10 (conv_i_src_c073_2_10 conv_i_c073_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_10 (conv_q_src_c073_2_10 0 conv_bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_2_10 (conv_q_src_c073_2_10 conv_q_c073_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_11 (conv_i_src_c073_2_11 0 conv_bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_2_11 (conv_i_src_c073_2_11 conv_i_c073_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_11 (conv_q_src_c073_2_11 0 conv_bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_2_11 (conv_q_src_c073_2_11 conv_q_c073_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_12 (conv_i_src_c073_2_12 0 conv_bpf_c073_2 0) vcvs gain=1.950903220161e-01
SCONVI_c073_2_12 (conv_i_src_c073_2_12 conv_i_c073_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_12 (conv_q_src_c073_2_12 0 conv_bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_2_12 (conv_q_src_c073_2_12 conv_q_c073_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_13 (conv_i_src_c073_2_13 0 conv_bpf_c073_2 0) vcvs gain=5.555702330196e-01
SCONVI_c073_2_13 (conv_i_src_c073_2_13 conv_i_c073_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_13 (conv_q_src_c073_2_13 0 conv_bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_2_13 (conv_q_src_c073_2_13 conv_q_c073_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_14 (conv_i_src_c073_2_14 0 conv_bpf_c073_2 0) vcvs gain=8.314696123025e-01
SCONVI_c073_2_14 (conv_i_src_c073_2_14 conv_i_c073_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_14 (conv_q_src_c073_2_14 0 conv_bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_2_14 (conv_q_src_c073_2_14 conv_q_c073_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_2_15 (conv_i_src_c073_2_15 0 conv_bpf_c073_2 0) vcvs gain=9.807852804032e-01
SCONVI_c073_2_15 (conv_i_src_c073_2_15 conv_i_c073_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_2_15 (conv_q_src_c073_2_15 0 conv_bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_2_15 (conv_q_src_c073_2_15 conv_q_c073_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c073_2 (conv_i_c073_2 0) resistor r=1G
RCONVQ_c073_2 (conv_q_c073_2 0) resistor r=1G
RCONVINTI_c073_2 (conv_i_c073_2 ConvIcar_c073_2) resistor r=1k
CCONVINTI_c073_2 (ConvIcar_c073_2 0) capacitor c=80p
RCONVINTQ_c073_2 (conv_q_c073_2 ConvQcar_c073_2) resistor r=1k
CCONVINTQ_c073_2 (ConvQcar_c073_2 0) capacitor c=80p
save conv_bpf_c073_2 ConvIcar_c073_2 ConvQcar_c073_2

// conventional mixed baseline bl073, carrier_3: 1000000000 Hz
CCONVBPF_c073_3 (bl073 n_conv_cbpf_c073_3) capacitor c=2.533029591058e-14
LCONVBPF_c073_3 (n_conv_cbpf_c073_3 conv_bpf_c073_3) inductor l=1.000000000000e-06
RCONVBPF_c073_3 (conv_bpf_c073_3 0) resistor r=3.141592653590e+02
ECONVI_c073_3_00 (conv_i_src_c073_3_00 0 conv_bpf_c073_3 0) vcvs gain=9.807852804032e-01
SCONVI_c073_3_00 (conv_i_src_c073_3_00 conv_i_c073_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_00 (conv_q_src_c073_3_00 0 conv_bpf_c073_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_3_00 (conv_q_src_c073_3_00 conv_q_c073_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_01 (conv_i_src_c073_3_01 0 conv_bpf_c073_3 0) vcvs gain=8.314696123025e-01
SCONVI_c073_3_01 (conv_i_src_c073_3_01 conv_i_c073_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_01 (conv_q_src_c073_3_01 0 conv_bpf_c073_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_3_01 (conv_q_src_c073_3_01 conv_q_c073_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_02 (conv_i_src_c073_3_02 0 conv_bpf_c073_3 0) vcvs gain=5.555702330196e-01
SCONVI_c073_3_02 (conv_i_src_c073_3_02 conv_i_c073_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_02 (conv_q_src_c073_3_02 0 conv_bpf_c073_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_3_02 (conv_q_src_c073_3_02 conv_q_c073_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_03 (conv_i_src_c073_3_03 0 conv_bpf_c073_3 0) vcvs gain=1.950903220161e-01
SCONVI_c073_3_03 (conv_i_src_c073_3_03 conv_i_c073_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_03 (conv_q_src_c073_3_03 0 conv_bpf_c073_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_3_03 (conv_q_src_c073_3_03 conv_q_c073_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_04 (conv_i_src_c073_3_04 0 conv_bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_3_04 (conv_i_src_c073_3_04 conv_i_c073_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_04 (conv_q_src_c073_3_04 0 conv_bpf_c073_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c073_3_04 (conv_q_src_c073_3_04 conv_q_c073_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_05 (conv_i_src_c073_3_05 0 conv_bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_3_05 (conv_i_src_c073_3_05 conv_i_c073_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_05 (conv_q_src_c073_3_05 0 conv_bpf_c073_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c073_3_05 (conv_q_src_c073_3_05 conv_q_c073_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_06 (conv_i_src_c073_3_06 0 conv_bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_3_06 (conv_i_src_c073_3_06 conv_i_c073_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_06 (conv_q_src_c073_3_06 0 conv_bpf_c073_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c073_3_06 (conv_q_src_c073_3_06 conv_q_c073_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_07 (conv_i_src_c073_3_07 0 conv_bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_3_07 (conv_i_src_c073_3_07 conv_i_c073_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_07 (conv_q_src_c073_3_07 0 conv_bpf_c073_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c073_3_07 (conv_q_src_c073_3_07 conv_q_c073_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_08 (conv_i_src_c073_3_08 0 conv_bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c073_3_08 (conv_i_src_c073_3_08 conv_i_c073_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_08 (conv_q_src_c073_3_08 0 conv_bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_3_08 (conv_q_src_c073_3_08 conv_q_c073_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_09 (conv_i_src_c073_3_09 0 conv_bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c073_3_09 (conv_i_src_c073_3_09 conv_i_c073_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_09 (conv_q_src_c073_3_09 0 conv_bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_3_09 (conv_q_src_c073_3_09 conv_q_c073_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_10 (conv_i_src_c073_3_10 0 conv_bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c073_3_10 (conv_i_src_c073_3_10 conv_i_c073_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_10 (conv_q_src_c073_3_10 0 conv_bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_3_10 (conv_q_src_c073_3_10 conv_q_c073_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_11 (conv_i_src_c073_3_11 0 conv_bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c073_3_11 (conv_i_src_c073_3_11 conv_i_c073_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_11 (conv_q_src_c073_3_11 0 conv_bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_3_11 (conv_q_src_c073_3_11 conv_q_c073_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_12 (conv_i_src_c073_3_12 0 conv_bpf_c073_3 0) vcvs gain=1.950903220161e-01
SCONVI_c073_3_12 (conv_i_src_c073_3_12 conv_i_c073_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_12 (conv_q_src_c073_3_12 0 conv_bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c073_3_12 (conv_q_src_c073_3_12 conv_q_c073_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_13 (conv_i_src_c073_3_13 0 conv_bpf_c073_3 0) vcvs gain=5.555702330196e-01
SCONVI_c073_3_13 (conv_i_src_c073_3_13 conv_i_c073_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_13 (conv_q_src_c073_3_13 0 conv_bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c073_3_13 (conv_q_src_c073_3_13 conv_q_c073_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_14 (conv_i_src_c073_3_14 0 conv_bpf_c073_3 0) vcvs gain=8.314696123025e-01
SCONVI_c073_3_14 (conv_i_src_c073_3_14 conv_i_c073_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_14 (conv_q_src_c073_3_14 0 conv_bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c073_3_14 (conv_q_src_c073_3_14 conv_q_c073_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c073_3_15 (conv_i_src_c073_3_15 0 conv_bpf_c073_3 0) vcvs gain=9.807852804032e-01
SCONVI_c073_3_15 (conv_i_src_c073_3_15 conv_i_c073_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c073_3_15 (conv_q_src_c073_3_15 0 conv_bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c073_3_15 (conv_q_src_c073_3_15 conv_q_c073_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c073_3 (conv_i_c073_3 0) resistor r=1G
RCONVQ_c073_3 (conv_q_c073_3 0) resistor r=1G
RCONVINTI_c073_3 (conv_i_c073_3 ConvIcar_c073_3) resistor r=1k
CCONVINTI_c073_3 (ConvIcar_c073_3 0) capacitor c=80p
RCONVINTQ_c073_3 (conv_q_c073_3 ConvQcar_c073_3) resistor r=1k
CCONVINTQ_c073_3 (ConvQcar_c073_3 0) capacitor c=80p
save conv_bpf_c073_3 ConvIcar_c073_3 ConvQcar_c073_3

// conventional mixed baseline bl074, carrier_0: 250000000 Hz
CCONVBPF_c074_0 (bl074 n_conv_cbpf_c074_0) capacitor c=4.052847345694e-13
LCONVBPF_c074_0 (n_conv_cbpf_c074_0 conv_bpf_c074_0) inductor l=1.000000000000e-06
RCONVBPF_c074_0 (conv_bpf_c074_0 0) resistor r=7.853981633974e+01
ECONVI_c074_0_00 (conv_i_src_c074_0_00 0 conv_bpf_c074_0 0) vcvs gain=9.807852804032e-01
SCONVI_c074_0_00 (conv_i_src_c074_0_00 conv_i_c074_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_00 (conv_q_src_c074_0_00 0 conv_bpf_c074_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_0_00 (conv_q_src_c074_0_00 conv_q_c074_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_01 (conv_i_src_c074_0_01 0 conv_bpf_c074_0 0) vcvs gain=8.314696123025e-01
SCONVI_c074_0_01 (conv_i_src_c074_0_01 conv_i_c074_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_01 (conv_q_src_c074_0_01 0 conv_bpf_c074_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_0_01 (conv_q_src_c074_0_01 conv_q_c074_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_02 (conv_i_src_c074_0_02 0 conv_bpf_c074_0 0) vcvs gain=5.555702330196e-01
SCONVI_c074_0_02 (conv_i_src_c074_0_02 conv_i_c074_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_02 (conv_q_src_c074_0_02 0 conv_bpf_c074_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_0_02 (conv_q_src_c074_0_02 conv_q_c074_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_03 (conv_i_src_c074_0_03 0 conv_bpf_c074_0 0) vcvs gain=1.950903220161e-01
SCONVI_c074_0_03 (conv_i_src_c074_0_03 conv_i_c074_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_03 (conv_q_src_c074_0_03 0 conv_bpf_c074_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_0_03 (conv_q_src_c074_0_03 conv_q_c074_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_04 (conv_i_src_c074_0_04 0 conv_bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_0_04 (conv_i_src_c074_0_04 conv_i_c074_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_04 (conv_q_src_c074_0_04 0 conv_bpf_c074_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_0_04 (conv_q_src_c074_0_04 conv_q_c074_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_05 (conv_i_src_c074_0_05 0 conv_bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_0_05 (conv_i_src_c074_0_05 conv_i_c074_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_05 (conv_q_src_c074_0_05 0 conv_bpf_c074_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_0_05 (conv_q_src_c074_0_05 conv_q_c074_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_06 (conv_i_src_c074_0_06 0 conv_bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_0_06 (conv_i_src_c074_0_06 conv_i_c074_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_06 (conv_q_src_c074_0_06 0 conv_bpf_c074_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_0_06 (conv_q_src_c074_0_06 conv_q_c074_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_07 (conv_i_src_c074_0_07 0 conv_bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_0_07 (conv_i_src_c074_0_07 conv_i_c074_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_07 (conv_q_src_c074_0_07 0 conv_bpf_c074_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_0_07 (conv_q_src_c074_0_07 conv_q_c074_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_08 (conv_i_src_c074_0_08 0 conv_bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_0_08 (conv_i_src_c074_0_08 conv_i_c074_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_08 (conv_q_src_c074_0_08 0 conv_bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_0_08 (conv_q_src_c074_0_08 conv_q_c074_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_09 (conv_i_src_c074_0_09 0 conv_bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_0_09 (conv_i_src_c074_0_09 conv_i_c074_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_09 (conv_q_src_c074_0_09 0 conv_bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_0_09 (conv_q_src_c074_0_09 conv_q_c074_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_10 (conv_i_src_c074_0_10 0 conv_bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_0_10 (conv_i_src_c074_0_10 conv_i_c074_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_10 (conv_q_src_c074_0_10 0 conv_bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_0_10 (conv_q_src_c074_0_10 conv_q_c074_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_11 (conv_i_src_c074_0_11 0 conv_bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_0_11 (conv_i_src_c074_0_11 conv_i_c074_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_11 (conv_q_src_c074_0_11 0 conv_bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_0_11 (conv_q_src_c074_0_11 conv_q_c074_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_12 (conv_i_src_c074_0_12 0 conv_bpf_c074_0 0) vcvs gain=1.950903220161e-01
SCONVI_c074_0_12 (conv_i_src_c074_0_12 conv_i_c074_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_12 (conv_q_src_c074_0_12 0 conv_bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_0_12 (conv_q_src_c074_0_12 conv_q_c074_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_13 (conv_i_src_c074_0_13 0 conv_bpf_c074_0 0) vcvs gain=5.555702330196e-01
SCONVI_c074_0_13 (conv_i_src_c074_0_13 conv_i_c074_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_13 (conv_q_src_c074_0_13 0 conv_bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_0_13 (conv_q_src_c074_0_13 conv_q_c074_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_14 (conv_i_src_c074_0_14 0 conv_bpf_c074_0 0) vcvs gain=8.314696123025e-01
SCONVI_c074_0_14 (conv_i_src_c074_0_14 conv_i_c074_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_14 (conv_q_src_c074_0_14 0 conv_bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_0_14 (conv_q_src_c074_0_14 conv_q_c074_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_0_15 (conv_i_src_c074_0_15 0 conv_bpf_c074_0 0) vcvs gain=9.807852804032e-01
SCONVI_c074_0_15 (conv_i_src_c074_0_15 conv_i_c074_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_0_15 (conv_q_src_c074_0_15 0 conv_bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_0_15 (conv_q_src_c074_0_15 conv_q_c074_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c074_0 (conv_i_c074_0 0) resistor r=1G
RCONVQ_c074_0 (conv_q_c074_0 0) resistor r=1G
RCONVINTI_c074_0 (conv_i_c074_0 ConvIcar_c074_0) resistor r=1k
CCONVINTI_c074_0 (ConvIcar_c074_0 0) capacitor c=80p
RCONVINTQ_c074_0 (conv_q_c074_0 ConvQcar_c074_0) resistor r=1k
CCONVINTQ_c074_0 (ConvQcar_c074_0 0) capacitor c=80p
save conv_bpf_c074_0 ConvIcar_c074_0 ConvQcar_c074_0

// conventional mixed baseline bl074, carrier_1: 500000000 Hz
CCONVBPF_c074_1 (bl074 n_conv_cbpf_c074_1) capacitor c=1.013211836423e-13
LCONVBPF_c074_1 (n_conv_cbpf_c074_1 conv_bpf_c074_1) inductor l=1.000000000000e-06
RCONVBPF_c074_1 (conv_bpf_c074_1 0) resistor r=1.570796326795e+02
ECONVI_c074_1_00 (conv_i_src_c074_1_00 0 conv_bpf_c074_1 0) vcvs gain=9.807852804032e-01
SCONVI_c074_1_00 (conv_i_src_c074_1_00 conv_i_c074_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_00 (conv_q_src_c074_1_00 0 conv_bpf_c074_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_1_00 (conv_q_src_c074_1_00 conv_q_c074_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_01 (conv_i_src_c074_1_01 0 conv_bpf_c074_1 0) vcvs gain=8.314696123025e-01
SCONVI_c074_1_01 (conv_i_src_c074_1_01 conv_i_c074_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_01 (conv_q_src_c074_1_01 0 conv_bpf_c074_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_1_01 (conv_q_src_c074_1_01 conv_q_c074_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_02 (conv_i_src_c074_1_02 0 conv_bpf_c074_1 0) vcvs gain=5.555702330196e-01
SCONVI_c074_1_02 (conv_i_src_c074_1_02 conv_i_c074_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_02 (conv_q_src_c074_1_02 0 conv_bpf_c074_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_1_02 (conv_q_src_c074_1_02 conv_q_c074_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_03 (conv_i_src_c074_1_03 0 conv_bpf_c074_1 0) vcvs gain=1.950903220161e-01
SCONVI_c074_1_03 (conv_i_src_c074_1_03 conv_i_c074_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_03 (conv_q_src_c074_1_03 0 conv_bpf_c074_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_1_03 (conv_q_src_c074_1_03 conv_q_c074_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_04 (conv_i_src_c074_1_04 0 conv_bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_1_04 (conv_i_src_c074_1_04 conv_i_c074_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_04 (conv_q_src_c074_1_04 0 conv_bpf_c074_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_1_04 (conv_q_src_c074_1_04 conv_q_c074_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_05 (conv_i_src_c074_1_05 0 conv_bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_1_05 (conv_i_src_c074_1_05 conv_i_c074_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_05 (conv_q_src_c074_1_05 0 conv_bpf_c074_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_1_05 (conv_q_src_c074_1_05 conv_q_c074_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_06 (conv_i_src_c074_1_06 0 conv_bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_1_06 (conv_i_src_c074_1_06 conv_i_c074_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_06 (conv_q_src_c074_1_06 0 conv_bpf_c074_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_1_06 (conv_q_src_c074_1_06 conv_q_c074_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_07 (conv_i_src_c074_1_07 0 conv_bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_1_07 (conv_i_src_c074_1_07 conv_i_c074_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_07 (conv_q_src_c074_1_07 0 conv_bpf_c074_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_1_07 (conv_q_src_c074_1_07 conv_q_c074_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_08 (conv_i_src_c074_1_08 0 conv_bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_1_08 (conv_i_src_c074_1_08 conv_i_c074_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_08 (conv_q_src_c074_1_08 0 conv_bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_1_08 (conv_q_src_c074_1_08 conv_q_c074_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_09 (conv_i_src_c074_1_09 0 conv_bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_1_09 (conv_i_src_c074_1_09 conv_i_c074_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_09 (conv_q_src_c074_1_09 0 conv_bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_1_09 (conv_q_src_c074_1_09 conv_q_c074_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_10 (conv_i_src_c074_1_10 0 conv_bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_1_10 (conv_i_src_c074_1_10 conv_i_c074_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_10 (conv_q_src_c074_1_10 0 conv_bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_1_10 (conv_q_src_c074_1_10 conv_q_c074_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_11 (conv_i_src_c074_1_11 0 conv_bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_1_11 (conv_i_src_c074_1_11 conv_i_c074_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_11 (conv_q_src_c074_1_11 0 conv_bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_1_11 (conv_q_src_c074_1_11 conv_q_c074_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_12 (conv_i_src_c074_1_12 0 conv_bpf_c074_1 0) vcvs gain=1.950903220161e-01
SCONVI_c074_1_12 (conv_i_src_c074_1_12 conv_i_c074_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_12 (conv_q_src_c074_1_12 0 conv_bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_1_12 (conv_q_src_c074_1_12 conv_q_c074_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_13 (conv_i_src_c074_1_13 0 conv_bpf_c074_1 0) vcvs gain=5.555702330196e-01
SCONVI_c074_1_13 (conv_i_src_c074_1_13 conv_i_c074_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_13 (conv_q_src_c074_1_13 0 conv_bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_1_13 (conv_q_src_c074_1_13 conv_q_c074_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_14 (conv_i_src_c074_1_14 0 conv_bpf_c074_1 0) vcvs gain=8.314696123025e-01
SCONVI_c074_1_14 (conv_i_src_c074_1_14 conv_i_c074_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_14 (conv_q_src_c074_1_14 0 conv_bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_1_14 (conv_q_src_c074_1_14 conv_q_c074_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_1_15 (conv_i_src_c074_1_15 0 conv_bpf_c074_1 0) vcvs gain=9.807852804032e-01
SCONVI_c074_1_15 (conv_i_src_c074_1_15 conv_i_c074_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_1_15 (conv_q_src_c074_1_15 0 conv_bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_1_15 (conv_q_src_c074_1_15 conv_q_c074_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c074_1 (conv_i_c074_1 0) resistor r=1G
RCONVQ_c074_1 (conv_q_c074_1 0) resistor r=1G
RCONVINTI_c074_1 (conv_i_c074_1 ConvIcar_c074_1) resistor r=1k
CCONVINTI_c074_1 (ConvIcar_c074_1 0) capacitor c=80p
RCONVINTQ_c074_1 (conv_q_c074_1 ConvQcar_c074_1) resistor r=1k
CCONVINTQ_c074_1 (ConvQcar_c074_1 0) capacitor c=80p
save conv_bpf_c074_1 ConvIcar_c074_1 ConvQcar_c074_1

// conventional mixed baseline bl074, carrier_2: 750000000 Hz
CCONVBPF_c074_2 (bl074 n_conv_cbpf_c074_2) capacitor c=4.503163717437e-14
LCONVBPF_c074_2 (n_conv_cbpf_c074_2 conv_bpf_c074_2) inductor l=1.000000000000e-06
RCONVBPF_c074_2 (conv_bpf_c074_2 0) resistor r=2.356194490192e+02
ECONVI_c074_2_00 (conv_i_src_c074_2_00 0 conv_bpf_c074_2 0) vcvs gain=9.807852804032e-01
SCONVI_c074_2_00 (conv_i_src_c074_2_00 conv_i_c074_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_00 (conv_q_src_c074_2_00 0 conv_bpf_c074_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_2_00 (conv_q_src_c074_2_00 conv_q_c074_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_01 (conv_i_src_c074_2_01 0 conv_bpf_c074_2 0) vcvs gain=8.314696123025e-01
SCONVI_c074_2_01 (conv_i_src_c074_2_01 conv_i_c074_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_01 (conv_q_src_c074_2_01 0 conv_bpf_c074_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_2_01 (conv_q_src_c074_2_01 conv_q_c074_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_02 (conv_i_src_c074_2_02 0 conv_bpf_c074_2 0) vcvs gain=5.555702330196e-01
SCONVI_c074_2_02 (conv_i_src_c074_2_02 conv_i_c074_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_02 (conv_q_src_c074_2_02 0 conv_bpf_c074_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_2_02 (conv_q_src_c074_2_02 conv_q_c074_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_03 (conv_i_src_c074_2_03 0 conv_bpf_c074_2 0) vcvs gain=1.950903220161e-01
SCONVI_c074_2_03 (conv_i_src_c074_2_03 conv_i_c074_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_03 (conv_q_src_c074_2_03 0 conv_bpf_c074_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_2_03 (conv_q_src_c074_2_03 conv_q_c074_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_04 (conv_i_src_c074_2_04 0 conv_bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_2_04 (conv_i_src_c074_2_04 conv_i_c074_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_04 (conv_q_src_c074_2_04 0 conv_bpf_c074_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_2_04 (conv_q_src_c074_2_04 conv_q_c074_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_05 (conv_i_src_c074_2_05 0 conv_bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_2_05 (conv_i_src_c074_2_05 conv_i_c074_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_05 (conv_q_src_c074_2_05 0 conv_bpf_c074_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_2_05 (conv_q_src_c074_2_05 conv_q_c074_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_06 (conv_i_src_c074_2_06 0 conv_bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_2_06 (conv_i_src_c074_2_06 conv_i_c074_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_06 (conv_q_src_c074_2_06 0 conv_bpf_c074_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_2_06 (conv_q_src_c074_2_06 conv_q_c074_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_07 (conv_i_src_c074_2_07 0 conv_bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_2_07 (conv_i_src_c074_2_07 conv_i_c074_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_07 (conv_q_src_c074_2_07 0 conv_bpf_c074_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_2_07 (conv_q_src_c074_2_07 conv_q_c074_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_08 (conv_i_src_c074_2_08 0 conv_bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_2_08 (conv_i_src_c074_2_08 conv_i_c074_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_08 (conv_q_src_c074_2_08 0 conv_bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_2_08 (conv_q_src_c074_2_08 conv_q_c074_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_09 (conv_i_src_c074_2_09 0 conv_bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_2_09 (conv_i_src_c074_2_09 conv_i_c074_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_09 (conv_q_src_c074_2_09 0 conv_bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_2_09 (conv_q_src_c074_2_09 conv_q_c074_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_10 (conv_i_src_c074_2_10 0 conv_bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_2_10 (conv_i_src_c074_2_10 conv_i_c074_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_10 (conv_q_src_c074_2_10 0 conv_bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_2_10 (conv_q_src_c074_2_10 conv_q_c074_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_11 (conv_i_src_c074_2_11 0 conv_bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_2_11 (conv_i_src_c074_2_11 conv_i_c074_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_11 (conv_q_src_c074_2_11 0 conv_bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_2_11 (conv_q_src_c074_2_11 conv_q_c074_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_12 (conv_i_src_c074_2_12 0 conv_bpf_c074_2 0) vcvs gain=1.950903220161e-01
SCONVI_c074_2_12 (conv_i_src_c074_2_12 conv_i_c074_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_12 (conv_q_src_c074_2_12 0 conv_bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_2_12 (conv_q_src_c074_2_12 conv_q_c074_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_13 (conv_i_src_c074_2_13 0 conv_bpf_c074_2 0) vcvs gain=5.555702330196e-01
SCONVI_c074_2_13 (conv_i_src_c074_2_13 conv_i_c074_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_13 (conv_q_src_c074_2_13 0 conv_bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_2_13 (conv_q_src_c074_2_13 conv_q_c074_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_14 (conv_i_src_c074_2_14 0 conv_bpf_c074_2 0) vcvs gain=8.314696123025e-01
SCONVI_c074_2_14 (conv_i_src_c074_2_14 conv_i_c074_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_14 (conv_q_src_c074_2_14 0 conv_bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_2_14 (conv_q_src_c074_2_14 conv_q_c074_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_2_15 (conv_i_src_c074_2_15 0 conv_bpf_c074_2 0) vcvs gain=9.807852804032e-01
SCONVI_c074_2_15 (conv_i_src_c074_2_15 conv_i_c074_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_2_15 (conv_q_src_c074_2_15 0 conv_bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_2_15 (conv_q_src_c074_2_15 conv_q_c074_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c074_2 (conv_i_c074_2 0) resistor r=1G
RCONVQ_c074_2 (conv_q_c074_2 0) resistor r=1G
RCONVINTI_c074_2 (conv_i_c074_2 ConvIcar_c074_2) resistor r=1k
CCONVINTI_c074_2 (ConvIcar_c074_2 0) capacitor c=80p
RCONVINTQ_c074_2 (conv_q_c074_2 ConvQcar_c074_2) resistor r=1k
CCONVINTQ_c074_2 (ConvQcar_c074_2 0) capacitor c=80p
save conv_bpf_c074_2 ConvIcar_c074_2 ConvQcar_c074_2

// conventional mixed baseline bl074, carrier_3: 1000000000 Hz
CCONVBPF_c074_3 (bl074 n_conv_cbpf_c074_3) capacitor c=2.533029591058e-14
LCONVBPF_c074_3 (n_conv_cbpf_c074_3 conv_bpf_c074_3) inductor l=1.000000000000e-06
RCONVBPF_c074_3 (conv_bpf_c074_3 0) resistor r=3.141592653590e+02
ECONVI_c074_3_00 (conv_i_src_c074_3_00 0 conv_bpf_c074_3 0) vcvs gain=9.807852804032e-01
SCONVI_c074_3_00 (conv_i_src_c074_3_00 conv_i_c074_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_00 (conv_q_src_c074_3_00 0 conv_bpf_c074_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_3_00 (conv_q_src_c074_3_00 conv_q_c074_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_01 (conv_i_src_c074_3_01 0 conv_bpf_c074_3 0) vcvs gain=8.314696123025e-01
SCONVI_c074_3_01 (conv_i_src_c074_3_01 conv_i_c074_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_01 (conv_q_src_c074_3_01 0 conv_bpf_c074_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_3_01 (conv_q_src_c074_3_01 conv_q_c074_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_02 (conv_i_src_c074_3_02 0 conv_bpf_c074_3 0) vcvs gain=5.555702330196e-01
SCONVI_c074_3_02 (conv_i_src_c074_3_02 conv_i_c074_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_02 (conv_q_src_c074_3_02 0 conv_bpf_c074_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_3_02 (conv_q_src_c074_3_02 conv_q_c074_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_03 (conv_i_src_c074_3_03 0 conv_bpf_c074_3 0) vcvs gain=1.950903220161e-01
SCONVI_c074_3_03 (conv_i_src_c074_3_03 conv_i_c074_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_03 (conv_q_src_c074_3_03 0 conv_bpf_c074_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_3_03 (conv_q_src_c074_3_03 conv_q_c074_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_04 (conv_i_src_c074_3_04 0 conv_bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_3_04 (conv_i_src_c074_3_04 conv_i_c074_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_04 (conv_q_src_c074_3_04 0 conv_bpf_c074_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c074_3_04 (conv_q_src_c074_3_04 conv_q_c074_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_05 (conv_i_src_c074_3_05 0 conv_bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_3_05 (conv_i_src_c074_3_05 conv_i_c074_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_05 (conv_q_src_c074_3_05 0 conv_bpf_c074_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c074_3_05 (conv_q_src_c074_3_05 conv_q_c074_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_06 (conv_i_src_c074_3_06 0 conv_bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_3_06 (conv_i_src_c074_3_06 conv_i_c074_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_06 (conv_q_src_c074_3_06 0 conv_bpf_c074_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c074_3_06 (conv_q_src_c074_3_06 conv_q_c074_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_07 (conv_i_src_c074_3_07 0 conv_bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_3_07 (conv_i_src_c074_3_07 conv_i_c074_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_07 (conv_q_src_c074_3_07 0 conv_bpf_c074_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c074_3_07 (conv_q_src_c074_3_07 conv_q_c074_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_08 (conv_i_src_c074_3_08 0 conv_bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c074_3_08 (conv_i_src_c074_3_08 conv_i_c074_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_08 (conv_q_src_c074_3_08 0 conv_bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_3_08 (conv_q_src_c074_3_08 conv_q_c074_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_09 (conv_i_src_c074_3_09 0 conv_bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c074_3_09 (conv_i_src_c074_3_09 conv_i_c074_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_09 (conv_q_src_c074_3_09 0 conv_bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_3_09 (conv_q_src_c074_3_09 conv_q_c074_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_10 (conv_i_src_c074_3_10 0 conv_bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c074_3_10 (conv_i_src_c074_3_10 conv_i_c074_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_10 (conv_q_src_c074_3_10 0 conv_bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_3_10 (conv_q_src_c074_3_10 conv_q_c074_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_11 (conv_i_src_c074_3_11 0 conv_bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c074_3_11 (conv_i_src_c074_3_11 conv_i_c074_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_11 (conv_q_src_c074_3_11 0 conv_bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_3_11 (conv_q_src_c074_3_11 conv_q_c074_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_12 (conv_i_src_c074_3_12 0 conv_bpf_c074_3 0) vcvs gain=1.950903220161e-01
SCONVI_c074_3_12 (conv_i_src_c074_3_12 conv_i_c074_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_12 (conv_q_src_c074_3_12 0 conv_bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c074_3_12 (conv_q_src_c074_3_12 conv_q_c074_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_13 (conv_i_src_c074_3_13 0 conv_bpf_c074_3 0) vcvs gain=5.555702330196e-01
SCONVI_c074_3_13 (conv_i_src_c074_3_13 conv_i_c074_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_13 (conv_q_src_c074_3_13 0 conv_bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c074_3_13 (conv_q_src_c074_3_13 conv_q_c074_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_14 (conv_i_src_c074_3_14 0 conv_bpf_c074_3 0) vcvs gain=8.314696123025e-01
SCONVI_c074_3_14 (conv_i_src_c074_3_14 conv_i_c074_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_14 (conv_q_src_c074_3_14 0 conv_bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c074_3_14 (conv_q_src_c074_3_14 conv_q_c074_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c074_3_15 (conv_i_src_c074_3_15 0 conv_bpf_c074_3 0) vcvs gain=9.807852804032e-01
SCONVI_c074_3_15 (conv_i_src_c074_3_15 conv_i_c074_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c074_3_15 (conv_q_src_c074_3_15 0 conv_bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c074_3_15 (conv_q_src_c074_3_15 conv_q_c074_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c074_3 (conv_i_c074_3 0) resistor r=1G
RCONVQ_c074_3 (conv_q_c074_3 0) resistor r=1G
RCONVINTI_c074_3 (conv_i_c074_3 ConvIcar_c074_3) resistor r=1k
CCONVINTI_c074_3 (ConvIcar_c074_3 0) capacitor c=80p
RCONVINTQ_c074_3 (conv_q_c074_3 ConvQcar_c074_3) resistor r=1k
CCONVINTQ_c074_3 (ConvQcar_c074_3 0) capacitor c=80p
save conv_bpf_c074_3 ConvIcar_c074_3 ConvQcar_c074_3

// conventional mixed baseline bl075, carrier_0: 250000000 Hz
CCONVBPF_c075_0 (bl075 n_conv_cbpf_c075_0) capacitor c=4.052847345694e-13
LCONVBPF_c075_0 (n_conv_cbpf_c075_0 conv_bpf_c075_0) inductor l=1.000000000000e-06
RCONVBPF_c075_0 (conv_bpf_c075_0 0) resistor r=7.853981633974e+01
ECONVI_c075_0_00 (conv_i_src_c075_0_00 0 conv_bpf_c075_0 0) vcvs gain=9.807852804032e-01
SCONVI_c075_0_00 (conv_i_src_c075_0_00 conv_i_c075_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_00 (conv_q_src_c075_0_00 0 conv_bpf_c075_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_0_00 (conv_q_src_c075_0_00 conv_q_c075_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_01 (conv_i_src_c075_0_01 0 conv_bpf_c075_0 0) vcvs gain=8.314696123025e-01
SCONVI_c075_0_01 (conv_i_src_c075_0_01 conv_i_c075_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_01 (conv_q_src_c075_0_01 0 conv_bpf_c075_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_0_01 (conv_q_src_c075_0_01 conv_q_c075_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_02 (conv_i_src_c075_0_02 0 conv_bpf_c075_0 0) vcvs gain=5.555702330196e-01
SCONVI_c075_0_02 (conv_i_src_c075_0_02 conv_i_c075_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_02 (conv_q_src_c075_0_02 0 conv_bpf_c075_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_0_02 (conv_q_src_c075_0_02 conv_q_c075_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_03 (conv_i_src_c075_0_03 0 conv_bpf_c075_0 0) vcvs gain=1.950903220161e-01
SCONVI_c075_0_03 (conv_i_src_c075_0_03 conv_i_c075_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_03 (conv_q_src_c075_0_03 0 conv_bpf_c075_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_0_03 (conv_q_src_c075_0_03 conv_q_c075_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_04 (conv_i_src_c075_0_04 0 conv_bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_0_04 (conv_i_src_c075_0_04 conv_i_c075_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_04 (conv_q_src_c075_0_04 0 conv_bpf_c075_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_0_04 (conv_q_src_c075_0_04 conv_q_c075_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_05 (conv_i_src_c075_0_05 0 conv_bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_0_05 (conv_i_src_c075_0_05 conv_i_c075_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_05 (conv_q_src_c075_0_05 0 conv_bpf_c075_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_0_05 (conv_q_src_c075_0_05 conv_q_c075_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_06 (conv_i_src_c075_0_06 0 conv_bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_0_06 (conv_i_src_c075_0_06 conv_i_c075_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_06 (conv_q_src_c075_0_06 0 conv_bpf_c075_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_0_06 (conv_q_src_c075_0_06 conv_q_c075_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_07 (conv_i_src_c075_0_07 0 conv_bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_0_07 (conv_i_src_c075_0_07 conv_i_c075_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_07 (conv_q_src_c075_0_07 0 conv_bpf_c075_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_0_07 (conv_q_src_c075_0_07 conv_q_c075_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_08 (conv_i_src_c075_0_08 0 conv_bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_0_08 (conv_i_src_c075_0_08 conv_i_c075_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_08 (conv_q_src_c075_0_08 0 conv_bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_0_08 (conv_q_src_c075_0_08 conv_q_c075_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_09 (conv_i_src_c075_0_09 0 conv_bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_0_09 (conv_i_src_c075_0_09 conv_i_c075_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_09 (conv_q_src_c075_0_09 0 conv_bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_0_09 (conv_q_src_c075_0_09 conv_q_c075_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_10 (conv_i_src_c075_0_10 0 conv_bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_0_10 (conv_i_src_c075_0_10 conv_i_c075_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_10 (conv_q_src_c075_0_10 0 conv_bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_0_10 (conv_q_src_c075_0_10 conv_q_c075_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_11 (conv_i_src_c075_0_11 0 conv_bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_0_11 (conv_i_src_c075_0_11 conv_i_c075_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_11 (conv_q_src_c075_0_11 0 conv_bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_0_11 (conv_q_src_c075_0_11 conv_q_c075_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_12 (conv_i_src_c075_0_12 0 conv_bpf_c075_0 0) vcvs gain=1.950903220161e-01
SCONVI_c075_0_12 (conv_i_src_c075_0_12 conv_i_c075_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_12 (conv_q_src_c075_0_12 0 conv_bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_0_12 (conv_q_src_c075_0_12 conv_q_c075_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_13 (conv_i_src_c075_0_13 0 conv_bpf_c075_0 0) vcvs gain=5.555702330196e-01
SCONVI_c075_0_13 (conv_i_src_c075_0_13 conv_i_c075_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_13 (conv_q_src_c075_0_13 0 conv_bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_0_13 (conv_q_src_c075_0_13 conv_q_c075_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_14 (conv_i_src_c075_0_14 0 conv_bpf_c075_0 0) vcvs gain=8.314696123025e-01
SCONVI_c075_0_14 (conv_i_src_c075_0_14 conv_i_c075_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_14 (conv_q_src_c075_0_14 0 conv_bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_0_14 (conv_q_src_c075_0_14 conv_q_c075_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_0_15 (conv_i_src_c075_0_15 0 conv_bpf_c075_0 0) vcvs gain=9.807852804032e-01
SCONVI_c075_0_15 (conv_i_src_c075_0_15 conv_i_c075_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_0_15 (conv_q_src_c075_0_15 0 conv_bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_0_15 (conv_q_src_c075_0_15 conv_q_c075_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c075_0 (conv_i_c075_0 0) resistor r=1G
RCONVQ_c075_0 (conv_q_c075_0 0) resistor r=1G
RCONVINTI_c075_0 (conv_i_c075_0 ConvIcar_c075_0) resistor r=1k
CCONVINTI_c075_0 (ConvIcar_c075_0 0) capacitor c=80p
RCONVINTQ_c075_0 (conv_q_c075_0 ConvQcar_c075_0) resistor r=1k
CCONVINTQ_c075_0 (ConvQcar_c075_0 0) capacitor c=80p
save conv_bpf_c075_0 ConvIcar_c075_0 ConvQcar_c075_0

// conventional mixed baseline bl075, carrier_1: 500000000 Hz
CCONVBPF_c075_1 (bl075 n_conv_cbpf_c075_1) capacitor c=1.013211836423e-13
LCONVBPF_c075_1 (n_conv_cbpf_c075_1 conv_bpf_c075_1) inductor l=1.000000000000e-06
RCONVBPF_c075_1 (conv_bpf_c075_1 0) resistor r=1.570796326795e+02
ECONVI_c075_1_00 (conv_i_src_c075_1_00 0 conv_bpf_c075_1 0) vcvs gain=9.807852804032e-01
SCONVI_c075_1_00 (conv_i_src_c075_1_00 conv_i_c075_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_00 (conv_q_src_c075_1_00 0 conv_bpf_c075_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_1_00 (conv_q_src_c075_1_00 conv_q_c075_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_01 (conv_i_src_c075_1_01 0 conv_bpf_c075_1 0) vcvs gain=8.314696123025e-01
SCONVI_c075_1_01 (conv_i_src_c075_1_01 conv_i_c075_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_01 (conv_q_src_c075_1_01 0 conv_bpf_c075_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_1_01 (conv_q_src_c075_1_01 conv_q_c075_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_02 (conv_i_src_c075_1_02 0 conv_bpf_c075_1 0) vcvs gain=5.555702330196e-01
SCONVI_c075_1_02 (conv_i_src_c075_1_02 conv_i_c075_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_02 (conv_q_src_c075_1_02 0 conv_bpf_c075_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_1_02 (conv_q_src_c075_1_02 conv_q_c075_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_03 (conv_i_src_c075_1_03 0 conv_bpf_c075_1 0) vcvs gain=1.950903220161e-01
SCONVI_c075_1_03 (conv_i_src_c075_1_03 conv_i_c075_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_03 (conv_q_src_c075_1_03 0 conv_bpf_c075_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_1_03 (conv_q_src_c075_1_03 conv_q_c075_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_04 (conv_i_src_c075_1_04 0 conv_bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_1_04 (conv_i_src_c075_1_04 conv_i_c075_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_04 (conv_q_src_c075_1_04 0 conv_bpf_c075_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_1_04 (conv_q_src_c075_1_04 conv_q_c075_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_05 (conv_i_src_c075_1_05 0 conv_bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_1_05 (conv_i_src_c075_1_05 conv_i_c075_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_05 (conv_q_src_c075_1_05 0 conv_bpf_c075_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_1_05 (conv_q_src_c075_1_05 conv_q_c075_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_06 (conv_i_src_c075_1_06 0 conv_bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_1_06 (conv_i_src_c075_1_06 conv_i_c075_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_06 (conv_q_src_c075_1_06 0 conv_bpf_c075_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_1_06 (conv_q_src_c075_1_06 conv_q_c075_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_07 (conv_i_src_c075_1_07 0 conv_bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_1_07 (conv_i_src_c075_1_07 conv_i_c075_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_07 (conv_q_src_c075_1_07 0 conv_bpf_c075_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_1_07 (conv_q_src_c075_1_07 conv_q_c075_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_08 (conv_i_src_c075_1_08 0 conv_bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_1_08 (conv_i_src_c075_1_08 conv_i_c075_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_08 (conv_q_src_c075_1_08 0 conv_bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_1_08 (conv_q_src_c075_1_08 conv_q_c075_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_09 (conv_i_src_c075_1_09 0 conv_bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_1_09 (conv_i_src_c075_1_09 conv_i_c075_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_09 (conv_q_src_c075_1_09 0 conv_bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_1_09 (conv_q_src_c075_1_09 conv_q_c075_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_10 (conv_i_src_c075_1_10 0 conv_bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_1_10 (conv_i_src_c075_1_10 conv_i_c075_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_10 (conv_q_src_c075_1_10 0 conv_bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_1_10 (conv_q_src_c075_1_10 conv_q_c075_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_11 (conv_i_src_c075_1_11 0 conv_bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_1_11 (conv_i_src_c075_1_11 conv_i_c075_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_11 (conv_q_src_c075_1_11 0 conv_bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_1_11 (conv_q_src_c075_1_11 conv_q_c075_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_12 (conv_i_src_c075_1_12 0 conv_bpf_c075_1 0) vcvs gain=1.950903220161e-01
SCONVI_c075_1_12 (conv_i_src_c075_1_12 conv_i_c075_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_12 (conv_q_src_c075_1_12 0 conv_bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_1_12 (conv_q_src_c075_1_12 conv_q_c075_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_13 (conv_i_src_c075_1_13 0 conv_bpf_c075_1 0) vcvs gain=5.555702330196e-01
SCONVI_c075_1_13 (conv_i_src_c075_1_13 conv_i_c075_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_13 (conv_q_src_c075_1_13 0 conv_bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_1_13 (conv_q_src_c075_1_13 conv_q_c075_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_14 (conv_i_src_c075_1_14 0 conv_bpf_c075_1 0) vcvs gain=8.314696123025e-01
SCONVI_c075_1_14 (conv_i_src_c075_1_14 conv_i_c075_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_14 (conv_q_src_c075_1_14 0 conv_bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_1_14 (conv_q_src_c075_1_14 conv_q_c075_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_1_15 (conv_i_src_c075_1_15 0 conv_bpf_c075_1 0) vcvs gain=9.807852804032e-01
SCONVI_c075_1_15 (conv_i_src_c075_1_15 conv_i_c075_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_1_15 (conv_q_src_c075_1_15 0 conv_bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_1_15 (conv_q_src_c075_1_15 conv_q_c075_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c075_1 (conv_i_c075_1 0) resistor r=1G
RCONVQ_c075_1 (conv_q_c075_1 0) resistor r=1G
RCONVINTI_c075_1 (conv_i_c075_1 ConvIcar_c075_1) resistor r=1k
CCONVINTI_c075_1 (ConvIcar_c075_1 0) capacitor c=80p
RCONVINTQ_c075_1 (conv_q_c075_1 ConvQcar_c075_1) resistor r=1k
CCONVINTQ_c075_1 (ConvQcar_c075_1 0) capacitor c=80p
save conv_bpf_c075_1 ConvIcar_c075_1 ConvQcar_c075_1

// conventional mixed baseline bl075, carrier_2: 750000000 Hz
CCONVBPF_c075_2 (bl075 n_conv_cbpf_c075_2) capacitor c=4.503163717437e-14
LCONVBPF_c075_2 (n_conv_cbpf_c075_2 conv_bpf_c075_2) inductor l=1.000000000000e-06
RCONVBPF_c075_2 (conv_bpf_c075_2 0) resistor r=2.356194490192e+02
ECONVI_c075_2_00 (conv_i_src_c075_2_00 0 conv_bpf_c075_2 0) vcvs gain=9.807852804032e-01
SCONVI_c075_2_00 (conv_i_src_c075_2_00 conv_i_c075_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_00 (conv_q_src_c075_2_00 0 conv_bpf_c075_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_2_00 (conv_q_src_c075_2_00 conv_q_c075_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_01 (conv_i_src_c075_2_01 0 conv_bpf_c075_2 0) vcvs gain=8.314696123025e-01
SCONVI_c075_2_01 (conv_i_src_c075_2_01 conv_i_c075_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_01 (conv_q_src_c075_2_01 0 conv_bpf_c075_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_2_01 (conv_q_src_c075_2_01 conv_q_c075_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_02 (conv_i_src_c075_2_02 0 conv_bpf_c075_2 0) vcvs gain=5.555702330196e-01
SCONVI_c075_2_02 (conv_i_src_c075_2_02 conv_i_c075_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_02 (conv_q_src_c075_2_02 0 conv_bpf_c075_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_2_02 (conv_q_src_c075_2_02 conv_q_c075_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_03 (conv_i_src_c075_2_03 0 conv_bpf_c075_2 0) vcvs gain=1.950903220161e-01
SCONVI_c075_2_03 (conv_i_src_c075_2_03 conv_i_c075_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_03 (conv_q_src_c075_2_03 0 conv_bpf_c075_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_2_03 (conv_q_src_c075_2_03 conv_q_c075_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_04 (conv_i_src_c075_2_04 0 conv_bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_2_04 (conv_i_src_c075_2_04 conv_i_c075_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_04 (conv_q_src_c075_2_04 0 conv_bpf_c075_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_2_04 (conv_q_src_c075_2_04 conv_q_c075_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_05 (conv_i_src_c075_2_05 0 conv_bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_2_05 (conv_i_src_c075_2_05 conv_i_c075_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_05 (conv_q_src_c075_2_05 0 conv_bpf_c075_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_2_05 (conv_q_src_c075_2_05 conv_q_c075_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_06 (conv_i_src_c075_2_06 0 conv_bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_2_06 (conv_i_src_c075_2_06 conv_i_c075_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_06 (conv_q_src_c075_2_06 0 conv_bpf_c075_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_2_06 (conv_q_src_c075_2_06 conv_q_c075_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_07 (conv_i_src_c075_2_07 0 conv_bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_2_07 (conv_i_src_c075_2_07 conv_i_c075_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_07 (conv_q_src_c075_2_07 0 conv_bpf_c075_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_2_07 (conv_q_src_c075_2_07 conv_q_c075_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_08 (conv_i_src_c075_2_08 0 conv_bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_2_08 (conv_i_src_c075_2_08 conv_i_c075_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_08 (conv_q_src_c075_2_08 0 conv_bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_2_08 (conv_q_src_c075_2_08 conv_q_c075_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_09 (conv_i_src_c075_2_09 0 conv_bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_2_09 (conv_i_src_c075_2_09 conv_i_c075_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_09 (conv_q_src_c075_2_09 0 conv_bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_2_09 (conv_q_src_c075_2_09 conv_q_c075_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_10 (conv_i_src_c075_2_10 0 conv_bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_2_10 (conv_i_src_c075_2_10 conv_i_c075_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_10 (conv_q_src_c075_2_10 0 conv_bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_2_10 (conv_q_src_c075_2_10 conv_q_c075_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_11 (conv_i_src_c075_2_11 0 conv_bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_2_11 (conv_i_src_c075_2_11 conv_i_c075_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_11 (conv_q_src_c075_2_11 0 conv_bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_2_11 (conv_q_src_c075_2_11 conv_q_c075_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_12 (conv_i_src_c075_2_12 0 conv_bpf_c075_2 0) vcvs gain=1.950903220161e-01
SCONVI_c075_2_12 (conv_i_src_c075_2_12 conv_i_c075_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_12 (conv_q_src_c075_2_12 0 conv_bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_2_12 (conv_q_src_c075_2_12 conv_q_c075_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_13 (conv_i_src_c075_2_13 0 conv_bpf_c075_2 0) vcvs gain=5.555702330196e-01
SCONVI_c075_2_13 (conv_i_src_c075_2_13 conv_i_c075_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_13 (conv_q_src_c075_2_13 0 conv_bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_2_13 (conv_q_src_c075_2_13 conv_q_c075_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_14 (conv_i_src_c075_2_14 0 conv_bpf_c075_2 0) vcvs gain=8.314696123025e-01
SCONVI_c075_2_14 (conv_i_src_c075_2_14 conv_i_c075_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_14 (conv_q_src_c075_2_14 0 conv_bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_2_14 (conv_q_src_c075_2_14 conv_q_c075_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_2_15 (conv_i_src_c075_2_15 0 conv_bpf_c075_2 0) vcvs gain=9.807852804032e-01
SCONVI_c075_2_15 (conv_i_src_c075_2_15 conv_i_c075_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_2_15 (conv_q_src_c075_2_15 0 conv_bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_2_15 (conv_q_src_c075_2_15 conv_q_c075_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c075_2 (conv_i_c075_2 0) resistor r=1G
RCONVQ_c075_2 (conv_q_c075_2 0) resistor r=1G
RCONVINTI_c075_2 (conv_i_c075_2 ConvIcar_c075_2) resistor r=1k
CCONVINTI_c075_2 (ConvIcar_c075_2 0) capacitor c=80p
RCONVINTQ_c075_2 (conv_q_c075_2 ConvQcar_c075_2) resistor r=1k
CCONVINTQ_c075_2 (ConvQcar_c075_2 0) capacitor c=80p
save conv_bpf_c075_2 ConvIcar_c075_2 ConvQcar_c075_2

// conventional mixed baseline bl075, carrier_3: 1000000000 Hz
CCONVBPF_c075_3 (bl075 n_conv_cbpf_c075_3) capacitor c=2.533029591058e-14
LCONVBPF_c075_3 (n_conv_cbpf_c075_3 conv_bpf_c075_3) inductor l=1.000000000000e-06
RCONVBPF_c075_3 (conv_bpf_c075_3 0) resistor r=3.141592653590e+02
ECONVI_c075_3_00 (conv_i_src_c075_3_00 0 conv_bpf_c075_3 0) vcvs gain=9.807852804032e-01
SCONVI_c075_3_00 (conv_i_src_c075_3_00 conv_i_c075_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_00 (conv_q_src_c075_3_00 0 conv_bpf_c075_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_3_00 (conv_q_src_c075_3_00 conv_q_c075_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_01 (conv_i_src_c075_3_01 0 conv_bpf_c075_3 0) vcvs gain=8.314696123025e-01
SCONVI_c075_3_01 (conv_i_src_c075_3_01 conv_i_c075_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_01 (conv_q_src_c075_3_01 0 conv_bpf_c075_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_3_01 (conv_q_src_c075_3_01 conv_q_c075_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_02 (conv_i_src_c075_3_02 0 conv_bpf_c075_3 0) vcvs gain=5.555702330196e-01
SCONVI_c075_3_02 (conv_i_src_c075_3_02 conv_i_c075_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_02 (conv_q_src_c075_3_02 0 conv_bpf_c075_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_3_02 (conv_q_src_c075_3_02 conv_q_c075_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_03 (conv_i_src_c075_3_03 0 conv_bpf_c075_3 0) vcvs gain=1.950903220161e-01
SCONVI_c075_3_03 (conv_i_src_c075_3_03 conv_i_c075_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_03 (conv_q_src_c075_3_03 0 conv_bpf_c075_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_3_03 (conv_q_src_c075_3_03 conv_q_c075_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_04 (conv_i_src_c075_3_04 0 conv_bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_3_04 (conv_i_src_c075_3_04 conv_i_c075_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_04 (conv_q_src_c075_3_04 0 conv_bpf_c075_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c075_3_04 (conv_q_src_c075_3_04 conv_q_c075_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_05 (conv_i_src_c075_3_05 0 conv_bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_3_05 (conv_i_src_c075_3_05 conv_i_c075_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_05 (conv_q_src_c075_3_05 0 conv_bpf_c075_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c075_3_05 (conv_q_src_c075_3_05 conv_q_c075_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_06 (conv_i_src_c075_3_06 0 conv_bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_3_06 (conv_i_src_c075_3_06 conv_i_c075_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_06 (conv_q_src_c075_3_06 0 conv_bpf_c075_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c075_3_06 (conv_q_src_c075_3_06 conv_q_c075_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_07 (conv_i_src_c075_3_07 0 conv_bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_3_07 (conv_i_src_c075_3_07 conv_i_c075_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_07 (conv_q_src_c075_3_07 0 conv_bpf_c075_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c075_3_07 (conv_q_src_c075_3_07 conv_q_c075_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_08 (conv_i_src_c075_3_08 0 conv_bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c075_3_08 (conv_i_src_c075_3_08 conv_i_c075_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_08 (conv_q_src_c075_3_08 0 conv_bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_3_08 (conv_q_src_c075_3_08 conv_q_c075_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_09 (conv_i_src_c075_3_09 0 conv_bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c075_3_09 (conv_i_src_c075_3_09 conv_i_c075_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_09 (conv_q_src_c075_3_09 0 conv_bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_3_09 (conv_q_src_c075_3_09 conv_q_c075_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_10 (conv_i_src_c075_3_10 0 conv_bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c075_3_10 (conv_i_src_c075_3_10 conv_i_c075_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_10 (conv_q_src_c075_3_10 0 conv_bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_3_10 (conv_q_src_c075_3_10 conv_q_c075_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_11 (conv_i_src_c075_3_11 0 conv_bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c075_3_11 (conv_i_src_c075_3_11 conv_i_c075_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_11 (conv_q_src_c075_3_11 0 conv_bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_3_11 (conv_q_src_c075_3_11 conv_q_c075_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_12 (conv_i_src_c075_3_12 0 conv_bpf_c075_3 0) vcvs gain=1.950903220161e-01
SCONVI_c075_3_12 (conv_i_src_c075_3_12 conv_i_c075_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_12 (conv_q_src_c075_3_12 0 conv_bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c075_3_12 (conv_q_src_c075_3_12 conv_q_c075_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_13 (conv_i_src_c075_3_13 0 conv_bpf_c075_3 0) vcvs gain=5.555702330196e-01
SCONVI_c075_3_13 (conv_i_src_c075_3_13 conv_i_c075_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_13 (conv_q_src_c075_3_13 0 conv_bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c075_3_13 (conv_q_src_c075_3_13 conv_q_c075_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_14 (conv_i_src_c075_3_14 0 conv_bpf_c075_3 0) vcvs gain=8.314696123025e-01
SCONVI_c075_3_14 (conv_i_src_c075_3_14 conv_i_c075_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_14 (conv_q_src_c075_3_14 0 conv_bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c075_3_14 (conv_q_src_c075_3_14 conv_q_c075_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c075_3_15 (conv_i_src_c075_3_15 0 conv_bpf_c075_3 0) vcvs gain=9.807852804032e-01
SCONVI_c075_3_15 (conv_i_src_c075_3_15 conv_i_c075_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c075_3_15 (conv_q_src_c075_3_15 0 conv_bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c075_3_15 (conv_q_src_c075_3_15 conv_q_c075_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c075_3 (conv_i_c075_3 0) resistor r=1G
RCONVQ_c075_3 (conv_q_c075_3 0) resistor r=1G
RCONVINTI_c075_3 (conv_i_c075_3 ConvIcar_c075_3) resistor r=1k
CCONVINTI_c075_3 (ConvIcar_c075_3 0) capacitor c=80p
RCONVINTQ_c075_3 (conv_q_c075_3 ConvQcar_c075_3) resistor r=1k
CCONVINTQ_c075_3 (ConvQcar_c075_3 0) capacitor c=80p
save conv_bpf_c075_3 ConvIcar_c075_3 ConvQcar_c075_3

// conventional mixed baseline bl076, carrier_0: 250000000 Hz
CCONVBPF_c076_0 (bl076 n_conv_cbpf_c076_0) capacitor c=4.052847345694e-13
LCONVBPF_c076_0 (n_conv_cbpf_c076_0 conv_bpf_c076_0) inductor l=1.000000000000e-06
RCONVBPF_c076_0 (conv_bpf_c076_0 0) resistor r=7.853981633974e+01
ECONVI_c076_0_00 (conv_i_src_c076_0_00 0 conv_bpf_c076_0 0) vcvs gain=9.807852804032e-01
SCONVI_c076_0_00 (conv_i_src_c076_0_00 conv_i_c076_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_00 (conv_q_src_c076_0_00 0 conv_bpf_c076_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_0_00 (conv_q_src_c076_0_00 conv_q_c076_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_01 (conv_i_src_c076_0_01 0 conv_bpf_c076_0 0) vcvs gain=8.314696123025e-01
SCONVI_c076_0_01 (conv_i_src_c076_0_01 conv_i_c076_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_01 (conv_q_src_c076_0_01 0 conv_bpf_c076_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_0_01 (conv_q_src_c076_0_01 conv_q_c076_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_02 (conv_i_src_c076_0_02 0 conv_bpf_c076_0 0) vcvs gain=5.555702330196e-01
SCONVI_c076_0_02 (conv_i_src_c076_0_02 conv_i_c076_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_02 (conv_q_src_c076_0_02 0 conv_bpf_c076_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_0_02 (conv_q_src_c076_0_02 conv_q_c076_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_03 (conv_i_src_c076_0_03 0 conv_bpf_c076_0 0) vcvs gain=1.950903220161e-01
SCONVI_c076_0_03 (conv_i_src_c076_0_03 conv_i_c076_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_03 (conv_q_src_c076_0_03 0 conv_bpf_c076_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_0_03 (conv_q_src_c076_0_03 conv_q_c076_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_04 (conv_i_src_c076_0_04 0 conv_bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_0_04 (conv_i_src_c076_0_04 conv_i_c076_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_04 (conv_q_src_c076_0_04 0 conv_bpf_c076_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_0_04 (conv_q_src_c076_0_04 conv_q_c076_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_05 (conv_i_src_c076_0_05 0 conv_bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_0_05 (conv_i_src_c076_0_05 conv_i_c076_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_05 (conv_q_src_c076_0_05 0 conv_bpf_c076_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_0_05 (conv_q_src_c076_0_05 conv_q_c076_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_06 (conv_i_src_c076_0_06 0 conv_bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_0_06 (conv_i_src_c076_0_06 conv_i_c076_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_06 (conv_q_src_c076_0_06 0 conv_bpf_c076_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_0_06 (conv_q_src_c076_0_06 conv_q_c076_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_07 (conv_i_src_c076_0_07 0 conv_bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_0_07 (conv_i_src_c076_0_07 conv_i_c076_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_07 (conv_q_src_c076_0_07 0 conv_bpf_c076_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_0_07 (conv_q_src_c076_0_07 conv_q_c076_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_08 (conv_i_src_c076_0_08 0 conv_bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_0_08 (conv_i_src_c076_0_08 conv_i_c076_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_08 (conv_q_src_c076_0_08 0 conv_bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_0_08 (conv_q_src_c076_0_08 conv_q_c076_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_09 (conv_i_src_c076_0_09 0 conv_bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_0_09 (conv_i_src_c076_0_09 conv_i_c076_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_09 (conv_q_src_c076_0_09 0 conv_bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_0_09 (conv_q_src_c076_0_09 conv_q_c076_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_10 (conv_i_src_c076_0_10 0 conv_bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_0_10 (conv_i_src_c076_0_10 conv_i_c076_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_10 (conv_q_src_c076_0_10 0 conv_bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_0_10 (conv_q_src_c076_0_10 conv_q_c076_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_11 (conv_i_src_c076_0_11 0 conv_bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_0_11 (conv_i_src_c076_0_11 conv_i_c076_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_11 (conv_q_src_c076_0_11 0 conv_bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_0_11 (conv_q_src_c076_0_11 conv_q_c076_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_12 (conv_i_src_c076_0_12 0 conv_bpf_c076_0 0) vcvs gain=1.950903220161e-01
SCONVI_c076_0_12 (conv_i_src_c076_0_12 conv_i_c076_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_12 (conv_q_src_c076_0_12 0 conv_bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_0_12 (conv_q_src_c076_0_12 conv_q_c076_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_13 (conv_i_src_c076_0_13 0 conv_bpf_c076_0 0) vcvs gain=5.555702330196e-01
SCONVI_c076_0_13 (conv_i_src_c076_0_13 conv_i_c076_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_13 (conv_q_src_c076_0_13 0 conv_bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_0_13 (conv_q_src_c076_0_13 conv_q_c076_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_14 (conv_i_src_c076_0_14 0 conv_bpf_c076_0 0) vcvs gain=8.314696123025e-01
SCONVI_c076_0_14 (conv_i_src_c076_0_14 conv_i_c076_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_14 (conv_q_src_c076_0_14 0 conv_bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_0_14 (conv_q_src_c076_0_14 conv_q_c076_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_0_15 (conv_i_src_c076_0_15 0 conv_bpf_c076_0 0) vcvs gain=9.807852804032e-01
SCONVI_c076_0_15 (conv_i_src_c076_0_15 conv_i_c076_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_0_15 (conv_q_src_c076_0_15 0 conv_bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_0_15 (conv_q_src_c076_0_15 conv_q_c076_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c076_0 (conv_i_c076_0 0) resistor r=1G
RCONVQ_c076_0 (conv_q_c076_0 0) resistor r=1G
RCONVINTI_c076_0 (conv_i_c076_0 ConvIcar_c076_0) resistor r=1k
CCONVINTI_c076_0 (ConvIcar_c076_0 0) capacitor c=80p
RCONVINTQ_c076_0 (conv_q_c076_0 ConvQcar_c076_0) resistor r=1k
CCONVINTQ_c076_0 (ConvQcar_c076_0 0) capacitor c=80p
save conv_bpf_c076_0 ConvIcar_c076_0 ConvQcar_c076_0

// conventional mixed baseline bl076, carrier_1: 500000000 Hz
CCONVBPF_c076_1 (bl076 n_conv_cbpf_c076_1) capacitor c=1.013211836423e-13
LCONVBPF_c076_1 (n_conv_cbpf_c076_1 conv_bpf_c076_1) inductor l=1.000000000000e-06
RCONVBPF_c076_1 (conv_bpf_c076_1 0) resistor r=1.570796326795e+02
ECONVI_c076_1_00 (conv_i_src_c076_1_00 0 conv_bpf_c076_1 0) vcvs gain=9.807852804032e-01
SCONVI_c076_1_00 (conv_i_src_c076_1_00 conv_i_c076_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_00 (conv_q_src_c076_1_00 0 conv_bpf_c076_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_1_00 (conv_q_src_c076_1_00 conv_q_c076_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_01 (conv_i_src_c076_1_01 0 conv_bpf_c076_1 0) vcvs gain=8.314696123025e-01
SCONVI_c076_1_01 (conv_i_src_c076_1_01 conv_i_c076_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_01 (conv_q_src_c076_1_01 0 conv_bpf_c076_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_1_01 (conv_q_src_c076_1_01 conv_q_c076_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_02 (conv_i_src_c076_1_02 0 conv_bpf_c076_1 0) vcvs gain=5.555702330196e-01
SCONVI_c076_1_02 (conv_i_src_c076_1_02 conv_i_c076_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_02 (conv_q_src_c076_1_02 0 conv_bpf_c076_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_1_02 (conv_q_src_c076_1_02 conv_q_c076_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_03 (conv_i_src_c076_1_03 0 conv_bpf_c076_1 0) vcvs gain=1.950903220161e-01
SCONVI_c076_1_03 (conv_i_src_c076_1_03 conv_i_c076_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_03 (conv_q_src_c076_1_03 0 conv_bpf_c076_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_1_03 (conv_q_src_c076_1_03 conv_q_c076_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_04 (conv_i_src_c076_1_04 0 conv_bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_1_04 (conv_i_src_c076_1_04 conv_i_c076_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_04 (conv_q_src_c076_1_04 0 conv_bpf_c076_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_1_04 (conv_q_src_c076_1_04 conv_q_c076_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_05 (conv_i_src_c076_1_05 0 conv_bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_1_05 (conv_i_src_c076_1_05 conv_i_c076_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_05 (conv_q_src_c076_1_05 0 conv_bpf_c076_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_1_05 (conv_q_src_c076_1_05 conv_q_c076_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_06 (conv_i_src_c076_1_06 0 conv_bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_1_06 (conv_i_src_c076_1_06 conv_i_c076_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_06 (conv_q_src_c076_1_06 0 conv_bpf_c076_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_1_06 (conv_q_src_c076_1_06 conv_q_c076_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_07 (conv_i_src_c076_1_07 0 conv_bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_1_07 (conv_i_src_c076_1_07 conv_i_c076_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_07 (conv_q_src_c076_1_07 0 conv_bpf_c076_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_1_07 (conv_q_src_c076_1_07 conv_q_c076_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_08 (conv_i_src_c076_1_08 0 conv_bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_1_08 (conv_i_src_c076_1_08 conv_i_c076_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_08 (conv_q_src_c076_1_08 0 conv_bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_1_08 (conv_q_src_c076_1_08 conv_q_c076_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_09 (conv_i_src_c076_1_09 0 conv_bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_1_09 (conv_i_src_c076_1_09 conv_i_c076_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_09 (conv_q_src_c076_1_09 0 conv_bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_1_09 (conv_q_src_c076_1_09 conv_q_c076_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_10 (conv_i_src_c076_1_10 0 conv_bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_1_10 (conv_i_src_c076_1_10 conv_i_c076_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_10 (conv_q_src_c076_1_10 0 conv_bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_1_10 (conv_q_src_c076_1_10 conv_q_c076_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_11 (conv_i_src_c076_1_11 0 conv_bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_1_11 (conv_i_src_c076_1_11 conv_i_c076_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_11 (conv_q_src_c076_1_11 0 conv_bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_1_11 (conv_q_src_c076_1_11 conv_q_c076_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_12 (conv_i_src_c076_1_12 0 conv_bpf_c076_1 0) vcvs gain=1.950903220161e-01
SCONVI_c076_1_12 (conv_i_src_c076_1_12 conv_i_c076_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_12 (conv_q_src_c076_1_12 0 conv_bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_1_12 (conv_q_src_c076_1_12 conv_q_c076_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_13 (conv_i_src_c076_1_13 0 conv_bpf_c076_1 0) vcvs gain=5.555702330196e-01
SCONVI_c076_1_13 (conv_i_src_c076_1_13 conv_i_c076_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_13 (conv_q_src_c076_1_13 0 conv_bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_1_13 (conv_q_src_c076_1_13 conv_q_c076_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_14 (conv_i_src_c076_1_14 0 conv_bpf_c076_1 0) vcvs gain=8.314696123025e-01
SCONVI_c076_1_14 (conv_i_src_c076_1_14 conv_i_c076_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_14 (conv_q_src_c076_1_14 0 conv_bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_1_14 (conv_q_src_c076_1_14 conv_q_c076_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_1_15 (conv_i_src_c076_1_15 0 conv_bpf_c076_1 0) vcvs gain=9.807852804032e-01
SCONVI_c076_1_15 (conv_i_src_c076_1_15 conv_i_c076_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_1_15 (conv_q_src_c076_1_15 0 conv_bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_1_15 (conv_q_src_c076_1_15 conv_q_c076_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c076_1 (conv_i_c076_1 0) resistor r=1G
RCONVQ_c076_1 (conv_q_c076_1 0) resistor r=1G
RCONVINTI_c076_1 (conv_i_c076_1 ConvIcar_c076_1) resistor r=1k
CCONVINTI_c076_1 (ConvIcar_c076_1 0) capacitor c=80p
RCONVINTQ_c076_1 (conv_q_c076_1 ConvQcar_c076_1) resistor r=1k
CCONVINTQ_c076_1 (ConvQcar_c076_1 0) capacitor c=80p
save conv_bpf_c076_1 ConvIcar_c076_1 ConvQcar_c076_1

// conventional mixed baseline bl076, carrier_2: 750000000 Hz
CCONVBPF_c076_2 (bl076 n_conv_cbpf_c076_2) capacitor c=4.503163717437e-14
LCONVBPF_c076_2 (n_conv_cbpf_c076_2 conv_bpf_c076_2) inductor l=1.000000000000e-06
RCONVBPF_c076_2 (conv_bpf_c076_2 0) resistor r=2.356194490192e+02
ECONVI_c076_2_00 (conv_i_src_c076_2_00 0 conv_bpf_c076_2 0) vcvs gain=9.807852804032e-01
SCONVI_c076_2_00 (conv_i_src_c076_2_00 conv_i_c076_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_00 (conv_q_src_c076_2_00 0 conv_bpf_c076_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_2_00 (conv_q_src_c076_2_00 conv_q_c076_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_01 (conv_i_src_c076_2_01 0 conv_bpf_c076_2 0) vcvs gain=8.314696123025e-01
SCONVI_c076_2_01 (conv_i_src_c076_2_01 conv_i_c076_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_01 (conv_q_src_c076_2_01 0 conv_bpf_c076_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_2_01 (conv_q_src_c076_2_01 conv_q_c076_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_02 (conv_i_src_c076_2_02 0 conv_bpf_c076_2 0) vcvs gain=5.555702330196e-01
SCONVI_c076_2_02 (conv_i_src_c076_2_02 conv_i_c076_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_02 (conv_q_src_c076_2_02 0 conv_bpf_c076_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_2_02 (conv_q_src_c076_2_02 conv_q_c076_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_03 (conv_i_src_c076_2_03 0 conv_bpf_c076_2 0) vcvs gain=1.950903220161e-01
SCONVI_c076_2_03 (conv_i_src_c076_2_03 conv_i_c076_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_03 (conv_q_src_c076_2_03 0 conv_bpf_c076_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_2_03 (conv_q_src_c076_2_03 conv_q_c076_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_04 (conv_i_src_c076_2_04 0 conv_bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_2_04 (conv_i_src_c076_2_04 conv_i_c076_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_04 (conv_q_src_c076_2_04 0 conv_bpf_c076_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_2_04 (conv_q_src_c076_2_04 conv_q_c076_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_05 (conv_i_src_c076_2_05 0 conv_bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_2_05 (conv_i_src_c076_2_05 conv_i_c076_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_05 (conv_q_src_c076_2_05 0 conv_bpf_c076_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_2_05 (conv_q_src_c076_2_05 conv_q_c076_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_06 (conv_i_src_c076_2_06 0 conv_bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_2_06 (conv_i_src_c076_2_06 conv_i_c076_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_06 (conv_q_src_c076_2_06 0 conv_bpf_c076_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_2_06 (conv_q_src_c076_2_06 conv_q_c076_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_07 (conv_i_src_c076_2_07 0 conv_bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_2_07 (conv_i_src_c076_2_07 conv_i_c076_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_07 (conv_q_src_c076_2_07 0 conv_bpf_c076_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_2_07 (conv_q_src_c076_2_07 conv_q_c076_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_08 (conv_i_src_c076_2_08 0 conv_bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_2_08 (conv_i_src_c076_2_08 conv_i_c076_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_08 (conv_q_src_c076_2_08 0 conv_bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_2_08 (conv_q_src_c076_2_08 conv_q_c076_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_09 (conv_i_src_c076_2_09 0 conv_bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_2_09 (conv_i_src_c076_2_09 conv_i_c076_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_09 (conv_q_src_c076_2_09 0 conv_bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_2_09 (conv_q_src_c076_2_09 conv_q_c076_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_10 (conv_i_src_c076_2_10 0 conv_bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_2_10 (conv_i_src_c076_2_10 conv_i_c076_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_10 (conv_q_src_c076_2_10 0 conv_bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_2_10 (conv_q_src_c076_2_10 conv_q_c076_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_11 (conv_i_src_c076_2_11 0 conv_bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_2_11 (conv_i_src_c076_2_11 conv_i_c076_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_11 (conv_q_src_c076_2_11 0 conv_bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_2_11 (conv_q_src_c076_2_11 conv_q_c076_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_12 (conv_i_src_c076_2_12 0 conv_bpf_c076_2 0) vcvs gain=1.950903220161e-01
SCONVI_c076_2_12 (conv_i_src_c076_2_12 conv_i_c076_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_12 (conv_q_src_c076_2_12 0 conv_bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_2_12 (conv_q_src_c076_2_12 conv_q_c076_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_13 (conv_i_src_c076_2_13 0 conv_bpf_c076_2 0) vcvs gain=5.555702330196e-01
SCONVI_c076_2_13 (conv_i_src_c076_2_13 conv_i_c076_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_13 (conv_q_src_c076_2_13 0 conv_bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_2_13 (conv_q_src_c076_2_13 conv_q_c076_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_14 (conv_i_src_c076_2_14 0 conv_bpf_c076_2 0) vcvs gain=8.314696123025e-01
SCONVI_c076_2_14 (conv_i_src_c076_2_14 conv_i_c076_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_14 (conv_q_src_c076_2_14 0 conv_bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_2_14 (conv_q_src_c076_2_14 conv_q_c076_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_2_15 (conv_i_src_c076_2_15 0 conv_bpf_c076_2 0) vcvs gain=9.807852804032e-01
SCONVI_c076_2_15 (conv_i_src_c076_2_15 conv_i_c076_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_2_15 (conv_q_src_c076_2_15 0 conv_bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_2_15 (conv_q_src_c076_2_15 conv_q_c076_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c076_2 (conv_i_c076_2 0) resistor r=1G
RCONVQ_c076_2 (conv_q_c076_2 0) resistor r=1G
RCONVINTI_c076_2 (conv_i_c076_2 ConvIcar_c076_2) resistor r=1k
CCONVINTI_c076_2 (ConvIcar_c076_2 0) capacitor c=80p
RCONVINTQ_c076_2 (conv_q_c076_2 ConvQcar_c076_2) resistor r=1k
CCONVINTQ_c076_2 (ConvQcar_c076_2 0) capacitor c=80p
save conv_bpf_c076_2 ConvIcar_c076_2 ConvQcar_c076_2

// conventional mixed baseline bl076, carrier_3: 1000000000 Hz
CCONVBPF_c076_3 (bl076 n_conv_cbpf_c076_3) capacitor c=2.533029591058e-14
LCONVBPF_c076_3 (n_conv_cbpf_c076_3 conv_bpf_c076_3) inductor l=1.000000000000e-06
RCONVBPF_c076_3 (conv_bpf_c076_3 0) resistor r=3.141592653590e+02
ECONVI_c076_3_00 (conv_i_src_c076_3_00 0 conv_bpf_c076_3 0) vcvs gain=9.807852804032e-01
SCONVI_c076_3_00 (conv_i_src_c076_3_00 conv_i_c076_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_00 (conv_q_src_c076_3_00 0 conv_bpf_c076_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_3_00 (conv_q_src_c076_3_00 conv_q_c076_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_01 (conv_i_src_c076_3_01 0 conv_bpf_c076_3 0) vcvs gain=8.314696123025e-01
SCONVI_c076_3_01 (conv_i_src_c076_3_01 conv_i_c076_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_01 (conv_q_src_c076_3_01 0 conv_bpf_c076_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_3_01 (conv_q_src_c076_3_01 conv_q_c076_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_02 (conv_i_src_c076_3_02 0 conv_bpf_c076_3 0) vcvs gain=5.555702330196e-01
SCONVI_c076_3_02 (conv_i_src_c076_3_02 conv_i_c076_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_02 (conv_q_src_c076_3_02 0 conv_bpf_c076_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_3_02 (conv_q_src_c076_3_02 conv_q_c076_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_03 (conv_i_src_c076_3_03 0 conv_bpf_c076_3 0) vcvs gain=1.950903220161e-01
SCONVI_c076_3_03 (conv_i_src_c076_3_03 conv_i_c076_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_03 (conv_q_src_c076_3_03 0 conv_bpf_c076_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_3_03 (conv_q_src_c076_3_03 conv_q_c076_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_04 (conv_i_src_c076_3_04 0 conv_bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_3_04 (conv_i_src_c076_3_04 conv_i_c076_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_04 (conv_q_src_c076_3_04 0 conv_bpf_c076_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c076_3_04 (conv_q_src_c076_3_04 conv_q_c076_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_05 (conv_i_src_c076_3_05 0 conv_bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_3_05 (conv_i_src_c076_3_05 conv_i_c076_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_05 (conv_q_src_c076_3_05 0 conv_bpf_c076_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c076_3_05 (conv_q_src_c076_3_05 conv_q_c076_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_06 (conv_i_src_c076_3_06 0 conv_bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_3_06 (conv_i_src_c076_3_06 conv_i_c076_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_06 (conv_q_src_c076_3_06 0 conv_bpf_c076_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c076_3_06 (conv_q_src_c076_3_06 conv_q_c076_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_07 (conv_i_src_c076_3_07 0 conv_bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_3_07 (conv_i_src_c076_3_07 conv_i_c076_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_07 (conv_q_src_c076_3_07 0 conv_bpf_c076_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c076_3_07 (conv_q_src_c076_3_07 conv_q_c076_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_08 (conv_i_src_c076_3_08 0 conv_bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c076_3_08 (conv_i_src_c076_3_08 conv_i_c076_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_08 (conv_q_src_c076_3_08 0 conv_bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_3_08 (conv_q_src_c076_3_08 conv_q_c076_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_09 (conv_i_src_c076_3_09 0 conv_bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c076_3_09 (conv_i_src_c076_3_09 conv_i_c076_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_09 (conv_q_src_c076_3_09 0 conv_bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_3_09 (conv_q_src_c076_3_09 conv_q_c076_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_10 (conv_i_src_c076_3_10 0 conv_bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c076_3_10 (conv_i_src_c076_3_10 conv_i_c076_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_10 (conv_q_src_c076_3_10 0 conv_bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_3_10 (conv_q_src_c076_3_10 conv_q_c076_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_11 (conv_i_src_c076_3_11 0 conv_bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c076_3_11 (conv_i_src_c076_3_11 conv_i_c076_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_11 (conv_q_src_c076_3_11 0 conv_bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_3_11 (conv_q_src_c076_3_11 conv_q_c076_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_12 (conv_i_src_c076_3_12 0 conv_bpf_c076_3 0) vcvs gain=1.950903220161e-01
SCONVI_c076_3_12 (conv_i_src_c076_3_12 conv_i_c076_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_12 (conv_q_src_c076_3_12 0 conv_bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c076_3_12 (conv_q_src_c076_3_12 conv_q_c076_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_13 (conv_i_src_c076_3_13 0 conv_bpf_c076_3 0) vcvs gain=5.555702330196e-01
SCONVI_c076_3_13 (conv_i_src_c076_3_13 conv_i_c076_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_13 (conv_q_src_c076_3_13 0 conv_bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c076_3_13 (conv_q_src_c076_3_13 conv_q_c076_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_14 (conv_i_src_c076_3_14 0 conv_bpf_c076_3 0) vcvs gain=8.314696123025e-01
SCONVI_c076_3_14 (conv_i_src_c076_3_14 conv_i_c076_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_14 (conv_q_src_c076_3_14 0 conv_bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c076_3_14 (conv_q_src_c076_3_14 conv_q_c076_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c076_3_15 (conv_i_src_c076_3_15 0 conv_bpf_c076_3 0) vcvs gain=9.807852804032e-01
SCONVI_c076_3_15 (conv_i_src_c076_3_15 conv_i_c076_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c076_3_15 (conv_q_src_c076_3_15 0 conv_bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c076_3_15 (conv_q_src_c076_3_15 conv_q_c076_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c076_3 (conv_i_c076_3 0) resistor r=1G
RCONVQ_c076_3 (conv_q_c076_3 0) resistor r=1G
RCONVINTI_c076_3 (conv_i_c076_3 ConvIcar_c076_3) resistor r=1k
CCONVINTI_c076_3 (ConvIcar_c076_3 0) capacitor c=80p
RCONVINTQ_c076_3 (conv_q_c076_3 ConvQcar_c076_3) resistor r=1k
CCONVINTQ_c076_3 (ConvQcar_c076_3 0) capacitor c=80p
save conv_bpf_c076_3 ConvIcar_c076_3 ConvQcar_c076_3

// conventional mixed baseline bl077, carrier_0: 250000000 Hz
CCONVBPF_c077_0 (bl077 n_conv_cbpf_c077_0) capacitor c=4.052847345694e-13
LCONVBPF_c077_0 (n_conv_cbpf_c077_0 conv_bpf_c077_0) inductor l=1.000000000000e-06
RCONVBPF_c077_0 (conv_bpf_c077_0 0) resistor r=7.853981633974e+01
ECONVI_c077_0_00 (conv_i_src_c077_0_00 0 conv_bpf_c077_0 0) vcvs gain=9.807852804032e-01
SCONVI_c077_0_00 (conv_i_src_c077_0_00 conv_i_c077_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_00 (conv_q_src_c077_0_00 0 conv_bpf_c077_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_0_00 (conv_q_src_c077_0_00 conv_q_c077_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_01 (conv_i_src_c077_0_01 0 conv_bpf_c077_0 0) vcvs gain=8.314696123025e-01
SCONVI_c077_0_01 (conv_i_src_c077_0_01 conv_i_c077_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_01 (conv_q_src_c077_0_01 0 conv_bpf_c077_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_0_01 (conv_q_src_c077_0_01 conv_q_c077_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_02 (conv_i_src_c077_0_02 0 conv_bpf_c077_0 0) vcvs gain=5.555702330196e-01
SCONVI_c077_0_02 (conv_i_src_c077_0_02 conv_i_c077_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_02 (conv_q_src_c077_0_02 0 conv_bpf_c077_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_0_02 (conv_q_src_c077_0_02 conv_q_c077_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_03 (conv_i_src_c077_0_03 0 conv_bpf_c077_0 0) vcvs gain=1.950903220161e-01
SCONVI_c077_0_03 (conv_i_src_c077_0_03 conv_i_c077_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_03 (conv_q_src_c077_0_03 0 conv_bpf_c077_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_0_03 (conv_q_src_c077_0_03 conv_q_c077_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_04 (conv_i_src_c077_0_04 0 conv_bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_0_04 (conv_i_src_c077_0_04 conv_i_c077_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_04 (conv_q_src_c077_0_04 0 conv_bpf_c077_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_0_04 (conv_q_src_c077_0_04 conv_q_c077_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_05 (conv_i_src_c077_0_05 0 conv_bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_0_05 (conv_i_src_c077_0_05 conv_i_c077_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_05 (conv_q_src_c077_0_05 0 conv_bpf_c077_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_0_05 (conv_q_src_c077_0_05 conv_q_c077_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_06 (conv_i_src_c077_0_06 0 conv_bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_0_06 (conv_i_src_c077_0_06 conv_i_c077_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_06 (conv_q_src_c077_0_06 0 conv_bpf_c077_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_0_06 (conv_q_src_c077_0_06 conv_q_c077_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_07 (conv_i_src_c077_0_07 0 conv_bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_0_07 (conv_i_src_c077_0_07 conv_i_c077_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_07 (conv_q_src_c077_0_07 0 conv_bpf_c077_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_0_07 (conv_q_src_c077_0_07 conv_q_c077_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_08 (conv_i_src_c077_0_08 0 conv_bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_0_08 (conv_i_src_c077_0_08 conv_i_c077_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_08 (conv_q_src_c077_0_08 0 conv_bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_0_08 (conv_q_src_c077_0_08 conv_q_c077_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_09 (conv_i_src_c077_0_09 0 conv_bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_0_09 (conv_i_src_c077_0_09 conv_i_c077_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_09 (conv_q_src_c077_0_09 0 conv_bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_0_09 (conv_q_src_c077_0_09 conv_q_c077_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_10 (conv_i_src_c077_0_10 0 conv_bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_0_10 (conv_i_src_c077_0_10 conv_i_c077_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_10 (conv_q_src_c077_0_10 0 conv_bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_0_10 (conv_q_src_c077_0_10 conv_q_c077_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_11 (conv_i_src_c077_0_11 0 conv_bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_0_11 (conv_i_src_c077_0_11 conv_i_c077_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_11 (conv_q_src_c077_0_11 0 conv_bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_0_11 (conv_q_src_c077_0_11 conv_q_c077_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_12 (conv_i_src_c077_0_12 0 conv_bpf_c077_0 0) vcvs gain=1.950903220161e-01
SCONVI_c077_0_12 (conv_i_src_c077_0_12 conv_i_c077_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_12 (conv_q_src_c077_0_12 0 conv_bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_0_12 (conv_q_src_c077_0_12 conv_q_c077_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_13 (conv_i_src_c077_0_13 0 conv_bpf_c077_0 0) vcvs gain=5.555702330196e-01
SCONVI_c077_0_13 (conv_i_src_c077_0_13 conv_i_c077_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_13 (conv_q_src_c077_0_13 0 conv_bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_0_13 (conv_q_src_c077_0_13 conv_q_c077_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_14 (conv_i_src_c077_0_14 0 conv_bpf_c077_0 0) vcvs gain=8.314696123025e-01
SCONVI_c077_0_14 (conv_i_src_c077_0_14 conv_i_c077_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_14 (conv_q_src_c077_0_14 0 conv_bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_0_14 (conv_q_src_c077_0_14 conv_q_c077_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_0_15 (conv_i_src_c077_0_15 0 conv_bpf_c077_0 0) vcvs gain=9.807852804032e-01
SCONVI_c077_0_15 (conv_i_src_c077_0_15 conv_i_c077_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_0_15 (conv_q_src_c077_0_15 0 conv_bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_0_15 (conv_q_src_c077_0_15 conv_q_c077_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c077_0 (conv_i_c077_0 0) resistor r=1G
RCONVQ_c077_0 (conv_q_c077_0 0) resistor r=1G
RCONVINTI_c077_0 (conv_i_c077_0 ConvIcar_c077_0) resistor r=1k
CCONVINTI_c077_0 (ConvIcar_c077_0 0) capacitor c=80p
RCONVINTQ_c077_0 (conv_q_c077_0 ConvQcar_c077_0) resistor r=1k
CCONVINTQ_c077_0 (ConvQcar_c077_0 0) capacitor c=80p
save conv_bpf_c077_0 ConvIcar_c077_0 ConvQcar_c077_0

// conventional mixed baseline bl077, carrier_1: 500000000 Hz
CCONVBPF_c077_1 (bl077 n_conv_cbpf_c077_1) capacitor c=1.013211836423e-13
LCONVBPF_c077_1 (n_conv_cbpf_c077_1 conv_bpf_c077_1) inductor l=1.000000000000e-06
RCONVBPF_c077_1 (conv_bpf_c077_1 0) resistor r=1.570796326795e+02
ECONVI_c077_1_00 (conv_i_src_c077_1_00 0 conv_bpf_c077_1 0) vcvs gain=9.807852804032e-01
SCONVI_c077_1_00 (conv_i_src_c077_1_00 conv_i_c077_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_00 (conv_q_src_c077_1_00 0 conv_bpf_c077_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_1_00 (conv_q_src_c077_1_00 conv_q_c077_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_01 (conv_i_src_c077_1_01 0 conv_bpf_c077_1 0) vcvs gain=8.314696123025e-01
SCONVI_c077_1_01 (conv_i_src_c077_1_01 conv_i_c077_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_01 (conv_q_src_c077_1_01 0 conv_bpf_c077_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_1_01 (conv_q_src_c077_1_01 conv_q_c077_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_02 (conv_i_src_c077_1_02 0 conv_bpf_c077_1 0) vcvs gain=5.555702330196e-01
SCONVI_c077_1_02 (conv_i_src_c077_1_02 conv_i_c077_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_02 (conv_q_src_c077_1_02 0 conv_bpf_c077_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_1_02 (conv_q_src_c077_1_02 conv_q_c077_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_03 (conv_i_src_c077_1_03 0 conv_bpf_c077_1 0) vcvs gain=1.950903220161e-01
SCONVI_c077_1_03 (conv_i_src_c077_1_03 conv_i_c077_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_03 (conv_q_src_c077_1_03 0 conv_bpf_c077_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_1_03 (conv_q_src_c077_1_03 conv_q_c077_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_04 (conv_i_src_c077_1_04 0 conv_bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_1_04 (conv_i_src_c077_1_04 conv_i_c077_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_04 (conv_q_src_c077_1_04 0 conv_bpf_c077_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_1_04 (conv_q_src_c077_1_04 conv_q_c077_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_05 (conv_i_src_c077_1_05 0 conv_bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_1_05 (conv_i_src_c077_1_05 conv_i_c077_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_05 (conv_q_src_c077_1_05 0 conv_bpf_c077_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_1_05 (conv_q_src_c077_1_05 conv_q_c077_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_06 (conv_i_src_c077_1_06 0 conv_bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_1_06 (conv_i_src_c077_1_06 conv_i_c077_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_06 (conv_q_src_c077_1_06 0 conv_bpf_c077_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_1_06 (conv_q_src_c077_1_06 conv_q_c077_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_07 (conv_i_src_c077_1_07 0 conv_bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_1_07 (conv_i_src_c077_1_07 conv_i_c077_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_07 (conv_q_src_c077_1_07 0 conv_bpf_c077_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_1_07 (conv_q_src_c077_1_07 conv_q_c077_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_08 (conv_i_src_c077_1_08 0 conv_bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_1_08 (conv_i_src_c077_1_08 conv_i_c077_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_08 (conv_q_src_c077_1_08 0 conv_bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_1_08 (conv_q_src_c077_1_08 conv_q_c077_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_09 (conv_i_src_c077_1_09 0 conv_bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_1_09 (conv_i_src_c077_1_09 conv_i_c077_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_09 (conv_q_src_c077_1_09 0 conv_bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_1_09 (conv_q_src_c077_1_09 conv_q_c077_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_10 (conv_i_src_c077_1_10 0 conv_bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_1_10 (conv_i_src_c077_1_10 conv_i_c077_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_10 (conv_q_src_c077_1_10 0 conv_bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_1_10 (conv_q_src_c077_1_10 conv_q_c077_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_11 (conv_i_src_c077_1_11 0 conv_bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_1_11 (conv_i_src_c077_1_11 conv_i_c077_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_11 (conv_q_src_c077_1_11 0 conv_bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_1_11 (conv_q_src_c077_1_11 conv_q_c077_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_12 (conv_i_src_c077_1_12 0 conv_bpf_c077_1 0) vcvs gain=1.950903220161e-01
SCONVI_c077_1_12 (conv_i_src_c077_1_12 conv_i_c077_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_12 (conv_q_src_c077_1_12 0 conv_bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_1_12 (conv_q_src_c077_1_12 conv_q_c077_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_13 (conv_i_src_c077_1_13 0 conv_bpf_c077_1 0) vcvs gain=5.555702330196e-01
SCONVI_c077_1_13 (conv_i_src_c077_1_13 conv_i_c077_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_13 (conv_q_src_c077_1_13 0 conv_bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_1_13 (conv_q_src_c077_1_13 conv_q_c077_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_14 (conv_i_src_c077_1_14 0 conv_bpf_c077_1 0) vcvs gain=8.314696123025e-01
SCONVI_c077_1_14 (conv_i_src_c077_1_14 conv_i_c077_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_14 (conv_q_src_c077_1_14 0 conv_bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_1_14 (conv_q_src_c077_1_14 conv_q_c077_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_1_15 (conv_i_src_c077_1_15 0 conv_bpf_c077_1 0) vcvs gain=9.807852804032e-01
SCONVI_c077_1_15 (conv_i_src_c077_1_15 conv_i_c077_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_1_15 (conv_q_src_c077_1_15 0 conv_bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_1_15 (conv_q_src_c077_1_15 conv_q_c077_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c077_1 (conv_i_c077_1 0) resistor r=1G
RCONVQ_c077_1 (conv_q_c077_1 0) resistor r=1G
RCONVINTI_c077_1 (conv_i_c077_1 ConvIcar_c077_1) resistor r=1k
CCONVINTI_c077_1 (ConvIcar_c077_1 0) capacitor c=80p
RCONVINTQ_c077_1 (conv_q_c077_1 ConvQcar_c077_1) resistor r=1k
CCONVINTQ_c077_1 (ConvQcar_c077_1 0) capacitor c=80p
save conv_bpf_c077_1 ConvIcar_c077_1 ConvQcar_c077_1

// conventional mixed baseline bl077, carrier_2: 750000000 Hz
CCONVBPF_c077_2 (bl077 n_conv_cbpf_c077_2) capacitor c=4.503163717437e-14
LCONVBPF_c077_2 (n_conv_cbpf_c077_2 conv_bpf_c077_2) inductor l=1.000000000000e-06
RCONVBPF_c077_2 (conv_bpf_c077_2 0) resistor r=2.356194490192e+02
ECONVI_c077_2_00 (conv_i_src_c077_2_00 0 conv_bpf_c077_2 0) vcvs gain=9.807852804032e-01
SCONVI_c077_2_00 (conv_i_src_c077_2_00 conv_i_c077_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_00 (conv_q_src_c077_2_00 0 conv_bpf_c077_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_2_00 (conv_q_src_c077_2_00 conv_q_c077_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_01 (conv_i_src_c077_2_01 0 conv_bpf_c077_2 0) vcvs gain=8.314696123025e-01
SCONVI_c077_2_01 (conv_i_src_c077_2_01 conv_i_c077_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_01 (conv_q_src_c077_2_01 0 conv_bpf_c077_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_2_01 (conv_q_src_c077_2_01 conv_q_c077_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_02 (conv_i_src_c077_2_02 0 conv_bpf_c077_2 0) vcvs gain=5.555702330196e-01
SCONVI_c077_2_02 (conv_i_src_c077_2_02 conv_i_c077_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_02 (conv_q_src_c077_2_02 0 conv_bpf_c077_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_2_02 (conv_q_src_c077_2_02 conv_q_c077_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_03 (conv_i_src_c077_2_03 0 conv_bpf_c077_2 0) vcvs gain=1.950903220161e-01
SCONVI_c077_2_03 (conv_i_src_c077_2_03 conv_i_c077_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_03 (conv_q_src_c077_2_03 0 conv_bpf_c077_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_2_03 (conv_q_src_c077_2_03 conv_q_c077_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_04 (conv_i_src_c077_2_04 0 conv_bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_2_04 (conv_i_src_c077_2_04 conv_i_c077_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_04 (conv_q_src_c077_2_04 0 conv_bpf_c077_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_2_04 (conv_q_src_c077_2_04 conv_q_c077_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_05 (conv_i_src_c077_2_05 0 conv_bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_2_05 (conv_i_src_c077_2_05 conv_i_c077_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_05 (conv_q_src_c077_2_05 0 conv_bpf_c077_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_2_05 (conv_q_src_c077_2_05 conv_q_c077_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_06 (conv_i_src_c077_2_06 0 conv_bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_2_06 (conv_i_src_c077_2_06 conv_i_c077_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_06 (conv_q_src_c077_2_06 0 conv_bpf_c077_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_2_06 (conv_q_src_c077_2_06 conv_q_c077_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_07 (conv_i_src_c077_2_07 0 conv_bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_2_07 (conv_i_src_c077_2_07 conv_i_c077_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_07 (conv_q_src_c077_2_07 0 conv_bpf_c077_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_2_07 (conv_q_src_c077_2_07 conv_q_c077_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_08 (conv_i_src_c077_2_08 0 conv_bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_2_08 (conv_i_src_c077_2_08 conv_i_c077_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_08 (conv_q_src_c077_2_08 0 conv_bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_2_08 (conv_q_src_c077_2_08 conv_q_c077_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_09 (conv_i_src_c077_2_09 0 conv_bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_2_09 (conv_i_src_c077_2_09 conv_i_c077_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_09 (conv_q_src_c077_2_09 0 conv_bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_2_09 (conv_q_src_c077_2_09 conv_q_c077_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_10 (conv_i_src_c077_2_10 0 conv_bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_2_10 (conv_i_src_c077_2_10 conv_i_c077_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_10 (conv_q_src_c077_2_10 0 conv_bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_2_10 (conv_q_src_c077_2_10 conv_q_c077_2 conv_win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_11 (conv_i_src_c077_2_11 0 conv_bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_2_11 (conv_i_src_c077_2_11 conv_i_c077_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_11 (conv_q_src_c077_2_11 0 conv_bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_2_11 (conv_q_src_c077_2_11 conv_q_c077_2 conv_win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_12 (conv_i_src_c077_2_12 0 conv_bpf_c077_2 0) vcvs gain=1.950903220161e-01
SCONVI_c077_2_12 (conv_i_src_c077_2_12 conv_i_c077_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_12 (conv_q_src_c077_2_12 0 conv_bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_2_12 (conv_q_src_c077_2_12 conv_q_c077_2 conv_win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_13 (conv_i_src_c077_2_13 0 conv_bpf_c077_2 0) vcvs gain=5.555702330196e-01
SCONVI_c077_2_13 (conv_i_src_c077_2_13 conv_i_c077_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_13 (conv_q_src_c077_2_13 0 conv_bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_2_13 (conv_q_src_c077_2_13 conv_q_c077_2 conv_win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_14 (conv_i_src_c077_2_14 0 conv_bpf_c077_2 0) vcvs gain=8.314696123025e-01
SCONVI_c077_2_14 (conv_i_src_c077_2_14 conv_i_c077_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_14 (conv_q_src_c077_2_14 0 conv_bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_2_14 (conv_q_src_c077_2_14 conv_q_c077_2 conv_win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_2_15 (conv_i_src_c077_2_15 0 conv_bpf_c077_2 0) vcvs gain=9.807852804032e-01
SCONVI_c077_2_15 (conv_i_src_c077_2_15 conv_i_c077_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_2_15 (conv_q_src_c077_2_15 0 conv_bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_2_15 (conv_q_src_c077_2_15 conv_q_c077_2 conv_win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c077_2 (conv_i_c077_2 0) resistor r=1G
RCONVQ_c077_2 (conv_q_c077_2 0) resistor r=1G
RCONVINTI_c077_2 (conv_i_c077_2 ConvIcar_c077_2) resistor r=1k
CCONVINTI_c077_2 (ConvIcar_c077_2 0) capacitor c=80p
RCONVINTQ_c077_2 (conv_q_c077_2 ConvQcar_c077_2) resistor r=1k
CCONVINTQ_c077_2 (ConvQcar_c077_2 0) capacitor c=80p
save conv_bpf_c077_2 ConvIcar_c077_2 ConvQcar_c077_2

// conventional mixed baseline bl077, carrier_3: 1000000000 Hz
CCONVBPF_c077_3 (bl077 n_conv_cbpf_c077_3) capacitor c=2.533029591058e-14
LCONVBPF_c077_3 (n_conv_cbpf_c077_3 conv_bpf_c077_3) inductor l=1.000000000000e-06
RCONVBPF_c077_3 (conv_bpf_c077_3 0) resistor r=3.141592653590e+02
ECONVI_c077_3_00 (conv_i_src_c077_3_00 0 conv_bpf_c077_3 0) vcvs gain=9.807852804032e-01
SCONVI_c077_3_00 (conv_i_src_c077_3_00 conv_i_c077_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_00 (conv_q_src_c077_3_00 0 conv_bpf_c077_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_3_00 (conv_q_src_c077_3_00 conv_q_c077_3 conv_win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_01 (conv_i_src_c077_3_01 0 conv_bpf_c077_3 0) vcvs gain=8.314696123025e-01
SCONVI_c077_3_01 (conv_i_src_c077_3_01 conv_i_c077_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_01 (conv_q_src_c077_3_01 0 conv_bpf_c077_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_3_01 (conv_q_src_c077_3_01 conv_q_c077_3 conv_win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_02 (conv_i_src_c077_3_02 0 conv_bpf_c077_3 0) vcvs gain=5.555702330196e-01
SCONVI_c077_3_02 (conv_i_src_c077_3_02 conv_i_c077_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_02 (conv_q_src_c077_3_02 0 conv_bpf_c077_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_3_02 (conv_q_src_c077_3_02 conv_q_c077_3 conv_win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_03 (conv_i_src_c077_3_03 0 conv_bpf_c077_3 0) vcvs gain=1.950903220161e-01
SCONVI_c077_3_03 (conv_i_src_c077_3_03 conv_i_c077_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_03 (conv_q_src_c077_3_03 0 conv_bpf_c077_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_3_03 (conv_q_src_c077_3_03 conv_q_c077_3 conv_win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_04 (conv_i_src_c077_3_04 0 conv_bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_3_04 (conv_i_src_c077_3_04 conv_i_c077_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_04 (conv_q_src_c077_3_04 0 conv_bpf_c077_3 0) vcvs gain=9.807852804032e-01
SCONVQ_c077_3_04 (conv_q_src_c077_3_04 conv_q_c077_3 conv_win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_05 (conv_i_src_c077_3_05 0 conv_bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_3_05 (conv_i_src_c077_3_05 conv_i_c077_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_05 (conv_q_src_c077_3_05 0 conv_bpf_c077_3 0) vcvs gain=8.314696123025e-01
SCONVQ_c077_3_05 (conv_q_src_c077_3_05 conv_q_c077_3 conv_win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_06 (conv_i_src_c077_3_06 0 conv_bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_3_06 (conv_i_src_c077_3_06 conv_i_c077_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_06 (conv_q_src_c077_3_06 0 conv_bpf_c077_3 0) vcvs gain=5.555702330196e-01
SCONVQ_c077_3_06 (conv_q_src_c077_3_06 conv_q_c077_3 conv_win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_07 (conv_i_src_c077_3_07 0 conv_bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_3_07 (conv_i_src_c077_3_07 conv_i_c077_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_07 (conv_q_src_c077_3_07 0 conv_bpf_c077_3 0) vcvs gain=1.950903220161e-01
SCONVQ_c077_3_07 (conv_q_src_c077_3_07 conv_q_c077_3 conv_win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_08 (conv_i_src_c077_3_08 0 conv_bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SCONVI_c077_3_08 (conv_i_src_c077_3_08 conv_i_c077_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_08 (conv_q_src_c077_3_08 0 conv_bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_3_08 (conv_q_src_c077_3_08 conv_q_c077_3 conv_win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_09 (conv_i_src_c077_3_09 0 conv_bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SCONVI_c077_3_09 (conv_i_src_c077_3_09 conv_i_c077_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_09 (conv_q_src_c077_3_09 0 conv_bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_3_09 (conv_q_src_c077_3_09 conv_q_c077_3 conv_win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_10 (conv_i_src_c077_3_10 0 conv_bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SCONVI_c077_3_10 (conv_i_src_c077_3_10 conv_i_c077_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_10 (conv_q_src_c077_3_10 0 conv_bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_3_10 (conv_q_src_c077_3_10 conv_q_c077_3 conv_win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_11 (conv_i_src_c077_3_11 0 conv_bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SCONVI_c077_3_11 (conv_i_src_c077_3_11 conv_i_c077_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_11 (conv_q_src_c077_3_11 0 conv_bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_3_11 (conv_q_src_c077_3_11 conv_q_c077_3 conv_win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_12 (conv_i_src_c077_3_12 0 conv_bpf_c077_3 0) vcvs gain=1.950903220161e-01
SCONVI_c077_3_12 (conv_i_src_c077_3_12 conv_i_c077_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_12 (conv_q_src_c077_3_12 0 conv_bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SCONVQ_c077_3_12 (conv_q_src_c077_3_12 conv_q_c077_3 conv_win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_13 (conv_i_src_c077_3_13 0 conv_bpf_c077_3 0) vcvs gain=5.555702330196e-01
SCONVI_c077_3_13 (conv_i_src_c077_3_13 conv_i_c077_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_13 (conv_q_src_c077_3_13 0 conv_bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SCONVQ_c077_3_13 (conv_q_src_c077_3_13 conv_q_c077_3 conv_win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_14 (conv_i_src_c077_3_14 0 conv_bpf_c077_3 0) vcvs gain=8.314696123025e-01
SCONVI_c077_3_14 (conv_i_src_c077_3_14 conv_i_c077_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_14 (conv_q_src_c077_3_14 0 conv_bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SCONVQ_c077_3_14 (conv_q_src_c077_3_14 conv_q_c077_3 conv_win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c077_3_15 (conv_i_src_c077_3_15 0 conv_bpf_c077_3 0) vcvs gain=9.807852804032e-01
SCONVI_c077_3_15 (conv_i_src_c077_3_15 conv_i_c077_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c077_3_15 (conv_q_src_c077_3_15 0 conv_bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SCONVQ_c077_3_15 (conv_q_src_c077_3_15 conv_q_c077_3 conv_win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c077_3 (conv_i_c077_3 0) resistor r=1G
RCONVQ_c077_3 (conv_q_c077_3 0) resistor r=1G
RCONVINTI_c077_3 (conv_i_c077_3 ConvIcar_c077_3) resistor r=1k
CCONVINTI_c077_3 (ConvIcar_c077_3 0) capacitor c=80p
RCONVINTQ_c077_3 (conv_q_c077_3 ConvQcar_c077_3) resistor r=1k
CCONVINTQ_c077_3 (ConvQcar_c077_3 0) capacitor c=80p
save conv_bpf_c077_3 ConvIcar_c077_3 ConvQcar_c077_3

// conventional mixed baseline bl078, carrier_0: 250000000 Hz
CCONVBPF_c078_0 (bl078 n_conv_cbpf_c078_0) capacitor c=4.052847345694e-13
LCONVBPF_c078_0 (n_conv_cbpf_c078_0 conv_bpf_c078_0) inductor l=1.000000000000e-06
RCONVBPF_c078_0 (conv_bpf_c078_0 0) resistor r=7.853981633974e+01
ECONVI_c078_0_00 (conv_i_src_c078_0_00 0 conv_bpf_c078_0 0) vcvs gain=9.807852804032e-01
SCONVI_c078_0_00 (conv_i_src_c078_0_00 conv_i_c078_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_00 (conv_q_src_c078_0_00 0 conv_bpf_c078_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_0_00 (conv_q_src_c078_0_00 conv_q_c078_0 conv_win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_01 (conv_i_src_c078_0_01 0 conv_bpf_c078_0 0) vcvs gain=8.314696123025e-01
SCONVI_c078_0_01 (conv_i_src_c078_0_01 conv_i_c078_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_01 (conv_q_src_c078_0_01 0 conv_bpf_c078_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_0_01 (conv_q_src_c078_0_01 conv_q_c078_0 conv_win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_02 (conv_i_src_c078_0_02 0 conv_bpf_c078_0 0) vcvs gain=5.555702330196e-01
SCONVI_c078_0_02 (conv_i_src_c078_0_02 conv_i_c078_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_02 (conv_q_src_c078_0_02 0 conv_bpf_c078_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_0_02 (conv_q_src_c078_0_02 conv_q_c078_0 conv_win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_03 (conv_i_src_c078_0_03 0 conv_bpf_c078_0 0) vcvs gain=1.950903220161e-01
SCONVI_c078_0_03 (conv_i_src_c078_0_03 conv_i_c078_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_03 (conv_q_src_c078_0_03 0 conv_bpf_c078_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_0_03 (conv_q_src_c078_0_03 conv_q_c078_0 conv_win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_04 (conv_i_src_c078_0_04 0 conv_bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_0_04 (conv_i_src_c078_0_04 conv_i_c078_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_04 (conv_q_src_c078_0_04 0 conv_bpf_c078_0 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_0_04 (conv_q_src_c078_0_04 conv_q_c078_0 conv_win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_05 (conv_i_src_c078_0_05 0 conv_bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c078_0_05 (conv_i_src_c078_0_05 conv_i_c078_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_05 (conv_q_src_c078_0_05 0 conv_bpf_c078_0 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_0_05 (conv_q_src_c078_0_05 conv_q_c078_0 conv_win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_06 (conv_i_src_c078_0_06 0 conv_bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_0_06 (conv_i_src_c078_0_06 conv_i_c078_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_06 (conv_q_src_c078_0_06 0 conv_bpf_c078_0 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_0_06 (conv_q_src_c078_0_06 conv_q_c078_0 conv_win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_07 (conv_i_src_c078_0_07 0 conv_bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_0_07 (conv_i_src_c078_0_07 conv_i_c078_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_07 (conv_q_src_c078_0_07 0 conv_bpf_c078_0 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_0_07 (conv_q_src_c078_0_07 conv_q_c078_0 conv_win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_08 (conv_i_src_c078_0_08 0 conv_bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_0_08 (conv_i_src_c078_0_08 conv_i_c078_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_08 (conv_q_src_c078_0_08 0 conv_bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_0_08 (conv_q_src_c078_0_08 conv_q_c078_0 conv_win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_09 (conv_i_src_c078_0_09 0 conv_bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_0_09 (conv_i_src_c078_0_09 conv_i_c078_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_09 (conv_q_src_c078_0_09 0 conv_bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_0_09 (conv_q_src_c078_0_09 conv_q_c078_0 conv_win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_10 (conv_i_src_c078_0_10 0 conv_bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SCONVI_c078_0_10 (conv_i_src_c078_0_10 conv_i_c078_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_10 (conv_q_src_c078_0_10 0 conv_bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_0_10 (conv_q_src_c078_0_10 conv_q_c078_0 conv_win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_11 (conv_i_src_c078_0_11 0 conv_bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_0_11 (conv_i_src_c078_0_11 conv_i_c078_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_11 (conv_q_src_c078_0_11 0 conv_bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_0_11 (conv_q_src_c078_0_11 conv_q_c078_0 conv_win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_12 (conv_i_src_c078_0_12 0 conv_bpf_c078_0 0) vcvs gain=1.950903220161e-01
SCONVI_c078_0_12 (conv_i_src_c078_0_12 conv_i_c078_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_12 (conv_q_src_c078_0_12 0 conv_bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_0_12 (conv_q_src_c078_0_12 conv_q_c078_0 conv_win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_13 (conv_i_src_c078_0_13 0 conv_bpf_c078_0 0) vcvs gain=5.555702330196e-01
SCONVI_c078_0_13 (conv_i_src_c078_0_13 conv_i_c078_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_13 (conv_q_src_c078_0_13 0 conv_bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_0_13 (conv_q_src_c078_0_13 conv_q_c078_0 conv_win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_14 (conv_i_src_c078_0_14 0 conv_bpf_c078_0 0) vcvs gain=8.314696123025e-01
SCONVI_c078_0_14 (conv_i_src_c078_0_14 conv_i_c078_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_14 (conv_q_src_c078_0_14 0 conv_bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_0_14 (conv_q_src_c078_0_14 conv_q_c078_0 conv_win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_0_15 (conv_i_src_c078_0_15 0 conv_bpf_c078_0 0) vcvs gain=9.807852804032e-01
SCONVI_c078_0_15 (conv_i_src_c078_0_15 conv_i_c078_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_0_15 (conv_q_src_c078_0_15 0 conv_bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_0_15 (conv_q_src_c078_0_15 conv_q_c078_0 conv_win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c078_0 (conv_i_c078_0 0) resistor r=1G
RCONVQ_c078_0 (conv_q_c078_0 0) resistor r=1G
RCONVINTI_c078_0 (conv_i_c078_0 ConvIcar_c078_0) resistor r=1k
CCONVINTI_c078_0 (ConvIcar_c078_0 0) capacitor c=80p
RCONVINTQ_c078_0 (conv_q_c078_0 ConvQcar_c078_0) resistor r=1k
CCONVINTQ_c078_0 (ConvQcar_c078_0 0) capacitor c=80p
save conv_bpf_c078_0 ConvIcar_c078_0 ConvQcar_c078_0

// conventional mixed baseline bl078, carrier_1: 500000000 Hz
CCONVBPF_c078_1 (bl078 n_conv_cbpf_c078_1) capacitor c=1.013211836423e-13
LCONVBPF_c078_1 (n_conv_cbpf_c078_1 conv_bpf_c078_1) inductor l=1.000000000000e-06
RCONVBPF_c078_1 (conv_bpf_c078_1 0) resistor r=1.570796326795e+02
ECONVI_c078_1_00 (conv_i_src_c078_1_00 0 conv_bpf_c078_1 0) vcvs gain=9.807852804032e-01
SCONVI_c078_1_00 (conv_i_src_c078_1_00 conv_i_c078_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_00 (conv_q_src_c078_1_00 0 conv_bpf_c078_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_1_00 (conv_q_src_c078_1_00 conv_q_c078_1 conv_win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_01 (conv_i_src_c078_1_01 0 conv_bpf_c078_1 0) vcvs gain=8.314696123025e-01
SCONVI_c078_1_01 (conv_i_src_c078_1_01 conv_i_c078_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_01 (conv_q_src_c078_1_01 0 conv_bpf_c078_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_1_01 (conv_q_src_c078_1_01 conv_q_c078_1 conv_win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_02 (conv_i_src_c078_1_02 0 conv_bpf_c078_1 0) vcvs gain=5.555702330196e-01
SCONVI_c078_1_02 (conv_i_src_c078_1_02 conv_i_c078_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_02 (conv_q_src_c078_1_02 0 conv_bpf_c078_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_1_02 (conv_q_src_c078_1_02 conv_q_c078_1 conv_win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_03 (conv_i_src_c078_1_03 0 conv_bpf_c078_1 0) vcvs gain=1.950903220161e-01
SCONVI_c078_1_03 (conv_i_src_c078_1_03 conv_i_c078_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_03 (conv_q_src_c078_1_03 0 conv_bpf_c078_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_1_03 (conv_q_src_c078_1_03 conv_q_c078_1 conv_win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_04 (conv_i_src_c078_1_04 0 conv_bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_1_04 (conv_i_src_c078_1_04 conv_i_c078_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_04 (conv_q_src_c078_1_04 0 conv_bpf_c078_1 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_1_04 (conv_q_src_c078_1_04 conv_q_c078_1 conv_win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_05 (conv_i_src_c078_1_05 0 conv_bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c078_1_05 (conv_i_src_c078_1_05 conv_i_c078_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_05 (conv_q_src_c078_1_05 0 conv_bpf_c078_1 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_1_05 (conv_q_src_c078_1_05 conv_q_c078_1 conv_win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_06 (conv_i_src_c078_1_06 0 conv_bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_1_06 (conv_i_src_c078_1_06 conv_i_c078_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_06 (conv_q_src_c078_1_06 0 conv_bpf_c078_1 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_1_06 (conv_q_src_c078_1_06 conv_q_c078_1 conv_win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_07 (conv_i_src_c078_1_07 0 conv_bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_1_07 (conv_i_src_c078_1_07 conv_i_c078_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_07 (conv_q_src_c078_1_07 0 conv_bpf_c078_1 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_1_07 (conv_q_src_c078_1_07 conv_q_c078_1 conv_win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_08 (conv_i_src_c078_1_08 0 conv_bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_1_08 (conv_i_src_c078_1_08 conv_i_c078_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_08 (conv_q_src_c078_1_08 0 conv_bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_1_08 (conv_q_src_c078_1_08 conv_q_c078_1 conv_win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_09 (conv_i_src_c078_1_09 0 conv_bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_1_09 (conv_i_src_c078_1_09 conv_i_c078_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_09 (conv_q_src_c078_1_09 0 conv_bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_1_09 (conv_q_src_c078_1_09 conv_q_c078_1 conv_win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_10 (conv_i_src_c078_1_10 0 conv_bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SCONVI_c078_1_10 (conv_i_src_c078_1_10 conv_i_c078_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_10 (conv_q_src_c078_1_10 0 conv_bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_1_10 (conv_q_src_c078_1_10 conv_q_c078_1 conv_win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_11 (conv_i_src_c078_1_11 0 conv_bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_1_11 (conv_i_src_c078_1_11 conv_i_c078_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_11 (conv_q_src_c078_1_11 0 conv_bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_1_11 (conv_q_src_c078_1_11 conv_q_c078_1 conv_win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_12 (conv_i_src_c078_1_12 0 conv_bpf_c078_1 0) vcvs gain=1.950903220161e-01
SCONVI_c078_1_12 (conv_i_src_c078_1_12 conv_i_c078_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_12 (conv_q_src_c078_1_12 0 conv_bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SCONVQ_c078_1_12 (conv_q_src_c078_1_12 conv_q_c078_1 conv_win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_13 (conv_i_src_c078_1_13 0 conv_bpf_c078_1 0) vcvs gain=5.555702330196e-01
SCONVI_c078_1_13 (conv_i_src_c078_1_13 conv_i_c078_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_13 (conv_q_src_c078_1_13 0 conv_bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SCONVQ_c078_1_13 (conv_q_src_c078_1_13 conv_q_c078_1 conv_win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_14 (conv_i_src_c078_1_14 0 conv_bpf_c078_1 0) vcvs gain=8.314696123025e-01
SCONVI_c078_1_14 (conv_i_src_c078_1_14 conv_i_c078_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_14 (conv_q_src_c078_1_14 0 conv_bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_1_14 (conv_q_src_c078_1_14 conv_q_c078_1 conv_win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_1_15 (conv_i_src_c078_1_15 0 conv_bpf_c078_1 0) vcvs gain=9.807852804032e-01
SCONVI_c078_1_15 (conv_i_src_c078_1_15 conv_i_c078_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_1_15 (conv_q_src_c078_1_15 0 conv_bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_1_15 (conv_q_src_c078_1_15 conv_q_c078_1 conv_win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RCONVI_c078_1 (conv_i_c078_1 0) resistor r=1G
RCONVQ_c078_1 (conv_q_c078_1 0) resistor r=1G
RCONVINTI_c078_1 (conv_i_c078_1 ConvIcar_c078_1) resistor r=1k
CCONVINTI_c078_1 (ConvIcar_c078_1 0) capacitor c=80p
RCONVINTQ_c078_1 (conv_q_c078_1 ConvQcar_c078_1) resistor r=1k
CCONVINTQ_c078_1 (ConvQcar_c078_1 0) capacitor c=80p
save conv_bpf_c078_1 ConvIcar_c078_1 ConvQcar_c078_1

// conventional mixed baseline bl078, carrier_2: 750000000 Hz
CCONVBPF_c078_2 (bl078 n_conv_cbpf_c078_2) capacitor c=4.503163717437e-14
LCONVBPF_c078_2 (n_conv_cbpf_c078_2 conv_bpf_c078_2) inductor l=1.000000000000e-06
RCONVBPF_c078_2 (conv_bpf_c078_2 0) resistor r=2.356194490192e+02
ECONVI_c078_2_00 (conv_i_src_c078_2_00 0 conv_bpf_c078_2 0) vcvs gain=9.807852804032e-01
SCONVI_c078_2_00 (conv_i_src_c078_2_00 conv_i_c078_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_00 (conv_q_src_c078_2_00 0 conv_bpf_c078_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_2_00 (conv_q_src_c078_2_00 conv_q_c078_2 conv_win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_01 (conv_i_src_c078_2_01 0 conv_bpf_c078_2 0) vcvs gain=8.314696123025e-01
SCONVI_c078_2_01 (conv_i_src_c078_2_01 conv_i_c078_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_01 (conv_q_src_c078_2_01 0 conv_bpf_c078_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_2_01 (conv_q_src_c078_2_01 conv_q_c078_2 conv_win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_02 (conv_i_src_c078_2_02 0 conv_bpf_c078_2 0) vcvs gain=5.555702330196e-01
SCONVI_c078_2_02 (conv_i_src_c078_2_02 conv_i_c078_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_02 (conv_q_src_c078_2_02 0 conv_bpf_c078_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_2_02 (conv_q_src_c078_2_02 conv_q_c078_2 conv_win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_03 (conv_i_src_c078_2_03 0 conv_bpf_c078_2 0) vcvs gain=1.950903220161e-01
SCONVI_c078_2_03 (conv_i_src_c078_2_03 conv_i_c078_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_03 (conv_q_src_c078_2_03 0 conv_bpf_c078_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_2_03 (conv_q_src_c078_2_03 conv_q_c078_2 conv_win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_04 (conv_i_src_c078_2_04 0 conv_bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SCONVI_c078_2_04 (conv_i_src_c078_2_04 conv_i_c078_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_04 (conv_q_src_c078_2_04 0 conv_bpf_c078_2 0) vcvs gain=9.807852804032e-01
SCONVQ_c078_2_04 (conv_q_src_c078_2_04 conv_q_c078_2 conv_win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_05 (conv_i_src_c078_2_05 0 conv_bpf_c078_2 0) vcvs gain=-5.555702330196e-01
SCONVI_c078_2_05 (conv_i_src_c078_2_05 conv_i_c078_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_05 (conv_q_src_c078_2_05 0 conv_bpf_c078_2 0) vcvs gain=8.314696123025e-01
SCONVQ_c078_2_05 (conv_q_src_c078_2_05 conv_q_c078_2 conv_win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_06 (conv_i_src_c078_2_06 0 conv_bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_2_06 (conv_i_src_c078_2_06 conv_i_c078_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_06 (conv_q_src_c078_2_06 0 conv_bpf_c078_2 0) vcvs gain=5.555702330196e-01
SCONVQ_c078_2_06 (conv_q_src_c078_2_06 conv_q_c078_2 conv_win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_07 (conv_i_src_c078_2_07 0 conv_bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_2_07 (conv_i_src_c078_2_07 conv_i_c078_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_07 (conv_q_src_c078_2_07 0 conv_bpf_c078_2 0) vcvs gain=1.950903220161e-01
SCONVQ_c078_2_07 (conv_q_src_c078_2_07 conv_q_c078_2 conv_win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_08 (conv_i_src_c078_2_08 0 conv_bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SCONVI_c078_2_08 (conv_i_src_c078_2_08 conv_i_c078_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_08 (conv_q_src_c078_2_08 0 conv_bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SCONVQ_c078_2_08 (conv_q_src_c078_2_08 conv_q_c078_2 conv_win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_09 (conv_i_src_c078_2_09 0 conv_bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SCONVI_c078_2_09 (conv_i_src_c078_2_09 conv_i_c078_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVQ_c078_2_09 (conv_q_src_c078_2_09 0 conv_bpf_c078_2 0) vcvs gain=-5.555702330196e-01
SCONVQ_c078_2_09 (conv_q_src_c078_2_09 conv_q_c078_2 conv_win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
ECONVI_c078_2_10 (conv_i_src_c078_2_10 0 conv_bpf_c078_2 0) vcvs gain=-5.555702330196e-01
