SMIXQ_c099_1_13 (mix_q_src_c099_1_13 mix_q_c099_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_14 (mix_i_src_c099_1_14 0 bpf_c099_1 0) vcvs gain=8.314696123025e-01
SMIXI_c099_1_14 (mix_i_src_c099_1_14 mix_i_c099_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_14 (mix_q_src_c099_1_14 0 bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_1_14 (mix_q_src_c099_1_14 mix_q_c099_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_15 (mix_i_src_c099_1_15 0 bpf_c099_1 0) vcvs gain=9.807852804032e-01
SMIXI_c099_1_15 (mix_i_src_c099_1_15 mix_i_c099_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_15 (mix_q_src_c099_1_15 0 bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_1_15 (mix_q_src_c099_1_15 mix_q_c099_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c099_1 (mix_i_c099_1 0) resistor r=1G
RMIXQ_c099_1 (mix_q_c099_1 0) resistor r=1G
RINTI_c099_1 (mix_i_c099_1 Icar_c099_1) resistor r=1k
CINTI_c099_1 (Icar_c099_1 0) capacitor c=80p
RINTQ_c099_1 (mix_q_c099_1 Qcar_c099_1) resistor r=1k
CINTQ_c099_1 (Qcar_c099_1 0) capacitor c=80p

// bl099, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c099_2 (bl099 n_cbpf_c099_2) capacitor c=4.503163717437e-14
LBPF_c099_2 (n_cbpf_c099_2 bpf_c099_2) inductor l=1.000000000000e-06
RBPF_c099_2 (bpf_c099_2 0) resistor r=2.356194490192e+02
EMIXI_c099_2_00 (mix_i_src_c099_2_00 0 bpf_c099_2 0) vcvs gain=9.807852804032e-01
SMIXI_c099_2_00 (mix_i_src_c099_2_00 mix_i_c099_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_00 (mix_q_src_c099_2_00 0 bpf_c099_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_2_00 (mix_q_src_c099_2_00 mix_q_c099_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_01 (mix_i_src_c099_2_01 0 bpf_c099_2 0) vcvs gain=8.314696123025e-01
SMIXI_c099_2_01 (mix_i_src_c099_2_01 mix_i_c099_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_01 (mix_q_src_c099_2_01 0 bpf_c099_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_2_01 (mix_q_src_c099_2_01 mix_q_c099_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_02 (mix_i_src_c099_2_02 0 bpf_c099_2 0) vcvs gain=5.555702330196e-01
SMIXI_c099_2_02 (mix_i_src_c099_2_02 mix_i_c099_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_02 (mix_q_src_c099_2_02 0 bpf_c099_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_2_02 (mix_q_src_c099_2_02 mix_q_c099_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_03 (mix_i_src_c099_2_03 0 bpf_c099_2 0) vcvs gain=1.950903220161e-01
SMIXI_c099_2_03 (mix_i_src_c099_2_03 mix_i_c099_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_03 (mix_q_src_c099_2_03 0 bpf_c099_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_2_03 (mix_q_src_c099_2_03 mix_q_c099_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_04 (mix_i_src_c099_2_04 0 bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_2_04 (mix_i_src_c099_2_04 mix_i_c099_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_04 (mix_q_src_c099_2_04 0 bpf_c099_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_2_04 (mix_q_src_c099_2_04 mix_q_c099_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_05 (mix_i_src_c099_2_05 0 bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_2_05 (mix_i_src_c099_2_05 mix_i_c099_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_05 (mix_q_src_c099_2_05 0 bpf_c099_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_2_05 (mix_q_src_c099_2_05 mix_q_c099_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_06 (mix_i_src_c099_2_06 0 bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_2_06 (mix_i_src_c099_2_06 mix_i_c099_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_06 (mix_q_src_c099_2_06 0 bpf_c099_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_2_06 (mix_q_src_c099_2_06 mix_q_c099_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_07 (mix_i_src_c099_2_07 0 bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_2_07 (mix_i_src_c099_2_07 mix_i_c099_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_07 (mix_q_src_c099_2_07 0 bpf_c099_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_2_07 (mix_q_src_c099_2_07 mix_q_c099_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_08 (mix_i_src_c099_2_08 0 bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_2_08 (mix_i_src_c099_2_08 mix_i_c099_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_08 (mix_q_src_c099_2_08 0 bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_2_08 (mix_q_src_c099_2_08 mix_q_c099_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_09 (mix_i_src_c099_2_09 0 bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_2_09 (mix_i_src_c099_2_09 mix_i_c099_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_09 (mix_q_src_c099_2_09 0 bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_2_09 (mix_q_src_c099_2_09 mix_q_c099_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_10 (mix_i_src_c099_2_10 0 bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_2_10 (mix_i_src_c099_2_10 mix_i_c099_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_10 (mix_q_src_c099_2_10 0 bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c099_2_10 (mix_q_src_c099_2_10 mix_q_c099_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_11 (mix_i_src_c099_2_11 0 bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_2_11 (mix_i_src_c099_2_11 mix_i_c099_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_11 (mix_q_src_c099_2_11 0 bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_2_11 (mix_q_src_c099_2_11 mix_q_c099_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_12 (mix_i_src_c099_2_12 0 bpf_c099_2 0) vcvs gain=1.950903220161e-01
SMIXI_c099_2_12 (mix_i_src_c099_2_12 mix_i_c099_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_12 (mix_q_src_c099_2_12 0 bpf_c099_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_2_12 (mix_q_src_c099_2_12 mix_q_c099_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_13 (mix_i_src_c099_2_13 0 bpf_c099_2 0) vcvs gain=5.555702330196e-01
SMIXI_c099_2_13 (mix_i_src_c099_2_13 mix_i_c099_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_13 (mix_q_src_c099_2_13 0 bpf_c099_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c099_2_13 (mix_q_src_c099_2_13 mix_q_c099_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_14 (mix_i_src_c099_2_14 0 bpf_c099_2 0) vcvs gain=8.314696123025e-01
SMIXI_c099_2_14 (mix_i_src_c099_2_14 mix_i_c099_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_14 (mix_q_src_c099_2_14 0 bpf_c099_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_2_14 (mix_q_src_c099_2_14 mix_q_c099_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_2_15 (mix_i_src_c099_2_15 0 bpf_c099_2 0) vcvs gain=9.807852804032e-01
SMIXI_c099_2_15 (mix_i_src_c099_2_15 mix_i_c099_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_2_15 (mix_q_src_c099_2_15 0 bpf_c099_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_2_15 (mix_q_src_c099_2_15 mix_q_c099_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c099_2 (mix_i_c099_2 0) resistor r=1G
RMIXQ_c099_2 (mix_q_c099_2 0) resistor r=1G
RINTI_c099_2 (mix_i_c099_2 Icar_c099_2) resistor r=1k
CINTI_c099_2 (Icar_c099_2 0) capacitor c=80p
RINTQ_c099_2 (mix_q_c099_2 Qcar_c099_2) resistor r=1k
CINTQ_c099_2 (Qcar_c099_2 0) capacitor c=80p

// bl099, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c099_3 (bl099 n_cbpf_c099_3) capacitor c=2.533029591058e-14
LBPF_c099_3 (n_cbpf_c099_3 bpf_c099_3) inductor l=1.000000000000e-06
RBPF_c099_3 (bpf_c099_3 0) resistor r=3.141592653590e+02
EMIXI_c099_3_00 (mix_i_src_c099_3_00 0 bpf_c099_3 0) vcvs gain=9.807852804032e-01
SMIXI_c099_3_00 (mix_i_src_c099_3_00 mix_i_c099_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_00 (mix_q_src_c099_3_00 0 bpf_c099_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_3_00 (mix_q_src_c099_3_00 mix_q_c099_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_01 (mix_i_src_c099_3_01 0 bpf_c099_3 0) vcvs gain=8.314696123025e-01
SMIXI_c099_3_01 (mix_i_src_c099_3_01 mix_i_c099_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_01 (mix_q_src_c099_3_01 0 bpf_c099_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_3_01 (mix_q_src_c099_3_01 mix_q_c099_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_02 (mix_i_src_c099_3_02 0 bpf_c099_3 0) vcvs gain=5.555702330196e-01
SMIXI_c099_3_02 (mix_i_src_c099_3_02 mix_i_c099_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_02 (mix_q_src_c099_3_02 0 bpf_c099_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_3_02 (mix_q_src_c099_3_02 mix_q_c099_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_03 (mix_i_src_c099_3_03 0 bpf_c099_3 0) vcvs gain=1.950903220161e-01
SMIXI_c099_3_03 (mix_i_src_c099_3_03 mix_i_c099_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_03 (mix_q_src_c099_3_03 0 bpf_c099_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_3_03 (mix_q_src_c099_3_03 mix_q_c099_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_04 (mix_i_src_c099_3_04 0 bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_3_04 (mix_i_src_c099_3_04 mix_i_c099_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_04 (mix_q_src_c099_3_04 0 bpf_c099_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_3_04 (mix_q_src_c099_3_04 mix_q_c099_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_05 (mix_i_src_c099_3_05 0 bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_3_05 (mix_i_src_c099_3_05 mix_i_c099_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_05 (mix_q_src_c099_3_05 0 bpf_c099_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_3_05 (mix_q_src_c099_3_05 mix_q_c099_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_06 (mix_i_src_c099_3_06 0 bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_3_06 (mix_i_src_c099_3_06 mix_i_c099_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_06 (mix_q_src_c099_3_06 0 bpf_c099_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_3_06 (mix_q_src_c099_3_06 mix_q_c099_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_07 (mix_i_src_c099_3_07 0 bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_3_07 (mix_i_src_c099_3_07 mix_i_c099_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_07 (mix_q_src_c099_3_07 0 bpf_c099_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_3_07 (mix_q_src_c099_3_07 mix_q_c099_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_08 (mix_i_src_c099_3_08 0 bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_3_08 (mix_i_src_c099_3_08 mix_i_c099_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_08 (mix_q_src_c099_3_08 0 bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_3_08 (mix_q_src_c099_3_08 mix_q_c099_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_09 (mix_i_src_c099_3_09 0 bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_3_09 (mix_i_src_c099_3_09 mix_i_c099_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_09 (mix_q_src_c099_3_09 0 bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_3_09 (mix_q_src_c099_3_09 mix_q_c099_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_10 (mix_i_src_c099_3_10 0 bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_3_10 (mix_i_src_c099_3_10 mix_i_c099_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_10 (mix_q_src_c099_3_10 0 bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c099_3_10 (mix_q_src_c099_3_10 mix_q_c099_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_11 (mix_i_src_c099_3_11 0 bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_3_11 (mix_i_src_c099_3_11 mix_i_c099_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_11 (mix_q_src_c099_3_11 0 bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_3_11 (mix_q_src_c099_3_11 mix_q_c099_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_12 (mix_i_src_c099_3_12 0 bpf_c099_3 0) vcvs gain=1.950903220161e-01
SMIXI_c099_3_12 (mix_i_src_c099_3_12 mix_i_c099_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_12 (mix_q_src_c099_3_12 0 bpf_c099_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_3_12 (mix_q_src_c099_3_12 mix_q_c099_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_13 (mix_i_src_c099_3_13 0 bpf_c099_3 0) vcvs gain=5.555702330196e-01
SMIXI_c099_3_13 (mix_i_src_c099_3_13 mix_i_c099_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_13 (mix_q_src_c099_3_13 0 bpf_c099_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c099_3_13 (mix_q_src_c099_3_13 mix_q_c099_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_14 (mix_i_src_c099_3_14 0 bpf_c099_3 0) vcvs gain=8.314696123025e-01
SMIXI_c099_3_14 (mix_i_src_c099_3_14 mix_i_c099_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_14 (mix_q_src_c099_3_14 0 bpf_c099_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_3_14 (mix_q_src_c099_3_14 mix_q_c099_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_3_15 (mix_i_src_c099_3_15 0 bpf_c099_3 0) vcvs gain=9.807852804032e-01
SMIXI_c099_3_15 (mix_i_src_c099_3_15 mix_i_c099_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_3_15 (mix_q_src_c099_3_15 0 bpf_c099_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_3_15 (mix_q_src_c099_3_15 mix_q_c099_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c099_3 (mix_i_c099_3 0) resistor r=1G
RMIXQ_c099_3 (mix_q_c099_3 0) resistor r=1G
RINTI_c099_3 (mix_i_c099_3 Icar_c099_3) resistor r=1k
CINTI_c099_3 (Icar_c099_3 0) capacitor c=80p
RINTQ_c099_3 (mix_q_c099_3 Qcar_c099_3) resistor r=1k
CINTQ_c099_3 (Qcar_c099_3 0) capacitor c=80p

// bl100, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c100_0 (bl100 n_cbpf_c100_0) capacitor c=4.052847345694e-13
LBPF_c100_0 (n_cbpf_c100_0 bpf_c100_0) inductor l=1.000000000000e-06
RBPF_c100_0 (bpf_c100_0 0) resistor r=7.853981633974e+01
EMIXI_c100_0_00 (mix_i_src_c100_0_00 0 bpf_c100_0 0) vcvs gain=9.807852804032e-01
SMIXI_c100_0_00 (mix_i_src_c100_0_00 mix_i_c100_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_00 (mix_q_src_c100_0_00 0 bpf_c100_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_0_00 (mix_q_src_c100_0_00 mix_q_c100_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_01 (mix_i_src_c100_0_01 0 bpf_c100_0 0) vcvs gain=8.314696123025e-01
SMIXI_c100_0_01 (mix_i_src_c100_0_01 mix_i_c100_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_01 (mix_q_src_c100_0_01 0 bpf_c100_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_0_01 (mix_q_src_c100_0_01 mix_q_c100_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_02 (mix_i_src_c100_0_02 0 bpf_c100_0 0) vcvs gain=5.555702330196e-01
SMIXI_c100_0_02 (mix_i_src_c100_0_02 mix_i_c100_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_02 (mix_q_src_c100_0_02 0 bpf_c100_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_0_02 (mix_q_src_c100_0_02 mix_q_c100_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_03 (mix_i_src_c100_0_03 0 bpf_c100_0 0) vcvs gain=1.950903220161e-01
SMIXI_c100_0_03 (mix_i_src_c100_0_03 mix_i_c100_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_03 (mix_q_src_c100_0_03 0 bpf_c100_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_0_03 (mix_q_src_c100_0_03 mix_q_c100_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_04 (mix_i_src_c100_0_04 0 bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_0_04 (mix_i_src_c100_0_04 mix_i_c100_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_04 (mix_q_src_c100_0_04 0 bpf_c100_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_0_04 (mix_q_src_c100_0_04 mix_q_c100_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_05 (mix_i_src_c100_0_05 0 bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_0_05 (mix_i_src_c100_0_05 mix_i_c100_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_05 (mix_q_src_c100_0_05 0 bpf_c100_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_0_05 (mix_q_src_c100_0_05 mix_q_c100_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_06 (mix_i_src_c100_0_06 0 bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_0_06 (mix_i_src_c100_0_06 mix_i_c100_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_06 (mix_q_src_c100_0_06 0 bpf_c100_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_0_06 (mix_q_src_c100_0_06 mix_q_c100_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_07 (mix_i_src_c100_0_07 0 bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_0_07 (mix_i_src_c100_0_07 mix_i_c100_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_07 (mix_q_src_c100_0_07 0 bpf_c100_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_0_07 (mix_q_src_c100_0_07 mix_q_c100_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_08 (mix_i_src_c100_0_08 0 bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_0_08 (mix_i_src_c100_0_08 mix_i_c100_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_08 (mix_q_src_c100_0_08 0 bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_0_08 (mix_q_src_c100_0_08 mix_q_c100_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_09 (mix_i_src_c100_0_09 0 bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_0_09 (mix_i_src_c100_0_09 mix_i_c100_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_09 (mix_q_src_c100_0_09 0 bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_0_09 (mix_q_src_c100_0_09 mix_q_c100_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_10 (mix_i_src_c100_0_10 0 bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_0_10 (mix_i_src_c100_0_10 mix_i_c100_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_10 (mix_q_src_c100_0_10 0 bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_0_10 (mix_q_src_c100_0_10 mix_q_c100_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_11 (mix_i_src_c100_0_11 0 bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_0_11 (mix_i_src_c100_0_11 mix_i_c100_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_11 (mix_q_src_c100_0_11 0 bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_0_11 (mix_q_src_c100_0_11 mix_q_c100_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_12 (mix_i_src_c100_0_12 0 bpf_c100_0 0) vcvs gain=1.950903220161e-01
SMIXI_c100_0_12 (mix_i_src_c100_0_12 mix_i_c100_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_12 (mix_q_src_c100_0_12 0 bpf_c100_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_0_12 (mix_q_src_c100_0_12 mix_q_c100_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_13 (mix_i_src_c100_0_13 0 bpf_c100_0 0) vcvs gain=5.555702330196e-01
SMIXI_c100_0_13 (mix_i_src_c100_0_13 mix_i_c100_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_13 (mix_q_src_c100_0_13 0 bpf_c100_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_0_13 (mix_q_src_c100_0_13 mix_q_c100_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_14 (mix_i_src_c100_0_14 0 bpf_c100_0 0) vcvs gain=8.314696123025e-01
SMIXI_c100_0_14 (mix_i_src_c100_0_14 mix_i_c100_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_14 (mix_q_src_c100_0_14 0 bpf_c100_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_0_14 (mix_q_src_c100_0_14 mix_q_c100_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_0_15 (mix_i_src_c100_0_15 0 bpf_c100_0 0) vcvs gain=9.807852804032e-01
SMIXI_c100_0_15 (mix_i_src_c100_0_15 mix_i_c100_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_0_15 (mix_q_src_c100_0_15 0 bpf_c100_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_0_15 (mix_q_src_c100_0_15 mix_q_c100_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c100_0 (mix_i_c100_0 0) resistor r=1G
RMIXQ_c100_0 (mix_q_c100_0 0) resistor r=1G
RINTI_c100_0 (mix_i_c100_0 Icar_c100_0) resistor r=1k
CINTI_c100_0 (Icar_c100_0 0) capacitor c=80p
RINTQ_c100_0 (mix_q_c100_0 Qcar_c100_0) resistor r=1k
CINTQ_c100_0 (Qcar_c100_0 0) capacitor c=80p

// bl100, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c100_1 (bl100 n_cbpf_c100_1) capacitor c=1.013211836423e-13
LBPF_c100_1 (n_cbpf_c100_1 bpf_c100_1) inductor l=1.000000000000e-06
RBPF_c100_1 (bpf_c100_1 0) resistor r=1.570796326795e+02
EMIXI_c100_1_00 (mix_i_src_c100_1_00 0 bpf_c100_1 0) vcvs gain=9.807852804032e-01
SMIXI_c100_1_00 (mix_i_src_c100_1_00 mix_i_c100_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_00 (mix_q_src_c100_1_00 0 bpf_c100_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_1_00 (mix_q_src_c100_1_00 mix_q_c100_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_01 (mix_i_src_c100_1_01 0 bpf_c100_1 0) vcvs gain=8.314696123025e-01
SMIXI_c100_1_01 (mix_i_src_c100_1_01 mix_i_c100_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_01 (mix_q_src_c100_1_01 0 bpf_c100_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_1_01 (mix_q_src_c100_1_01 mix_q_c100_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_02 (mix_i_src_c100_1_02 0 bpf_c100_1 0) vcvs gain=5.555702330196e-01
SMIXI_c100_1_02 (mix_i_src_c100_1_02 mix_i_c100_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_02 (mix_q_src_c100_1_02 0 bpf_c100_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_1_02 (mix_q_src_c100_1_02 mix_q_c100_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_03 (mix_i_src_c100_1_03 0 bpf_c100_1 0) vcvs gain=1.950903220161e-01
SMIXI_c100_1_03 (mix_i_src_c100_1_03 mix_i_c100_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_03 (mix_q_src_c100_1_03 0 bpf_c100_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_1_03 (mix_q_src_c100_1_03 mix_q_c100_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_04 (mix_i_src_c100_1_04 0 bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_1_04 (mix_i_src_c100_1_04 mix_i_c100_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_04 (mix_q_src_c100_1_04 0 bpf_c100_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_1_04 (mix_q_src_c100_1_04 mix_q_c100_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_05 (mix_i_src_c100_1_05 0 bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_1_05 (mix_i_src_c100_1_05 mix_i_c100_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_05 (mix_q_src_c100_1_05 0 bpf_c100_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_1_05 (mix_q_src_c100_1_05 mix_q_c100_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_06 (mix_i_src_c100_1_06 0 bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_1_06 (mix_i_src_c100_1_06 mix_i_c100_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_06 (mix_q_src_c100_1_06 0 bpf_c100_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_1_06 (mix_q_src_c100_1_06 mix_q_c100_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_07 (mix_i_src_c100_1_07 0 bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_1_07 (mix_i_src_c100_1_07 mix_i_c100_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_07 (mix_q_src_c100_1_07 0 bpf_c100_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_1_07 (mix_q_src_c100_1_07 mix_q_c100_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_08 (mix_i_src_c100_1_08 0 bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_1_08 (mix_i_src_c100_1_08 mix_i_c100_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_08 (mix_q_src_c100_1_08 0 bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_1_08 (mix_q_src_c100_1_08 mix_q_c100_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_09 (mix_i_src_c100_1_09 0 bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_1_09 (mix_i_src_c100_1_09 mix_i_c100_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_09 (mix_q_src_c100_1_09 0 bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_1_09 (mix_q_src_c100_1_09 mix_q_c100_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_10 (mix_i_src_c100_1_10 0 bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_1_10 (mix_i_src_c100_1_10 mix_i_c100_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_10 (mix_q_src_c100_1_10 0 bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_1_10 (mix_q_src_c100_1_10 mix_q_c100_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_11 (mix_i_src_c100_1_11 0 bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_1_11 (mix_i_src_c100_1_11 mix_i_c100_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_11 (mix_q_src_c100_1_11 0 bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_1_11 (mix_q_src_c100_1_11 mix_q_c100_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_12 (mix_i_src_c100_1_12 0 bpf_c100_1 0) vcvs gain=1.950903220161e-01
SMIXI_c100_1_12 (mix_i_src_c100_1_12 mix_i_c100_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_12 (mix_q_src_c100_1_12 0 bpf_c100_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_1_12 (mix_q_src_c100_1_12 mix_q_c100_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_13 (mix_i_src_c100_1_13 0 bpf_c100_1 0) vcvs gain=5.555702330196e-01
SMIXI_c100_1_13 (mix_i_src_c100_1_13 mix_i_c100_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_13 (mix_q_src_c100_1_13 0 bpf_c100_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_1_13 (mix_q_src_c100_1_13 mix_q_c100_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_14 (mix_i_src_c100_1_14 0 bpf_c100_1 0) vcvs gain=8.314696123025e-01
SMIXI_c100_1_14 (mix_i_src_c100_1_14 mix_i_c100_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_14 (mix_q_src_c100_1_14 0 bpf_c100_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_1_14 (mix_q_src_c100_1_14 mix_q_c100_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_1_15 (mix_i_src_c100_1_15 0 bpf_c100_1 0) vcvs gain=9.807852804032e-01
SMIXI_c100_1_15 (mix_i_src_c100_1_15 mix_i_c100_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_1_15 (mix_q_src_c100_1_15 0 bpf_c100_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_1_15 (mix_q_src_c100_1_15 mix_q_c100_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c100_1 (mix_i_c100_1 0) resistor r=1G
RMIXQ_c100_1 (mix_q_c100_1 0) resistor r=1G
RINTI_c100_1 (mix_i_c100_1 Icar_c100_1) resistor r=1k
CINTI_c100_1 (Icar_c100_1 0) capacitor c=80p
RINTQ_c100_1 (mix_q_c100_1 Qcar_c100_1) resistor r=1k
CINTQ_c100_1 (Qcar_c100_1 0) capacitor c=80p

// bl100, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c100_2 (bl100 n_cbpf_c100_2) capacitor c=4.503163717437e-14
LBPF_c100_2 (n_cbpf_c100_2 bpf_c100_2) inductor l=1.000000000000e-06
RBPF_c100_2 (bpf_c100_2 0) resistor r=2.356194490192e+02
EMIXI_c100_2_00 (mix_i_src_c100_2_00 0 bpf_c100_2 0) vcvs gain=9.807852804032e-01
SMIXI_c100_2_00 (mix_i_src_c100_2_00 mix_i_c100_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_00 (mix_q_src_c100_2_00 0 bpf_c100_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_2_00 (mix_q_src_c100_2_00 mix_q_c100_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_01 (mix_i_src_c100_2_01 0 bpf_c100_2 0) vcvs gain=8.314696123025e-01
SMIXI_c100_2_01 (mix_i_src_c100_2_01 mix_i_c100_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_01 (mix_q_src_c100_2_01 0 bpf_c100_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_2_01 (mix_q_src_c100_2_01 mix_q_c100_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_02 (mix_i_src_c100_2_02 0 bpf_c100_2 0) vcvs gain=5.555702330196e-01
SMIXI_c100_2_02 (mix_i_src_c100_2_02 mix_i_c100_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_02 (mix_q_src_c100_2_02 0 bpf_c100_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_2_02 (mix_q_src_c100_2_02 mix_q_c100_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_03 (mix_i_src_c100_2_03 0 bpf_c100_2 0) vcvs gain=1.950903220161e-01
SMIXI_c100_2_03 (mix_i_src_c100_2_03 mix_i_c100_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_03 (mix_q_src_c100_2_03 0 bpf_c100_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_2_03 (mix_q_src_c100_2_03 mix_q_c100_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_04 (mix_i_src_c100_2_04 0 bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_2_04 (mix_i_src_c100_2_04 mix_i_c100_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_04 (mix_q_src_c100_2_04 0 bpf_c100_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_2_04 (mix_q_src_c100_2_04 mix_q_c100_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_05 (mix_i_src_c100_2_05 0 bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_2_05 (mix_i_src_c100_2_05 mix_i_c100_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_05 (mix_q_src_c100_2_05 0 bpf_c100_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_2_05 (mix_q_src_c100_2_05 mix_q_c100_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_06 (mix_i_src_c100_2_06 0 bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_2_06 (mix_i_src_c100_2_06 mix_i_c100_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_06 (mix_q_src_c100_2_06 0 bpf_c100_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_2_06 (mix_q_src_c100_2_06 mix_q_c100_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_07 (mix_i_src_c100_2_07 0 bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_2_07 (mix_i_src_c100_2_07 mix_i_c100_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_07 (mix_q_src_c100_2_07 0 bpf_c100_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_2_07 (mix_q_src_c100_2_07 mix_q_c100_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_08 (mix_i_src_c100_2_08 0 bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_2_08 (mix_i_src_c100_2_08 mix_i_c100_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_08 (mix_q_src_c100_2_08 0 bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_2_08 (mix_q_src_c100_2_08 mix_q_c100_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_09 (mix_i_src_c100_2_09 0 bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_2_09 (mix_i_src_c100_2_09 mix_i_c100_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_09 (mix_q_src_c100_2_09 0 bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_2_09 (mix_q_src_c100_2_09 mix_q_c100_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_10 (mix_i_src_c100_2_10 0 bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_2_10 (mix_i_src_c100_2_10 mix_i_c100_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_10 (mix_q_src_c100_2_10 0 bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_2_10 (mix_q_src_c100_2_10 mix_q_c100_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_11 (mix_i_src_c100_2_11 0 bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_2_11 (mix_i_src_c100_2_11 mix_i_c100_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_11 (mix_q_src_c100_2_11 0 bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_2_11 (mix_q_src_c100_2_11 mix_q_c100_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_12 (mix_i_src_c100_2_12 0 bpf_c100_2 0) vcvs gain=1.950903220161e-01
SMIXI_c100_2_12 (mix_i_src_c100_2_12 mix_i_c100_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_12 (mix_q_src_c100_2_12 0 bpf_c100_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_2_12 (mix_q_src_c100_2_12 mix_q_c100_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_13 (mix_i_src_c100_2_13 0 bpf_c100_2 0) vcvs gain=5.555702330196e-01
SMIXI_c100_2_13 (mix_i_src_c100_2_13 mix_i_c100_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_13 (mix_q_src_c100_2_13 0 bpf_c100_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_2_13 (mix_q_src_c100_2_13 mix_q_c100_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_14 (mix_i_src_c100_2_14 0 bpf_c100_2 0) vcvs gain=8.314696123025e-01
SMIXI_c100_2_14 (mix_i_src_c100_2_14 mix_i_c100_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_14 (mix_q_src_c100_2_14 0 bpf_c100_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_2_14 (mix_q_src_c100_2_14 mix_q_c100_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_2_15 (mix_i_src_c100_2_15 0 bpf_c100_2 0) vcvs gain=9.807852804032e-01
SMIXI_c100_2_15 (mix_i_src_c100_2_15 mix_i_c100_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_2_15 (mix_q_src_c100_2_15 0 bpf_c100_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_2_15 (mix_q_src_c100_2_15 mix_q_c100_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c100_2 (mix_i_c100_2 0) resistor r=1G
RMIXQ_c100_2 (mix_q_c100_2 0) resistor r=1G
RINTI_c100_2 (mix_i_c100_2 Icar_c100_2) resistor r=1k
CINTI_c100_2 (Icar_c100_2 0) capacitor c=80p
RINTQ_c100_2 (mix_q_c100_2 Qcar_c100_2) resistor r=1k
CINTQ_c100_2 (Qcar_c100_2 0) capacitor c=80p

// bl100, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c100_3 (bl100 n_cbpf_c100_3) capacitor c=2.533029591058e-14
LBPF_c100_3 (n_cbpf_c100_3 bpf_c100_3) inductor l=1.000000000000e-06
RBPF_c100_3 (bpf_c100_3 0) resistor r=3.141592653590e+02
EMIXI_c100_3_00 (mix_i_src_c100_3_00 0 bpf_c100_3 0) vcvs gain=9.807852804032e-01
SMIXI_c100_3_00 (mix_i_src_c100_3_00 mix_i_c100_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_00 (mix_q_src_c100_3_00 0 bpf_c100_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_3_00 (mix_q_src_c100_3_00 mix_q_c100_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_01 (mix_i_src_c100_3_01 0 bpf_c100_3 0) vcvs gain=8.314696123025e-01
SMIXI_c100_3_01 (mix_i_src_c100_3_01 mix_i_c100_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_01 (mix_q_src_c100_3_01 0 bpf_c100_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_3_01 (mix_q_src_c100_3_01 mix_q_c100_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_02 (mix_i_src_c100_3_02 0 bpf_c100_3 0) vcvs gain=5.555702330196e-01
SMIXI_c100_3_02 (mix_i_src_c100_3_02 mix_i_c100_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_02 (mix_q_src_c100_3_02 0 bpf_c100_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_3_02 (mix_q_src_c100_3_02 mix_q_c100_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_03 (mix_i_src_c100_3_03 0 bpf_c100_3 0) vcvs gain=1.950903220161e-01
SMIXI_c100_3_03 (mix_i_src_c100_3_03 mix_i_c100_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_03 (mix_q_src_c100_3_03 0 bpf_c100_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_3_03 (mix_q_src_c100_3_03 mix_q_c100_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_04 (mix_i_src_c100_3_04 0 bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_3_04 (mix_i_src_c100_3_04 mix_i_c100_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_04 (mix_q_src_c100_3_04 0 bpf_c100_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c100_3_04 (mix_q_src_c100_3_04 mix_q_c100_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_05 (mix_i_src_c100_3_05 0 bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_3_05 (mix_i_src_c100_3_05 mix_i_c100_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_05 (mix_q_src_c100_3_05 0 bpf_c100_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c100_3_05 (mix_q_src_c100_3_05 mix_q_c100_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_06 (mix_i_src_c100_3_06 0 bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_3_06 (mix_i_src_c100_3_06 mix_i_c100_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_06 (mix_q_src_c100_3_06 0 bpf_c100_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c100_3_06 (mix_q_src_c100_3_06 mix_q_c100_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_07 (mix_i_src_c100_3_07 0 bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_3_07 (mix_i_src_c100_3_07 mix_i_c100_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_07 (mix_q_src_c100_3_07 0 bpf_c100_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c100_3_07 (mix_q_src_c100_3_07 mix_q_c100_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_08 (mix_i_src_c100_3_08 0 bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c100_3_08 (mix_i_src_c100_3_08 mix_i_c100_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_08 (mix_q_src_c100_3_08 0 bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_3_08 (mix_q_src_c100_3_08 mix_q_c100_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_09 (mix_i_src_c100_3_09 0 bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c100_3_09 (mix_i_src_c100_3_09 mix_i_c100_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_09 (mix_q_src_c100_3_09 0 bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_3_09 (mix_q_src_c100_3_09 mix_q_c100_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_10 (mix_i_src_c100_3_10 0 bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c100_3_10 (mix_i_src_c100_3_10 mix_i_c100_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_10 (mix_q_src_c100_3_10 0 bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_3_10 (mix_q_src_c100_3_10 mix_q_c100_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_11 (mix_i_src_c100_3_11 0 bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c100_3_11 (mix_i_src_c100_3_11 mix_i_c100_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_11 (mix_q_src_c100_3_11 0 bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_3_11 (mix_q_src_c100_3_11 mix_q_c100_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_12 (mix_i_src_c100_3_12 0 bpf_c100_3 0) vcvs gain=1.950903220161e-01
SMIXI_c100_3_12 (mix_i_src_c100_3_12 mix_i_c100_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_12 (mix_q_src_c100_3_12 0 bpf_c100_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c100_3_12 (mix_q_src_c100_3_12 mix_q_c100_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_13 (mix_i_src_c100_3_13 0 bpf_c100_3 0) vcvs gain=5.555702330196e-01
SMIXI_c100_3_13 (mix_i_src_c100_3_13 mix_i_c100_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_13 (mix_q_src_c100_3_13 0 bpf_c100_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c100_3_13 (mix_q_src_c100_3_13 mix_q_c100_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_14 (mix_i_src_c100_3_14 0 bpf_c100_3 0) vcvs gain=8.314696123025e-01
SMIXI_c100_3_14 (mix_i_src_c100_3_14 mix_i_c100_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_14 (mix_q_src_c100_3_14 0 bpf_c100_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c100_3_14 (mix_q_src_c100_3_14 mix_q_c100_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c100_3_15 (mix_i_src_c100_3_15 0 bpf_c100_3 0) vcvs gain=9.807852804032e-01
SMIXI_c100_3_15 (mix_i_src_c100_3_15 mix_i_c100_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c100_3_15 (mix_q_src_c100_3_15 0 bpf_c100_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c100_3_15 (mix_q_src_c100_3_15 mix_q_c100_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c100_3 (mix_i_c100_3 0) resistor r=1G
RMIXQ_c100_3 (mix_q_c100_3 0) resistor r=1G
RINTI_c100_3 (mix_i_c100_3 Icar_c100_3) resistor r=1k
CINTI_c100_3 (Icar_c100_3 0) capacitor c=80p
RINTQ_c100_3 (mix_q_c100_3 Qcar_c100_3) resistor r=1k
CINTQ_c100_3 (Qcar_c100_3 0) capacitor c=80p

// bl101, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c101_0 (bl101 n_cbpf_c101_0) capacitor c=4.052847345694e-13
LBPF_c101_0 (n_cbpf_c101_0 bpf_c101_0) inductor l=1.000000000000e-06
RBPF_c101_0 (bpf_c101_0 0) resistor r=7.853981633974e+01
EMIXI_c101_0_00 (mix_i_src_c101_0_00 0 bpf_c101_0 0) vcvs gain=9.807852804032e-01
SMIXI_c101_0_00 (mix_i_src_c101_0_00 mix_i_c101_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_00 (mix_q_src_c101_0_00 0 bpf_c101_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_0_00 (mix_q_src_c101_0_00 mix_q_c101_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_01 (mix_i_src_c101_0_01 0 bpf_c101_0 0) vcvs gain=8.314696123025e-01
SMIXI_c101_0_01 (mix_i_src_c101_0_01 mix_i_c101_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_01 (mix_q_src_c101_0_01 0 bpf_c101_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_0_01 (mix_q_src_c101_0_01 mix_q_c101_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_02 (mix_i_src_c101_0_02 0 bpf_c101_0 0) vcvs gain=5.555702330196e-01
SMIXI_c101_0_02 (mix_i_src_c101_0_02 mix_i_c101_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_02 (mix_q_src_c101_0_02 0 bpf_c101_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_0_02 (mix_q_src_c101_0_02 mix_q_c101_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_03 (mix_i_src_c101_0_03 0 bpf_c101_0 0) vcvs gain=1.950903220161e-01
SMIXI_c101_0_03 (mix_i_src_c101_0_03 mix_i_c101_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_03 (mix_q_src_c101_0_03 0 bpf_c101_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_0_03 (mix_q_src_c101_0_03 mix_q_c101_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_04 (mix_i_src_c101_0_04 0 bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_0_04 (mix_i_src_c101_0_04 mix_i_c101_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_04 (mix_q_src_c101_0_04 0 bpf_c101_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_0_04 (mix_q_src_c101_0_04 mix_q_c101_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_05 (mix_i_src_c101_0_05 0 bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_0_05 (mix_i_src_c101_0_05 mix_i_c101_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_05 (mix_q_src_c101_0_05 0 bpf_c101_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_0_05 (mix_q_src_c101_0_05 mix_q_c101_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_06 (mix_i_src_c101_0_06 0 bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_0_06 (mix_i_src_c101_0_06 mix_i_c101_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_06 (mix_q_src_c101_0_06 0 bpf_c101_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_0_06 (mix_q_src_c101_0_06 mix_q_c101_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_07 (mix_i_src_c101_0_07 0 bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_0_07 (mix_i_src_c101_0_07 mix_i_c101_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_07 (mix_q_src_c101_0_07 0 bpf_c101_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_0_07 (mix_q_src_c101_0_07 mix_q_c101_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_08 (mix_i_src_c101_0_08 0 bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_0_08 (mix_i_src_c101_0_08 mix_i_c101_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_08 (mix_q_src_c101_0_08 0 bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_0_08 (mix_q_src_c101_0_08 mix_q_c101_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_09 (mix_i_src_c101_0_09 0 bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_0_09 (mix_i_src_c101_0_09 mix_i_c101_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_09 (mix_q_src_c101_0_09 0 bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_0_09 (mix_q_src_c101_0_09 mix_q_c101_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_10 (mix_i_src_c101_0_10 0 bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_0_10 (mix_i_src_c101_0_10 mix_i_c101_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_10 (mix_q_src_c101_0_10 0 bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_0_10 (mix_q_src_c101_0_10 mix_q_c101_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_11 (mix_i_src_c101_0_11 0 bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_0_11 (mix_i_src_c101_0_11 mix_i_c101_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_11 (mix_q_src_c101_0_11 0 bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_0_11 (mix_q_src_c101_0_11 mix_q_c101_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_12 (mix_i_src_c101_0_12 0 bpf_c101_0 0) vcvs gain=1.950903220161e-01
SMIXI_c101_0_12 (mix_i_src_c101_0_12 mix_i_c101_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_12 (mix_q_src_c101_0_12 0 bpf_c101_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_0_12 (mix_q_src_c101_0_12 mix_q_c101_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_13 (mix_i_src_c101_0_13 0 bpf_c101_0 0) vcvs gain=5.555702330196e-01
SMIXI_c101_0_13 (mix_i_src_c101_0_13 mix_i_c101_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_13 (mix_q_src_c101_0_13 0 bpf_c101_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_0_13 (mix_q_src_c101_0_13 mix_q_c101_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_14 (mix_i_src_c101_0_14 0 bpf_c101_0 0) vcvs gain=8.314696123025e-01
SMIXI_c101_0_14 (mix_i_src_c101_0_14 mix_i_c101_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_14 (mix_q_src_c101_0_14 0 bpf_c101_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_0_14 (mix_q_src_c101_0_14 mix_q_c101_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_0_15 (mix_i_src_c101_0_15 0 bpf_c101_0 0) vcvs gain=9.807852804032e-01
SMIXI_c101_0_15 (mix_i_src_c101_0_15 mix_i_c101_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_0_15 (mix_q_src_c101_0_15 0 bpf_c101_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_0_15 (mix_q_src_c101_0_15 mix_q_c101_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c101_0 (mix_i_c101_0 0) resistor r=1G
RMIXQ_c101_0 (mix_q_c101_0 0) resistor r=1G
RINTI_c101_0 (mix_i_c101_0 Icar_c101_0) resistor r=1k
CINTI_c101_0 (Icar_c101_0 0) capacitor c=80p
RINTQ_c101_0 (mix_q_c101_0 Qcar_c101_0) resistor r=1k
CINTQ_c101_0 (Qcar_c101_0 0) capacitor c=80p

// bl101, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c101_1 (bl101 n_cbpf_c101_1) capacitor c=1.013211836423e-13
LBPF_c101_1 (n_cbpf_c101_1 bpf_c101_1) inductor l=1.000000000000e-06
RBPF_c101_1 (bpf_c101_1 0) resistor r=1.570796326795e+02
EMIXI_c101_1_00 (mix_i_src_c101_1_00 0 bpf_c101_1 0) vcvs gain=9.807852804032e-01
SMIXI_c101_1_00 (mix_i_src_c101_1_00 mix_i_c101_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_00 (mix_q_src_c101_1_00 0 bpf_c101_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_1_00 (mix_q_src_c101_1_00 mix_q_c101_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_01 (mix_i_src_c101_1_01 0 bpf_c101_1 0) vcvs gain=8.314696123025e-01
SMIXI_c101_1_01 (mix_i_src_c101_1_01 mix_i_c101_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_01 (mix_q_src_c101_1_01 0 bpf_c101_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_1_01 (mix_q_src_c101_1_01 mix_q_c101_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_02 (mix_i_src_c101_1_02 0 bpf_c101_1 0) vcvs gain=5.555702330196e-01
SMIXI_c101_1_02 (mix_i_src_c101_1_02 mix_i_c101_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_02 (mix_q_src_c101_1_02 0 bpf_c101_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_1_02 (mix_q_src_c101_1_02 mix_q_c101_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_03 (mix_i_src_c101_1_03 0 bpf_c101_1 0) vcvs gain=1.950903220161e-01
SMIXI_c101_1_03 (mix_i_src_c101_1_03 mix_i_c101_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_03 (mix_q_src_c101_1_03 0 bpf_c101_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_1_03 (mix_q_src_c101_1_03 mix_q_c101_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_04 (mix_i_src_c101_1_04 0 bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_1_04 (mix_i_src_c101_1_04 mix_i_c101_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_04 (mix_q_src_c101_1_04 0 bpf_c101_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_1_04 (mix_q_src_c101_1_04 mix_q_c101_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_05 (mix_i_src_c101_1_05 0 bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_1_05 (mix_i_src_c101_1_05 mix_i_c101_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_05 (mix_q_src_c101_1_05 0 bpf_c101_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_1_05 (mix_q_src_c101_1_05 mix_q_c101_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_06 (mix_i_src_c101_1_06 0 bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_1_06 (mix_i_src_c101_1_06 mix_i_c101_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_06 (mix_q_src_c101_1_06 0 bpf_c101_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_1_06 (mix_q_src_c101_1_06 mix_q_c101_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_07 (mix_i_src_c101_1_07 0 bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_1_07 (mix_i_src_c101_1_07 mix_i_c101_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_07 (mix_q_src_c101_1_07 0 bpf_c101_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_1_07 (mix_q_src_c101_1_07 mix_q_c101_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_08 (mix_i_src_c101_1_08 0 bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_1_08 (mix_i_src_c101_1_08 mix_i_c101_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_08 (mix_q_src_c101_1_08 0 bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_1_08 (mix_q_src_c101_1_08 mix_q_c101_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_09 (mix_i_src_c101_1_09 0 bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_1_09 (mix_i_src_c101_1_09 mix_i_c101_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_09 (mix_q_src_c101_1_09 0 bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_1_09 (mix_q_src_c101_1_09 mix_q_c101_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_10 (mix_i_src_c101_1_10 0 bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_1_10 (mix_i_src_c101_1_10 mix_i_c101_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_10 (mix_q_src_c101_1_10 0 bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_1_10 (mix_q_src_c101_1_10 mix_q_c101_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_11 (mix_i_src_c101_1_11 0 bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_1_11 (mix_i_src_c101_1_11 mix_i_c101_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_11 (mix_q_src_c101_1_11 0 bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_1_11 (mix_q_src_c101_1_11 mix_q_c101_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_12 (mix_i_src_c101_1_12 0 bpf_c101_1 0) vcvs gain=1.950903220161e-01
SMIXI_c101_1_12 (mix_i_src_c101_1_12 mix_i_c101_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_12 (mix_q_src_c101_1_12 0 bpf_c101_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_1_12 (mix_q_src_c101_1_12 mix_q_c101_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_13 (mix_i_src_c101_1_13 0 bpf_c101_1 0) vcvs gain=5.555702330196e-01
SMIXI_c101_1_13 (mix_i_src_c101_1_13 mix_i_c101_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_13 (mix_q_src_c101_1_13 0 bpf_c101_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_1_13 (mix_q_src_c101_1_13 mix_q_c101_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_14 (mix_i_src_c101_1_14 0 bpf_c101_1 0) vcvs gain=8.314696123025e-01
SMIXI_c101_1_14 (mix_i_src_c101_1_14 mix_i_c101_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_14 (mix_q_src_c101_1_14 0 bpf_c101_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_1_14 (mix_q_src_c101_1_14 mix_q_c101_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_1_15 (mix_i_src_c101_1_15 0 bpf_c101_1 0) vcvs gain=9.807852804032e-01
SMIXI_c101_1_15 (mix_i_src_c101_1_15 mix_i_c101_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_1_15 (mix_q_src_c101_1_15 0 bpf_c101_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_1_15 (mix_q_src_c101_1_15 mix_q_c101_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c101_1 (mix_i_c101_1 0) resistor r=1G
RMIXQ_c101_1 (mix_q_c101_1 0) resistor r=1G
RINTI_c101_1 (mix_i_c101_1 Icar_c101_1) resistor r=1k
CINTI_c101_1 (Icar_c101_1 0) capacitor c=80p
RINTQ_c101_1 (mix_q_c101_1 Qcar_c101_1) resistor r=1k
CINTQ_c101_1 (Qcar_c101_1 0) capacitor c=80p

// bl101, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c101_2 (bl101 n_cbpf_c101_2) capacitor c=4.503163717437e-14
LBPF_c101_2 (n_cbpf_c101_2 bpf_c101_2) inductor l=1.000000000000e-06
RBPF_c101_2 (bpf_c101_2 0) resistor r=2.356194490192e+02
EMIXI_c101_2_00 (mix_i_src_c101_2_00 0 bpf_c101_2 0) vcvs gain=9.807852804032e-01
SMIXI_c101_2_00 (mix_i_src_c101_2_00 mix_i_c101_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_00 (mix_q_src_c101_2_00 0 bpf_c101_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_2_00 (mix_q_src_c101_2_00 mix_q_c101_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_01 (mix_i_src_c101_2_01 0 bpf_c101_2 0) vcvs gain=8.314696123025e-01
SMIXI_c101_2_01 (mix_i_src_c101_2_01 mix_i_c101_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_01 (mix_q_src_c101_2_01 0 bpf_c101_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_2_01 (mix_q_src_c101_2_01 mix_q_c101_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_02 (mix_i_src_c101_2_02 0 bpf_c101_2 0) vcvs gain=5.555702330196e-01
SMIXI_c101_2_02 (mix_i_src_c101_2_02 mix_i_c101_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_02 (mix_q_src_c101_2_02 0 bpf_c101_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_2_02 (mix_q_src_c101_2_02 mix_q_c101_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_03 (mix_i_src_c101_2_03 0 bpf_c101_2 0) vcvs gain=1.950903220161e-01
SMIXI_c101_2_03 (mix_i_src_c101_2_03 mix_i_c101_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_03 (mix_q_src_c101_2_03 0 bpf_c101_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_2_03 (mix_q_src_c101_2_03 mix_q_c101_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_04 (mix_i_src_c101_2_04 0 bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_2_04 (mix_i_src_c101_2_04 mix_i_c101_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_04 (mix_q_src_c101_2_04 0 bpf_c101_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_2_04 (mix_q_src_c101_2_04 mix_q_c101_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_05 (mix_i_src_c101_2_05 0 bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_2_05 (mix_i_src_c101_2_05 mix_i_c101_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_05 (mix_q_src_c101_2_05 0 bpf_c101_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_2_05 (mix_q_src_c101_2_05 mix_q_c101_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_06 (mix_i_src_c101_2_06 0 bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_2_06 (mix_i_src_c101_2_06 mix_i_c101_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_06 (mix_q_src_c101_2_06 0 bpf_c101_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_2_06 (mix_q_src_c101_2_06 mix_q_c101_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_07 (mix_i_src_c101_2_07 0 bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_2_07 (mix_i_src_c101_2_07 mix_i_c101_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_07 (mix_q_src_c101_2_07 0 bpf_c101_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_2_07 (mix_q_src_c101_2_07 mix_q_c101_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_08 (mix_i_src_c101_2_08 0 bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_2_08 (mix_i_src_c101_2_08 mix_i_c101_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_08 (mix_q_src_c101_2_08 0 bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_2_08 (mix_q_src_c101_2_08 mix_q_c101_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_09 (mix_i_src_c101_2_09 0 bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_2_09 (mix_i_src_c101_2_09 mix_i_c101_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_09 (mix_q_src_c101_2_09 0 bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_2_09 (mix_q_src_c101_2_09 mix_q_c101_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_10 (mix_i_src_c101_2_10 0 bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_2_10 (mix_i_src_c101_2_10 mix_i_c101_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_10 (mix_q_src_c101_2_10 0 bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_2_10 (mix_q_src_c101_2_10 mix_q_c101_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_11 (mix_i_src_c101_2_11 0 bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_2_11 (mix_i_src_c101_2_11 mix_i_c101_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_11 (mix_q_src_c101_2_11 0 bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_2_11 (mix_q_src_c101_2_11 mix_q_c101_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_12 (mix_i_src_c101_2_12 0 bpf_c101_2 0) vcvs gain=1.950903220161e-01
SMIXI_c101_2_12 (mix_i_src_c101_2_12 mix_i_c101_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_12 (mix_q_src_c101_2_12 0 bpf_c101_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_2_12 (mix_q_src_c101_2_12 mix_q_c101_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_13 (mix_i_src_c101_2_13 0 bpf_c101_2 0) vcvs gain=5.555702330196e-01
SMIXI_c101_2_13 (mix_i_src_c101_2_13 mix_i_c101_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_13 (mix_q_src_c101_2_13 0 bpf_c101_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_2_13 (mix_q_src_c101_2_13 mix_q_c101_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_14 (mix_i_src_c101_2_14 0 bpf_c101_2 0) vcvs gain=8.314696123025e-01
SMIXI_c101_2_14 (mix_i_src_c101_2_14 mix_i_c101_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_14 (mix_q_src_c101_2_14 0 bpf_c101_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_2_14 (mix_q_src_c101_2_14 mix_q_c101_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_2_15 (mix_i_src_c101_2_15 0 bpf_c101_2 0) vcvs gain=9.807852804032e-01
SMIXI_c101_2_15 (mix_i_src_c101_2_15 mix_i_c101_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_2_15 (mix_q_src_c101_2_15 0 bpf_c101_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_2_15 (mix_q_src_c101_2_15 mix_q_c101_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c101_2 (mix_i_c101_2 0) resistor r=1G
RMIXQ_c101_2 (mix_q_c101_2 0) resistor r=1G
RINTI_c101_2 (mix_i_c101_2 Icar_c101_2) resistor r=1k
CINTI_c101_2 (Icar_c101_2 0) capacitor c=80p
RINTQ_c101_2 (mix_q_c101_2 Qcar_c101_2) resistor r=1k
CINTQ_c101_2 (Qcar_c101_2 0) capacitor c=80p

// bl101, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c101_3 (bl101 n_cbpf_c101_3) capacitor c=2.533029591058e-14
LBPF_c101_3 (n_cbpf_c101_3 bpf_c101_3) inductor l=1.000000000000e-06
RBPF_c101_3 (bpf_c101_3 0) resistor r=3.141592653590e+02
EMIXI_c101_3_00 (mix_i_src_c101_3_00 0 bpf_c101_3 0) vcvs gain=9.807852804032e-01
SMIXI_c101_3_00 (mix_i_src_c101_3_00 mix_i_c101_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_00 (mix_q_src_c101_3_00 0 bpf_c101_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_3_00 (mix_q_src_c101_3_00 mix_q_c101_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_01 (mix_i_src_c101_3_01 0 bpf_c101_3 0) vcvs gain=8.314696123025e-01
SMIXI_c101_3_01 (mix_i_src_c101_3_01 mix_i_c101_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_01 (mix_q_src_c101_3_01 0 bpf_c101_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_3_01 (mix_q_src_c101_3_01 mix_q_c101_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_02 (mix_i_src_c101_3_02 0 bpf_c101_3 0) vcvs gain=5.555702330196e-01
SMIXI_c101_3_02 (mix_i_src_c101_3_02 mix_i_c101_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_02 (mix_q_src_c101_3_02 0 bpf_c101_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_3_02 (mix_q_src_c101_3_02 mix_q_c101_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_03 (mix_i_src_c101_3_03 0 bpf_c101_3 0) vcvs gain=1.950903220161e-01
SMIXI_c101_3_03 (mix_i_src_c101_3_03 mix_i_c101_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_03 (mix_q_src_c101_3_03 0 bpf_c101_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_3_03 (mix_q_src_c101_3_03 mix_q_c101_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_04 (mix_i_src_c101_3_04 0 bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_3_04 (mix_i_src_c101_3_04 mix_i_c101_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_04 (mix_q_src_c101_3_04 0 bpf_c101_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c101_3_04 (mix_q_src_c101_3_04 mix_q_c101_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_05 (mix_i_src_c101_3_05 0 bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_3_05 (mix_i_src_c101_3_05 mix_i_c101_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_05 (mix_q_src_c101_3_05 0 bpf_c101_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c101_3_05 (mix_q_src_c101_3_05 mix_q_c101_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_06 (mix_i_src_c101_3_06 0 bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_3_06 (mix_i_src_c101_3_06 mix_i_c101_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_06 (mix_q_src_c101_3_06 0 bpf_c101_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c101_3_06 (mix_q_src_c101_3_06 mix_q_c101_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_07 (mix_i_src_c101_3_07 0 bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_3_07 (mix_i_src_c101_3_07 mix_i_c101_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_07 (mix_q_src_c101_3_07 0 bpf_c101_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c101_3_07 (mix_q_src_c101_3_07 mix_q_c101_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_08 (mix_i_src_c101_3_08 0 bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c101_3_08 (mix_i_src_c101_3_08 mix_i_c101_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_08 (mix_q_src_c101_3_08 0 bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_3_08 (mix_q_src_c101_3_08 mix_q_c101_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_09 (mix_i_src_c101_3_09 0 bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c101_3_09 (mix_i_src_c101_3_09 mix_i_c101_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_09 (mix_q_src_c101_3_09 0 bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_3_09 (mix_q_src_c101_3_09 mix_q_c101_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_10 (mix_i_src_c101_3_10 0 bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c101_3_10 (mix_i_src_c101_3_10 mix_i_c101_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_10 (mix_q_src_c101_3_10 0 bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_3_10 (mix_q_src_c101_3_10 mix_q_c101_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_11 (mix_i_src_c101_3_11 0 bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c101_3_11 (mix_i_src_c101_3_11 mix_i_c101_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_11 (mix_q_src_c101_3_11 0 bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_3_11 (mix_q_src_c101_3_11 mix_q_c101_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_12 (mix_i_src_c101_3_12 0 bpf_c101_3 0) vcvs gain=1.950903220161e-01
SMIXI_c101_3_12 (mix_i_src_c101_3_12 mix_i_c101_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_12 (mix_q_src_c101_3_12 0 bpf_c101_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c101_3_12 (mix_q_src_c101_3_12 mix_q_c101_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_13 (mix_i_src_c101_3_13 0 bpf_c101_3 0) vcvs gain=5.555702330196e-01
SMIXI_c101_3_13 (mix_i_src_c101_3_13 mix_i_c101_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_13 (mix_q_src_c101_3_13 0 bpf_c101_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c101_3_13 (mix_q_src_c101_3_13 mix_q_c101_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_14 (mix_i_src_c101_3_14 0 bpf_c101_3 0) vcvs gain=8.314696123025e-01
SMIXI_c101_3_14 (mix_i_src_c101_3_14 mix_i_c101_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_14 (mix_q_src_c101_3_14 0 bpf_c101_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c101_3_14 (mix_q_src_c101_3_14 mix_q_c101_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c101_3_15 (mix_i_src_c101_3_15 0 bpf_c101_3 0) vcvs gain=9.807852804032e-01
SMIXI_c101_3_15 (mix_i_src_c101_3_15 mix_i_c101_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c101_3_15 (mix_q_src_c101_3_15 0 bpf_c101_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c101_3_15 (mix_q_src_c101_3_15 mix_q_c101_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c101_3 (mix_i_c101_3 0) resistor r=1G
RMIXQ_c101_3 (mix_q_c101_3 0) resistor r=1G
RINTI_c101_3 (mix_i_c101_3 Icar_c101_3) resistor r=1k
CINTI_c101_3 (Icar_c101_3 0) capacitor c=80p
RINTQ_c101_3 (mix_q_c101_3 Qcar_c101_3) resistor r=1k
CINTQ_c101_3 (Qcar_c101_3 0) capacitor c=80p

// bl102, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c102_0 (bl102 n_cbpf_c102_0) capacitor c=4.052847345694e-13
LBPF_c102_0 (n_cbpf_c102_0 bpf_c102_0) inductor l=1.000000000000e-06
RBPF_c102_0 (bpf_c102_0 0) resistor r=7.853981633974e+01
EMIXI_c102_0_00 (mix_i_src_c102_0_00 0 bpf_c102_0 0) vcvs gain=9.807852804032e-01
SMIXI_c102_0_00 (mix_i_src_c102_0_00 mix_i_c102_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_00 (mix_q_src_c102_0_00 0 bpf_c102_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_0_00 (mix_q_src_c102_0_00 mix_q_c102_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_01 (mix_i_src_c102_0_01 0 bpf_c102_0 0) vcvs gain=8.314696123025e-01
SMIXI_c102_0_01 (mix_i_src_c102_0_01 mix_i_c102_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_01 (mix_q_src_c102_0_01 0 bpf_c102_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_0_01 (mix_q_src_c102_0_01 mix_q_c102_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_02 (mix_i_src_c102_0_02 0 bpf_c102_0 0) vcvs gain=5.555702330196e-01
SMIXI_c102_0_02 (mix_i_src_c102_0_02 mix_i_c102_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_02 (mix_q_src_c102_0_02 0 bpf_c102_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_0_02 (mix_q_src_c102_0_02 mix_q_c102_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_03 (mix_i_src_c102_0_03 0 bpf_c102_0 0) vcvs gain=1.950903220161e-01
SMIXI_c102_0_03 (mix_i_src_c102_0_03 mix_i_c102_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_03 (mix_q_src_c102_0_03 0 bpf_c102_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_0_03 (mix_q_src_c102_0_03 mix_q_c102_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_04 (mix_i_src_c102_0_04 0 bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_0_04 (mix_i_src_c102_0_04 mix_i_c102_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_04 (mix_q_src_c102_0_04 0 bpf_c102_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_0_04 (mix_q_src_c102_0_04 mix_q_c102_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_05 (mix_i_src_c102_0_05 0 bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_0_05 (mix_i_src_c102_0_05 mix_i_c102_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_05 (mix_q_src_c102_0_05 0 bpf_c102_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_0_05 (mix_q_src_c102_0_05 mix_q_c102_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_06 (mix_i_src_c102_0_06 0 bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_0_06 (mix_i_src_c102_0_06 mix_i_c102_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_06 (mix_q_src_c102_0_06 0 bpf_c102_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_0_06 (mix_q_src_c102_0_06 mix_q_c102_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_07 (mix_i_src_c102_0_07 0 bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_0_07 (mix_i_src_c102_0_07 mix_i_c102_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_07 (mix_q_src_c102_0_07 0 bpf_c102_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_0_07 (mix_q_src_c102_0_07 mix_q_c102_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_08 (mix_i_src_c102_0_08 0 bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_0_08 (mix_i_src_c102_0_08 mix_i_c102_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_08 (mix_q_src_c102_0_08 0 bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_0_08 (mix_q_src_c102_0_08 mix_q_c102_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_09 (mix_i_src_c102_0_09 0 bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_0_09 (mix_i_src_c102_0_09 mix_i_c102_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_09 (mix_q_src_c102_0_09 0 bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_0_09 (mix_q_src_c102_0_09 mix_q_c102_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_10 (mix_i_src_c102_0_10 0 bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_0_10 (mix_i_src_c102_0_10 mix_i_c102_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_10 (mix_q_src_c102_0_10 0 bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_0_10 (mix_q_src_c102_0_10 mix_q_c102_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_11 (mix_i_src_c102_0_11 0 bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_0_11 (mix_i_src_c102_0_11 mix_i_c102_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_11 (mix_q_src_c102_0_11 0 bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_0_11 (mix_q_src_c102_0_11 mix_q_c102_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_12 (mix_i_src_c102_0_12 0 bpf_c102_0 0) vcvs gain=1.950903220161e-01
SMIXI_c102_0_12 (mix_i_src_c102_0_12 mix_i_c102_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_12 (mix_q_src_c102_0_12 0 bpf_c102_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_0_12 (mix_q_src_c102_0_12 mix_q_c102_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_13 (mix_i_src_c102_0_13 0 bpf_c102_0 0) vcvs gain=5.555702330196e-01
SMIXI_c102_0_13 (mix_i_src_c102_0_13 mix_i_c102_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_13 (mix_q_src_c102_0_13 0 bpf_c102_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_0_13 (mix_q_src_c102_0_13 mix_q_c102_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_14 (mix_i_src_c102_0_14 0 bpf_c102_0 0) vcvs gain=8.314696123025e-01
SMIXI_c102_0_14 (mix_i_src_c102_0_14 mix_i_c102_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_14 (mix_q_src_c102_0_14 0 bpf_c102_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_0_14 (mix_q_src_c102_0_14 mix_q_c102_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_0_15 (mix_i_src_c102_0_15 0 bpf_c102_0 0) vcvs gain=9.807852804032e-01
SMIXI_c102_0_15 (mix_i_src_c102_0_15 mix_i_c102_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_0_15 (mix_q_src_c102_0_15 0 bpf_c102_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_0_15 (mix_q_src_c102_0_15 mix_q_c102_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c102_0 (mix_i_c102_0 0) resistor r=1G
RMIXQ_c102_0 (mix_q_c102_0 0) resistor r=1G
RINTI_c102_0 (mix_i_c102_0 Icar_c102_0) resistor r=1k
CINTI_c102_0 (Icar_c102_0 0) capacitor c=80p
RINTQ_c102_0 (mix_q_c102_0 Qcar_c102_0) resistor r=1k
CINTQ_c102_0 (Qcar_c102_0 0) capacitor c=80p

// bl102, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c102_1 (bl102 n_cbpf_c102_1) capacitor c=1.013211836423e-13
LBPF_c102_1 (n_cbpf_c102_1 bpf_c102_1) inductor l=1.000000000000e-06
RBPF_c102_1 (bpf_c102_1 0) resistor r=1.570796326795e+02
EMIXI_c102_1_00 (mix_i_src_c102_1_00 0 bpf_c102_1 0) vcvs gain=9.807852804032e-01
SMIXI_c102_1_00 (mix_i_src_c102_1_00 mix_i_c102_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_00 (mix_q_src_c102_1_00 0 bpf_c102_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_1_00 (mix_q_src_c102_1_00 mix_q_c102_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_01 (mix_i_src_c102_1_01 0 bpf_c102_1 0) vcvs gain=8.314696123025e-01
SMIXI_c102_1_01 (mix_i_src_c102_1_01 mix_i_c102_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_01 (mix_q_src_c102_1_01 0 bpf_c102_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_1_01 (mix_q_src_c102_1_01 mix_q_c102_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_02 (mix_i_src_c102_1_02 0 bpf_c102_1 0) vcvs gain=5.555702330196e-01
SMIXI_c102_1_02 (mix_i_src_c102_1_02 mix_i_c102_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_02 (mix_q_src_c102_1_02 0 bpf_c102_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_1_02 (mix_q_src_c102_1_02 mix_q_c102_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_03 (mix_i_src_c102_1_03 0 bpf_c102_1 0) vcvs gain=1.950903220161e-01
SMIXI_c102_1_03 (mix_i_src_c102_1_03 mix_i_c102_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_03 (mix_q_src_c102_1_03 0 bpf_c102_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_1_03 (mix_q_src_c102_1_03 mix_q_c102_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_04 (mix_i_src_c102_1_04 0 bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_1_04 (mix_i_src_c102_1_04 mix_i_c102_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_04 (mix_q_src_c102_1_04 0 bpf_c102_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_1_04 (mix_q_src_c102_1_04 mix_q_c102_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_05 (mix_i_src_c102_1_05 0 bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_1_05 (mix_i_src_c102_1_05 mix_i_c102_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_05 (mix_q_src_c102_1_05 0 bpf_c102_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_1_05 (mix_q_src_c102_1_05 mix_q_c102_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_06 (mix_i_src_c102_1_06 0 bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_1_06 (mix_i_src_c102_1_06 mix_i_c102_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_06 (mix_q_src_c102_1_06 0 bpf_c102_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_1_06 (mix_q_src_c102_1_06 mix_q_c102_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_07 (mix_i_src_c102_1_07 0 bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_1_07 (mix_i_src_c102_1_07 mix_i_c102_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_07 (mix_q_src_c102_1_07 0 bpf_c102_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_1_07 (mix_q_src_c102_1_07 mix_q_c102_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_08 (mix_i_src_c102_1_08 0 bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_1_08 (mix_i_src_c102_1_08 mix_i_c102_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_08 (mix_q_src_c102_1_08 0 bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_1_08 (mix_q_src_c102_1_08 mix_q_c102_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_09 (mix_i_src_c102_1_09 0 bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_1_09 (mix_i_src_c102_1_09 mix_i_c102_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_09 (mix_q_src_c102_1_09 0 bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_1_09 (mix_q_src_c102_1_09 mix_q_c102_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_10 (mix_i_src_c102_1_10 0 bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_1_10 (mix_i_src_c102_1_10 mix_i_c102_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_10 (mix_q_src_c102_1_10 0 bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_1_10 (mix_q_src_c102_1_10 mix_q_c102_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_11 (mix_i_src_c102_1_11 0 bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_1_11 (mix_i_src_c102_1_11 mix_i_c102_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_11 (mix_q_src_c102_1_11 0 bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_1_11 (mix_q_src_c102_1_11 mix_q_c102_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_12 (mix_i_src_c102_1_12 0 bpf_c102_1 0) vcvs gain=1.950903220161e-01
SMIXI_c102_1_12 (mix_i_src_c102_1_12 mix_i_c102_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_12 (mix_q_src_c102_1_12 0 bpf_c102_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_1_12 (mix_q_src_c102_1_12 mix_q_c102_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_13 (mix_i_src_c102_1_13 0 bpf_c102_1 0) vcvs gain=5.555702330196e-01
SMIXI_c102_1_13 (mix_i_src_c102_1_13 mix_i_c102_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_13 (mix_q_src_c102_1_13 0 bpf_c102_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_1_13 (mix_q_src_c102_1_13 mix_q_c102_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_14 (mix_i_src_c102_1_14 0 bpf_c102_1 0) vcvs gain=8.314696123025e-01
SMIXI_c102_1_14 (mix_i_src_c102_1_14 mix_i_c102_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_14 (mix_q_src_c102_1_14 0 bpf_c102_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_1_14 (mix_q_src_c102_1_14 mix_q_c102_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_1_15 (mix_i_src_c102_1_15 0 bpf_c102_1 0) vcvs gain=9.807852804032e-01
SMIXI_c102_1_15 (mix_i_src_c102_1_15 mix_i_c102_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_1_15 (mix_q_src_c102_1_15 0 bpf_c102_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_1_15 (mix_q_src_c102_1_15 mix_q_c102_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c102_1 (mix_i_c102_1 0) resistor r=1G
RMIXQ_c102_1 (mix_q_c102_1 0) resistor r=1G
RINTI_c102_1 (mix_i_c102_1 Icar_c102_1) resistor r=1k
CINTI_c102_1 (Icar_c102_1 0) capacitor c=80p
RINTQ_c102_1 (mix_q_c102_1 Qcar_c102_1) resistor r=1k
CINTQ_c102_1 (Qcar_c102_1 0) capacitor c=80p

// bl102, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c102_2 (bl102 n_cbpf_c102_2) capacitor c=4.503163717437e-14
LBPF_c102_2 (n_cbpf_c102_2 bpf_c102_2) inductor l=1.000000000000e-06
RBPF_c102_2 (bpf_c102_2 0) resistor r=2.356194490192e+02
EMIXI_c102_2_00 (mix_i_src_c102_2_00 0 bpf_c102_2 0) vcvs gain=9.807852804032e-01
SMIXI_c102_2_00 (mix_i_src_c102_2_00 mix_i_c102_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_00 (mix_q_src_c102_2_00 0 bpf_c102_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_2_00 (mix_q_src_c102_2_00 mix_q_c102_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_01 (mix_i_src_c102_2_01 0 bpf_c102_2 0) vcvs gain=8.314696123025e-01
SMIXI_c102_2_01 (mix_i_src_c102_2_01 mix_i_c102_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_01 (mix_q_src_c102_2_01 0 bpf_c102_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_2_01 (mix_q_src_c102_2_01 mix_q_c102_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_02 (mix_i_src_c102_2_02 0 bpf_c102_2 0) vcvs gain=5.555702330196e-01
SMIXI_c102_2_02 (mix_i_src_c102_2_02 mix_i_c102_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_02 (mix_q_src_c102_2_02 0 bpf_c102_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_2_02 (mix_q_src_c102_2_02 mix_q_c102_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_03 (mix_i_src_c102_2_03 0 bpf_c102_2 0) vcvs gain=1.950903220161e-01
SMIXI_c102_2_03 (mix_i_src_c102_2_03 mix_i_c102_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_03 (mix_q_src_c102_2_03 0 bpf_c102_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_2_03 (mix_q_src_c102_2_03 mix_q_c102_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_04 (mix_i_src_c102_2_04 0 bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_2_04 (mix_i_src_c102_2_04 mix_i_c102_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_04 (mix_q_src_c102_2_04 0 bpf_c102_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_2_04 (mix_q_src_c102_2_04 mix_q_c102_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_05 (mix_i_src_c102_2_05 0 bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_2_05 (mix_i_src_c102_2_05 mix_i_c102_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_05 (mix_q_src_c102_2_05 0 bpf_c102_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_2_05 (mix_q_src_c102_2_05 mix_q_c102_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_06 (mix_i_src_c102_2_06 0 bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_2_06 (mix_i_src_c102_2_06 mix_i_c102_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_06 (mix_q_src_c102_2_06 0 bpf_c102_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_2_06 (mix_q_src_c102_2_06 mix_q_c102_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_07 (mix_i_src_c102_2_07 0 bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_2_07 (mix_i_src_c102_2_07 mix_i_c102_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_07 (mix_q_src_c102_2_07 0 bpf_c102_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_2_07 (mix_q_src_c102_2_07 mix_q_c102_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_08 (mix_i_src_c102_2_08 0 bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_2_08 (mix_i_src_c102_2_08 mix_i_c102_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_08 (mix_q_src_c102_2_08 0 bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_2_08 (mix_q_src_c102_2_08 mix_q_c102_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_09 (mix_i_src_c102_2_09 0 bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_2_09 (mix_i_src_c102_2_09 mix_i_c102_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_09 (mix_q_src_c102_2_09 0 bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_2_09 (mix_q_src_c102_2_09 mix_q_c102_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_10 (mix_i_src_c102_2_10 0 bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_2_10 (mix_i_src_c102_2_10 mix_i_c102_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_10 (mix_q_src_c102_2_10 0 bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_2_10 (mix_q_src_c102_2_10 mix_q_c102_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_11 (mix_i_src_c102_2_11 0 bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_2_11 (mix_i_src_c102_2_11 mix_i_c102_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_11 (mix_q_src_c102_2_11 0 bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_2_11 (mix_q_src_c102_2_11 mix_q_c102_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_12 (mix_i_src_c102_2_12 0 bpf_c102_2 0) vcvs gain=1.950903220161e-01
SMIXI_c102_2_12 (mix_i_src_c102_2_12 mix_i_c102_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_12 (mix_q_src_c102_2_12 0 bpf_c102_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_2_12 (mix_q_src_c102_2_12 mix_q_c102_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_13 (mix_i_src_c102_2_13 0 bpf_c102_2 0) vcvs gain=5.555702330196e-01
SMIXI_c102_2_13 (mix_i_src_c102_2_13 mix_i_c102_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_13 (mix_q_src_c102_2_13 0 bpf_c102_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_2_13 (mix_q_src_c102_2_13 mix_q_c102_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_14 (mix_i_src_c102_2_14 0 bpf_c102_2 0) vcvs gain=8.314696123025e-01
SMIXI_c102_2_14 (mix_i_src_c102_2_14 mix_i_c102_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_14 (mix_q_src_c102_2_14 0 bpf_c102_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_2_14 (mix_q_src_c102_2_14 mix_q_c102_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_2_15 (mix_i_src_c102_2_15 0 bpf_c102_2 0) vcvs gain=9.807852804032e-01
SMIXI_c102_2_15 (mix_i_src_c102_2_15 mix_i_c102_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_2_15 (mix_q_src_c102_2_15 0 bpf_c102_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_2_15 (mix_q_src_c102_2_15 mix_q_c102_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c102_2 (mix_i_c102_2 0) resistor r=1G
RMIXQ_c102_2 (mix_q_c102_2 0) resistor r=1G
RINTI_c102_2 (mix_i_c102_2 Icar_c102_2) resistor r=1k
CINTI_c102_2 (Icar_c102_2 0) capacitor c=80p
RINTQ_c102_2 (mix_q_c102_2 Qcar_c102_2) resistor r=1k
CINTQ_c102_2 (Qcar_c102_2 0) capacitor c=80p

// bl102, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c102_3 (bl102 n_cbpf_c102_3) capacitor c=2.533029591058e-14
LBPF_c102_3 (n_cbpf_c102_3 bpf_c102_3) inductor l=1.000000000000e-06
RBPF_c102_3 (bpf_c102_3 0) resistor r=3.141592653590e+02
EMIXI_c102_3_00 (mix_i_src_c102_3_00 0 bpf_c102_3 0) vcvs gain=9.807852804032e-01
SMIXI_c102_3_00 (mix_i_src_c102_3_00 mix_i_c102_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_00 (mix_q_src_c102_3_00 0 bpf_c102_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_3_00 (mix_q_src_c102_3_00 mix_q_c102_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_01 (mix_i_src_c102_3_01 0 bpf_c102_3 0) vcvs gain=8.314696123025e-01
SMIXI_c102_3_01 (mix_i_src_c102_3_01 mix_i_c102_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_01 (mix_q_src_c102_3_01 0 bpf_c102_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_3_01 (mix_q_src_c102_3_01 mix_q_c102_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_02 (mix_i_src_c102_3_02 0 bpf_c102_3 0) vcvs gain=5.555702330196e-01
SMIXI_c102_3_02 (mix_i_src_c102_3_02 mix_i_c102_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_02 (mix_q_src_c102_3_02 0 bpf_c102_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_3_02 (mix_q_src_c102_3_02 mix_q_c102_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_03 (mix_i_src_c102_3_03 0 bpf_c102_3 0) vcvs gain=1.950903220161e-01
SMIXI_c102_3_03 (mix_i_src_c102_3_03 mix_i_c102_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_03 (mix_q_src_c102_3_03 0 bpf_c102_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_3_03 (mix_q_src_c102_3_03 mix_q_c102_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_04 (mix_i_src_c102_3_04 0 bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_3_04 (mix_i_src_c102_3_04 mix_i_c102_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_04 (mix_q_src_c102_3_04 0 bpf_c102_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c102_3_04 (mix_q_src_c102_3_04 mix_q_c102_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_05 (mix_i_src_c102_3_05 0 bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_3_05 (mix_i_src_c102_3_05 mix_i_c102_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_05 (mix_q_src_c102_3_05 0 bpf_c102_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c102_3_05 (mix_q_src_c102_3_05 mix_q_c102_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_06 (mix_i_src_c102_3_06 0 bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_3_06 (mix_i_src_c102_3_06 mix_i_c102_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_06 (mix_q_src_c102_3_06 0 bpf_c102_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c102_3_06 (mix_q_src_c102_3_06 mix_q_c102_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_07 (mix_i_src_c102_3_07 0 bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_3_07 (mix_i_src_c102_3_07 mix_i_c102_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_07 (mix_q_src_c102_3_07 0 bpf_c102_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c102_3_07 (mix_q_src_c102_3_07 mix_q_c102_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_08 (mix_i_src_c102_3_08 0 bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c102_3_08 (mix_i_src_c102_3_08 mix_i_c102_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_08 (mix_q_src_c102_3_08 0 bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_3_08 (mix_q_src_c102_3_08 mix_q_c102_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_09 (mix_i_src_c102_3_09 0 bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c102_3_09 (mix_i_src_c102_3_09 mix_i_c102_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_09 (mix_q_src_c102_3_09 0 bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_3_09 (mix_q_src_c102_3_09 mix_q_c102_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_10 (mix_i_src_c102_3_10 0 bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c102_3_10 (mix_i_src_c102_3_10 mix_i_c102_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_10 (mix_q_src_c102_3_10 0 bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_3_10 (mix_q_src_c102_3_10 mix_q_c102_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_11 (mix_i_src_c102_3_11 0 bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c102_3_11 (mix_i_src_c102_3_11 mix_i_c102_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_11 (mix_q_src_c102_3_11 0 bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_3_11 (mix_q_src_c102_3_11 mix_q_c102_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_12 (mix_i_src_c102_3_12 0 bpf_c102_3 0) vcvs gain=1.950903220161e-01
SMIXI_c102_3_12 (mix_i_src_c102_3_12 mix_i_c102_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_12 (mix_q_src_c102_3_12 0 bpf_c102_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c102_3_12 (mix_q_src_c102_3_12 mix_q_c102_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_13 (mix_i_src_c102_3_13 0 bpf_c102_3 0) vcvs gain=5.555702330196e-01
SMIXI_c102_3_13 (mix_i_src_c102_3_13 mix_i_c102_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_13 (mix_q_src_c102_3_13 0 bpf_c102_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c102_3_13 (mix_q_src_c102_3_13 mix_q_c102_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_14 (mix_i_src_c102_3_14 0 bpf_c102_3 0) vcvs gain=8.314696123025e-01
SMIXI_c102_3_14 (mix_i_src_c102_3_14 mix_i_c102_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_14 (mix_q_src_c102_3_14 0 bpf_c102_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c102_3_14 (mix_q_src_c102_3_14 mix_q_c102_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c102_3_15 (mix_i_src_c102_3_15 0 bpf_c102_3 0) vcvs gain=9.807852804032e-01
SMIXI_c102_3_15 (mix_i_src_c102_3_15 mix_i_c102_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c102_3_15 (mix_q_src_c102_3_15 0 bpf_c102_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c102_3_15 (mix_q_src_c102_3_15 mix_q_c102_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c102_3 (mix_i_c102_3 0) resistor r=1G
RMIXQ_c102_3 (mix_q_c102_3 0) resistor r=1G
RINTI_c102_3 (mix_i_c102_3 Icar_c102_3) resistor r=1k
CINTI_c102_3 (Icar_c102_3 0) capacitor c=80p
RINTQ_c102_3 (mix_q_c102_3 Qcar_c102_3) resistor r=1k
CINTQ_c102_3 (Qcar_c102_3 0) capacitor c=80p

// bl103, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c103_0 (bl103 n_cbpf_c103_0) capacitor c=4.052847345694e-13
LBPF_c103_0 (n_cbpf_c103_0 bpf_c103_0) inductor l=1.000000000000e-06
RBPF_c103_0 (bpf_c103_0 0) resistor r=7.853981633974e+01
EMIXI_c103_0_00 (mix_i_src_c103_0_00 0 bpf_c103_0 0) vcvs gain=9.807852804032e-01
SMIXI_c103_0_00 (mix_i_src_c103_0_00 mix_i_c103_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_00 (mix_q_src_c103_0_00 0 bpf_c103_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_0_00 (mix_q_src_c103_0_00 mix_q_c103_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_01 (mix_i_src_c103_0_01 0 bpf_c103_0 0) vcvs gain=8.314696123025e-01
SMIXI_c103_0_01 (mix_i_src_c103_0_01 mix_i_c103_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_01 (mix_q_src_c103_0_01 0 bpf_c103_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_0_01 (mix_q_src_c103_0_01 mix_q_c103_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_02 (mix_i_src_c103_0_02 0 bpf_c103_0 0) vcvs gain=5.555702330196e-01
SMIXI_c103_0_02 (mix_i_src_c103_0_02 mix_i_c103_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_02 (mix_q_src_c103_0_02 0 bpf_c103_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_0_02 (mix_q_src_c103_0_02 mix_q_c103_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_03 (mix_i_src_c103_0_03 0 bpf_c103_0 0) vcvs gain=1.950903220161e-01
SMIXI_c103_0_03 (mix_i_src_c103_0_03 mix_i_c103_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_03 (mix_q_src_c103_0_03 0 bpf_c103_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_0_03 (mix_q_src_c103_0_03 mix_q_c103_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_04 (mix_i_src_c103_0_04 0 bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_0_04 (mix_i_src_c103_0_04 mix_i_c103_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_04 (mix_q_src_c103_0_04 0 bpf_c103_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_0_04 (mix_q_src_c103_0_04 mix_q_c103_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_05 (mix_i_src_c103_0_05 0 bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_0_05 (mix_i_src_c103_0_05 mix_i_c103_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_05 (mix_q_src_c103_0_05 0 bpf_c103_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_0_05 (mix_q_src_c103_0_05 mix_q_c103_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_06 (mix_i_src_c103_0_06 0 bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_0_06 (mix_i_src_c103_0_06 mix_i_c103_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_06 (mix_q_src_c103_0_06 0 bpf_c103_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_0_06 (mix_q_src_c103_0_06 mix_q_c103_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_07 (mix_i_src_c103_0_07 0 bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_0_07 (mix_i_src_c103_0_07 mix_i_c103_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_07 (mix_q_src_c103_0_07 0 bpf_c103_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_0_07 (mix_q_src_c103_0_07 mix_q_c103_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_08 (mix_i_src_c103_0_08 0 bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_0_08 (mix_i_src_c103_0_08 mix_i_c103_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_08 (mix_q_src_c103_0_08 0 bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_0_08 (mix_q_src_c103_0_08 mix_q_c103_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_09 (mix_i_src_c103_0_09 0 bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_0_09 (mix_i_src_c103_0_09 mix_i_c103_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_09 (mix_q_src_c103_0_09 0 bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_0_09 (mix_q_src_c103_0_09 mix_q_c103_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_10 (mix_i_src_c103_0_10 0 bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_0_10 (mix_i_src_c103_0_10 mix_i_c103_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_10 (mix_q_src_c103_0_10 0 bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_0_10 (mix_q_src_c103_0_10 mix_q_c103_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_11 (mix_i_src_c103_0_11 0 bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_0_11 (mix_i_src_c103_0_11 mix_i_c103_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_11 (mix_q_src_c103_0_11 0 bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_0_11 (mix_q_src_c103_0_11 mix_q_c103_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_12 (mix_i_src_c103_0_12 0 bpf_c103_0 0) vcvs gain=1.950903220161e-01
SMIXI_c103_0_12 (mix_i_src_c103_0_12 mix_i_c103_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_12 (mix_q_src_c103_0_12 0 bpf_c103_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_0_12 (mix_q_src_c103_0_12 mix_q_c103_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_13 (mix_i_src_c103_0_13 0 bpf_c103_0 0) vcvs gain=5.555702330196e-01
SMIXI_c103_0_13 (mix_i_src_c103_0_13 mix_i_c103_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_13 (mix_q_src_c103_0_13 0 bpf_c103_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_0_13 (mix_q_src_c103_0_13 mix_q_c103_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_14 (mix_i_src_c103_0_14 0 bpf_c103_0 0) vcvs gain=8.314696123025e-01
SMIXI_c103_0_14 (mix_i_src_c103_0_14 mix_i_c103_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_14 (mix_q_src_c103_0_14 0 bpf_c103_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_0_14 (mix_q_src_c103_0_14 mix_q_c103_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_0_15 (mix_i_src_c103_0_15 0 bpf_c103_0 0) vcvs gain=9.807852804032e-01
SMIXI_c103_0_15 (mix_i_src_c103_0_15 mix_i_c103_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_0_15 (mix_q_src_c103_0_15 0 bpf_c103_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_0_15 (mix_q_src_c103_0_15 mix_q_c103_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c103_0 (mix_i_c103_0 0) resistor r=1G
RMIXQ_c103_0 (mix_q_c103_0 0) resistor r=1G
RINTI_c103_0 (mix_i_c103_0 Icar_c103_0) resistor r=1k
CINTI_c103_0 (Icar_c103_0 0) capacitor c=80p
RINTQ_c103_0 (mix_q_c103_0 Qcar_c103_0) resistor r=1k
CINTQ_c103_0 (Qcar_c103_0 0) capacitor c=80p

// bl103, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c103_1 (bl103 n_cbpf_c103_1) capacitor c=1.013211836423e-13
LBPF_c103_1 (n_cbpf_c103_1 bpf_c103_1) inductor l=1.000000000000e-06
RBPF_c103_1 (bpf_c103_1 0) resistor r=1.570796326795e+02
EMIXI_c103_1_00 (mix_i_src_c103_1_00 0 bpf_c103_1 0) vcvs gain=9.807852804032e-01
SMIXI_c103_1_00 (mix_i_src_c103_1_00 mix_i_c103_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_00 (mix_q_src_c103_1_00 0 bpf_c103_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_1_00 (mix_q_src_c103_1_00 mix_q_c103_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_01 (mix_i_src_c103_1_01 0 bpf_c103_1 0) vcvs gain=8.314696123025e-01
SMIXI_c103_1_01 (mix_i_src_c103_1_01 mix_i_c103_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_01 (mix_q_src_c103_1_01 0 bpf_c103_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_1_01 (mix_q_src_c103_1_01 mix_q_c103_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_02 (mix_i_src_c103_1_02 0 bpf_c103_1 0) vcvs gain=5.555702330196e-01
SMIXI_c103_1_02 (mix_i_src_c103_1_02 mix_i_c103_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_02 (mix_q_src_c103_1_02 0 bpf_c103_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_1_02 (mix_q_src_c103_1_02 mix_q_c103_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_03 (mix_i_src_c103_1_03 0 bpf_c103_1 0) vcvs gain=1.950903220161e-01
SMIXI_c103_1_03 (mix_i_src_c103_1_03 mix_i_c103_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_03 (mix_q_src_c103_1_03 0 bpf_c103_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_1_03 (mix_q_src_c103_1_03 mix_q_c103_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_04 (mix_i_src_c103_1_04 0 bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_1_04 (mix_i_src_c103_1_04 mix_i_c103_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_04 (mix_q_src_c103_1_04 0 bpf_c103_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_1_04 (mix_q_src_c103_1_04 mix_q_c103_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_05 (mix_i_src_c103_1_05 0 bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_1_05 (mix_i_src_c103_1_05 mix_i_c103_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_05 (mix_q_src_c103_1_05 0 bpf_c103_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_1_05 (mix_q_src_c103_1_05 mix_q_c103_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_06 (mix_i_src_c103_1_06 0 bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_1_06 (mix_i_src_c103_1_06 mix_i_c103_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_06 (mix_q_src_c103_1_06 0 bpf_c103_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_1_06 (mix_q_src_c103_1_06 mix_q_c103_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_07 (mix_i_src_c103_1_07 0 bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_1_07 (mix_i_src_c103_1_07 mix_i_c103_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_07 (mix_q_src_c103_1_07 0 bpf_c103_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_1_07 (mix_q_src_c103_1_07 mix_q_c103_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_08 (mix_i_src_c103_1_08 0 bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_1_08 (mix_i_src_c103_1_08 mix_i_c103_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_08 (mix_q_src_c103_1_08 0 bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_1_08 (mix_q_src_c103_1_08 mix_q_c103_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_09 (mix_i_src_c103_1_09 0 bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_1_09 (mix_i_src_c103_1_09 mix_i_c103_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_09 (mix_q_src_c103_1_09 0 bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_1_09 (mix_q_src_c103_1_09 mix_q_c103_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_10 (mix_i_src_c103_1_10 0 bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_1_10 (mix_i_src_c103_1_10 mix_i_c103_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_10 (mix_q_src_c103_1_10 0 bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_1_10 (mix_q_src_c103_1_10 mix_q_c103_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_11 (mix_i_src_c103_1_11 0 bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_1_11 (mix_i_src_c103_1_11 mix_i_c103_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_11 (mix_q_src_c103_1_11 0 bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_1_11 (mix_q_src_c103_1_11 mix_q_c103_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_12 (mix_i_src_c103_1_12 0 bpf_c103_1 0) vcvs gain=1.950903220161e-01
SMIXI_c103_1_12 (mix_i_src_c103_1_12 mix_i_c103_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_12 (mix_q_src_c103_1_12 0 bpf_c103_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_1_12 (mix_q_src_c103_1_12 mix_q_c103_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_13 (mix_i_src_c103_1_13 0 bpf_c103_1 0) vcvs gain=5.555702330196e-01
SMIXI_c103_1_13 (mix_i_src_c103_1_13 mix_i_c103_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_13 (mix_q_src_c103_1_13 0 bpf_c103_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_1_13 (mix_q_src_c103_1_13 mix_q_c103_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_14 (mix_i_src_c103_1_14 0 bpf_c103_1 0) vcvs gain=8.314696123025e-01
SMIXI_c103_1_14 (mix_i_src_c103_1_14 mix_i_c103_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_14 (mix_q_src_c103_1_14 0 bpf_c103_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_1_14 (mix_q_src_c103_1_14 mix_q_c103_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_1_15 (mix_i_src_c103_1_15 0 bpf_c103_1 0) vcvs gain=9.807852804032e-01
SMIXI_c103_1_15 (mix_i_src_c103_1_15 mix_i_c103_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_1_15 (mix_q_src_c103_1_15 0 bpf_c103_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_1_15 (mix_q_src_c103_1_15 mix_q_c103_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c103_1 (mix_i_c103_1 0) resistor r=1G
RMIXQ_c103_1 (mix_q_c103_1 0) resistor r=1G
RINTI_c103_1 (mix_i_c103_1 Icar_c103_1) resistor r=1k
CINTI_c103_1 (Icar_c103_1 0) capacitor c=80p
RINTQ_c103_1 (mix_q_c103_1 Qcar_c103_1) resistor r=1k
CINTQ_c103_1 (Qcar_c103_1 0) capacitor c=80p

// bl103, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c103_2 (bl103 n_cbpf_c103_2) capacitor c=4.503163717437e-14
LBPF_c103_2 (n_cbpf_c103_2 bpf_c103_2) inductor l=1.000000000000e-06
RBPF_c103_2 (bpf_c103_2 0) resistor r=2.356194490192e+02
EMIXI_c103_2_00 (mix_i_src_c103_2_00 0 bpf_c103_2 0) vcvs gain=9.807852804032e-01
SMIXI_c103_2_00 (mix_i_src_c103_2_00 mix_i_c103_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_00 (mix_q_src_c103_2_00 0 bpf_c103_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_2_00 (mix_q_src_c103_2_00 mix_q_c103_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_01 (mix_i_src_c103_2_01 0 bpf_c103_2 0) vcvs gain=8.314696123025e-01
SMIXI_c103_2_01 (mix_i_src_c103_2_01 mix_i_c103_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_01 (mix_q_src_c103_2_01 0 bpf_c103_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_2_01 (mix_q_src_c103_2_01 mix_q_c103_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_02 (mix_i_src_c103_2_02 0 bpf_c103_2 0) vcvs gain=5.555702330196e-01
SMIXI_c103_2_02 (mix_i_src_c103_2_02 mix_i_c103_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_02 (mix_q_src_c103_2_02 0 bpf_c103_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_2_02 (mix_q_src_c103_2_02 mix_q_c103_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_03 (mix_i_src_c103_2_03 0 bpf_c103_2 0) vcvs gain=1.950903220161e-01
SMIXI_c103_2_03 (mix_i_src_c103_2_03 mix_i_c103_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_03 (mix_q_src_c103_2_03 0 bpf_c103_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_2_03 (mix_q_src_c103_2_03 mix_q_c103_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_04 (mix_i_src_c103_2_04 0 bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_2_04 (mix_i_src_c103_2_04 mix_i_c103_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_04 (mix_q_src_c103_2_04 0 bpf_c103_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_2_04 (mix_q_src_c103_2_04 mix_q_c103_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_05 (mix_i_src_c103_2_05 0 bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_2_05 (mix_i_src_c103_2_05 mix_i_c103_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_05 (mix_q_src_c103_2_05 0 bpf_c103_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_2_05 (mix_q_src_c103_2_05 mix_q_c103_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_06 (mix_i_src_c103_2_06 0 bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_2_06 (mix_i_src_c103_2_06 mix_i_c103_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_06 (mix_q_src_c103_2_06 0 bpf_c103_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_2_06 (mix_q_src_c103_2_06 mix_q_c103_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_07 (mix_i_src_c103_2_07 0 bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_2_07 (mix_i_src_c103_2_07 mix_i_c103_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_07 (mix_q_src_c103_2_07 0 bpf_c103_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_2_07 (mix_q_src_c103_2_07 mix_q_c103_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_08 (mix_i_src_c103_2_08 0 bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_2_08 (mix_i_src_c103_2_08 mix_i_c103_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_08 (mix_q_src_c103_2_08 0 bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_2_08 (mix_q_src_c103_2_08 mix_q_c103_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_09 (mix_i_src_c103_2_09 0 bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_2_09 (mix_i_src_c103_2_09 mix_i_c103_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_09 (mix_q_src_c103_2_09 0 bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_2_09 (mix_q_src_c103_2_09 mix_q_c103_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_10 (mix_i_src_c103_2_10 0 bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_2_10 (mix_i_src_c103_2_10 mix_i_c103_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_10 (mix_q_src_c103_2_10 0 bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_2_10 (mix_q_src_c103_2_10 mix_q_c103_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_11 (mix_i_src_c103_2_11 0 bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_2_11 (mix_i_src_c103_2_11 mix_i_c103_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_11 (mix_q_src_c103_2_11 0 bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_2_11 (mix_q_src_c103_2_11 mix_q_c103_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_12 (mix_i_src_c103_2_12 0 bpf_c103_2 0) vcvs gain=1.950903220161e-01
SMIXI_c103_2_12 (mix_i_src_c103_2_12 mix_i_c103_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_12 (mix_q_src_c103_2_12 0 bpf_c103_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_2_12 (mix_q_src_c103_2_12 mix_q_c103_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_13 (mix_i_src_c103_2_13 0 bpf_c103_2 0) vcvs gain=5.555702330196e-01
SMIXI_c103_2_13 (mix_i_src_c103_2_13 mix_i_c103_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_13 (mix_q_src_c103_2_13 0 bpf_c103_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_2_13 (mix_q_src_c103_2_13 mix_q_c103_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_14 (mix_i_src_c103_2_14 0 bpf_c103_2 0) vcvs gain=8.314696123025e-01
SMIXI_c103_2_14 (mix_i_src_c103_2_14 mix_i_c103_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_14 (mix_q_src_c103_2_14 0 bpf_c103_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_2_14 (mix_q_src_c103_2_14 mix_q_c103_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_2_15 (mix_i_src_c103_2_15 0 bpf_c103_2 0) vcvs gain=9.807852804032e-01
SMIXI_c103_2_15 (mix_i_src_c103_2_15 mix_i_c103_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_2_15 (mix_q_src_c103_2_15 0 bpf_c103_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_2_15 (mix_q_src_c103_2_15 mix_q_c103_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c103_2 (mix_i_c103_2 0) resistor r=1G
RMIXQ_c103_2 (mix_q_c103_2 0) resistor r=1G
RINTI_c103_2 (mix_i_c103_2 Icar_c103_2) resistor r=1k
CINTI_c103_2 (Icar_c103_2 0) capacitor c=80p
RINTQ_c103_2 (mix_q_c103_2 Qcar_c103_2) resistor r=1k
CINTQ_c103_2 (Qcar_c103_2 0) capacitor c=80p

// bl103, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c103_3 (bl103 n_cbpf_c103_3) capacitor c=2.533029591058e-14
LBPF_c103_3 (n_cbpf_c103_3 bpf_c103_3) inductor l=1.000000000000e-06
RBPF_c103_3 (bpf_c103_3 0) resistor r=3.141592653590e+02
EMIXI_c103_3_00 (mix_i_src_c103_3_00 0 bpf_c103_3 0) vcvs gain=9.807852804032e-01
SMIXI_c103_3_00 (mix_i_src_c103_3_00 mix_i_c103_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_00 (mix_q_src_c103_3_00 0 bpf_c103_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_3_00 (mix_q_src_c103_3_00 mix_q_c103_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_01 (mix_i_src_c103_3_01 0 bpf_c103_3 0) vcvs gain=8.314696123025e-01
SMIXI_c103_3_01 (mix_i_src_c103_3_01 mix_i_c103_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_01 (mix_q_src_c103_3_01 0 bpf_c103_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_3_01 (mix_q_src_c103_3_01 mix_q_c103_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_02 (mix_i_src_c103_3_02 0 bpf_c103_3 0) vcvs gain=5.555702330196e-01
SMIXI_c103_3_02 (mix_i_src_c103_3_02 mix_i_c103_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_02 (mix_q_src_c103_3_02 0 bpf_c103_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_3_02 (mix_q_src_c103_3_02 mix_q_c103_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_03 (mix_i_src_c103_3_03 0 bpf_c103_3 0) vcvs gain=1.950903220161e-01
SMIXI_c103_3_03 (mix_i_src_c103_3_03 mix_i_c103_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_03 (mix_q_src_c103_3_03 0 bpf_c103_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_3_03 (mix_q_src_c103_3_03 mix_q_c103_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_04 (mix_i_src_c103_3_04 0 bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_3_04 (mix_i_src_c103_3_04 mix_i_c103_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_04 (mix_q_src_c103_3_04 0 bpf_c103_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c103_3_04 (mix_q_src_c103_3_04 mix_q_c103_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_05 (mix_i_src_c103_3_05 0 bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_3_05 (mix_i_src_c103_3_05 mix_i_c103_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_05 (mix_q_src_c103_3_05 0 bpf_c103_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c103_3_05 (mix_q_src_c103_3_05 mix_q_c103_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_06 (mix_i_src_c103_3_06 0 bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_3_06 (mix_i_src_c103_3_06 mix_i_c103_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_06 (mix_q_src_c103_3_06 0 bpf_c103_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c103_3_06 (mix_q_src_c103_3_06 mix_q_c103_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_07 (mix_i_src_c103_3_07 0 bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_3_07 (mix_i_src_c103_3_07 mix_i_c103_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_07 (mix_q_src_c103_3_07 0 bpf_c103_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c103_3_07 (mix_q_src_c103_3_07 mix_q_c103_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_08 (mix_i_src_c103_3_08 0 bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c103_3_08 (mix_i_src_c103_3_08 mix_i_c103_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_08 (mix_q_src_c103_3_08 0 bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_3_08 (mix_q_src_c103_3_08 mix_q_c103_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_09 (mix_i_src_c103_3_09 0 bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c103_3_09 (mix_i_src_c103_3_09 mix_i_c103_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_09 (mix_q_src_c103_3_09 0 bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_3_09 (mix_q_src_c103_3_09 mix_q_c103_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_10 (mix_i_src_c103_3_10 0 bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c103_3_10 (mix_i_src_c103_3_10 mix_i_c103_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_10 (mix_q_src_c103_3_10 0 bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_3_10 (mix_q_src_c103_3_10 mix_q_c103_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_11 (mix_i_src_c103_3_11 0 bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c103_3_11 (mix_i_src_c103_3_11 mix_i_c103_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_11 (mix_q_src_c103_3_11 0 bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_3_11 (mix_q_src_c103_3_11 mix_q_c103_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_12 (mix_i_src_c103_3_12 0 bpf_c103_3 0) vcvs gain=1.950903220161e-01
SMIXI_c103_3_12 (mix_i_src_c103_3_12 mix_i_c103_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_12 (mix_q_src_c103_3_12 0 bpf_c103_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c103_3_12 (mix_q_src_c103_3_12 mix_q_c103_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_13 (mix_i_src_c103_3_13 0 bpf_c103_3 0) vcvs gain=5.555702330196e-01
SMIXI_c103_3_13 (mix_i_src_c103_3_13 mix_i_c103_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_13 (mix_q_src_c103_3_13 0 bpf_c103_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c103_3_13 (mix_q_src_c103_3_13 mix_q_c103_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_14 (mix_i_src_c103_3_14 0 bpf_c103_3 0) vcvs gain=8.314696123025e-01
SMIXI_c103_3_14 (mix_i_src_c103_3_14 mix_i_c103_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_14 (mix_q_src_c103_3_14 0 bpf_c103_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c103_3_14 (mix_q_src_c103_3_14 mix_q_c103_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c103_3_15 (mix_i_src_c103_3_15 0 bpf_c103_3 0) vcvs gain=9.807852804032e-01
SMIXI_c103_3_15 (mix_i_src_c103_3_15 mix_i_c103_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c103_3_15 (mix_q_src_c103_3_15 0 bpf_c103_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c103_3_15 (mix_q_src_c103_3_15 mix_q_c103_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c103_3 (mix_i_c103_3 0) resistor r=1G
RMIXQ_c103_3 (mix_q_c103_3 0) resistor r=1G
RINTI_c103_3 (mix_i_c103_3 Icar_c103_3) resistor r=1k
CINTI_c103_3 (Icar_c103_3 0) capacitor c=80p
RINTQ_c103_3 (mix_q_c103_3 Qcar_c103_3) resistor r=1k
CINTQ_c103_3 (Qcar_c103_3 0) capacitor c=80p

// bl104, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c104_0 (bl104 n_cbpf_c104_0) capacitor c=4.052847345694e-13
LBPF_c104_0 (n_cbpf_c104_0 bpf_c104_0) inductor l=1.000000000000e-06
RBPF_c104_0 (bpf_c104_0 0) resistor r=7.853981633974e+01
EMIXI_c104_0_00 (mix_i_src_c104_0_00 0 bpf_c104_0 0) vcvs gain=9.807852804032e-01
SMIXI_c104_0_00 (mix_i_src_c104_0_00 mix_i_c104_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_00 (mix_q_src_c104_0_00 0 bpf_c104_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_0_00 (mix_q_src_c104_0_00 mix_q_c104_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_01 (mix_i_src_c104_0_01 0 bpf_c104_0 0) vcvs gain=8.314696123025e-01
SMIXI_c104_0_01 (mix_i_src_c104_0_01 mix_i_c104_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_01 (mix_q_src_c104_0_01 0 bpf_c104_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_0_01 (mix_q_src_c104_0_01 mix_q_c104_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_02 (mix_i_src_c104_0_02 0 bpf_c104_0 0) vcvs gain=5.555702330196e-01
SMIXI_c104_0_02 (mix_i_src_c104_0_02 mix_i_c104_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_02 (mix_q_src_c104_0_02 0 bpf_c104_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_0_02 (mix_q_src_c104_0_02 mix_q_c104_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_03 (mix_i_src_c104_0_03 0 bpf_c104_0 0) vcvs gain=1.950903220161e-01
SMIXI_c104_0_03 (mix_i_src_c104_0_03 mix_i_c104_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_03 (mix_q_src_c104_0_03 0 bpf_c104_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_0_03 (mix_q_src_c104_0_03 mix_q_c104_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_04 (mix_i_src_c104_0_04 0 bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_0_04 (mix_i_src_c104_0_04 mix_i_c104_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_04 (mix_q_src_c104_0_04 0 bpf_c104_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_0_04 (mix_q_src_c104_0_04 mix_q_c104_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_05 (mix_i_src_c104_0_05 0 bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_0_05 (mix_i_src_c104_0_05 mix_i_c104_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_05 (mix_q_src_c104_0_05 0 bpf_c104_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_0_05 (mix_q_src_c104_0_05 mix_q_c104_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_06 (mix_i_src_c104_0_06 0 bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_0_06 (mix_i_src_c104_0_06 mix_i_c104_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_06 (mix_q_src_c104_0_06 0 bpf_c104_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_0_06 (mix_q_src_c104_0_06 mix_q_c104_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_07 (mix_i_src_c104_0_07 0 bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_0_07 (mix_i_src_c104_0_07 mix_i_c104_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_07 (mix_q_src_c104_0_07 0 bpf_c104_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_0_07 (mix_q_src_c104_0_07 mix_q_c104_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_08 (mix_i_src_c104_0_08 0 bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_0_08 (mix_i_src_c104_0_08 mix_i_c104_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_08 (mix_q_src_c104_0_08 0 bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_0_08 (mix_q_src_c104_0_08 mix_q_c104_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_09 (mix_i_src_c104_0_09 0 bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_0_09 (mix_i_src_c104_0_09 mix_i_c104_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_09 (mix_q_src_c104_0_09 0 bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_0_09 (mix_q_src_c104_0_09 mix_q_c104_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_10 (mix_i_src_c104_0_10 0 bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_0_10 (mix_i_src_c104_0_10 mix_i_c104_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_10 (mix_q_src_c104_0_10 0 bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_0_10 (mix_q_src_c104_0_10 mix_q_c104_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_11 (mix_i_src_c104_0_11 0 bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_0_11 (mix_i_src_c104_0_11 mix_i_c104_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_11 (mix_q_src_c104_0_11 0 bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_0_11 (mix_q_src_c104_0_11 mix_q_c104_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_12 (mix_i_src_c104_0_12 0 bpf_c104_0 0) vcvs gain=1.950903220161e-01
SMIXI_c104_0_12 (mix_i_src_c104_0_12 mix_i_c104_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_12 (mix_q_src_c104_0_12 0 bpf_c104_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_0_12 (mix_q_src_c104_0_12 mix_q_c104_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_13 (mix_i_src_c104_0_13 0 bpf_c104_0 0) vcvs gain=5.555702330196e-01
SMIXI_c104_0_13 (mix_i_src_c104_0_13 mix_i_c104_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_13 (mix_q_src_c104_0_13 0 bpf_c104_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_0_13 (mix_q_src_c104_0_13 mix_q_c104_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_14 (mix_i_src_c104_0_14 0 bpf_c104_0 0) vcvs gain=8.314696123025e-01
SMIXI_c104_0_14 (mix_i_src_c104_0_14 mix_i_c104_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_14 (mix_q_src_c104_0_14 0 bpf_c104_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_0_14 (mix_q_src_c104_0_14 mix_q_c104_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_0_15 (mix_i_src_c104_0_15 0 bpf_c104_0 0) vcvs gain=9.807852804032e-01
SMIXI_c104_0_15 (mix_i_src_c104_0_15 mix_i_c104_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_0_15 (mix_q_src_c104_0_15 0 bpf_c104_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_0_15 (mix_q_src_c104_0_15 mix_q_c104_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c104_0 (mix_i_c104_0 0) resistor r=1G
RMIXQ_c104_0 (mix_q_c104_0 0) resistor r=1G
RINTI_c104_0 (mix_i_c104_0 Icar_c104_0) resistor r=1k
CINTI_c104_0 (Icar_c104_0 0) capacitor c=80p
RINTQ_c104_0 (mix_q_c104_0 Qcar_c104_0) resistor r=1k
CINTQ_c104_0 (Qcar_c104_0 0) capacitor c=80p

// bl104, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c104_1 (bl104 n_cbpf_c104_1) capacitor c=1.013211836423e-13
LBPF_c104_1 (n_cbpf_c104_1 bpf_c104_1) inductor l=1.000000000000e-06
RBPF_c104_1 (bpf_c104_1 0) resistor r=1.570796326795e+02
EMIXI_c104_1_00 (mix_i_src_c104_1_00 0 bpf_c104_1 0) vcvs gain=9.807852804032e-01
SMIXI_c104_1_00 (mix_i_src_c104_1_00 mix_i_c104_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_00 (mix_q_src_c104_1_00 0 bpf_c104_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_1_00 (mix_q_src_c104_1_00 mix_q_c104_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_01 (mix_i_src_c104_1_01 0 bpf_c104_1 0) vcvs gain=8.314696123025e-01
SMIXI_c104_1_01 (mix_i_src_c104_1_01 mix_i_c104_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_01 (mix_q_src_c104_1_01 0 bpf_c104_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_1_01 (mix_q_src_c104_1_01 mix_q_c104_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_02 (mix_i_src_c104_1_02 0 bpf_c104_1 0) vcvs gain=5.555702330196e-01
SMIXI_c104_1_02 (mix_i_src_c104_1_02 mix_i_c104_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_02 (mix_q_src_c104_1_02 0 bpf_c104_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_1_02 (mix_q_src_c104_1_02 mix_q_c104_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_03 (mix_i_src_c104_1_03 0 bpf_c104_1 0) vcvs gain=1.950903220161e-01
SMIXI_c104_1_03 (mix_i_src_c104_1_03 mix_i_c104_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_03 (mix_q_src_c104_1_03 0 bpf_c104_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_1_03 (mix_q_src_c104_1_03 mix_q_c104_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_04 (mix_i_src_c104_1_04 0 bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_1_04 (mix_i_src_c104_1_04 mix_i_c104_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_04 (mix_q_src_c104_1_04 0 bpf_c104_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_1_04 (mix_q_src_c104_1_04 mix_q_c104_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_05 (mix_i_src_c104_1_05 0 bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_1_05 (mix_i_src_c104_1_05 mix_i_c104_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_05 (mix_q_src_c104_1_05 0 bpf_c104_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_1_05 (mix_q_src_c104_1_05 mix_q_c104_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_06 (mix_i_src_c104_1_06 0 bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_1_06 (mix_i_src_c104_1_06 mix_i_c104_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_06 (mix_q_src_c104_1_06 0 bpf_c104_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_1_06 (mix_q_src_c104_1_06 mix_q_c104_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_07 (mix_i_src_c104_1_07 0 bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_1_07 (mix_i_src_c104_1_07 mix_i_c104_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_07 (mix_q_src_c104_1_07 0 bpf_c104_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_1_07 (mix_q_src_c104_1_07 mix_q_c104_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_08 (mix_i_src_c104_1_08 0 bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_1_08 (mix_i_src_c104_1_08 mix_i_c104_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_08 (mix_q_src_c104_1_08 0 bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_1_08 (mix_q_src_c104_1_08 mix_q_c104_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_09 (mix_i_src_c104_1_09 0 bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_1_09 (mix_i_src_c104_1_09 mix_i_c104_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_09 (mix_q_src_c104_1_09 0 bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_1_09 (mix_q_src_c104_1_09 mix_q_c104_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_10 (mix_i_src_c104_1_10 0 bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_1_10 (mix_i_src_c104_1_10 mix_i_c104_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_10 (mix_q_src_c104_1_10 0 bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_1_10 (mix_q_src_c104_1_10 mix_q_c104_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_11 (mix_i_src_c104_1_11 0 bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_1_11 (mix_i_src_c104_1_11 mix_i_c104_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_11 (mix_q_src_c104_1_11 0 bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_1_11 (mix_q_src_c104_1_11 mix_q_c104_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_12 (mix_i_src_c104_1_12 0 bpf_c104_1 0) vcvs gain=1.950903220161e-01
SMIXI_c104_1_12 (mix_i_src_c104_1_12 mix_i_c104_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_12 (mix_q_src_c104_1_12 0 bpf_c104_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_1_12 (mix_q_src_c104_1_12 mix_q_c104_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_13 (mix_i_src_c104_1_13 0 bpf_c104_1 0) vcvs gain=5.555702330196e-01
SMIXI_c104_1_13 (mix_i_src_c104_1_13 mix_i_c104_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_13 (mix_q_src_c104_1_13 0 bpf_c104_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_1_13 (mix_q_src_c104_1_13 mix_q_c104_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_14 (mix_i_src_c104_1_14 0 bpf_c104_1 0) vcvs gain=8.314696123025e-01
SMIXI_c104_1_14 (mix_i_src_c104_1_14 mix_i_c104_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_14 (mix_q_src_c104_1_14 0 bpf_c104_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_1_14 (mix_q_src_c104_1_14 mix_q_c104_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_1_15 (mix_i_src_c104_1_15 0 bpf_c104_1 0) vcvs gain=9.807852804032e-01
SMIXI_c104_1_15 (mix_i_src_c104_1_15 mix_i_c104_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_1_15 (mix_q_src_c104_1_15 0 bpf_c104_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_1_15 (mix_q_src_c104_1_15 mix_q_c104_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c104_1 (mix_i_c104_1 0) resistor r=1G
RMIXQ_c104_1 (mix_q_c104_1 0) resistor r=1G
RINTI_c104_1 (mix_i_c104_1 Icar_c104_1) resistor r=1k
CINTI_c104_1 (Icar_c104_1 0) capacitor c=80p
RINTQ_c104_1 (mix_q_c104_1 Qcar_c104_1) resistor r=1k
CINTQ_c104_1 (Qcar_c104_1 0) capacitor c=80p

// bl104, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c104_2 (bl104 n_cbpf_c104_2) capacitor c=4.503163717437e-14
LBPF_c104_2 (n_cbpf_c104_2 bpf_c104_2) inductor l=1.000000000000e-06
RBPF_c104_2 (bpf_c104_2 0) resistor r=2.356194490192e+02
EMIXI_c104_2_00 (mix_i_src_c104_2_00 0 bpf_c104_2 0) vcvs gain=9.807852804032e-01
SMIXI_c104_2_00 (mix_i_src_c104_2_00 mix_i_c104_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_00 (mix_q_src_c104_2_00 0 bpf_c104_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_2_00 (mix_q_src_c104_2_00 mix_q_c104_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_01 (mix_i_src_c104_2_01 0 bpf_c104_2 0) vcvs gain=8.314696123025e-01
SMIXI_c104_2_01 (mix_i_src_c104_2_01 mix_i_c104_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_01 (mix_q_src_c104_2_01 0 bpf_c104_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_2_01 (mix_q_src_c104_2_01 mix_q_c104_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_02 (mix_i_src_c104_2_02 0 bpf_c104_2 0) vcvs gain=5.555702330196e-01
SMIXI_c104_2_02 (mix_i_src_c104_2_02 mix_i_c104_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_02 (mix_q_src_c104_2_02 0 bpf_c104_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_2_02 (mix_q_src_c104_2_02 mix_q_c104_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_03 (mix_i_src_c104_2_03 0 bpf_c104_2 0) vcvs gain=1.950903220161e-01
SMIXI_c104_2_03 (mix_i_src_c104_2_03 mix_i_c104_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_03 (mix_q_src_c104_2_03 0 bpf_c104_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_2_03 (mix_q_src_c104_2_03 mix_q_c104_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_04 (mix_i_src_c104_2_04 0 bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_2_04 (mix_i_src_c104_2_04 mix_i_c104_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_04 (mix_q_src_c104_2_04 0 bpf_c104_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_2_04 (mix_q_src_c104_2_04 mix_q_c104_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_05 (mix_i_src_c104_2_05 0 bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_2_05 (mix_i_src_c104_2_05 mix_i_c104_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_05 (mix_q_src_c104_2_05 0 bpf_c104_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_2_05 (mix_q_src_c104_2_05 mix_q_c104_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_06 (mix_i_src_c104_2_06 0 bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_2_06 (mix_i_src_c104_2_06 mix_i_c104_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_06 (mix_q_src_c104_2_06 0 bpf_c104_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_2_06 (mix_q_src_c104_2_06 mix_q_c104_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_07 (mix_i_src_c104_2_07 0 bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_2_07 (mix_i_src_c104_2_07 mix_i_c104_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_07 (mix_q_src_c104_2_07 0 bpf_c104_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_2_07 (mix_q_src_c104_2_07 mix_q_c104_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_08 (mix_i_src_c104_2_08 0 bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_2_08 (mix_i_src_c104_2_08 mix_i_c104_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_08 (mix_q_src_c104_2_08 0 bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_2_08 (mix_q_src_c104_2_08 mix_q_c104_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_09 (mix_i_src_c104_2_09 0 bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_2_09 (mix_i_src_c104_2_09 mix_i_c104_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_09 (mix_q_src_c104_2_09 0 bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_2_09 (mix_q_src_c104_2_09 mix_q_c104_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_10 (mix_i_src_c104_2_10 0 bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_2_10 (mix_i_src_c104_2_10 mix_i_c104_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_10 (mix_q_src_c104_2_10 0 bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_2_10 (mix_q_src_c104_2_10 mix_q_c104_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_11 (mix_i_src_c104_2_11 0 bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_2_11 (mix_i_src_c104_2_11 mix_i_c104_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_11 (mix_q_src_c104_2_11 0 bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_2_11 (mix_q_src_c104_2_11 mix_q_c104_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_12 (mix_i_src_c104_2_12 0 bpf_c104_2 0) vcvs gain=1.950903220161e-01
SMIXI_c104_2_12 (mix_i_src_c104_2_12 mix_i_c104_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_12 (mix_q_src_c104_2_12 0 bpf_c104_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_2_12 (mix_q_src_c104_2_12 mix_q_c104_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_13 (mix_i_src_c104_2_13 0 bpf_c104_2 0) vcvs gain=5.555702330196e-01
SMIXI_c104_2_13 (mix_i_src_c104_2_13 mix_i_c104_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_13 (mix_q_src_c104_2_13 0 bpf_c104_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_2_13 (mix_q_src_c104_2_13 mix_q_c104_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_14 (mix_i_src_c104_2_14 0 bpf_c104_2 0) vcvs gain=8.314696123025e-01
SMIXI_c104_2_14 (mix_i_src_c104_2_14 mix_i_c104_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_14 (mix_q_src_c104_2_14 0 bpf_c104_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_2_14 (mix_q_src_c104_2_14 mix_q_c104_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_2_15 (mix_i_src_c104_2_15 0 bpf_c104_2 0) vcvs gain=9.807852804032e-01
SMIXI_c104_2_15 (mix_i_src_c104_2_15 mix_i_c104_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_2_15 (mix_q_src_c104_2_15 0 bpf_c104_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_2_15 (mix_q_src_c104_2_15 mix_q_c104_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c104_2 (mix_i_c104_2 0) resistor r=1G
RMIXQ_c104_2 (mix_q_c104_2 0) resistor r=1G
RINTI_c104_2 (mix_i_c104_2 Icar_c104_2) resistor r=1k
CINTI_c104_2 (Icar_c104_2 0) capacitor c=80p
RINTQ_c104_2 (mix_q_c104_2 Qcar_c104_2) resistor r=1k
CINTQ_c104_2 (Qcar_c104_2 0) capacitor c=80p

// bl104, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c104_3 (bl104 n_cbpf_c104_3) capacitor c=2.533029591058e-14
LBPF_c104_3 (n_cbpf_c104_3 bpf_c104_3) inductor l=1.000000000000e-06
RBPF_c104_3 (bpf_c104_3 0) resistor r=3.141592653590e+02
EMIXI_c104_3_00 (mix_i_src_c104_3_00 0 bpf_c104_3 0) vcvs gain=9.807852804032e-01
SMIXI_c104_3_00 (mix_i_src_c104_3_00 mix_i_c104_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_00 (mix_q_src_c104_3_00 0 bpf_c104_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_3_00 (mix_q_src_c104_3_00 mix_q_c104_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_01 (mix_i_src_c104_3_01 0 bpf_c104_3 0) vcvs gain=8.314696123025e-01
SMIXI_c104_3_01 (mix_i_src_c104_3_01 mix_i_c104_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_01 (mix_q_src_c104_3_01 0 bpf_c104_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_3_01 (mix_q_src_c104_3_01 mix_q_c104_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_02 (mix_i_src_c104_3_02 0 bpf_c104_3 0) vcvs gain=5.555702330196e-01
SMIXI_c104_3_02 (mix_i_src_c104_3_02 mix_i_c104_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_02 (mix_q_src_c104_3_02 0 bpf_c104_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_3_02 (mix_q_src_c104_3_02 mix_q_c104_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_03 (mix_i_src_c104_3_03 0 bpf_c104_3 0) vcvs gain=1.950903220161e-01
SMIXI_c104_3_03 (mix_i_src_c104_3_03 mix_i_c104_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_03 (mix_q_src_c104_3_03 0 bpf_c104_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_3_03 (mix_q_src_c104_3_03 mix_q_c104_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_04 (mix_i_src_c104_3_04 0 bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_3_04 (mix_i_src_c104_3_04 mix_i_c104_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_04 (mix_q_src_c104_3_04 0 bpf_c104_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c104_3_04 (mix_q_src_c104_3_04 mix_q_c104_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_05 (mix_i_src_c104_3_05 0 bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_3_05 (mix_i_src_c104_3_05 mix_i_c104_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_05 (mix_q_src_c104_3_05 0 bpf_c104_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c104_3_05 (mix_q_src_c104_3_05 mix_q_c104_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_06 (mix_i_src_c104_3_06 0 bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_3_06 (mix_i_src_c104_3_06 mix_i_c104_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_06 (mix_q_src_c104_3_06 0 bpf_c104_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c104_3_06 (mix_q_src_c104_3_06 mix_q_c104_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_07 (mix_i_src_c104_3_07 0 bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_3_07 (mix_i_src_c104_3_07 mix_i_c104_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_07 (mix_q_src_c104_3_07 0 bpf_c104_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c104_3_07 (mix_q_src_c104_3_07 mix_q_c104_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_08 (mix_i_src_c104_3_08 0 bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c104_3_08 (mix_i_src_c104_3_08 mix_i_c104_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_08 (mix_q_src_c104_3_08 0 bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_3_08 (mix_q_src_c104_3_08 mix_q_c104_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_09 (mix_i_src_c104_3_09 0 bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c104_3_09 (mix_i_src_c104_3_09 mix_i_c104_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_09 (mix_q_src_c104_3_09 0 bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_3_09 (mix_q_src_c104_3_09 mix_q_c104_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_10 (mix_i_src_c104_3_10 0 bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c104_3_10 (mix_i_src_c104_3_10 mix_i_c104_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_10 (mix_q_src_c104_3_10 0 bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_3_10 (mix_q_src_c104_3_10 mix_q_c104_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_11 (mix_i_src_c104_3_11 0 bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c104_3_11 (mix_i_src_c104_3_11 mix_i_c104_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_11 (mix_q_src_c104_3_11 0 bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_3_11 (mix_q_src_c104_3_11 mix_q_c104_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_12 (mix_i_src_c104_3_12 0 bpf_c104_3 0) vcvs gain=1.950903220161e-01
SMIXI_c104_3_12 (mix_i_src_c104_3_12 mix_i_c104_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_12 (mix_q_src_c104_3_12 0 bpf_c104_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c104_3_12 (mix_q_src_c104_3_12 mix_q_c104_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_13 (mix_i_src_c104_3_13 0 bpf_c104_3 0) vcvs gain=5.555702330196e-01
SMIXI_c104_3_13 (mix_i_src_c104_3_13 mix_i_c104_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_13 (mix_q_src_c104_3_13 0 bpf_c104_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c104_3_13 (mix_q_src_c104_3_13 mix_q_c104_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_14 (mix_i_src_c104_3_14 0 bpf_c104_3 0) vcvs gain=8.314696123025e-01
SMIXI_c104_3_14 (mix_i_src_c104_3_14 mix_i_c104_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_14 (mix_q_src_c104_3_14 0 bpf_c104_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c104_3_14 (mix_q_src_c104_3_14 mix_q_c104_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c104_3_15 (mix_i_src_c104_3_15 0 bpf_c104_3 0) vcvs gain=9.807852804032e-01
SMIXI_c104_3_15 (mix_i_src_c104_3_15 mix_i_c104_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c104_3_15 (mix_q_src_c104_3_15 0 bpf_c104_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c104_3_15 (mix_q_src_c104_3_15 mix_q_c104_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c104_3 (mix_i_c104_3 0) resistor r=1G
RMIXQ_c104_3 (mix_q_c104_3 0) resistor r=1G
RINTI_c104_3 (mix_i_c104_3 Icar_c104_3) resistor r=1k
CINTI_c104_3 (Icar_c104_3 0) capacitor c=80p
RINTQ_c104_3 (mix_q_c104_3 Qcar_c104_3) resistor r=1k
CINTQ_c104_3 (Qcar_c104_3 0) capacitor c=80p

// bl105, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c105_0 (bl105 n_cbpf_c105_0) capacitor c=4.052847345694e-13
LBPF_c105_0 (n_cbpf_c105_0 bpf_c105_0) inductor l=1.000000000000e-06
RBPF_c105_0 (bpf_c105_0 0) resistor r=7.853981633974e+01
EMIXI_c105_0_00 (mix_i_src_c105_0_00 0 bpf_c105_0 0) vcvs gain=9.807852804032e-01
SMIXI_c105_0_00 (mix_i_src_c105_0_00 mix_i_c105_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_00 (mix_q_src_c105_0_00 0 bpf_c105_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_0_00 (mix_q_src_c105_0_00 mix_q_c105_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_01 (mix_i_src_c105_0_01 0 bpf_c105_0 0) vcvs gain=8.314696123025e-01
SMIXI_c105_0_01 (mix_i_src_c105_0_01 mix_i_c105_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_01 (mix_q_src_c105_0_01 0 bpf_c105_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_0_01 (mix_q_src_c105_0_01 mix_q_c105_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_02 (mix_i_src_c105_0_02 0 bpf_c105_0 0) vcvs gain=5.555702330196e-01
SMIXI_c105_0_02 (mix_i_src_c105_0_02 mix_i_c105_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_02 (mix_q_src_c105_0_02 0 bpf_c105_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_0_02 (mix_q_src_c105_0_02 mix_q_c105_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_03 (mix_i_src_c105_0_03 0 bpf_c105_0 0) vcvs gain=1.950903220161e-01
SMIXI_c105_0_03 (mix_i_src_c105_0_03 mix_i_c105_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_03 (mix_q_src_c105_0_03 0 bpf_c105_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_0_03 (mix_q_src_c105_0_03 mix_q_c105_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_04 (mix_i_src_c105_0_04 0 bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_0_04 (mix_i_src_c105_0_04 mix_i_c105_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_04 (mix_q_src_c105_0_04 0 bpf_c105_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_0_04 (mix_q_src_c105_0_04 mix_q_c105_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_05 (mix_i_src_c105_0_05 0 bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_0_05 (mix_i_src_c105_0_05 mix_i_c105_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_05 (mix_q_src_c105_0_05 0 bpf_c105_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_0_05 (mix_q_src_c105_0_05 mix_q_c105_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_06 (mix_i_src_c105_0_06 0 bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_0_06 (mix_i_src_c105_0_06 mix_i_c105_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_06 (mix_q_src_c105_0_06 0 bpf_c105_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_0_06 (mix_q_src_c105_0_06 mix_q_c105_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_07 (mix_i_src_c105_0_07 0 bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_0_07 (mix_i_src_c105_0_07 mix_i_c105_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_07 (mix_q_src_c105_0_07 0 bpf_c105_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_0_07 (mix_q_src_c105_0_07 mix_q_c105_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_08 (mix_i_src_c105_0_08 0 bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_0_08 (mix_i_src_c105_0_08 mix_i_c105_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_08 (mix_q_src_c105_0_08 0 bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_0_08 (mix_q_src_c105_0_08 mix_q_c105_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_09 (mix_i_src_c105_0_09 0 bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_0_09 (mix_i_src_c105_0_09 mix_i_c105_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_09 (mix_q_src_c105_0_09 0 bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_0_09 (mix_q_src_c105_0_09 mix_q_c105_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_10 (mix_i_src_c105_0_10 0 bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_0_10 (mix_i_src_c105_0_10 mix_i_c105_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_10 (mix_q_src_c105_0_10 0 bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_0_10 (mix_q_src_c105_0_10 mix_q_c105_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_11 (mix_i_src_c105_0_11 0 bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_0_11 (mix_i_src_c105_0_11 mix_i_c105_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_11 (mix_q_src_c105_0_11 0 bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_0_11 (mix_q_src_c105_0_11 mix_q_c105_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_12 (mix_i_src_c105_0_12 0 bpf_c105_0 0) vcvs gain=1.950903220161e-01
SMIXI_c105_0_12 (mix_i_src_c105_0_12 mix_i_c105_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_12 (mix_q_src_c105_0_12 0 bpf_c105_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_0_12 (mix_q_src_c105_0_12 mix_q_c105_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_13 (mix_i_src_c105_0_13 0 bpf_c105_0 0) vcvs gain=5.555702330196e-01
SMIXI_c105_0_13 (mix_i_src_c105_0_13 mix_i_c105_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_13 (mix_q_src_c105_0_13 0 bpf_c105_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_0_13 (mix_q_src_c105_0_13 mix_q_c105_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_14 (mix_i_src_c105_0_14 0 bpf_c105_0 0) vcvs gain=8.314696123025e-01
SMIXI_c105_0_14 (mix_i_src_c105_0_14 mix_i_c105_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_14 (mix_q_src_c105_0_14 0 bpf_c105_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_0_14 (mix_q_src_c105_0_14 mix_q_c105_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_0_15 (mix_i_src_c105_0_15 0 bpf_c105_0 0) vcvs gain=9.807852804032e-01
SMIXI_c105_0_15 (mix_i_src_c105_0_15 mix_i_c105_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_0_15 (mix_q_src_c105_0_15 0 bpf_c105_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_0_15 (mix_q_src_c105_0_15 mix_q_c105_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c105_0 (mix_i_c105_0 0) resistor r=1G
RMIXQ_c105_0 (mix_q_c105_0 0) resistor r=1G
RINTI_c105_0 (mix_i_c105_0 Icar_c105_0) resistor r=1k
CINTI_c105_0 (Icar_c105_0 0) capacitor c=80p
RINTQ_c105_0 (mix_q_c105_0 Qcar_c105_0) resistor r=1k
CINTQ_c105_0 (Qcar_c105_0 0) capacitor c=80p

// bl105, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c105_1 (bl105 n_cbpf_c105_1) capacitor c=1.013211836423e-13
LBPF_c105_1 (n_cbpf_c105_1 bpf_c105_1) inductor l=1.000000000000e-06
RBPF_c105_1 (bpf_c105_1 0) resistor r=1.570796326795e+02
EMIXI_c105_1_00 (mix_i_src_c105_1_00 0 bpf_c105_1 0) vcvs gain=9.807852804032e-01
SMIXI_c105_1_00 (mix_i_src_c105_1_00 mix_i_c105_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_00 (mix_q_src_c105_1_00 0 bpf_c105_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_1_00 (mix_q_src_c105_1_00 mix_q_c105_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_01 (mix_i_src_c105_1_01 0 bpf_c105_1 0) vcvs gain=8.314696123025e-01
SMIXI_c105_1_01 (mix_i_src_c105_1_01 mix_i_c105_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_01 (mix_q_src_c105_1_01 0 bpf_c105_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_1_01 (mix_q_src_c105_1_01 mix_q_c105_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_02 (mix_i_src_c105_1_02 0 bpf_c105_1 0) vcvs gain=5.555702330196e-01
SMIXI_c105_1_02 (mix_i_src_c105_1_02 mix_i_c105_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_02 (mix_q_src_c105_1_02 0 bpf_c105_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_1_02 (mix_q_src_c105_1_02 mix_q_c105_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_03 (mix_i_src_c105_1_03 0 bpf_c105_1 0) vcvs gain=1.950903220161e-01
SMIXI_c105_1_03 (mix_i_src_c105_1_03 mix_i_c105_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_03 (mix_q_src_c105_1_03 0 bpf_c105_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_1_03 (mix_q_src_c105_1_03 mix_q_c105_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_04 (mix_i_src_c105_1_04 0 bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_1_04 (mix_i_src_c105_1_04 mix_i_c105_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_04 (mix_q_src_c105_1_04 0 bpf_c105_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_1_04 (mix_q_src_c105_1_04 mix_q_c105_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_05 (mix_i_src_c105_1_05 0 bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_1_05 (mix_i_src_c105_1_05 mix_i_c105_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_05 (mix_q_src_c105_1_05 0 bpf_c105_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_1_05 (mix_q_src_c105_1_05 mix_q_c105_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_06 (mix_i_src_c105_1_06 0 bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_1_06 (mix_i_src_c105_1_06 mix_i_c105_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_06 (mix_q_src_c105_1_06 0 bpf_c105_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_1_06 (mix_q_src_c105_1_06 mix_q_c105_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_07 (mix_i_src_c105_1_07 0 bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_1_07 (mix_i_src_c105_1_07 mix_i_c105_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_07 (mix_q_src_c105_1_07 0 bpf_c105_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_1_07 (mix_q_src_c105_1_07 mix_q_c105_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_08 (mix_i_src_c105_1_08 0 bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_1_08 (mix_i_src_c105_1_08 mix_i_c105_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_08 (mix_q_src_c105_1_08 0 bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_1_08 (mix_q_src_c105_1_08 mix_q_c105_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_09 (mix_i_src_c105_1_09 0 bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_1_09 (mix_i_src_c105_1_09 mix_i_c105_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_09 (mix_q_src_c105_1_09 0 bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_1_09 (mix_q_src_c105_1_09 mix_q_c105_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_10 (mix_i_src_c105_1_10 0 bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_1_10 (mix_i_src_c105_1_10 mix_i_c105_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_10 (mix_q_src_c105_1_10 0 bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_1_10 (mix_q_src_c105_1_10 mix_q_c105_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_11 (mix_i_src_c105_1_11 0 bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_1_11 (mix_i_src_c105_1_11 mix_i_c105_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_11 (mix_q_src_c105_1_11 0 bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_1_11 (mix_q_src_c105_1_11 mix_q_c105_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_12 (mix_i_src_c105_1_12 0 bpf_c105_1 0) vcvs gain=1.950903220161e-01
SMIXI_c105_1_12 (mix_i_src_c105_1_12 mix_i_c105_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_12 (mix_q_src_c105_1_12 0 bpf_c105_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_1_12 (mix_q_src_c105_1_12 mix_q_c105_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_13 (mix_i_src_c105_1_13 0 bpf_c105_1 0) vcvs gain=5.555702330196e-01
SMIXI_c105_1_13 (mix_i_src_c105_1_13 mix_i_c105_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_13 (mix_q_src_c105_1_13 0 bpf_c105_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_1_13 (mix_q_src_c105_1_13 mix_q_c105_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_14 (mix_i_src_c105_1_14 0 bpf_c105_1 0) vcvs gain=8.314696123025e-01
SMIXI_c105_1_14 (mix_i_src_c105_1_14 mix_i_c105_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_14 (mix_q_src_c105_1_14 0 bpf_c105_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_1_14 (mix_q_src_c105_1_14 mix_q_c105_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_1_15 (mix_i_src_c105_1_15 0 bpf_c105_1 0) vcvs gain=9.807852804032e-01
SMIXI_c105_1_15 (mix_i_src_c105_1_15 mix_i_c105_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_1_15 (mix_q_src_c105_1_15 0 bpf_c105_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_1_15 (mix_q_src_c105_1_15 mix_q_c105_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c105_1 (mix_i_c105_1 0) resistor r=1G
RMIXQ_c105_1 (mix_q_c105_1 0) resistor r=1G
RINTI_c105_1 (mix_i_c105_1 Icar_c105_1) resistor r=1k
CINTI_c105_1 (Icar_c105_1 0) capacitor c=80p
RINTQ_c105_1 (mix_q_c105_1 Qcar_c105_1) resistor r=1k
CINTQ_c105_1 (Qcar_c105_1 0) capacitor c=80p

// bl105, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c105_2 (bl105 n_cbpf_c105_2) capacitor c=4.503163717437e-14
LBPF_c105_2 (n_cbpf_c105_2 bpf_c105_2) inductor l=1.000000000000e-06
RBPF_c105_2 (bpf_c105_2 0) resistor r=2.356194490192e+02
EMIXI_c105_2_00 (mix_i_src_c105_2_00 0 bpf_c105_2 0) vcvs gain=9.807852804032e-01
SMIXI_c105_2_00 (mix_i_src_c105_2_00 mix_i_c105_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_00 (mix_q_src_c105_2_00 0 bpf_c105_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_2_00 (mix_q_src_c105_2_00 mix_q_c105_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_01 (mix_i_src_c105_2_01 0 bpf_c105_2 0) vcvs gain=8.314696123025e-01
SMIXI_c105_2_01 (mix_i_src_c105_2_01 mix_i_c105_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_01 (mix_q_src_c105_2_01 0 bpf_c105_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_2_01 (mix_q_src_c105_2_01 mix_q_c105_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_02 (mix_i_src_c105_2_02 0 bpf_c105_2 0) vcvs gain=5.555702330196e-01
SMIXI_c105_2_02 (mix_i_src_c105_2_02 mix_i_c105_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_02 (mix_q_src_c105_2_02 0 bpf_c105_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_2_02 (mix_q_src_c105_2_02 mix_q_c105_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_03 (mix_i_src_c105_2_03 0 bpf_c105_2 0) vcvs gain=1.950903220161e-01
SMIXI_c105_2_03 (mix_i_src_c105_2_03 mix_i_c105_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_03 (mix_q_src_c105_2_03 0 bpf_c105_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_2_03 (mix_q_src_c105_2_03 mix_q_c105_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_04 (mix_i_src_c105_2_04 0 bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_2_04 (mix_i_src_c105_2_04 mix_i_c105_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_04 (mix_q_src_c105_2_04 0 bpf_c105_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_2_04 (mix_q_src_c105_2_04 mix_q_c105_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_05 (mix_i_src_c105_2_05 0 bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_2_05 (mix_i_src_c105_2_05 mix_i_c105_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_05 (mix_q_src_c105_2_05 0 bpf_c105_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_2_05 (mix_q_src_c105_2_05 mix_q_c105_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_06 (mix_i_src_c105_2_06 0 bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_2_06 (mix_i_src_c105_2_06 mix_i_c105_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_06 (mix_q_src_c105_2_06 0 bpf_c105_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_2_06 (mix_q_src_c105_2_06 mix_q_c105_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_07 (mix_i_src_c105_2_07 0 bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_2_07 (mix_i_src_c105_2_07 mix_i_c105_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_07 (mix_q_src_c105_2_07 0 bpf_c105_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_2_07 (mix_q_src_c105_2_07 mix_q_c105_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_08 (mix_i_src_c105_2_08 0 bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_2_08 (mix_i_src_c105_2_08 mix_i_c105_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_08 (mix_q_src_c105_2_08 0 bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_2_08 (mix_q_src_c105_2_08 mix_q_c105_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_09 (mix_i_src_c105_2_09 0 bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_2_09 (mix_i_src_c105_2_09 mix_i_c105_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_09 (mix_q_src_c105_2_09 0 bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_2_09 (mix_q_src_c105_2_09 mix_q_c105_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_10 (mix_i_src_c105_2_10 0 bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_2_10 (mix_i_src_c105_2_10 mix_i_c105_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_10 (mix_q_src_c105_2_10 0 bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_2_10 (mix_q_src_c105_2_10 mix_q_c105_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_11 (mix_i_src_c105_2_11 0 bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_2_11 (mix_i_src_c105_2_11 mix_i_c105_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_11 (mix_q_src_c105_2_11 0 bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_2_11 (mix_q_src_c105_2_11 mix_q_c105_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_12 (mix_i_src_c105_2_12 0 bpf_c105_2 0) vcvs gain=1.950903220161e-01
SMIXI_c105_2_12 (mix_i_src_c105_2_12 mix_i_c105_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_12 (mix_q_src_c105_2_12 0 bpf_c105_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_2_12 (mix_q_src_c105_2_12 mix_q_c105_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_13 (mix_i_src_c105_2_13 0 bpf_c105_2 0) vcvs gain=5.555702330196e-01
SMIXI_c105_2_13 (mix_i_src_c105_2_13 mix_i_c105_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_13 (mix_q_src_c105_2_13 0 bpf_c105_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_2_13 (mix_q_src_c105_2_13 mix_q_c105_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_14 (mix_i_src_c105_2_14 0 bpf_c105_2 0) vcvs gain=8.314696123025e-01
SMIXI_c105_2_14 (mix_i_src_c105_2_14 mix_i_c105_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_14 (mix_q_src_c105_2_14 0 bpf_c105_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_2_14 (mix_q_src_c105_2_14 mix_q_c105_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_2_15 (mix_i_src_c105_2_15 0 bpf_c105_2 0) vcvs gain=9.807852804032e-01
SMIXI_c105_2_15 (mix_i_src_c105_2_15 mix_i_c105_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_2_15 (mix_q_src_c105_2_15 0 bpf_c105_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_2_15 (mix_q_src_c105_2_15 mix_q_c105_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c105_2 (mix_i_c105_2 0) resistor r=1G
RMIXQ_c105_2 (mix_q_c105_2 0) resistor r=1G
RINTI_c105_2 (mix_i_c105_2 Icar_c105_2) resistor r=1k
CINTI_c105_2 (Icar_c105_2 0) capacitor c=80p
RINTQ_c105_2 (mix_q_c105_2 Qcar_c105_2) resistor r=1k
CINTQ_c105_2 (Qcar_c105_2 0) capacitor c=80p

// bl105, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c105_3 (bl105 n_cbpf_c105_3) capacitor c=2.533029591058e-14
LBPF_c105_3 (n_cbpf_c105_3 bpf_c105_3) inductor l=1.000000000000e-06
RBPF_c105_3 (bpf_c105_3 0) resistor r=3.141592653590e+02
EMIXI_c105_3_00 (mix_i_src_c105_3_00 0 bpf_c105_3 0) vcvs gain=9.807852804032e-01
SMIXI_c105_3_00 (mix_i_src_c105_3_00 mix_i_c105_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_00 (mix_q_src_c105_3_00 0 bpf_c105_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_3_00 (mix_q_src_c105_3_00 mix_q_c105_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_01 (mix_i_src_c105_3_01 0 bpf_c105_3 0) vcvs gain=8.314696123025e-01
SMIXI_c105_3_01 (mix_i_src_c105_3_01 mix_i_c105_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_01 (mix_q_src_c105_3_01 0 bpf_c105_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_3_01 (mix_q_src_c105_3_01 mix_q_c105_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_02 (mix_i_src_c105_3_02 0 bpf_c105_3 0) vcvs gain=5.555702330196e-01
SMIXI_c105_3_02 (mix_i_src_c105_3_02 mix_i_c105_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_02 (mix_q_src_c105_3_02 0 bpf_c105_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_3_02 (mix_q_src_c105_3_02 mix_q_c105_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_03 (mix_i_src_c105_3_03 0 bpf_c105_3 0) vcvs gain=1.950903220161e-01
SMIXI_c105_3_03 (mix_i_src_c105_3_03 mix_i_c105_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_03 (mix_q_src_c105_3_03 0 bpf_c105_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_3_03 (mix_q_src_c105_3_03 mix_q_c105_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_04 (mix_i_src_c105_3_04 0 bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_3_04 (mix_i_src_c105_3_04 mix_i_c105_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_04 (mix_q_src_c105_3_04 0 bpf_c105_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c105_3_04 (mix_q_src_c105_3_04 mix_q_c105_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_05 (mix_i_src_c105_3_05 0 bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_3_05 (mix_i_src_c105_3_05 mix_i_c105_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_05 (mix_q_src_c105_3_05 0 bpf_c105_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c105_3_05 (mix_q_src_c105_3_05 mix_q_c105_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_06 (mix_i_src_c105_3_06 0 bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_3_06 (mix_i_src_c105_3_06 mix_i_c105_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_06 (mix_q_src_c105_3_06 0 bpf_c105_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c105_3_06 (mix_q_src_c105_3_06 mix_q_c105_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_07 (mix_i_src_c105_3_07 0 bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_3_07 (mix_i_src_c105_3_07 mix_i_c105_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_07 (mix_q_src_c105_3_07 0 bpf_c105_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c105_3_07 (mix_q_src_c105_3_07 mix_q_c105_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_08 (mix_i_src_c105_3_08 0 bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c105_3_08 (mix_i_src_c105_3_08 mix_i_c105_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_08 (mix_q_src_c105_3_08 0 bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_3_08 (mix_q_src_c105_3_08 mix_q_c105_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_09 (mix_i_src_c105_3_09 0 bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c105_3_09 (mix_i_src_c105_3_09 mix_i_c105_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_09 (mix_q_src_c105_3_09 0 bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_3_09 (mix_q_src_c105_3_09 mix_q_c105_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_10 (mix_i_src_c105_3_10 0 bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c105_3_10 (mix_i_src_c105_3_10 mix_i_c105_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_10 (mix_q_src_c105_3_10 0 bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_3_10 (mix_q_src_c105_3_10 mix_q_c105_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_11 (mix_i_src_c105_3_11 0 bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c105_3_11 (mix_i_src_c105_3_11 mix_i_c105_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_11 (mix_q_src_c105_3_11 0 bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_3_11 (mix_q_src_c105_3_11 mix_q_c105_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_12 (mix_i_src_c105_3_12 0 bpf_c105_3 0) vcvs gain=1.950903220161e-01
SMIXI_c105_3_12 (mix_i_src_c105_3_12 mix_i_c105_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_12 (mix_q_src_c105_3_12 0 bpf_c105_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c105_3_12 (mix_q_src_c105_3_12 mix_q_c105_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_13 (mix_i_src_c105_3_13 0 bpf_c105_3 0) vcvs gain=5.555702330196e-01
SMIXI_c105_3_13 (mix_i_src_c105_3_13 mix_i_c105_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_13 (mix_q_src_c105_3_13 0 bpf_c105_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c105_3_13 (mix_q_src_c105_3_13 mix_q_c105_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_14 (mix_i_src_c105_3_14 0 bpf_c105_3 0) vcvs gain=8.314696123025e-01
SMIXI_c105_3_14 (mix_i_src_c105_3_14 mix_i_c105_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_14 (mix_q_src_c105_3_14 0 bpf_c105_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c105_3_14 (mix_q_src_c105_3_14 mix_q_c105_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c105_3_15 (mix_i_src_c105_3_15 0 bpf_c105_3 0) vcvs gain=9.807852804032e-01
SMIXI_c105_3_15 (mix_i_src_c105_3_15 mix_i_c105_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c105_3_15 (mix_q_src_c105_3_15 0 bpf_c105_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c105_3_15 (mix_q_src_c105_3_15 mix_q_c105_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c105_3 (mix_i_c105_3 0) resistor r=1G
RMIXQ_c105_3 (mix_q_c105_3 0) resistor r=1G
RINTI_c105_3 (mix_i_c105_3 Icar_c105_3) resistor r=1k
CINTI_c105_3 (Icar_c105_3 0) capacitor c=80p
RINTQ_c105_3 (mix_q_c105_3 Qcar_c105_3) resistor r=1k
CINTQ_c105_3 (Qcar_c105_3 0) capacitor c=80p

// bl106, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c106_0 (bl106 n_cbpf_c106_0) capacitor c=4.052847345694e-13
LBPF_c106_0 (n_cbpf_c106_0 bpf_c106_0) inductor l=1.000000000000e-06
RBPF_c106_0 (bpf_c106_0 0) resistor r=7.853981633974e+01
EMIXI_c106_0_00 (mix_i_src_c106_0_00 0 bpf_c106_0 0) vcvs gain=9.807852804032e-01
SMIXI_c106_0_00 (mix_i_src_c106_0_00 mix_i_c106_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_00 (mix_q_src_c106_0_00 0 bpf_c106_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_0_00 (mix_q_src_c106_0_00 mix_q_c106_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_01 (mix_i_src_c106_0_01 0 bpf_c106_0 0) vcvs gain=8.314696123025e-01
SMIXI_c106_0_01 (mix_i_src_c106_0_01 mix_i_c106_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_01 (mix_q_src_c106_0_01 0 bpf_c106_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_0_01 (mix_q_src_c106_0_01 mix_q_c106_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_02 (mix_i_src_c106_0_02 0 bpf_c106_0 0) vcvs gain=5.555702330196e-01
SMIXI_c106_0_02 (mix_i_src_c106_0_02 mix_i_c106_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_02 (mix_q_src_c106_0_02 0 bpf_c106_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_0_02 (mix_q_src_c106_0_02 mix_q_c106_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_03 (mix_i_src_c106_0_03 0 bpf_c106_0 0) vcvs gain=1.950903220161e-01
SMIXI_c106_0_03 (mix_i_src_c106_0_03 mix_i_c106_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_03 (mix_q_src_c106_0_03 0 bpf_c106_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_0_03 (mix_q_src_c106_0_03 mix_q_c106_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_04 (mix_i_src_c106_0_04 0 bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_0_04 (mix_i_src_c106_0_04 mix_i_c106_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_04 (mix_q_src_c106_0_04 0 bpf_c106_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_0_04 (mix_q_src_c106_0_04 mix_q_c106_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_05 (mix_i_src_c106_0_05 0 bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_0_05 (mix_i_src_c106_0_05 mix_i_c106_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_05 (mix_q_src_c106_0_05 0 bpf_c106_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_0_05 (mix_q_src_c106_0_05 mix_q_c106_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_06 (mix_i_src_c106_0_06 0 bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_0_06 (mix_i_src_c106_0_06 mix_i_c106_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_06 (mix_q_src_c106_0_06 0 bpf_c106_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_0_06 (mix_q_src_c106_0_06 mix_q_c106_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_07 (mix_i_src_c106_0_07 0 bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_0_07 (mix_i_src_c106_0_07 mix_i_c106_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_07 (mix_q_src_c106_0_07 0 bpf_c106_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_0_07 (mix_q_src_c106_0_07 mix_q_c106_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_08 (mix_i_src_c106_0_08 0 bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_0_08 (mix_i_src_c106_0_08 mix_i_c106_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_08 (mix_q_src_c106_0_08 0 bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_0_08 (mix_q_src_c106_0_08 mix_q_c106_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_09 (mix_i_src_c106_0_09 0 bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_0_09 (mix_i_src_c106_0_09 mix_i_c106_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_09 (mix_q_src_c106_0_09 0 bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_0_09 (mix_q_src_c106_0_09 mix_q_c106_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_10 (mix_i_src_c106_0_10 0 bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_0_10 (mix_i_src_c106_0_10 mix_i_c106_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_10 (mix_q_src_c106_0_10 0 bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_0_10 (mix_q_src_c106_0_10 mix_q_c106_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_11 (mix_i_src_c106_0_11 0 bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_0_11 (mix_i_src_c106_0_11 mix_i_c106_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_11 (mix_q_src_c106_0_11 0 bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_0_11 (mix_q_src_c106_0_11 mix_q_c106_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_12 (mix_i_src_c106_0_12 0 bpf_c106_0 0) vcvs gain=1.950903220161e-01
SMIXI_c106_0_12 (mix_i_src_c106_0_12 mix_i_c106_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_12 (mix_q_src_c106_0_12 0 bpf_c106_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_0_12 (mix_q_src_c106_0_12 mix_q_c106_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_13 (mix_i_src_c106_0_13 0 bpf_c106_0 0) vcvs gain=5.555702330196e-01
SMIXI_c106_0_13 (mix_i_src_c106_0_13 mix_i_c106_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_13 (mix_q_src_c106_0_13 0 bpf_c106_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_0_13 (mix_q_src_c106_0_13 mix_q_c106_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_14 (mix_i_src_c106_0_14 0 bpf_c106_0 0) vcvs gain=8.314696123025e-01
SMIXI_c106_0_14 (mix_i_src_c106_0_14 mix_i_c106_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_14 (mix_q_src_c106_0_14 0 bpf_c106_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_0_14 (mix_q_src_c106_0_14 mix_q_c106_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_0_15 (mix_i_src_c106_0_15 0 bpf_c106_0 0) vcvs gain=9.807852804032e-01
SMIXI_c106_0_15 (mix_i_src_c106_0_15 mix_i_c106_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_0_15 (mix_q_src_c106_0_15 0 bpf_c106_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_0_15 (mix_q_src_c106_0_15 mix_q_c106_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c106_0 (mix_i_c106_0 0) resistor r=1G
RMIXQ_c106_0 (mix_q_c106_0 0) resistor r=1G
RINTI_c106_0 (mix_i_c106_0 Icar_c106_0) resistor r=1k
CINTI_c106_0 (Icar_c106_0 0) capacitor c=80p
RINTQ_c106_0 (mix_q_c106_0 Qcar_c106_0) resistor r=1k
CINTQ_c106_0 (Qcar_c106_0 0) capacitor c=80p

// bl106, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c106_1 (bl106 n_cbpf_c106_1) capacitor c=1.013211836423e-13
LBPF_c106_1 (n_cbpf_c106_1 bpf_c106_1) inductor l=1.000000000000e-06
RBPF_c106_1 (bpf_c106_1 0) resistor r=1.570796326795e+02
EMIXI_c106_1_00 (mix_i_src_c106_1_00 0 bpf_c106_1 0) vcvs gain=9.807852804032e-01
SMIXI_c106_1_00 (mix_i_src_c106_1_00 mix_i_c106_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_00 (mix_q_src_c106_1_00 0 bpf_c106_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_1_00 (mix_q_src_c106_1_00 mix_q_c106_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_01 (mix_i_src_c106_1_01 0 bpf_c106_1 0) vcvs gain=8.314696123025e-01
SMIXI_c106_1_01 (mix_i_src_c106_1_01 mix_i_c106_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_01 (mix_q_src_c106_1_01 0 bpf_c106_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_1_01 (mix_q_src_c106_1_01 mix_q_c106_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_02 (mix_i_src_c106_1_02 0 bpf_c106_1 0) vcvs gain=5.555702330196e-01
SMIXI_c106_1_02 (mix_i_src_c106_1_02 mix_i_c106_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_02 (mix_q_src_c106_1_02 0 bpf_c106_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_1_02 (mix_q_src_c106_1_02 mix_q_c106_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_03 (mix_i_src_c106_1_03 0 bpf_c106_1 0) vcvs gain=1.950903220161e-01
SMIXI_c106_1_03 (mix_i_src_c106_1_03 mix_i_c106_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_03 (mix_q_src_c106_1_03 0 bpf_c106_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_1_03 (mix_q_src_c106_1_03 mix_q_c106_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_04 (mix_i_src_c106_1_04 0 bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_1_04 (mix_i_src_c106_1_04 mix_i_c106_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_04 (mix_q_src_c106_1_04 0 bpf_c106_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_1_04 (mix_q_src_c106_1_04 mix_q_c106_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_05 (mix_i_src_c106_1_05 0 bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_1_05 (mix_i_src_c106_1_05 mix_i_c106_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_05 (mix_q_src_c106_1_05 0 bpf_c106_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_1_05 (mix_q_src_c106_1_05 mix_q_c106_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_06 (mix_i_src_c106_1_06 0 bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_1_06 (mix_i_src_c106_1_06 mix_i_c106_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_06 (mix_q_src_c106_1_06 0 bpf_c106_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_1_06 (mix_q_src_c106_1_06 mix_q_c106_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_07 (mix_i_src_c106_1_07 0 bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_1_07 (mix_i_src_c106_1_07 mix_i_c106_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_07 (mix_q_src_c106_1_07 0 bpf_c106_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_1_07 (mix_q_src_c106_1_07 mix_q_c106_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_08 (mix_i_src_c106_1_08 0 bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_1_08 (mix_i_src_c106_1_08 mix_i_c106_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_08 (mix_q_src_c106_1_08 0 bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_1_08 (mix_q_src_c106_1_08 mix_q_c106_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_09 (mix_i_src_c106_1_09 0 bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_1_09 (mix_i_src_c106_1_09 mix_i_c106_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_09 (mix_q_src_c106_1_09 0 bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_1_09 (mix_q_src_c106_1_09 mix_q_c106_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_10 (mix_i_src_c106_1_10 0 bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_1_10 (mix_i_src_c106_1_10 mix_i_c106_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_10 (mix_q_src_c106_1_10 0 bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_1_10 (mix_q_src_c106_1_10 mix_q_c106_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_11 (mix_i_src_c106_1_11 0 bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_1_11 (mix_i_src_c106_1_11 mix_i_c106_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_11 (mix_q_src_c106_1_11 0 bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_1_11 (mix_q_src_c106_1_11 mix_q_c106_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_12 (mix_i_src_c106_1_12 0 bpf_c106_1 0) vcvs gain=1.950903220161e-01
SMIXI_c106_1_12 (mix_i_src_c106_1_12 mix_i_c106_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_12 (mix_q_src_c106_1_12 0 bpf_c106_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_1_12 (mix_q_src_c106_1_12 mix_q_c106_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_13 (mix_i_src_c106_1_13 0 bpf_c106_1 0) vcvs gain=5.555702330196e-01
SMIXI_c106_1_13 (mix_i_src_c106_1_13 mix_i_c106_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_13 (mix_q_src_c106_1_13 0 bpf_c106_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_1_13 (mix_q_src_c106_1_13 mix_q_c106_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_14 (mix_i_src_c106_1_14 0 bpf_c106_1 0) vcvs gain=8.314696123025e-01
SMIXI_c106_1_14 (mix_i_src_c106_1_14 mix_i_c106_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_14 (mix_q_src_c106_1_14 0 bpf_c106_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_1_14 (mix_q_src_c106_1_14 mix_q_c106_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_1_15 (mix_i_src_c106_1_15 0 bpf_c106_1 0) vcvs gain=9.807852804032e-01
SMIXI_c106_1_15 (mix_i_src_c106_1_15 mix_i_c106_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_1_15 (mix_q_src_c106_1_15 0 bpf_c106_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_1_15 (mix_q_src_c106_1_15 mix_q_c106_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c106_1 (mix_i_c106_1 0) resistor r=1G
RMIXQ_c106_1 (mix_q_c106_1 0) resistor r=1G
RINTI_c106_1 (mix_i_c106_1 Icar_c106_1) resistor r=1k
CINTI_c106_1 (Icar_c106_1 0) capacitor c=80p
RINTQ_c106_1 (mix_q_c106_1 Qcar_c106_1) resistor r=1k
CINTQ_c106_1 (Qcar_c106_1 0) capacitor c=80p

// bl106, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c106_2 (bl106 n_cbpf_c106_2) capacitor c=4.503163717437e-14
LBPF_c106_2 (n_cbpf_c106_2 bpf_c106_2) inductor l=1.000000000000e-06
RBPF_c106_2 (bpf_c106_2 0) resistor r=2.356194490192e+02
EMIXI_c106_2_00 (mix_i_src_c106_2_00 0 bpf_c106_2 0) vcvs gain=9.807852804032e-01
SMIXI_c106_2_00 (mix_i_src_c106_2_00 mix_i_c106_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_00 (mix_q_src_c106_2_00 0 bpf_c106_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_2_00 (mix_q_src_c106_2_00 mix_q_c106_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_01 (mix_i_src_c106_2_01 0 bpf_c106_2 0) vcvs gain=8.314696123025e-01
SMIXI_c106_2_01 (mix_i_src_c106_2_01 mix_i_c106_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_01 (mix_q_src_c106_2_01 0 bpf_c106_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_2_01 (mix_q_src_c106_2_01 mix_q_c106_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_02 (mix_i_src_c106_2_02 0 bpf_c106_2 0) vcvs gain=5.555702330196e-01
SMIXI_c106_2_02 (mix_i_src_c106_2_02 mix_i_c106_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_02 (mix_q_src_c106_2_02 0 bpf_c106_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_2_02 (mix_q_src_c106_2_02 mix_q_c106_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_03 (mix_i_src_c106_2_03 0 bpf_c106_2 0) vcvs gain=1.950903220161e-01
SMIXI_c106_2_03 (mix_i_src_c106_2_03 mix_i_c106_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_03 (mix_q_src_c106_2_03 0 bpf_c106_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_2_03 (mix_q_src_c106_2_03 mix_q_c106_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_04 (mix_i_src_c106_2_04 0 bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_2_04 (mix_i_src_c106_2_04 mix_i_c106_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_04 (mix_q_src_c106_2_04 0 bpf_c106_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_2_04 (mix_q_src_c106_2_04 mix_q_c106_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_05 (mix_i_src_c106_2_05 0 bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_2_05 (mix_i_src_c106_2_05 mix_i_c106_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_05 (mix_q_src_c106_2_05 0 bpf_c106_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_2_05 (mix_q_src_c106_2_05 mix_q_c106_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_06 (mix_i_src_c106_2_06 0 bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_2_06 (mix_i_src_c106_2_06 mix_i_c106_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_06 (mix_q_src_c106_2_06 0 bpf_c106_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_2_06 (mix_q_src_c106_2_06 mix_q_c106_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_07 (mix_i_src_c106_2_07 0 bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_2_07 (mix_i_src_c106_2_07 mix_i_c106_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_07 (mix_q_src_c106_2_07 0 bpf_c106_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_2_07 (mix_q_src_c106_2_07 mix_q_c106_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_08 (mix_i_src_c106_2_08 0 bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_2_08 (mix_i_src_c106_2_08 mix_i_c106_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_08 (mix_q_src_c106_2_08 0 bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_2_08 (mix_q_src_c106_2_08 mix_q_c106_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_09 (mix_i_src_c106_2_09 0 bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_2_09 (mix_i_src_c106_2_09 mix_i_c106_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_09 (mix_q_src_c106_2_09 0 bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_2_09 (mix_q_src_c106_2_09 mix_q_c106_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_10 (mix_i_src_c106_2_10 0 bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_2_10 (mix_i_src_c106_2_10 mix_i_c106_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_10 (mix_q_src_c106_2_10 0 bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_2_10 (mix_q_src_c106_2_10 mix_q_c106_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_11 (mix_i_src_c106_2_11 0 bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_2_11 (mix_i_src_c106_2_11 mix_i_c106_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_11 (mix_q_src_c106_2_11 0 bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_2_11 (mix_q_src_c106_2_11 mix_q_c106_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_12 (mix_i_src_c106_2_12 0 bpf_c106_2 0) vcvs gain=1.950903220161e-01
SMIXI_c106_2_12 (mix_i_src_c106_2_12 mix_i_c106_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_12 (mix_q_src_c106_2_12 0 bpf_c106_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_2_12 (mix_q_src_c106_2_12 mix_q_c106_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_13 (mix_i_src_c106_2_13 0 bpf_c106_2 0) vcvs gain=5.555702330196e-01
SMIXI_c106_2_13 (mix_i_src_c106_2_13 mix_i_c106_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_13 (mix_q_src_c106_2_13 0 bpf_c106_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_2_13 (mix_q_src_c106_2_13 mix_q_c106_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_14 (mix_i_src_c106_2_14 0 bpf_c106_2 0) vcvs gain=8.314696123025e-01
SMIXI_c106_2_14 (mix_i_src_c106_2_14 mix_i_c106_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_14 (mix_q_src_c106_2_14 0 bpf_c106_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_2_14 (mix_q_src_c106_2_14 mix_q_c106_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_2_15 (mix_i_src_c106_2_15 0 bpf_c106_2 0) vcvs gain=9.807852804032e-01
SMIXI_c106_2_15 (mix_i_src_c106_2_15 mix_i_c106_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_2_15 (mix_q_src_c106_2_15 0 bpf_c106_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_2_15 (mix_q_src_c106_2_15 mix_q_c106_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c106_2 (mix_i_c106_2 0) resistor r=1G
RMIXQ_c106_2 (mix_q_c106_2 0) resistor r=1G
RINTI_c106_2 (mix_i_c106_2 Icar_c106_2) resistor r=1k
CINTI_c106_2 (Icar_c106_2 0) capacitor c=80p
RINTQ_c106_2 (mix_q_c106_2 Qcar_c106_2) resistor r=1k
CINTQ_c106_2 (Qcar_c106_2 0) capacitor c=80p

// bl106, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c106_3 (bl106 n_cbpf_c106_3) capacitor c=2.533029591058e-14
LBPF_c106_3 (n_cbpf_c106_3 bpf_c106_3) inductor l=1.000000000000e-06
RBPF_c106_3 (bpf_c106_3 0) resistor r=3.141592653590e+02
EMIXI_c106_3_00 (mix_i_src_c106_3_00 0 bpf_c106_3 0) vcvs gain=9.807852804032e-01
SMIXI_c106_3_00 (mix_i_src_c106_3_00 mix_i_c106_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_00 (mix_q_src_c106_3_00 0 bpf_c106_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_3_00 (mix_q_src_c106_3_00 mix_q_c106_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_01 (mix_i_src_c106_3_01 0 bpf_c106_3 0) vcvs gain=8.314696123025e-01
SMIXI_c106_3_01 (mix_i_src_c106_3_01 mix_i_c106_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_01 (mix_q_src_c106_3_01 0 bpf_c106_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_3_01 (mix_q_src_c106_3_01 mix_q_c106_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_02 (mix_i_src_c106_3_02 0 bpf_c106_3 0) vcvs gain=5.555702330196e-01
SMIXI_c106_3_02 (mix_i_src_c106_3_02 mix_i_c106_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_02 (mix_q_src_c106_3_02 0 bpf_c106_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_3_02 (mix_q_src_c106_3_02 mix_q_c106_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_03 (mix_i_src_c106_3_03 0 bpf_c106_3 0) vcvs gain=1.950903220161e-01
SMIXI_c106_3_03 (mix_i_src_c106_3_03 mix_i_c106_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_03 (mix_q_src_c106_3_03 0 bpf_c106_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_3_03 (mix_q_src_c106_3_03 mix_q_c106_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_04 (mix_i_src_c106_3_04 0 bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_3_04 (mix_i_src_c106_3_04 mix_i_c106_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_04 (mix_q_src_c106_3_04 0 bpf_c106_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c106_3_04 (mix_q_src_c106_3_04 mix_q_c106_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_05 (mix_i_src_c106_3_05 0 bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_3_05 (mix_i_src_c106_3_05 mix_i_c106_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_05 (mix_q_src_c106_3_05 0 bpf_c106_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c106_3_05 (mix_q_src_c106_3_05 mix_q_c106_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_06 (mix_i_src_c106_3_06 0 bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_3_06 (mix_i_src_c106_3_06 mix_i_c106_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_06 (mix_q_src_c106_3_06 0 bpf_c106_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c106_3_06 (mix_q_src_c106_3_06 mix_q_c106_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_07 (mix_i_src_c106_3_07 0 bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_3_07 (mix_i_src_c106_3_07 mix_i_c106_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_07 (mix_q_src_c106_3_07 0 bpf_c106_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c106_3_07 (mix_q_src_c106_3_07 mix_q_c106_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_08 (mix_i_src_c106_3_08 0 bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c106_3_08 (mix_i_src_c106_3_08 mix_i_c106_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_08 (mix_q_src_c106_3_08 0 bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_3_08 (mix_q_src_c106_3_08 mix_q_c106_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_09 (mix_i_src_c106_3_09 0 bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c106_3_09 (mix_i_src_c106_3_09 mix_i_c106_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_09 (mix_q_src_c106_3_09 0 bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_3_09 (mix_q_src_c106_3_09 mix_q_c106_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_10 (mix_i_src_c106_3_10 0 bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c106_3_10 (mix_i_src_c106_3_10 mix_i_c106_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_10 (mix_q_src_c106_3_10 0 bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_3_10 (mix_q_src_c106_3_10 mix_q_c106_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_11 (mix_i_src_c106_3_11 0 bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c106_3_11 (mix_i_src_c106_3_11 mix_i_c106_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_11 (mix_q_src_c106_3_11 0 bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_3_11 (mix_q_src_c106_3_11 mix_q_c106_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_12 (mix_i_src_c106_3_12 0 bpf_c106_3 0) vcvs gain=1.950903220161e-01
SMIXI_c106_3_12 (mix_i_src_c106_3_12 mix_i_c106_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_12 (mix_q_src_c106_3_12 0 bpf_c106_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c106_3_12 (mix_q_src_c106_3_12 mix_q_c106_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_13 (mix_i_src_c106_3_13 0 bpf_c106_3 0) vcvs gain=5.555702330196e-01
SMIXI_c106_3_13 (mix_i_src_c106_3_13 mix_i_c106_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_13 (mix_q_src_c106_3_13 0 bpf_c106_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c106_3_13 (mix_q_src_c106_3_13 mix_q_c106_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_14 (mix_i_src_c106_3_14 0 bpf_c106_3 0) vcvs gain=8.314696123025e-01
SMIXI_c106_3_14 (mix_i_src_c106_3_14 mix_i_c106_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_14 (mix_q_src_c106_3_14 0 bpf_c106_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c106_3_14 (mix_q_src_c106_3_14 mix_q_c106_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c106_3_15 (mix_i_src_c106_3_15 0 bpf_c106_3 0) vcvs gain=9.807852804032e-01
SMIXI_c106_3_15 (mix_i_src_c106_3_15 mix_i_c106_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c106_3_15 (mix_q_src_c106_3_15 0 bpf_c106_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c106_3_15 (mix_q_src_c106_3_15 mix_q_c106_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c106_3 (mix_i_c106_3 0) resistor r=1G
RMIXQ_c106_3 (mix_q_c106_3 0) resistor r=1G
RINTI_c106_3 (mix_i_c106_3 Icar_c106_3) resistor r=1k
CINTI_c106_3 (Icar_c106_3 0) capacitor c=80p
RINTQ_c106_3 (mix_q_c106_3 Qcar_c106_3) resistor r=1k
CINTQ_c106_3 (Qcar_c106_3 0) capacitor c=80p

// bl107, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c107_0 (bl107 n_cbpf_c107_0) capacitor c=4.052847345694e-13
LBPF_c107_0 (n_cbpf_c107_0 bpf_c107_0) inductor l=1.000000000000e-06
RBPF_c107_0 (bpf_c107_0 0) resistor r=7.853981633974e+01
EMIXI_c107_0_00 (mix_i_src_c107_0_00 0 bpf_c107_0 0) vcvs gain=9.807852804032e-01
SMIXI_c107_0_00 (mix_i_src_c107_0_00 mix_i_c107_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_00 (mix_q_src_c107_0_00 0 bpf_c107_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_0_00 (mix_q_src_c107_0_00 mix_q_c107_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_01 (mix_i_src_c107_0_01 0 bpf_c107_0 0) vcvs gain=8.314696123025e-01
SMIXI_c107_0_01 (mix_i_src_c107_0_01 mix_i_c107_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_01 (mix_q_src_c107_0_01 0 bpf_c107_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_0_01 (mix_q_src_c107_0_01 mix_q_c107_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_02 (mix_i_src_c107_0_02 0 bpf_c107_0 0) vcvs gain=5.555702330196e-01
SMIXI_c107_0_02 (mix_i_src_c107_0_02 mix_i_c107_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_02 (mix_q_src_c107_0_02 0 bpf_c107_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_0_02 (mix_q_src_c107_0_02 mix_q_c107_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_03 (mix_i_src_c107_0_03 0 bpf_c107_0 0) vcvs gain=1.950903220161e-01
SMIXI_c107_0_03 (mix_i_src_c107_0_03 mix_i_c107_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_03 (mix_q_src_c107_0_03 0 bpf_c107_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_0_03 (mix_q_src_c107_0_03 mix_q_c107_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_04 (mix_i_src_c107_0_04 0 bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_0_04 (mix_i_src_c107_0_04 mix_i_c107_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_04 (mix_q_src_c107_0_04 0 bpf_c107_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_0_04 (mix_q_src_c107_0_04 mix_q_c107_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_05 (mix_i_src_c107_0_05 0 bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_0_05 (mix_i_src_c107_0_05 mix_i_c107_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_05 (mix_q_src_c107_0_05 0 bpf_c107_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_0_05 (mix_q_src_c107_0_05 mix_q_c107_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_06 (mix_i_src_c107_0_06 0 bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_0_06 (mix_i_src_c107_0_06 mix_i_c107_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_06 (mix_q_src_c107_0_06 0 bpf_c107_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_0_06 (mix_q_src_c107_0_06 mix_q_c107_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_07 (mix_i_src_c107_0_07 0 bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_0_07 (mix_i_src_c107_0_07 mix_i_c107_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_07 (mix_q_src_c107_0_07 0 bpf_c107_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_0_07 (mix_q_src_c107_0_07 mix_q_c107_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_08 (mix_i_src_c107_0_08 0 bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_0_08 (mix_i_src_c107_0_08 mix_i_c107_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_08 (mix_q_src_c107_0_08 0 bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_0_08 (mix_q_src_c107_0_08 mix_q_c107_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_09 (mix_i_src_c107_0_09 0 bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_0_09 (mix_i_src_c107_0_09 mix_i_c107_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_09 (mix_q_src_c107_0_09 0 bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_0_09 (mix_q_src_c107_0_09 mix_q_c107_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_10 (mix_i_src_c107_0_10 0 bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_0_10 (mix_i_src_c107_0_10 mix_i_c107_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_10 (mix_q_src_c107_0_10 0 bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_0_10 (mix_q_src_c107_0_10 mix_q_c107_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_11 (mix_i_src_c107_0_11 0 bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_0_11 (mix_i_src_c107_0_11 mix_i_c107_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_11 (mix_q_src_c107_0_11 0 bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_0_11 (mix_q_src_c107_0_11 mix_q_c107_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_12 (mix_i_src_c107_0_12 0 bpf_c107_0 0) vcvs gain=1.950903220161e-01
SMIXI_c107_0_12 (mix_i_src_c107_0_12 mix_i_c107_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_12 (mix_q_src_c107_0_12 0 bpf_c107_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_0_12 (mix_q_src_c107_0_12 mix_q_c107_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_13 (mix_i_src_c107_0_13 0 bpf_c107_0 0) vcvs gain=5.555702330196e-01
SMIXI_c107_0_13 (mix_i_src_c107_0_13 mix_i_c107_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_13 (mix_q_src_c107_0_13 0 bpf_c107_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_0_13 (mix_q_src_c107_0_13 mix_q_c107_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_14 (mix_i_src_c107_0_14 0 bpf_c107_0 0) vcvs gain=8.314696123025e-01
SMIXI_c107_0_14 (mix_i_src_c107_0_14 mix_i_c107_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_14 (mix_q_src_c107_0_14 0 bpf_c107_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_0_14 (mix_q_src_c107_0_14 mix_q_c107_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_0_15 (mix_i_src_c107_0_15 0 bpf_c107_0 0) vcvs gain=9.807852804032e-01
SMIXI_c107_0_15 (mix_i_src_c107_0_15 mix_i_c107_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_0_15 (mix_q_src_c107_0_15 0 bpf_c107_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_0_15 (mix_q_src_c107_0_15 mix_q_c107_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c107_0 (mix_i_c107_0 0) resistor r=1G
RMIXQ_c107_0 (mix_q_c107_0 0) resistor r=1G
RINTI_c107_0 (mix_i_c107_0 Icar_c107_0) resistor r=1k
CINTI_c107_0 (Icar_c107_0 0) capacitor c=80p
RINTQ_c107_0 (mix_q_c107_0 Qcar_c107_0) resistor r=1k
CINTQ_c107_0 (Qcar_c107_0 0) capacitor c=80p

// bl107, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c107_1 (bl107 n_cbpf_c107_1) capacitor c=1.013211836423e-13
LBPF_c107_1 (n_cbpf_c107_1 bpf_c107_1) inductor l=1.000000000000e-06
RBPF_c107_1 (bpf_c107_1 0) resistor r=1.570796326795e+02
EMIXI_c107_1_00 (mix_i_src_c107_1_00 0 bpf_c107_1 0) vcvs gain=9.807852804032e-01
SMIXI_c107_1_00 (mix_i_src_c107_1_00 mix_i_c107_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_00 (mix_q_src_c107_1_00 0 bpf_c107_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_1_00 (mix_q_src_c107_1_00 mix_q_c107_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_01 (mix_i_src_c107_1_01 0 bpf_c107_1 0) vcvs gain=8.314696123025e-01
SMIXI_c107_1_01 (mix_i_src_c107_1_01 mix_i_c107_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_01 (mix_q_src_c107_1_01 0 bpf_c107_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_1_01 (mix_q_src_c107_1_01 mix_q_c107_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_02 (mix_i_src_c107_1_02 0 bpf_c107_1 0) vcvs gain=5.555702330196e-01
SMIXI_c107_1_02 (mix_i_src_c107_1_02 mix_i_c107_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_02 (mix_q_src_c107_1_02 0 bpf_c107_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_1_02 (mix_q_src_c107_1_02 mix_q_c107_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_03 (mix_i_src_c107_1_03 0 bpf_c107_1 0) vcvs gain=1.950903220161e-01
SMIXI_c107_1_03 (mix_i_src_c107_1_03 mix_i_c107_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_03 (mix_q_src_c107_1_03 0 bpf_c107_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_1_03 (mix_q_src_c107_1_03 mix_q_c107_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_04 (mix_i_src_c107_1_04 0 bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_1_04 (mix_i_src_c107_1_04 mix_i_c107_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_04 (mix_q_src_c107_1_04 0 bpf_c107_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_1_04 (mix_q_src_c107_1_04 mix_q_c107_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_05 (mix_i_src_c107_1_05 0 bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_1_05 (mix_i_src_c107_1_05 mix_i_c107_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_05 (mix_q_src_c107_1_05 0 bpf_c107_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_1_05 (mix_q_src_c107_1_05 mix_q_c107_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_06 (mix_i_src_c107_1_06 0 bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_1_06 (mix_i_src_c107_1_06 mix_i_c107_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_06 (mix_q_src_c107_1_06 0 bpf_c107_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_1_06 (mix_q_src_c107_1_06 mix_q_c107_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_07 (mix_i_src_c107_1_07 0 bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_1_07 (mix_i_src_c107_1_07 mix_i_c107_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_07 (mix_q_src_c107_1_07 0 bpf_c107_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_1_07 (mix_q_src_c107_1_07 mix_q_c107_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_08 (mix_i_src_c107_1_08 0 bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_1_08 (mix_i_src_c107_1_08 mix_i_c107_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_08 (mix_q_src_c107_1_08 0 bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_1_08 (mix_q_src_c107_1_08 mix_q_c107_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_09 (mix_i_src_c107_1_09 0 bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_1_09 (mix_i_src_c107_1_09 mix_i_c107_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_09 (mix_q_src_c107_1_09 0 bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_1_09 (mix_q_src_c107_1_09 mix_q_c107_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_10 (mix_i_src_c107_1_10 0 bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_1_10 (mix_i_src_c107_1_10 mix_i_c107_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_10 (mix_q_src_c107_1_10 0 bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_1_10 (mix_q_src_c107_1_10 mix_q_c107_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_11 (mix_i_src_c107_1_11 0 bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_1_11 (mix_i_src_c107_1_11 mix_i_c107_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_11 (mix_q_src_c107_1_11 0 bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_1_11 (mix_q_src_c107_1_11 mix_q_c107_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_12 (mix_i_src_c107_1_12 0 bpf_c107_1 0) vcvs gain=1.950903220161e-01
SMIXI_c107_1_12 (mix_i_src_c107_1_12 mix_i_c107_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_12 (mix_q_src_c107_1_12 0 bpf_c107_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_1_12 (mix_q_src_c107_1_12 mix_q_c107_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_13 (mix_i_src_c107_1_13 0 bpf_c107_1 0) vcvs gain=5.555702330196e-01
SMIXI_c107_1_13 (mix_i_src_c107_1_13 mix_i_c107_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_13 (mix_q_src_c107_1_13 0 bpf_c107_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_1_13 (mix_q_src_c107_1_13 mix_q_c107_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_14 (mix_i_src_c107_1_14 0 bpf_c107_1 0) vcvs gain=8.314696123025e-01
SMIXI_c107_1_14 (mix_i_src_c107_1_14 mix_i_c107_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_14 (mix_q_src_c107_1_14 0 bpf_c107_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_1_14 (mix_q_src_c107_1_14 mix_q_c107_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_1_15 (mix_i_src_c107_1_15 0 bpf_c107_1 0) vcvs gain=9.807852804032e-01
SMIXI_c107_1_15 (mix_i_src_c107_1_15 mix_i_c107_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_1_15 (mix_q_src_c107_1_15 0 bpf_c107_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_1_15 (mix_q_src_c107_1_15 mix_q_c107_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c107_1 (mix_i_c107_1 0) resistor r=1G
RMIXQ_c107_1 (mix_q_c107_1 0) resistor r=1G
RINTI_c107_1 (mix_i_c107_1 Icar_c107_1) resistor r=1k
CINTI_c107_1 (Icar_c107_1 0) capacitor c=80p
RINTQ_c107_1 (mix_q_c107_1 Qcar_c107_1) resistor r=1k
CINTQ_c107_1 (Qcar_c107_1 0) capacitor c=80p

// bl107, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c107_2 (bl107 n_cbpf_c107_2) capacitor c=4.503163717437e-14
LBPF_c107_2 (n_cbpf_c107_2 bpf_c107_2) inductor l=1.000000000000e-06
RBPF_c107_2 (bpf_c107_2 0) resistor r=2.356194490192e+02
EMIXI_c107_2_00 (mix_i_src_c107_2_00 0 bpf_c107_2 0) vcvs gain=9.807852804032e-01
SMIXI_c107_2_00 (mix_i_src_c107_2_00 mix_i_c107_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_00 (mix_q_src_c107_2_00 0 bpf_c107_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_2_00 (mix_q_src_c107_2_00 mix_q_c107_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_01 (mix_i_src_c107_2_01 0 bpf_c107_2 0) vcvs gain=8.314696123025e-01
SMIXI_c107_2_01 (mix_i_src_c107_2_01 mix_i_c107_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_01 (mix_q_src_c107_2_01 0 bpf_c107_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_2_01 (mix_q_src_c107_2_01 mix_q_c107_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_02 (mix_i_src_c107_2_02 0 bpf_c107_2 0) vcvs gain=5.555702330196e-01
SMIXI_c107_2_02 (mix_i_src_c107_2_02 mix_i_c107_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_02 (mix_q_src_c107_2_02 0 bpf_c107_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_2_02 (mix_q_src_c107_2_02 mix_q_c107_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_03 (mix_i_src_c107_2_03 0 bpf_c107_2 0) vcvs gain=1.950903220161e-01
SMIXI_c107_2_03 (mix_i_src_c107_2_03 mix_i_c107_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_03 (mix_q_src_c107_2_03 0 bpf_c107_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_2_03 (mix_q_src_c107_2_03 mix_q_c107_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_04 (mix_i_src_c107_2_04 0 bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_2_04 (mix_i_src_c107_2_04 mix_i_c107_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_04 (mix_q_src_c107_2_04 0 bpf_c107_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_2_04 (mix_q_src_c107_2_04 mix_q_c107_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_05 (mix_i_src_c107_2_05 0 bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_2_05 (mix_i_src_c107_2_05 mix_i_c107_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_05 (mix_q_src_c107_2_05 0 bpf_c107_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_2_05 (mix_q_src_c107_2_05 mix_q_c107_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_06 (mix_i_src_c107_2_06 0 bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_2_06 (mix_i_src_c107_2_06 mix_i_c107_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_06 (mix_q_src_c107_2_06 0 bpf_c107_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_2_06 (mix_q_src_c107_2_06 mix_q_c107_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_07 (mix_i_src_c107_2_07 0 bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_2_07 (mix_i_src_c107_2_07 mix_i_c107_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_07 (mix_q_src_c107_2_07 0 bpf_c107_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_2_07 (mix_q_src_c107_2_07 mix_q_c107_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_08 (mix_i_src_c107_2_08 0 bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_2_08 (mix_i_src_c107_2_08 mix_i_c107_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_08 (mix_q_src_c107_2_08 0 bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_2_08 (mix_q_src_c107_2_08 mix_q_c107_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_09 (mix_i_src_c107_2_09 0 bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_2_09 (mix_i_src_c107_2_09 mix_i_c107_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_09 (mix_q_src_c107_2_09 0 bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_2_09 (mix_q_src_c107_2_09 mix_q_c107_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_10 (mix_i_src_c107_2_10 0 bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_2_10 (mix_i_src_c107_2_10 mix_i_c107_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_10 (mix_q_src_c107_2_10 0 bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_2_10 (mix_q_src_c107_2_10 mix_q_c107_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_11 (mix_i_src_c107_2_11 0 bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_2_11 (mix_i_src_c107_2_11 mix_i_c107_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_11 (mix_q_src_c107_2_11 0 bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_2_11 (mix_q_src_c107_2_11 mix_q_c107_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_12 (mix_i_src_c107_2_12 0 bpf_c107_2 0) vcvs gain=1.950903220161e-01
SMIXI_c107_2_12 (mix_i_src_c107_2_12 mix_i_c107_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_12 (mix_q_src_c107_2_12 0 bpf_c107_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_2_12 (mix_q_src_c107_2_12 mix_q_c107_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_13 (mix_i_src_c107_2_13 0 bpf_c107_2 0) vcvs gain=5.555702330196e-01
SMIXI_c107_2_13 (mix_i_src_c107_2_13 mix_i_c107_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_13 (mix_q_src_c107_2_13 0 bpf_c107_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_2_13 (mix_q_src_c107_2_13 mix_q_c107_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_14 (mix_i_src_c107_2_14 0 bpf_c107_2 0) vcvs gain=8.314696123025e-01
SMIXI_c107_2_14 (mix_i_src_c107_2_14 mix_i_c107_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_14 (mix_q_src_c107_2_14 0 bpf_c107_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_2_14 (mix_q_src_c107_2_14 mix_q_c107_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_2_15 (mix_i_src_c107_2_15 0 bpf_c107_2 0) vcvs gain=9.807852804032e-01
SMIXI_c107_2_15 (mix_i_src_c107_2_15 mix_i_c107_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_2_15 (mix_q_src_c107_2_15 0 bpf_c107_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_2_15 (mix_q_src_c107_2_15 mix_q_c107_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c107_2 (mix_i_c107_2 0) resistor r=1G
RMIXQ_c107_2 (mix_q_c107_2 0) resistor r=1G
RINTI_c107_2 (mix_i_c107_2 Icar_c107_2) resistor r=1k
CINTI_c107_2 (Icar_c107_2 0) capacitor c=80p
RINTQ_c107_2 (mix_q_c107_2 Qcar_c107_2) resistor r=1k
CINTQ_c107_2 (Qcar_c107_2 0) capacitor c=80p

// bl107, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c107_3 (bl107 n_cbpf_c107_3) capacitor c=2.533029591058e-14
LBPF_c107_3 (n_cbpf_c107_3 bpf_c107_3) inductor l=1.000000000000e-06
RBPF_c107_3 (bpf_c107_3 0) resistor r=3.141592653590e+02
EMIXI_c107_3_00 (mix_i_src_c107_3_00 0 bpf_c107_3 0) vcvs gain=9.807852804032e-01
SMIXI_c107_3_00 (mix_i_src_c107_3_00 mix_i_c107_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_00 (mix_q_src_c107_3_00 0 bpf_c107_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_3_00 (mix_q_src_c107_3_00 mix_q_c107_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_01 (mix_i_src_c107_3_01 0 bpf_c107_3 0) vcvs gain=8.314696123025e-01
SMIXI_c107_3_01 (mix_i_src_c107_3_01 mix_i_c107_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_01 (mix_q_src_c107_3_01 0 bpf_c107_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_3_01 (mix_q_src_c107_3_01 mix_q_c107_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_02 (mix_i_src_c107_3_02 0 bpf_c107_3 0) vcvs gain=5.555702330196e-01
SMIXI_c107_3_02 (mix_i_src_c107_3_02 mix_i_c107_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_02 (mix_q_src_c107_3_02 0 bpf_c107_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_3_02 (mix_q_src_c107_3_02 mix_q_c107_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_03 (mix_i_src_c107_3_03 0 bpf_c107_3 0) vcvs gain=1.950903220161e-01
SMIXI_c107_3_03 (mix_i_src_c107_3_03 mix_i_c107_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_03 (mix_q_src_c107_3_03 0 bpf_c107_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_3_03 (mix_q_src_c107_3_03 mix_q_c107_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_04 (mix_i_src_c107_3_04 0 bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_3_04 (mix_i_src_c107_3_04 mix_i_c107_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_04 (mix_q_src_c107_3_04 0 bpf_c107_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c107_3_04 (mix_q_src_c107_3_04 mix_q_c107_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_05 (mix_i_src_c107_3_05 0 bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_3_05 (mix_i_src_c107_3_05 mix_i_c107_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_05 (mix_q_src_c107_3_05 0 bpf_c107_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c107_3_05 (mix_q_src_c107_3_05 mix_q_c107_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_06 (mix_i_src_c107_3_06 0 bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_3_06 (mix_i_src_c107_3_06 mix_i_c107_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_06 (mix_q_src_c107_3_06 0 bpf_c107_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c107_3_06 (mix_q_src_c107_3_06 mix_q_c107_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_07 (mix_i_src_c107_3_07 0 bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_3_07 (mix_i_src_c107_3_07 mix_i_c107_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_07 (mix_q_src_c107_3_07 0 bpf_c107_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c107_3_07 (mix_q_src_c107_3_07 mix_q_c107_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_08 (mix_i_src_c107_3_08 0 bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c107_3_08 (mix_i_src_c107_3_08 mix_i_c107_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_08 (mix_q_src_c107_3_08 0 bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_3_08 (mix_q_src_c107_3_08 mix_q_c107_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_09 (mix_i_src_c107_3_09 0 bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c107_3_09 (mix_i_src_c107_3_09 mix_i_c107_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_09 (mix_q_src_c107_3_09 0 bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_3_09 (mix_q_src_c107_3_09 mix_q_c107_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_10 (mix_i_src_c107_3_10 0 bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c107_3_10 (mix_i_src_c107_3_10 mix_i_c107_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_10 (mix_q_src_c107_3_10 0 bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_3_10 (mix_q_src_c107_3_10 mix_q_c107_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_11 (mix_i_src_c107_3_11 0 bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c107_3_11 (mix_i_src_c107_3_11 mix_i_c107_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_11 (mix_q_src_c107_3_11 0 bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_3_11 (mix_q_src_c107_3_11 mix_q_c107_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_12 (mix_i_src_c107_3_12 0 bpf_c107_3 0) vcvs gain=1.950903220161e-01
SMIXI_c107_3_12 (mix_i_src_c107_3_12 mix_i_c107_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_12 (mix_q_src_c107_3_12 0 bpf_c107_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c107_3_12 (mix_q_src_c107_3_12 mix_q_c107_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_13 (mix_i_src_c107_3_13 0 bpf_c107_3 0) vcvs gain=5.555702330196e-01
SMIXI_c107_3_13 (mix_i_src_c107_3_13 mix_i_c107_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_13 (mix_q_src_c107_3_13 0 bpf_c107_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c107_3_13 (mix_q_src_c107_3_13 mix_q_c107_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_14 (mix_i_src_c107_3_14 0 bpf_c107_3 0) vcvs gain=8.314696123025e-01
SMIXI_c107_3_14 (mix_i_src_c107_3_14 mix_i_c107_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_14 (mix_q_src_c107_3_14 0 bpf_c107_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c107_3_14 (mix_q_src_c107_3_14 mix_q_c107_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c107_3_15 (mix_i_src_c107_3_15 0 bpf_c107_3 0) vcvs gain=9.807852804032e-01
SMIXI_c107_3_15 (mix_i_src_c107_3_15 mix_i_c107_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c107_3_15 (mix_q_src_c107_3_15 0 bpf_c107_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c107_3_15 (mix_q_src_c107_3_15 mix_q_c107_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c107_3 (mix_i_c107_3 0) resistor r=1G
RMIXQ_c107_3 (mix_q_c107_3 0) resistor r=1G
RINTI_c107_3 (mix_i_c107_3 Icar_c107_3) resistor r=1k
CINTI_c107_3 (Icar_c107_3 0) capacitor c=80p
RINTQ_c107_3 (mix_q_c107_3 Qcar_c107_3) resistor r=1k
CINTQ_c107_3 (Qcar_c107_3 0) capacitor c=80p

// bl108, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c108_0 (bl108 n_cbpf_c108_0) capacitor c=4.052847345694e-13
LBPF_c108_0 (n_cbpf_c108_0 bpf_c108_0) inductor l=1.000000000000e-06
RBPF_c108_0 (bpf_c108_0 0) resistor r=7.853981633974e+01
EMIXI_c108_0_00 (mix_i_src_c108_0_00 0 bpf_c108_0 0) vcvs gain=9.807852804032e-01
SMIXI_c108_0_00 (mix_i_src_c108_0_00 mix_i_c108_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_00 (mix_q_src_c108_0_00 0 bpf_c108_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_0_00 (mix_q_src_c108_0_00 mix_q_c108_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_01 (mix_i_src_c108_0_01 0 bpf_c108_0 0) vcvs gain=8.314696123025e-01
SMIXI_c108_0_01 (mix_i_src_c108_0_01 mix_i_c108_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_01 (mix_q_src_c108_0_01 0 bpf_c108_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_0_01 (mix_q_src_c108_0_01 mix_q_c108_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_02 (mix_i_src_c108_0_02 0 bpf_c108_0 0) vcvs gain=5.555702330196e-01
SMIXI_c108_0_02 (mix_i_src_c108_0_02 mix_i_c108_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_02 (mix_q_src_c108_0_02 0 bpf_c108_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_0_02 (mix_q_src_c108_0_02 mix_q_c108_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_03 (mix_i_src_c108_0_03 0 bpf_c108_0 0) vcvs gain=1.950903220161e-01
SMIXI_c108_0_03 (mix_i_src_c108_0_03 mix_i_c108_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_03 (mix_q_src_c108_0_03 0 bpf_c108_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_0_03 (mix_q_src_c108_0_03 mix_q_c108_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_04 (mix_i_src_c108_0_04 0 bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_0_04 (mix_i_src_c108_0_04 mix_i_c108_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_04 (mix_q_src_c108_0_04 0 bpf_c108_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_0_04 (mix_q_src_c108_0_04 mix_q_c108_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_05 (mix_i_src_c108_0_05 0 bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_0_05 (mix_i_src_c108_0_05 mix_i_c108_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_05 (mix_q_src_c108_0_05 0 bpf_c108_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_0_05 (mix_q_src_c108_0_05 mix_q_c108_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_06 (mix_i_src_c108_0_06 0 bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_0_06 (mix_i_src_c108_0_06 mix_i_c108_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_06 (mix_q_src_c108_0_06 0 bpf_c108_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_0_06 (mix_q_src_c108_0_06 mix_q_c108_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_07 (mix_i_src_c108_0_07 0 bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_0_07 (mix_i_src_c108_0_07 mix_i_c108_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_07 (mix_q_src_c108_0_07 0 bpf_c108_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_0_07 (mix_q_src_c108_0_07 mix_q_c108_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_08 (mix_i_src_c108_0_08 0 bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_0_08 (mix_i_src_c108_0_08 mix_i_c108_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_08 (mix_q_src_c108_0_08 0 bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_0_08 (mix_q_src_c108_0_08 mix_q_c108_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_09 (mix_i_src_c108_0_09 0 bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_0_09 (mix_i_src_c108_0_09 mix_i_c108_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_09 (mix_q_src_c108_0_09 0 bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_0_09 (mix_q_src_c108_0_09 mix_q_c108_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_10 (mix_i_src_c108_0_10 0 bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_0_10 (mix_i_src_c108_0_10 mix_i_c108_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_10 (mix_q_src_c108_0_10 0 bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_0_10 (mix_q_src_c108_0_10 mix_q_c108_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_11 (mix_i_src_c108_0_11 0 bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_0_11 (mix_i_src_c108_0_11 mix_i_c108_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_11 (mix_q_src_c108_0_11 0 bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_0_11 (mix_q_src_c108_0_11 mix_q_c108_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_12 (mix_i_src_c108_0_12 0 bpf_c108_0 0) vcvs gain=1.950903220161e-01
SMIXI_c108_0_12 (mix_i_src_c108_0_12 mix_i_c108_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_12 (mix_q_src_c108_0_12 0 bpf_c108_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_0_12 (mix_q_src_c108_0_12 mix_q_c108_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_13 (mix_i_src_c108_0_13 0 bpf_c108_0 0) vcvs gain=5.555702330196e-01
SMIXI_c108_0_13 (mix_i_src_c108_0_13 mix_i_c108_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_13 (mix_q_src_c108_0_13 0 bpf_c108_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_0_13 (mix_q_src_c108_0_13 mix_q_c108_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_14 (mix_i_src_c108_0_14 0 bpf_c108_0 0) vcvs gain=8.314696123025e-01
SMIXI_c108_0_14 (mix_i_src_c108_0_14 mix_i_c108_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_14 (mix_q_src_c108_0_14 0 bpf_c108_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_0_14 (mix_q_src_c108_0_14 mix_q_c108_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_0_15 (mix_i_src_c108_0_15 0 bpf_c108_0 0) vcvs gain=9.807852804032e-01
SMIXI_c108_0_15 (mix_i_src_c108_0_15 mix_i_c108_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_0_15 (mix_q_src_c108_0_15 0 bpf_c108_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_0_15 (mix_q_src_c108_0_15 mix_q_c108_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c108_0 (mix_i_c108_0 0) resistor r=1G
RMIXQ_c108_0 (mix_q_c108_0 0) resistor r=1G
RINTI_c108_0 (mix_i_c108_0 Icar_c108_0) resistor r=1k
CINTI_c108_0 (Icar_c108_0 0) capacitor c=80p
RINTQ_c108_0 (mix_q_c108_0 Qcar_c108_0) resistor r=1k
CINTQ_c108_0 (Qcar_c108_0 0) capacitor c=80p

// bl108, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c108_1 (bl108 n_cbpf_c108_1) capacitor c=1.013211836423e-13
LBPF_c108_1 (n_cbpf_c108_1 bpf_c108_1) inductor l=1.000000000000e-06
RBPF_c108_1 (bpf_c108_1 0) resistor r=1.570796326795e+02
EMIXI_c108_1_00 (mix_i_src_c108_1_00 0 bpf_c108_1 0) vcvs gain=9.807852804032e-01
SMIXI_c108_1_00 (mix_i_src_c108_1_00 mix_i_c108_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_00 (mix_q_src_c108_1_00 0 bpf_c108_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_1_00 (mix_q_src_c108_1_00 mix_q_c108_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_01 (mix_i_src_c108_1_01 0 bpf_c108_1 0) vcvs gain=8.314696123025e-01
SMIXI_c108_1_01 (mix_i_src_c108_1_01 mix_i_c108_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_01 (mix_q_src_c108_1_01 0 bpf_c108_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_1_01 (mix_q_src_c108_1_01 mix_q_c108_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_02 (mix_i_src_c108_1_02 0 bpf_c108_1 0) vcvs gain=5.555702330196e-01
SMIXI_c108_1_02 (mix_i_src_c108_1_02 mix_i_c108_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_02 (mix_q_src_c108_1_02 0 bpf_c108_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_1_02 (mix_q_src_c108_1_02 mix_q_c108_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_03 (mix_i_src_c108_1_03 0 bpf_c108_1 0) vcvs gain=1.950903220161e-01
SMIXI_c108_1_03 (mix_i_src_c108_1_03 mix_i_c108_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_03 (mix_q_src_c108_1_03 0 bpf_c108_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_1_03 (mix_q_src_c108_1_03 mix_q_c108_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_04 (mix_i_src_c108_1_04 0 bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_1_04 (mix_i_src_c108_1_04 mix_i_c108_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_04 (mix_q_src_c108_1_04 0 bpf_c108_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_1_04 (mix_q_src_c108_1_04 mix_q_c108_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_05 (mix_i_src_c108_1_05 0 bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_1_05 (mix_i_src_c108_1_05 mix_i_c108_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_05 (mix_q_src_c108_1_05 0 bpf_c108_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_1_05 (mix_q_src_c108_1_05 mix_q_c108_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_06 (mix_i_src_c108_1_06 0 bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_1_06 (mix_i_src_c108_1_06 mix_i_c108_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_06 (mix_q_src_c108_1_06 0 bpf_c108_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_1_06 (mix_q_src_c108_1_06 mix_q_c108_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_07 (mix_i_src_c108_1_07 0 bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_1_07 (mix_i_src_c108_1_07 mix_i_c108_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_07 (mix_q_src_c108_1_07 0 bpf_c108_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_1_07 (mix_q_src_c108_1_07 mix_q_c108_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_08 (mix_i_src_c108_1_08 0 bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_1_08 (mix_i_src_c108_1_08 mix_i_c108_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_08 (mix_q_src_c108_1_08 0 bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_1_08 (mix_q_src_c108_1_08 mix_q_c108_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_09 (mix_i_src_c108_1_09 0 bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_1_09 (mix_i_src_c108_1_09 mix_i_c108_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_09 (mix_q_src_c108_1_09 0 bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_1_09 (mix_q_src_c108_1_09 mix_q_c108_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_10 (mix_i_src_c108_1_10 0 bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_1_10 (mix_i_src_c108_1_10 mix_i_c108_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_10 (mix_q_src_c108_1_10 0 bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_1_10 (mix_q_src_c108_1_10 mix_q_c108_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_11 (mix_i_src_c108_1_11 0 bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_1_11 (mix_i_src_c108_1_11 mix_i_c108_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_11 (mix_q_src_c108_1_11 0 bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_1_11 (mix_q_src_c108_1_11 mix_q_c108_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_12 (mix_i_src_c108_1_12 0 bpf_c108_1 0) vcvs gain=1.950903220161e-01
SMIXI_c108_1_12 (mix_i_src_c108_1_12 mix_i_c108_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_12 (mix_q_src_c108_1_12 0 bpf_c108_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_1_12 (mix_q_src_c108_1_12 mix_q_c108_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_13 (mix_i_src_c108_1_13 0 bpf_c108_1 0) vcvs gain=5.555702330196e-01
SMIXI_c108_1_13 (mix_i_src_c108_1_13 mix_i_c108_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_13 (mix_q_src_c108_1_13 0 bpf_c108_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_1_13 (mix_q_src_c108_1_13 mix_q_c108_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_14 (mix_i_src_c108_1_14 0 bpf_c108_1 0) vcvs gain=8.314696123025e-01
SMIXI_c108_1_14 (mix_i_src_c108_1_14 mix_i_c108_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_14 (mix_q_src_c108_1_14 0 bpf_c108_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_1_14 (mix_q_src_c108_1_14 mix_q_c108_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_1_15 (mix_i_src_c108_1_15 0 bpf_c108_1 0) vcvs gain=9.807852804032e-01
SMIXI_c108_1_15 (mix_i_src_c108_1_15 mix_i_c108_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_1_15 (mix_q_src_c108_1_15 0 bpf_c108_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_1_15 (mix_q_src_c108_1_15 mix_q_c108_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c108_1 (mix_i_c108_1 0) resistor r=1G
RMIXQ_c108_1 (mix_q_c108_1 0) resistor r=1G
RINTI_c108_1 (mix_i_c108_1 Icar_c108_1) resistor r=1k
CINTI_c108_1 (Icar_c108_1 0) capacitor c=80p
RINTQ_c108_1 (mix_q_c108_1 Qcar_c108_1) resistor r=1k
CINTQ_c108_1 (Qcar_c108_1 0) capacitor c=80p

// bl108, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c108_2 (bl108 n_cbpf_c108_2) capacitor c=4.503163717437e-14
LBPF_c108_2 (n_cbpf_c108_2 bpf_c108_2) inductor l=1.000000000000e-06
RBPF_c108_2 (bpf_c108_2 0) resistor r=2.356194490192e+02
EMIXI_c108_2_00 (mix_i_src_c108_2_00 0 bpf_c108_2 0) vcvs gain=9.807852804032e-01
SMIXI_c108_2_00 (mix_i_src_c108_2_00 mix_i_c108_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_00 (mix_q_src_c108_2_00 0 bpf_c108_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_2_00 (mix_q_src_c108_2_00 mix_q_c108_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_01 (mix_i_src_c108_2_01 0 bpf_c108_2 0) vcvs gain=8.314696123025e-01
SMIXI_c108_2_01 (mix_i_src_c108_2_01 mix_i_c108_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_01 (mix_q_src_c108_2_01 0 bpf_c108_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_2_01 (mix_q_src_c108_2_01 mix_q_c108_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_02 (mix_i_src_c108_2_02 0 bpf_c108_2 0) vcvs gain=5.555702330196e-01
SMIXI_c108_2_02 (mix_i_src_c108_2_02 mix_i_c108_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_02 (mix_q_src_c108_2_02 0 bpf_c108_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_2_02 (mix_q_src_c108_2_02 mix_q_c108_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_03 (mix_i_src_c108_2_03 0 bpf_c108_2 0) vcvs gain=1.950903220161e-01
SMIXI_c108_2_03 (mix_i_src_c108_2_03 mix_i_c108_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_03 (mix_q_src_c108_2_03 0 bpf_c108_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_2_03 (mix_q_src_c108_2_03 mix_q_c108_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_04 (mix_i_src_c108_2_04 0 bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_2_04 (mix_i_src_c108_2_04 mix_i_c108_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_04 (mix_q_src_c108_2_04 0 bpf_c108_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_2_04 (mix_q_src_c108_2_04 mix_q_c108_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_05 (mix_i_src_c108_2_05 0 bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_2_05 (mix_i_src_c108_2_05 mix_i_c108_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_05 (mix_q_src_c108_2_05 0 bpf_c108_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_2_05 (mix_q_src_c108_2_05 mix_q_c108_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_06 (mix_i_src_c108_2_06 0 bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_2_06 (mix_i_src_c108_2_06 mix_i_c108_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_06 (mix_q_src_c108_2_06 0 bpf_c108_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_2_06 (mix_q_src_c108_2_06 mix_q_c108_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_07 (mix_i_src_c108_2_07 0 bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_2_07 (mix_i_src_c108_2_07 mix_i_c108_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_07 (mix_q_src_c108_2_07 0 bpf_c108_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_2_07 (mix_q_src_c108_2_07 mix_q_c108_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_08 (mix_i_src_c108_2_08 0 bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_2_08 (mix_i_src_c108_2_08 mix_i_c108_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_08 (mix_q_src_c108_2_08 0 bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_2_08 (mix_q_src_c108_2_08 mix_q_c108_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_09 (mix_i_src_c108_2_09 0 bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_2_09 (mix_i_src_c108_2_09 mix_i_c108_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_09 (mix_q_src_c108_2_09 0 bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_2_09 (mix_q_src_c108_2_09 mix_q_c108_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_10 (mix_i_src_c108_2_10 0 bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_2_10 (mix_i_src_c108_2_10 mix_i_c108_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_10 (mix_q_src_c108_2_10 0 bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_2_10 (mix_q_src_c108_2_10 mix_q_c108_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_11 (mix_i_src_c108_2_11 0 bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_2_11 (mix_i_src_c108_2_11 mix_i_c108_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_11 (mix_q_src_c108_2_11 0 bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_2_11 (mix_q_src_c108_2_11 mix_q_c108_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_12 (mix_i_src_c108_2_12 0 bpf_c108_2 0) vcvs gain=1.950903220161e-01
SMIXI_c108_2_12 (mix_i_src_c108_2_12 mix_i_c108_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_12 (mix_q_src_c108_2_12 0 bpf_c108_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_2_12 (mix_q_src_c108_2_12 mix_q_c108_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_13 (mix_i_src_c108_2_13 0 bpf_c108_2 0) vcvs gain=5.555702330196e-01
SMIXI_c108_2_13 (mix_i_src_c108_2_13 mix_i_c108_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_13 (mix_q_src_c108_2_13 0 bpf_c108_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_2_13 (mix_q_src_c108_2_13 mix_q_c108_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_14 (mix_i_src_c108_2_14 0 bpf_c108_2 0) vcvs gain=8.314696123025e-01
SMIXI_c108_2_14 (mix_i_src_c108_2_14 mix_i_c108_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_14 (mix_q_src_c108_2_14 0 bpf_c108_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_2_14 (mix_q_src_c108_2_14 mix_q_c108_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_2_15 (mix_i_src_c108_2_15 0 bpf_c108_2 0) vcvs gain=9.807852804032e-01
SMIXI_c108_2_15 (mix_i_src_c108_2_15 mix_i_c108_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_2_15 (mix_q_src_c108_2_15 0 bpf_c108_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_2_15 (mix_q_src_c108_2_15 mix_q_c108_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c108_2 (mix_i_c108_2 0) resistor r=1G
RMIXQ_c108_2 (mix_q_c108_2 0) resistor r=1G
RINTI_c108_2 (mix_i_c108_2 Icar_c108_2) resistor r=1k
CINTI_c108_2 (Icar_c108_2 0) capacitor c=80p
RINTQ_c108_2 (mix_q_c108_2 Qcar_c108_2) resistor r=1k
CINTQ_c108_2 (Qcar_c108_2 0) capacitor c=80p

// bl108, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c108_3 (bl108 n_cbpf_c108_3) capacitor c=2.533029591058e-14
LBPF_c108_3 (n_cbpf_c108_3 bpf_c108_3) inductor l=1.000000000000e-06
RBPF_c108_3 (bpf_c108_3 0) resistor r=3.141592653590e+02
EMIXI_c108_3_00 (mix_i_src_c108_3_00 0 bpf_c108_3 0) vcvs gain=9.807852804032e-01
SMIXI_c108_3_00 (mix_i_src_c108_3_00 mix_i_c108_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_00 (mix_q_src_c108_3_00 0 bpf_c108_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_3_00 (mix_q_src_c108_3_00 mix_q_c108_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_01 (mix_i_src_c108_3_01 0 bpf_c108_3 0) vcvs gain=8.314696123025e-01
SMIXI_c108_3_01 (mix_i_src_c108_3_01 mix_i_c108_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_01 (mix_q_src_c108_3_01 0 bpf_c108_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_3_01 (mix_q_src_c108_3_01 mix_q_c108_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_02 (mix_i_src_c108_3_02 0 bpf_c108_3 0) vcvs gain=5.555702330196e-01
SMIXI_c108_3_02 (mix_i_src_c108_3_02 mix_i_c108_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_02 (mix_q_src_c108_3_02 0 bpf_c108_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_3_02 (mix_q_src_c108_3_02 mix_q_c108_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_03 (mix_i_src_c108_3_03 0 bpf_c108_3 0) vcvs gain=1.950903220161e-01
SMIXI_c108_3_03 (mix_i_src_c108_3_03 mix_i_c108_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_03 (mix_q_src_c108_3_03 0 bpf_c108_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_3_03 (mix_q_src_c108_3_03 mix_q_c108_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_04 (mix_i_src_c108_3_04 0 bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_3_04 (mix_i_src_c108_3_04 mix_i_c108_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_04 (mix_q_src_c108_3_04 0 bpf_c108_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c108_3_04 (mix_q_src_c108_3_04 mix_q_c108_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_05 (mix_i_src_c108_3_05 0 bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_3_05 (mix_i_src_c108_3_05 mix_i_c108_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_05 (mix_q_src_c108_3_05 0 bpf_c108_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c108_3_05 (mix_q_src_c108_3_05 mix_q_c108_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_06 (mix_i_src_c108_3_06 0 bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_3_06 (mix_i_src_c108_3_06 mix_i_c108_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_06 (mix_q_src_c108_3_06 0 bpf_c108_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c108_3_06 (mix_q_src_c108_3_06 mix_q_c108_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_07 (mix_i_src_c108_3_07 0 bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_3_07 (mix_i_src_c108_3_07 mix_i_c108_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_07 (mix_q_src_c108_3_07 0 bpf_c108_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c108_3_07 (mix_q_src_c108_3_07 mix_q_c108_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_08 (mix_i_src_c108_3_08 0 bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c108_3_08 (mix_i_src_c108_3_08 mix_i_c108_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_08 (mix_q_src_c108_3_08 0 bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_3_08 (mix_q_src_c108_3_08 mix_q_c108_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_09 (mix_i_src_c108_3_09 0 bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c108_3_09 (mix_i_src_c108_3_09 mix_i_c108_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_09 (mix_q_src_c108_3_09 0 bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_3_09 (mix_q_src_c108_3_09 mix_q_c108_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_10 (mix_i_src_c108_3_10 0 bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c108_3_10 (mix_i_src_c108_3_10 mix_i_c108_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_10 (mix_q_src_c108_3_10 0 bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_3_10 (mix_q_src_c108_3_10 mix_q_c108_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_11 (mix_i_src_c108_3_11 0 bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c108_3_11 (mix_i_src_c108_3_11 mix_i_c108_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_11 (mix_q_src_c108_3_11 0 bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_3_11 (mix_q_src_c108_3_11 mix_q_c108_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_12 (mix_i_src_c108_3_12 0 bpf_c108_3 0) vcvs gain=1.950903220161e-01
SMIXI_c108_3_12 (mix_i_src_c108_3_12 mix_i_c108_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_12 (mix_q_src_c108_3_12 0 bpf_c108_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c108_3_12 (mix_q_src_c108_3_12 mix_q_c108_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_13 (mix_i_src_c108_3_13 0 bpf_c108_3 0) vcvs gain=5.555702330196e-01
SMIXI_c108_3_13 (mix_i_src_c108_3_13 mix_i_c108_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_13 (mix_q_src_c108_3_13 0 bpf_c108_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c108_3_13 (mix_q_src_c108_3_13 mix_q_c108_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_14 (mix_i_src_c108_3_14 0 bpf_c108_3 0) vcvs gain=8.314696123025e-01
SMIXI_c108_3_14 (mix_i_src_c108_3_14 mix_i_c108_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_14 (mix_q_src_c108_3_14 0 bpf_c108_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c108_3_14 (mix_q_src_c108_3_14 mix_q_c108_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c108_3_15 (mix_i_src_c108_3_15 0 bpf_c108_3 0) vcvs gain=9.807852804032e-01
SMIXI_c108_3_15 (mix_i_src_c108_3_15 mix_i_c108_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c108_3_15 (mix_q_src_c108_3_15 0 bpf_c108_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c108_3_15 (mix_q_src_c108_3_15 mix_q_c108_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c108_3 (mix_i_c108_3 0) resistor r=1G
RMIXQ_c108_3 (mix_q_c108_3 0) resistor r=1G
RINTI_c108_3 (mix_i_c108_3 Icar_c108_3) resistor r=1k
CINTI_c108_3 (Icar_c108_3 0) capacitor c=80p
RINTQ_c108_3 (mix_q_c108_3 Qcar_c108_3) resistor r=1k
CINTQ_c108_3 (Qcar_c108_3 0) capacitor c=80p

// bl109, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c109_0 (bl109 n_cbpf_c109_0) capacitor c=4.052847345694e-13
LBPF_c109_0 (n_cbpf_c109_0 bpf_c109_0) inductor l=1.000000000000e-06
RBPF_c109_0 (bpf_c109_0 0) resistor r=7.853981633974e+01
EMIXI_c109_0_00 (mix_i_src_c109_0_00 0 bpf_c109_0 0) vcvs gain=9.807852804032e-01
SMIXI_c109_0_00 (mix_i_src_c109_0_00 mix_i_c109_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_00 (mix_q_src_c109_0_00 0 bpf_c109_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_0_00 (mix_q_src_c109_0_00 mix_q_c109_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_01 (mix_i_src_c109_0_01 0 bpf_c109_0 0) vcvs gain=8.314696123025e-01
SMIXI_c109_0_01 (mix_i_src_c109_0_01 mix_i_c109_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_01 (mix_q_src_c109_0_01 0 bpf_c109_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_0_01 (mix_q_src_c109_0_01 mix_q_c109_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_02 (mix_i_src_c109_0_02 0 bpf_c109_0 0) vcvs gain=5.555702330196e-01
SMIXI_c109_0_02 (mix_i_src_c109_0_02 mix_i_c109_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_02 (mix_q_src_c109_0_02 0 bpf_c109_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_0_02 (mix_q_src_c109_0_02 mix_q_c109_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_03 (mix_i_src_c109_0_03 0 bpf_c109_0 0) vcvs gain=1.950903220161e-01
SMIXI_c109_0_03 (mix_i_src_c109_0_03 mix_i_c109_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_03 (mix_q_src_c109_0_03 0 bpf_c109_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_0_03 (mix_q_src_c109_0_03 mix_q_c109_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_04 (mix_i_src_c109_0_04 0 bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_0_04 (mix_i_src_c109_0_04 mix_i_c109_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_04 (mix_q_src_c109_0_04 0 bpf_c109_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_0_04 (mix_q_src_c109_0_04 mix_q_c109_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_05 (mix_i_src_c109_0_05 0 bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_0_05 (mix_i_src_c109_0_05 mix_i_c109_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_05 (mix_q_src_c109_0_05 0 bpf_c109_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_0_05 (mix_q_src_c109_0_05 mix_q_c109_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_06 (mix_i_src_c109_0_06 0 bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_0_06 (mix_i_src_c109_0_06 mix_i_c109_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_06 (mix_q_src_c109_0_06 0 bpf_c109_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_0_06 (mix_q_src_c109_0_06 mix_q_c109_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_07 (mix_i_src_c109_0_07 0 bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_0_07 (mix_i_src_c109_0_07 mix_i_c109_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_07 (mix_q_src_c109_0_07 0 bpf_c109_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_0_07 (mix_q_src_c109_0_07 mix_q_c109_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_08 (mix_i_src_c109_0_08 0 bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_0_08 (mix_i_src_c109_0_08 mix_i_c109_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_08 (mix_q_src_c109_0_08 0 bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_0_08 (mix_q_src_c109_0_08 mix_q_c109_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_09 (mix_i_src_c109_0_09 0 bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_0_09 (mix_i_src_c109_0_09 mix_i_c109_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_09 (mix_q_src_c109_0_09 0 bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_0_09 (mix_q_src_c109_0_09 mix_q_c109_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_10 (mix_i_src_c109_0_10 0 bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_0_10 (mix_i_src_c109_0_10 mix_i_c109_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_10 (mix_q_src_c109_0_10 0 bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_0_10 (mix_q_src_c109_0_10 mix_q_c109_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_11 (mix_i_src_c109_0_11 0 bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_0_11 (mix_i_src_c109_0_11 mix_i_c109_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_11 (mix_q_src_c109_0_11 0 bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_0_11 (mix_q_src_c109_0_11 mix_q_c109_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_12 (mix_i_src_c109_0_12 0 bpf_c109_0 0) vcvs gain=1.950903220161e-01
SMIXI_c109_0_12 (mix_i_src_c109_0_12 mix_i_c109_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_12 (mix_q_src_c109_0_12 0 bpf_c109_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_0_12 (mix_q_src_c109_0_12 mix_q_c109_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_13 (mix_i_src_c109_0_13 0 bpf_c109_0 0) vcvs gain=5.555702330196e-01
SMIXI_c109_0_13 (mix_i_src_c109_0_13 mix_i_c109_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_13 (mix_q_src_c109_0_13 0 bpf_c109_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_0_13 (mix_q_src_c109_0_13 mix_q_c109_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_14 (mix_i_src_c109_0_14 0 bpf_c109_0 0) vcvs gain=8.314696123025e-01
SMIXI_c109_0_14 (mix_i_src_c109_0_14 mix_i_c109_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_14 (mix_q_src_c109_0_14 0 bpf_c109_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_0_14 (mix_q_src_c109_0_14 mix_q_c109_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_0_15 (mix_i_src_c109_0_15 0 bpf_c109_0 0) vcvs gain=9.807852804032e-01
SMIXI_c109_0_15 (mix_i_src_c109_0_15 mix_i_c109_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_0_15 (mix_q_src_c109_0_15 0 bpf_c109_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_0_15 (mix_q_src_c109_0_15 mix_q_c109_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c109_0 (mix_i_c109_0 0) resistor r=1G
RMIXQ_c109_0 (mix_q_c109_0 0) resistor r=1G
RINTI_c109_0 (mix_i_c109_0 Icar_c109_0) resistor r=1k
CINTI_c109_0 (Icar_c109_0 0) capacitor c=80p
RINTQ_c109_0 (mix_q_c109_0 Qcar_c109_0) resistor r=1k
CINTQ_c109_0 (Qcar_c109_0 0) capacitor c=80p

// bl109, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c109_1 (bl109 n_cbpf_c109_1) capacitor c=1.013211836423e-13
LBPF_c109_1 (n_cbpf_c109_1 bpf_c109_1) inductor l=1.000000000000e-06
RBPF_c109_1 (bpf_c109_1 0) resistor r=1.570796326795e+02
EMIXI_c109_1_00 (mix_i_src_c109_1_00 0 bpf_c109_1 0) vcvs gain=9.807852804032e-01
SMIXI_c109_1_00 (mix_i_src_c109_1_00 mix_i_c109_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_00 (mix_q_src_c109_1_00 0 bpf_c109_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_1_00 (mix_q_src_c109_1_00 mix_q_c109_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_01 (mix_i_src_c109_1_01 0 bpf_c109_1 0) vcvs gain=8.314696123025e-01
SMIXI_c109_1_01 (mix_i_src_c109_1_01 mix_i_c109_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_01 (mix_q_src_c109_1_01 0 bpf_c109_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_1_01 (mix_q_src_c109_1_01 mix_q_c109_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_02 (mix_i_src_c109_1_02 0 bpf_c109_1 0) vcvs gain=5.555702330196e-01
SMIXI_c109_1_02 (mix_i_src_c109_1_02 mix_i_c109_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_02 (mix_q_src_c109_1_02 0 bpf_c109_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_1_02 (mix_q_src_c109_1_02 mix_q_c109_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_03 (mix_i_src_c109_1_03 0 bpf_c109_1 0) vcvs gain=1.950903220161e-01
SMIXI_c109_1_03 (mix_i_src_c109_1_03 mix_i_c109_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_03 (mix_q_src_c109_1_03 0 bpf_c109_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_1_03 (mix_q_src_c109_1_03 mix_q_c109_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_04 (mix_i_src_c109_1_04 0 bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_1_04 (mix_i_src_c109_1_04 mix_i_c109_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_04 (mix_q_src_c109_1_04 0 bpf_c109_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_1_04 (mix_q_src_c109_1_04 mix_q_c109_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_05 (mix_i_src_c109_1_05 0 bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_1_05 (mix_i_src_c109_1_05 mix_i_c109_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_05 (mix_q_src_c109_1_05 0 bpf_c109_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_1_05 (mix_q_src_c109_1_05 mix_q_c109_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_06 (mix_i_src_c109_1_06 0 bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_1_06 (mix_i_src_c109_1_06 mix_i_c109_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_06 (mix_q_src_c109_1_06 0 bpf_c109_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_1_06 (mix_q_src_c109_1_06 mix_q_c109_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_07 (mix_i_src_c109_1_07 0 bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_1_07 (mix_i_src_c109_1_07 mix_i_c109_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_07 (mix_q_src_c109_1_07 0 bpf_c109_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_1_07 (mix_q_src_c109_1_07 mix_q_c109_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_08 (mix_i_src_c109_1_08 0 bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_1_08 (mix_i_src_c109_1_08 mix_i_c109_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_08 (mix_q_src_c109_1_08 0 bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_1_08 (mix_q_src_c109_1_08 mix_q_c109_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_09 (mix_i_src_c109_1_09 0 bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_1_09 (mix_i_src_c109_1_09 mix_i_c109_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_09 (mix_q_src_c109_1_09 0 bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_1_09 (mix_q_src_c109_1_09 mix_q_c109_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_10 (mix_i_src_c109_1_10 0 bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_1_10 (mix_i_src_c109_1_10 mix_i_c109_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_10 (mix_q_src_c109_1_10 0 bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_1_10 (mix_q_src_c109_1_10 mix_q_c109_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_11 (mix_i_src_c109_1_11 0 bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_1_11 (mix_i_src_c109_1_11 mix_i_c109_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_11 (mix_q_src_c109_1_11 0 bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_1_11 (mix_q_src_c109_1_11 mix_q_c109_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_12 (mix_i_src_c109_1_12 0 bpf_c109_1 0) vcvs gain=1.950903220161e-01
SMIXI_c109_1_12 (mix_i_src_c109_1_12 mix_i_c109_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_12 (mix_q_src_c109_1_12 0 bpf_c109_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_1_12 (mix_q_src_c109_1_12 mix_q_c109_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_13 (mix_i_src_c109_1_13 0 bpf_c109_1 0) vcvs gain=5.555702330196e-01
SMIXI_c109_1_13 (mix_i_src_c109_1_13 mix_i_c109_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_13 (mix_q_src_c109_1_13 0 bpf_c109_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_1_13 (mix_q_src_c109_1_13 mix_q_c109_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_14 (mix_i_src_c109_1_14 0 bpf_c109_1 0) vcvs gain=8.314696123025e-01
SMIXI_c109_1_14 (mix_i_src_c109_1_14 mix_i_c109_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_14 (mix_q_src_c109_1_14 0 bpf_c109_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_1_14 (mix_q_src_c109_1_14 mix_q_c109_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_1_15 (mix_i_src_c109_1_15 0 bpf_c109_1 0) vcvs gain=9.807852804032e-01
SMIXI_c109_1_15 (mix_i_src_c109_1_15 mix_i_c109_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_1_15 (mix_q_src_c109_1_15 0 bpf_c109_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_1_15 (mix_q_src_c109_1_15 mix_q_c109_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c109_1 (mix_i_c109_1 0) resistor r=1G
RMIXQ_c109_1 (mix_q_c109_1 0) resistor r=1G
RINTI_c109_1 (mix_i_c109_1 Icar_c109_1) resistor r=1k
CINTI_c109_1 (Icar_c109_1 0) capacitor c=80p
RINTQ_c109_1 (mix_q_c109_1 Qcar_c109_1) resistor r=1k
CINTQ_c109_1 (Qcar_c109_1 0) capacitor c=80p

// bl109, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c109_2 (bl109 n_cbpf_c109_2) capacitor c=4.503163717437e-14
LBPF_c109_2 (n_cbpf_c109_2 bpf_c109_2) inductor l=1.000000000000e-06
RBPF_c109_2 (bpf_c109_2 0) resistor r=2.356194490192e+02
EMIXI_c109_2_00 (mix_i_src_c109_2_00 0 bpf_c109_2 0) vcvs gain=9.807852804032e-01
SMIXI_c109_2_00 (mix_i_src_c109_2_00 mix_i_c109_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_00 (mix_q_src_c109_2_00 0 bpf_c109_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_2_00 (mix_q_src_c109_2_00 mix_q_c109_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_01 (mix_i_src_c109_2_01 0 bpf_c109_2 0) vcvs gain=8.314696123025e-01
SMIXI_c109_2_01 (mix_i_src_c109_2_01 mix_i_c109_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_01 (mix_q_src_c109_2_01 0 bpf_c109_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_2_01 (mix_q_src_c109_2_01 mix_q_c109_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_02 (mix_i_src_c109_2_02 0 bpf_c109_2 0) vcvs gain=5.555702330196e-01
SMIXI_c109_2_02 (mix_i_src_c109_2_02 mix_i_c109_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_02 (mix_q_src_c109_2_02 0 bpf_c109_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_2_02 (mix_q_src_c109_2_02 mix_q_c109_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_03 (mix_i_src_c109_2_03 0 bpf_c109_2 0) vcvs gain=1.950903220161e-01
SMIXI_c109_2_03 (mix_i_src_c109_2_03 mix_i_c109_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_03 (mix_q_src_c109_2_03 0 bpf_c109_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_2_03 (mix_q_src_c109_2_03 mix_q_c109_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_04 (mix_i_src_c109_2_04 0 bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_2_04 (mix_i_src_c109_2_04 mix_i_c109_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_04 (mix_q_src_c109_2_04 0 bpf_c109_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_2_04 (mix_q_src_c109_2_04 mix_q_c109_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_05 (mix_i_src_c109_2_05 0 bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_2_05 (mix_i_src_c109_2_05 mix_i_c109_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_05 (mix_q_src_c109_2_05 0 bpf_c109_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_2_05 (mix_q_src_c109_2_05 mix_q_c109_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_06 (mix_i_src_c109_2_06 0 bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_2_06 (mix_i_src_c109_2_06 mix_i_c109_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_06 (mix_q_src_c109_2_06 0 bpf_c109_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_2_06 (mix_q_src_c109_2_06 mix_q_c109_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_07 (mix_i_src_c109_2_07 0 bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_2_07 (mix_i_src_c109_2_07 mix_i_c109_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_07 (mix_q_src_c109_2_07 0 bpf_c109_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_2_07 (mix_q_src_c109_2_07 mix_q_c109_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_08 (mix_i_src_c109_2_08 0 bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_2_08 (mix_i_src_c109_2_08 mix_i_c109_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_08 (mix_q_src_c109_2_08 0 bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_2_08 (mix_q_src_c109_2_08 mix_q_c109_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_09 (mix_i_src_c109_2_09 0 bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_2_09 (mix_i_src_c109_2_09 mix_i_c109_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_09 (mix_q_src_c109_2_09 0 bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_2_09 (mix_q_src_c109_2_09 mix_q_c109_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_10 (mix_i_src_c109_2_10 0 bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_2_10 (mix_i_src_c109_2_10 mix_i_c109_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_10 (mix_q_src_c109_2_10 0 bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_2_10 (mix_q_src_c109_2_10 mix_q_c109_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_11 (mix_i_src_c109_2_11 0 bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_2_11 (mix_i_src_c109_2_11 mix_i_c109_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_11 (mix_q_src_c109_2_11 0 bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_2_11 (mix_q_src_c109_2_11 mix_q_c109_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_12 (mix_i_src_c109_2_12 0 bpf_c109_2 0) vcvs gain=1.950903220161e-01
SMIXI_c109_2_12 (mix_i_src_c109_2_12 mix_i_c109_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_12 (mix_q_src_c109_2_12 0 bpf_c109_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_2_12 (mix_q_src_c109_2_12 mix_q_c109_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_13 (mix_i_src_c109_2_13 0 bpf_c109_2 0) vcvs gain=5.555702330196e-01
SMIXI_c109_2_13 (mix_i_src_c109_2_13 mix_i_c109_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_13 (mix_q_src_c109_2_13 0 bpf_c109_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_2_13 (mix_q_src_c109_2_13 mix_q_c109_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_14 (mix_i_src_c109_2_14 0 bpf_c109_2 0) vcvs gain=8.314696123025e-01
SMIXI_c109_2_14 (mix_i_src_c109_2_14 mix_i_c109_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_14 (mix_q_src_c109_2_14 0 bpf_c109_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_2_14 (mix_q_src_c109_2_14 mix_q_c109_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_2_15 (mix_i_src_c109_2_15 0 bpf_c109_2 0) vcvs gain=9.807852804032e-01
SMIXI_c109_2_15 (mix_i_src_c109_2_15 mix_i_c109_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_2_15 (mix_q_src_c109_2_15 0 bpf_c109_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_2_15 (mix_q_src_c109_2_15 mix_q_c109_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c109_2 (mix_i_c109_2 0) resistor r=1G
RMIXQ_c109_2 (mix_q_c109_2 0) resistor r=1G
RINTI_c109_2 (mix_i_c109_2 Icar_c109_2) resistor r=1k
CINTI_c109_2 (Icar_c109_2 0) capacitor c=80p
RINTQ_c109_2 (mix_q_c109_2 Qcar_c109_2) resistor r=1k
CINTQ_c109_2 (Qcar_c109_2 0) capacitor c=80p

// bl109, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c109_3 (bl109 n_cbpf_c109_3) capacitor c=2.533029591058e-14
LBPF_c109_3 (n_cbpf_c109_3 bpf_c109_3) inductor l=1.000000000000e-06
RBPF_c109_3 (bpf_c109_3 0) resistor r=3.141592653590e+02
EMIXI_c109_3_00 (mix_i_src_c109_3_00 0 bpf_c109_3 0) vcvs gain=9.807852804032e-01
SMIXI_c109_3_00 (mix_i_src_c109_3_00 mix_i_c109_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_00 (mix_q_src_c109_3_00 0 bpf_c109_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_3_00 (mix_q_src_c109_3_00 mix_q_c109_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_01 (mix_i_src_c109_3_01 0 bpf_c109_3 0) vcvs gain=8.314696123025e-01
SMIXI_c109_3_01 (mix_i_src_c109_3_01 mix_i_c109_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_01 (mix_q_src_c109_3_01 0 bpf_c109_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_3_01 (mix_q_src_c109_3_01 mix_q_c109_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_02 (mix_i_src_c109_3_02 0 bpf_c109_3 0) vcvs gain=5.555702330196e-01
SMIXI_c109_3_02 (mix_i_src_c109_3_02 mix_i_c109_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_02 (mix_q_src_c109_3_02 0 bpf_c109_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_3_02 (mix_q_src_c109_3_02 mix_q_c109_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_03 (mix_i_src_c109_3_03 0 bpf_c109_3 0) vcvs gain=1.950903220161e-01
SMIXI_c109_3_03 (mix_i_src_c109_3_03 mix_i_c109_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_03 (mix_q_src_c109_3_03 0 bpf_c109_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_3_03 (mix_q_src_c109_3_03 mix_q_c109_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_04 (mix_i_src_c109_3_04 0 bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_3_04 (mix_i_src_c109_3_04 mix_i_c109_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_04 (mix_q_src_c109_3_04 0 bpf_c109_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c109_3_04 (mix_q_src_c109_3_04 mix_q_c109_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_05 (mix_i_src_c109_3_05 0 bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_3_05 (mix_i_src_c109_3_05 mix_i_c109_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_05 (mix_q_src_c109_3_05 0 bpf_c109_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c109_3_05 (mix_q_src_c109_3_05 mix_q_c109_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_06 (mix_i_src_c109_3_06 0 bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_3_06 (mix_i_src_c109_3_06 mix_i_c109_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_06 (mix_q_src_c109_3_06 0 bpf_c109_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c109_3_06 (mix_q_src_c109_3_06 mix_q_c109_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_07 (mix_i_src_c109_3_07 0 bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_3_07 (mix_i_src_c109_3_07 mix_i_c109_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_07 (mix_q_src_c109_3_07 0 bpf_c109_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c109_3_07 (mix_q_src_c109_3_07 mix_q_c109_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_08 (mix_i_src_c109_3_08 0 bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c109_3_08 (mix_i_src_c109_3_08 mix_i_c109_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_08 (mix_q_src_c109_3_08 0 bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_3_08 (mix_q_src_c109_3_08 mix_q_c109_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_09 (mix_i_src_c109_3_09 0 bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c109_3_09 (mix_i_src_c109_3_09 mix_i_c109_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_09 (mix_q_src_c109_3_09 0 bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_3_09 (mix_q_src_c109_3_09 mix_q_c109_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_10 (mix_i_src_c109_3_10 0 bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c109_3_10 (mix_i_src_c109_3_10 mix_i_c109_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_10 (mix_q_src_c109_3_10 0 bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_3_10 (mix_q_src_c109_3_10 mix_q_c109_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_11 (mix_i_src_c109_3_11 0 bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c109_3_11 (mix_i_src_c109_3_11 mix_i_c109_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_11 (mix_q_src_c109_3_11 0 bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_3_11 (mix_q_src_c109_3_11 mix_q_c109_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_12 (mix_i_src_c109_3_12 0 bpf_c109_3 0) vcvs gain=1.950903220161e-01
SMIXI_c109_3_12 (mix_i_src_c109_3_12 mix_i_c109_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_12 (mix_q_src_c109_3_12 0 bpf_c109_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c109_3_12 (mix_q_src_c109_3_12 mix_q_c109_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_13 (mix_i_src_c109_3_13 0 bpf_c109_3 0) vcvs gain=5.555702330196e-01
SMIXI_c109_3_13 (mix_i_src_c109_3_13 mix_i_c109_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_13 (mix_q_src_c109_3_13 0 bpf_c109_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c109_3_13 (mix_q_src_c109_3_13 mix_q_c109_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_14 (mix_i_src_c109_3_14 0 bpf_c109_3 0) vcvs gain=8.314696123025e-01
SMIXI_c109_3_14 (mix_i_src_c109_3_14 mix_i_c109_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_14 (mix_q_src_c109_3_14 0 bpf_c109_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c109_3_14 (mix_q_src_c109_3_14 mix_q_c109_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c109_3_15 (mix_i_src_c109_3_15 0 bpf_c109_3 0) vcvs gain=9.807852804032e-01
SMIXI_c109_3_15 (mix_i_src_c109_3_15 mix_i_c109_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c109_3_15 (mix_q_src_c109_3_15 0 bpf_c109_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c109_3_15 (mix_q_src_c109_3_15 mix_q_c109_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c109_3 (mix_i_c109_3 0) resistor r=1G
RMIXQ_c109_3 (mix_q_c109_3 0) resistor r=1G
RINTI_c109_3 (mix_i_c109_3 Icar_c109_3) resistor r=1k
CINTI_c109_3 (Icar_c109_3 0) capacitor c=80p
RINTQ_c109_3 (mix_q_c109_3 Qcar_c109_3) resistor r=1k
CINTQ_c109_3 (Qcar_c109_3 0) capacitor c=80p

// bl110, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c110_0 (bl110 n_cbpf_c110_0) capacitor c=4.052847345694e-13
LBPF_c110_0 (n_cbpf_c110_0 bpf_c110_0) inductor l=1.000000000000e-06
RBPF_c110_0 (bpf_c110_0 0) resistor r=7.853981633974e+01
EMIXI_c110_0_00 (mix_i_src_c110_0_00 0 bpf_c110_0 0) vcvs gain=9.807852804032e-01
SMIXI_c110_0_00 (mix_i_src_c110_0_00 mix_i_c110_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_00 (mix_q_src_c110_0_00 0 bpf_c110_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_0_00 (mix_q_src_c110_0_00 mix_q_c110_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_01 (mix_i_src_c110_0_01 0 bpf_c110_0 0) vcvs gain=8.314696123025e-01
SMIXI_c110_0_01 (mix_i_src_c110_0_01 mix_i_c110_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_01 (mix_q_src_c110_0_01 0 bpf_c110_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_0_01 (mix_q_src_c110_0_01 mix_q_c110_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_02 (mix_i_src_c110_0_02 0 bpf_c110_0 0) vcvs gain=5.555702330196e-01
SMIXI_c110_0_02 (mix_i_src_c110_0_02 mix_i_c110_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_02 (mix_q_src_c110_0_02 0 bpf_c110_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_0_02 (mix_q_src_c110_0_02 mix_q_c110_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_03 (mix_i_src_c110_0_03 0 bpf_c110_0 0) vcvs gain=1.950903220161e-01
SMIXI_c110_0_03 (mix_i_src_c110_0_03 mix_i_c110_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_03 (mix_q_src_c110_0_03 0 bpf_c110_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_0_03 (mix_q_src_c110_0_03 mix_q_c110_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_04 (mix_i_src_c110_0_04 0 bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_0_04 (mix_i_src_c110_0_04 mix_i_c110_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_04 (mix_q_src_c110_0_04 0 bpf_c110_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_0_04 (mix_q_src_c110_0_04 mix_q_c110_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_05 (mix_i_src_c110_0_05 0 bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_0_05 (mix_i_src_c110_0_05 mix_i_c110_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_05 (mix_q_src_c110_0_05 0 bpf_c110_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_0_05 (mix_q_src_c110_0_05 mix_q_c110_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_06 (mix_i_src_c110_0_06 0 bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_0_06 (mix_i_src_c110_0_06 mix_i_c110_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_06 (mix_q_src_c110_0_06 0 bpf_c110_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_0_06 (mix_q_src_c110_0_06 mix_q_c110_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_07 (mix_i_src_c110_0_07 0 bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_0_07 (mix_i_src_c110_0_07 mix_i_c110_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_07 (mix_q_src_c110_0_07 0 bpf_c110_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_0_07 (mix_q_src_c110_0_07 mix_q_c110_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_08 (mix_i_src_c110_0_08 0 bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_0_08 (mix_i_src_c110_0_08 mix_i_c110_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_08 (mix_q_src_c110_0_08 0 bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_0_08 (mix_q_src_c110_0_08 mix_q_c110_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_09 (mix_i_src_c110_0_09 0 bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_0_09 (mix_i_src_c110_0_09 mix_i_c110_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_09 (mix_q_src_c110_0_09 0 bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_0_09 (mix_q_src_c110_0_09 mix_q_c110_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_10 (mix_i_src_c110_0_10 0 bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_0_10 (mix_i_src_c110_0_10 mix_i_c110_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_10 (mix_q_src_c110_0_10 0 bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_0_10 (mix_q_src_c110_0_10 mix_q_c110_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_11 (mix_i_src_c110_0_11 0 bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_0_11 (mix_i_src_c110_0_11 mix_i_c110_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_11 (mix_q_src_c110_0_11 0 bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_0_11 (mix_q_src_c110_0_11 mix_q_c110_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_12 (mix_i_src_c110_0_12 0 bpf_c110_0 0) vcvs gain=1.950903220161e-01
SMIXI_c110_0_12 (mix_i_src_c110_0_12 mix_i_c110_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_12 (mix_q_src_c110_0_12 0 bpf_c110_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_0_12 (mix_q_src_c110_0_12 mix_q_c110_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_13 (mix_i_src_c110_0_13 0 bpf_c110_0 0) vcvs gain=5.555702330196e-01
SMIXI_c110_0_13 (mix_i_src_c110_0_13 mix_i_c110_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_13 (mix_q_src_c110_0_13 0 bpf_c110_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_0_13 (mix_q_src_c110_0_13 mix_q_c110_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_14 (mix_i_src_c110_0_14 0 bpf_c110_0 0) vcvs gain=8.314696123025e-01
SMIXI_c110_0_14 (mix_i_src_c110_0_14 mix_i_c110_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_14 (mix_q_src_c110_0_14 0 bpf_c110_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_0_14 (mix_q_src_c110_0_14 mix_q_c110_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_0_15 (mix_i_src_c110_0_15 0 bpf_c110_0 0) vcvs gain=9.807852804032e-01
SMIXI_c110_0_15 (mix_i_src_c110_0_15 mix_i_c110_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_0_15 (mix_q_src_c110_0_15 0 bpf_c110_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_0_15 (mix_q_src_c110_0_15 mix_q_c110_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c110_0 (mix_i_c110_0 0) resistor r=1G
RMIXQ_c110_0 (mix_q_c110_0 0) resistor r=1G
RINTI_c110_0 (mix_i_c110_0 Icar_c110_0) resistor r=1k
CINTI_c110_0 (Icar_c110_0 0) capacitor c=80p
RINTQ_c110_0 (mix_q_c110_0 Qcar_c110_0) resistor r=1k
CINTQ_c110_0 (Qcar_c110_0 0) capacitor c=80p

// bl110, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c110_1 (bl110 n_cbpf_c110_1) capacitor c=1.013211836423e-13
LBPF_c110_1 (n_cbpf_c110_1 bpf_c110_1) inductor l=1.000000000000e-06
RBPF_c110_1 (bpf_c110_1 0) resistor r=1.570796326795e+02
EMIXI_c110_1_00 (mix_i_src_c110_1_00 0 bpf_c110_1 0) vcvs gain=9.807852804032e-01
SMIXI_c110_1_00 (mix_i_src_c110_1_00 mix_i_c110_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_00 (mix_q_src_c110_1_00 0 bpf_c110_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_1_00 (mix_q_src_c110_1_00 mix_q_c110_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_01 (mix_i_src_c110_1_01 0 bpf_c110_1 0) vcvs gain=8.314696123025e-01
SMIXI_c110_1_01 (mix_i_src_c110_1_01 mix_i_c110_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_01 (mix_q_src_c110_1_01 0 bpf_c110_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_1_01 (mix_q_src_c110_1_01 mix_q_c110_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_02 (mix_i_src_c110_1_02 0 bpf_c110_1 0) vcvs gain=5.555702330196e-01
SMIXI_c110_1_02 (mix_i_src_c110_1_02 mix_i_c110_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_02 (mix_q_src_c110_1_02 0 bpf_c110_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_1_02 (mix_q_src_c110_1_02 mix_q_c110_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_03 (mix_i_src_c110_1_03 0 bpf_c110_1 0) vcvs gain=1.950903220161e-01
SMIXI_c110_1_03 (mix_i_src_c110_1_03 mix_i_c110_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_03 (mix_q_src_c110_1_03 0 bpf_c110_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_1_03 (mix_q_src_c110_1_03 mix_q_c110_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_04 (mix_i_src_c110_1_04 0 bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_1_04 (mix_i_src_c110_1_04 mix_i_c110_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_04 (mix_q_src_c110_1_04 0 bpf_c110_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_1_04 (mix_q_src_c110_1_04 mix_q_c110_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_05 (mix_i_src_c110_1_05 0 bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_1_05 (mix_i_src_c110_1_05 mix_i_c110_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_05 (mix_q_src_c110_1_05 0 bpf_c110_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_1_05 (mix_q_src_c110_1_05 mix_q_c110_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_06 (mix_i_src_c110_1_06 0 bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_1_06 (mix_i_src_c110_1_06 mix_i_c110_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_06 (mix_q_src_c110_1_06 0 bpf_c110_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_1_06 (mix_q_src_c110_1_06 mix_q_c110_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_07 (mix_i_src_c110_1_07 0 bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_1_07 (mix_i_src_c110_1_07 mix_i_c110_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_07 (mix_q_src_c110_1_07 0 bpf_c110_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_1_07 (mix_q_src_c110_1_07 mix_q_c110_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_08 (mix_i_src_c110_1_08 0 bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_1_08 (mix_i_src_c110_1_08 mix_i_c110_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_08 (mix_q_src_c110_1_08 0 bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_1_08 (mix_q_src_c110_1_08 mix_q_c110_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_09 (mix_i_src_c110_1_09 0 bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_1_09 (mix_i_src_c110_1_09 mix_i_c110_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_09 (mix_q_src_c110_1_09 0 bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_1_09 (mix_q_src_c110_1_09 mix_q_c110_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_10 (mix_i_src_c110_1_10 0 bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_1_10 (mix_i_src_c110_1_10 mix_i_c110_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_10 (mix_q_src_c110_1_10 0 bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_1_10 (mix_q_src_c110_1_10 mix_q_c110_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_11 (mix_i_src_c110_1_11 0 bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_1_11 (mix_i_src_c110_1_11 mix_i_c110_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_11 (mix_q_src_c110_1_11 0 bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_1_11 (mix_q_src_c110_1_11 mix_q_c110_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_12 (mix_i_src_c110_1_12 0 bpf_c110_1 0) vcvs gain=1.950903220161e-01
SMIXI_c110_1_12 (mix_i_src_c110_1_12 mix_i_c110_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_12 (mix_q_src_c110_1_12 0 bpf_c110_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_1_12 (mix_q_src_c110_1_12 mix_q_c110_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_13 (mix_i_src_c110_1_13 0 bpf_c110_1 0) vcvs gain=5.555702330196e-01
SMIXI_c110_1_13 (mix_i_src_c110_1_13 mix_i_c110_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_13 (mix_q_src_c110_1_13 0 bpf_c110_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_1_13 (mix_q_src_c110_1_13 mix_q_c110_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_14 (mix_i_src_c110_1_14 0 bpf_c110_1 0) vcvs gain=8.314696123025e-01
SMIXI_c110_1_14 (mix_i_src_c110_1_14 mix_i_c110_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_14 (mix_q_src_c110_1_14 0 bpf_c110_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_1_14 (mix_q_src_c110_1_14 mix_q_c110_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_1_15 (mix_i_src_c110_1_15 0 bpf_c110_1 0) vcvs gain=9.807852804032e-01
SMIXI_c110_1_15 (mix_i_src_c110_1_15 mix_i_c110_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_1_15 (mix_q_src_c110_1_15 0 bpf_c110_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_1_15 (mix_q_src_c110_1_15 mix_q_c110_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c110_1 (mix_i_c110_1 0) resistor r=1G
RMIXQ_c110_1 (mix_q_c110_1 0) resistor r=1G
RINTI_c110_1 (mix_i_c110_1 Icar_c110_1) resistor r=1k
CINTI_c110_1 (Icar_c110_1 0) capacitor c=80p
RINTQ_c110_1 (mix_q_c110_1 Qcar_c110_1) resistor r=1k
CINTQ_c110_1 (Qcar_c110_1 0) capacitor c=80p

// bl110, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c110_2 (bl110 n_cbpf_c110_2) capacitor c=4.503163717437e-14
LBPF_c110_2 (n_cbpf_c110_2 bpf_c110_2) inductor l=1.000000000000e-06
RBPF_c110_2 (bpf_c110_2 0) resistor r=2.356194490192e+02
EMIXI_c110_2_00 (mix_i_src_c110_2_00 0 bpf_c110_2 0) vcvs gain=9.807852804032e-01
SMIXI_c110_2_00 (mix_i_src_c110_2_00 mix_i_c110_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_00 (mix_q_src_c110_2_00 0 bpf_c110_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_2_00 (mix_q_src_c110_2_00 mix_q_c110_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_01 (mix_i_src_c110_2_01 0 bpf_c110_2 0) vcvs gain=8.314696123025e-01
SMIXI_c110_2_01 (mix_i_src_c110_2_01 mix_i_c110_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_01 (mix_q_src_c110_2_01 0 bpf_c110_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_2_01 (mix_q_src_c110_2_01 mix_q_c110_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_02 (mix_i_src_c110_2_02 0 bpf_c110_2 0) vcvs gain=5.555702330196e-01
SMIXI_c110_2_02 (mix_i_src_c110_2_02 mix_i_c110_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_02 (mix_q_src_c110_2_02 0 bpf_c110_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_2_02 (mix_q_src_c110_2_02 mix_q_c110_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_03 (mix_i_src_c110_2_03 0 bpf_c110_2 0) vcvs gain=1.950903220161e-01
SMIXI_c110_2_03 (mix_i_src_c110_2_03 mix_i_c110_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_03 (mix_q_src_c110_2_03 0 bpf_c110_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_2_03 (mix_q_src_c110_2_03 mix_q_c110_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_04 (mix_i_src_c110_2_04 0 bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_2_04 (mix_i_src_c110_2_04 mix_i_c110_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_04 (mix_q_src_c110_2_04 0 bpf_c110_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_2_04 (mix_q_src_c110_2_04 mix_q_c110_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_05 (mix_i_src_c110_2_05 0 bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_2_05 (mix_i_src_c110_2_05 mix_i_c110_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_05 (mix_q_src_c110_2_05 0 bpf_c110_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_2_05 (mix_q_src_c110_2_05 mix_q_c110_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_06 (mix_i_src_c110_2_06 0 bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_2_06 (mix_i_src_c110_2_06 mix_i_c110_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_06 (mix_q_src_c110_2_06 0 bpf_c110_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_2_06 (mix_q_src_c110_2_06 mix_q_c110_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_07 (mix_i_src_c110_2_07 0 bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_2_07 (mix_i_src_c110_2_07 mix_i_c110_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_07 (mix_q_src_c110_2_07 0 bpf_c110_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_2_07 (mix_q_src_c110_2_07 mix_q_c110_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_08 (mix_i_src_c110_2_08 0 bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_2_08 (mix_i_src_c110_2_08 mix_i_c110_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_08 (mix_q_src_c110_2_08 0 bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_2_08 (mix_q_src_c110_2_08 mix_q_c110_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_09 (mix_i_src_c110_2_09 0 bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_2_09 (mix_i_src_c110_2_09 mix_i_c110_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_09 (mix_q_src_c110_2_09 0 bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_2_09 (mix_q_src_c110_2_09 mix_q_c110_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_10 (mix_i_src_c110_2_10 0 bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_2_10 (mix_i_src_c110_2_10 mix_i_c110_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_10 (mix_q_src_c110_2_10 0 bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_2_10 (mix_q_src_c110_2_10 mix_q_c110_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_11 (mix_i_src_c110_2_11 0 bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_2_11 (mix_i_src_c110_2_11 mix_i_c110_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_11 (mix_q_src_c110_2_11 0 bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_2_11 (mix_q_src_c110_2_11 mix_q_c110_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_12 (mix_i_src_c110_2_12 0 bpf_c110_2 0) vcvs gain=1.950903220161e-01
SMIXI_c110_2_12 (mix_i_src_c110_2_12 mix_i_c110_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_12 (mix_q_src_c110_2_12 0 bpf_c110_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_2_12 (mix_q_src_c110_2_12 mix_q_c110_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_13 (mix_i_src_c110_2_13 0 bpf_c110_2 0) vcvs gain=5.555702330196e-01
SMIXI_c110_2_13 (mix_i_src_c110_2_13 mix_i_c110_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_13 (mix_q_src_c110_2_13 0 bpf_c110_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_2_13 (mix_q_src_c110_2_13 mix_q_c110_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_14 (mix_i_src_c110_2_14 0 bpf_c110_2 0) vcvs gain=8.314696123025e-01
SMIXI_c110_2_14 (mix_i_src_c110_2_14 mix_i_c110_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_14 (mix_q_src_c110_2_14 0 bpf_c110_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_2_14 (mix_q_src_c110_2_14 mix_q_c110_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_2_15 (mix_i_src_c110_2_15 0 bpf_c110_2 0) vcvs gain=9.807852804032e-01
SMIXI_c110_2_15 (mix_i_src_c110_2_15 mix_i_c110_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_2_15 (mix_q_src_c110_2_15 0 bpf_c110_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_2_15 (mix_q_src_c110_2_15 mix_q_c110_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c110_2 (mix_i_c110_2 0) resistor r=1G
RMIXQ_c110_2 (mix_q_c110_2 0) resistor r=1G
RINTI_c110_2 (mix_i_c110_2 Icar_c110_2) resistor r=1k
CINTI_c110_2 (Icar_c110_2 0) capacitor c=80p
RINTQ_c110_2 (mix_q_c110_2 Qcar_c110_2) resistor r=1k
CINTQ_c110_2 (Qcar_c110_2 0) capacitor c=80p

// bl110, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c110_3 (bl110 n_cbpf_c110_3) capacitor c=2.533029591058e-14
LBPF_c110_3 (n_cbpf_c110_3 bpf_c110_3) inductor l=1.000000000000e-06
RBPF_c110_3 (bpf_c110_3 0) resistor r=3.141592653590e+02
EMIXI_c110_3_00 (mix_i_src_c110_3_00 0 bpf_c110_3 0) vcvs gain=9.807852804032e-01
SMIXI_c110_3_00 (mix_i_src_c110_3_00 mix_i_c110_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_00 (mix_q_src_c110_3_00 0 bpf_c110_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_3_00 (mix_q_src_c110_3_00 mix_q_c110_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_01 (mix_i_src_c110_3_01 0 bpf_c110_3 0) vcvs gain=8.314696123025e-01
SMIXI_c110_3_01 (mix_i_src_c110_3_01 mix_i_c110_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_01 (mix_q_src_c110_3_01 0 bpf_c110_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_3_01 (mix_q_src_c110_3_01 mix_q_c110_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_02 (mix_i_src_c110_3_02 0 bpf_c110_3 0) vcvs gain=5.555702330196e-01
SMIXI_c110_3_02 (mix_i_src_c110_3_02 mix_i_c110_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_02 (mix_q_src_c110_3_02 0 bpf_c110_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_3_02 (mix_q_src_c110_3_02 mix_q_c110_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_03 (mix_i_src_c110_3_03 0 bpf_c110_3 0) vcvs gain=1.950903220161e-01
SMIXI_c110_3_03 (mix_i_src_c110_3_03 mix_i_c110_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_03 (mix_q_src_c110_3_03 0 bpf_c110_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_3_03 (mix_q_src_c110_3_03 mix_q_c110_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_04 (mix_i_src_c110_3_04 0 bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_3_04 (mix_i_src_c110_3_04 mix_i_c110_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_04 (mix_q_src_c110_3_04 0 bpf_c110_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c110_3_04 (mix_q_src_c110_3_04 mix_q_c110_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_05 (mix_i_src_c110_3_05 0 bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_3_05 (mix_i_src_c110_3_05 mix_i_c110_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_05 (mix_q_src_c110_3_05 0 bpf_c110_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c110_3_05 (mix_q_src_c110_3_05 mix_q_c110_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_06 (mix_i_src_c110_3_06 0 bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_3_06 (mix_i_src_c110_3_06 mix_i_c110_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_06 (mix_q_src_c110_3_06 0 bpf_c110_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c110_3_06 (mix_q_src_c110_3_06 mix_q_c110_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_07 (mix_i_src_c110_3_07 0 bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_3_07 (mix_i_src_c110_3_07 mix_i_c110_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_07 (mix_q_src_c110_3_07 0 bpf_c110_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c110_3_07 (mix_q_src_c110_3_07 mix_q_c110_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_08 (mix_i_src_c110_3_08 0 bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c110_3_08 (mix_i_src_c110_3_08 mix_i_c110_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_08 (mix_q_src_c110_3_08 0 bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_3_08 (mix_q_src_c110_3_08 mix_q_c110_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_09 (mix_i_src_c110_3_09 0 bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c110_3_09 (mix_i_src_c110_3_09 mix_i_c110_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_09 (mix_q_src_c110_3_09 0 bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_3_09 (mix_q_src_c110_3_09 mix_q_c110_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_10 (mix_i_src_c110_3_10 0 bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c110_3_10 (mix_i_src_c110_3_10 mix_i_c110_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_10 (mix_q_src_c110_3_10 0 bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_3_10 (mix_q_src_c110_3_10 mix_q_c110_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_11 (mix_i_src_c110_3_11 0 bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c110_3_11 (mix_i_src_c110_3_11 mix_i_c110_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_11 (mix_q_src_c110_3_11 0 bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_3_11 (mix_q_src_c110_3_11 mix_q_c110_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_12 (mix_i_src_c110_3_12 0 bpf_c110_3 0) vcvs gain=1.950903220161e-01
SMIXI_c110_3_12 (mix_i_src_c110_3_12 mix_i_c110_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_12 (mix_q_src_c110_3_12 0 bpf_c110_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c110_3_12 (mix_q_src_c110_3_12 mix_q_c110_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_13 (mix_i_src_c110_3_13 0 bpf_c110_3 0) vcvs gain=5.555702330196e-01
SMIXI_c110_3_13 (mix_i_src_c110_3_13 mix_i_c110_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_13 (mix_q_src_c110_3_13 0 bpf_c110_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c110_3_13 (mix_q_src_c110_3_13 mix_q_c110_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_14 (mix_i_src_c110_3_14 0 bpf_c110_3 0) vcvs gain=8.314696123025e-01
SMIXI_c110_3_14 (mix_i_src_c110_3_14 mix_i_c110_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_14 (mix_q_src_c110_3_14 0 bpf_c110_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c110_3_14 (mix_q_src_c110_3_14 mix_q_c110_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c110_3_15 (mix_i_src_c110_3_15 0 bpf_c110_3 0) vcvs gain=9.807852804032e-01
SMIXI_c110_3_15 (mix_i_src_c110_3_15 mix_i_c110_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c110_3_15 (mix_q_src_c110_3_15 0 bpf_c110_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c110_3_15 (mix_q_src_c110_3_15 mix_q_c110_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c110_3 (mix_i_c110_3 0) resistor r=1G
RMIXQ_c110_3 (mix_q_c110_3 0) resistor r=1G
RINTI_c110_3 (mix_i_c110_3 Icar_c110_3) resistor r=1k
CINTI_c110_3 (Icar_c110_3 0) capacitor c=80p
RINTQ_c110_3 (mix_q_c110_3 Qcar_c110_3) resistor r=1k
CINTQ_c110_3 (Qcar_c110_3 0) capacitor c=80p

// bl111, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c111_0 (bl111 n_cbpf_c111_0) capacitor c=4.052847345694e-13
LBPF_c111_0 (n_cbpf_c111_0 bpf_c111_0) inductor l=1.000000000000e-06
RBPF_c111_0 (bpf_c111_0 0) resistor r=7.853981633974e+01
EMIXI_c111_0_00 (mix_i_src_c111_0_00 0 bpf_c111_0 0) vcvs gain=9.807852804032e-01
SMIXI_c111_0_00 (mix_i_src_c111_0_00 mix_i_c111_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_00 (mix_q_src_c111_0_00 0 bpf_c111_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_0_00 (mix_q_src_c111_0_00 mix_q_c111_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_01 (mix_i_src_c111_0_01 0 bpf_c111_0 0) vcvs gain=8.314696123025e-01
SMIXI_c111_0_01 (mix_i_src_c111_0_01 mix_i_c111_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_01 (mix_q_src_c111_0_01 0 bpf_c111_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_0_01 (mix_q_src_c111_0_01 mix_q_c111_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_02 (mix_i_src_c111_0_02 0 bpf_c111_0 0) vcvs gain=5.555702330196e-01
SMIXI_c111_0_02 (mix_i_src_c111_0_02 mix_i_c111_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_02 (mix_q_src_c111_0_02 0 bpf_c111_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_0_02 (mix_q_src_c111_0_02 mix_q_c111_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_03 (mix_i_src_c111_0_03 0 bpf_c111_0 0) vcvs gain=1.950903220161e-01
SMIXI_c111_0_03 (mix_i_src_c111_0_03 mix_i_c111_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_03 (mix_q_src_c111_0_03 0 bpf_c111_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_0_03 (mix_q_src_c111_0_03 mix_q_c111_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_04 (mix_i_src_c111_0_04 0 bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_0_04 (mix_i_src_c111_0_04 mix_i_c111_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_04 (mix_q_src_c111_0_04 0 bpf_c111_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_0_04 (mix_q_src_c111_0_04 mix_q_c111_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_05 (mix_i_src_c111_0_05 0 bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_0_05 (mix_i_src_c111_0_05 mix_i_c111_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_05 (mix_q_src_c111_0_05 0 bpf_c111_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_0_05 (mix_q_src_c111_0_05 mix_q_c111_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_06 (mix_i_src_c111_0_06 0 bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_0_06 (mix_i_src_c111_0_06 mix_i_c111_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_06 (mix_q_src_c111_0_06 0 bpf_c111_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_0_06 (mix_q_src_c111_0_06 mix_q_c111_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_07 (mix_i_src_c111_0_07 0 bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_0_07 (mix_i_src_c111_0_07 mix_i_c111_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_07 (mix_q_src_c111_0_07 0 bpf_c111_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_0_07 (mix_q_src_c111_0_07 mix_q_c111_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_08 (mix_i_src_c111_0_08 0 bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_0_08 (mix_i_src_c111_0_08 mix_i_c111_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_08 (mix_q_src_c111_0_08 0 bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_0_08 (mix_q_src_c111_0_08 mix_q_c111_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_09 (mix_i_src_c111_0_09 0 bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_0_09 (mix_i_src_c111_0_09 mix_i_c111_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_09 (mix_q_src_c111_0_09 0 bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_0_09 (mix_q_src_c111_0_09 mix_q_c111_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_10 (mix_i_src_c111_0_10 0 bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_0_10 (mix_i_src_c111_0_10 mix_i_c111_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_10 (mix_q_src_c111_0_10 0 bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_0_10 (mix_q_src_c111_0_10 mix_q_c111_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_11 (mix_i_src_c111_0_11 0 bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_0_11 (mix_i_src_c111_0_11 mix_i_c111_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_11 (mix_q_src_c111_0_11 0 bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_0_11 (mix_q_src_c111_0_11 mix_q_c111_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_12 (mix_i_src_c111_0_12 0 bpf_c111_0 0) vcvs gain=1.950903220161e-01
SMIXI_c111_0_12 (mix_i_src_c111_0_12 mix_i_c111_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_12 (mix_q_src_c111_0_12 0 bpf_c111_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_0_12 (mix_q_src_c111_0_12 mix_q_c111_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_13 (mix_i_src_c111_0_13 0 bpf_c111_0 0) vcvs gain=5.555702330196e-01
SMIXI_c111_0_13 (mix_i_src_c111_0_13 mix_i_c111_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_13 (mix_q_src_c111_0_13 0 bpf_c111_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_0_13 (mix_q_src_c111_0_13 mix_q_c111_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_14 (mix_i_src_c111_0_14 0 bpf_c111_0 0) vcvs gain=8.314696123025e-01
SMIXI_c111_0_14 (mix_i_src_c111_0_14 mix_i_c111_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_14 (mix_q_src_c111_0_14 0 bpf_c111_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_0_14 (mix_q_src_c111_0_14 mix_q_c111_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_0_15 (mix_i_src_c111_0_15 0 bpf_c111_0 0) vcvs gain=9.807852804032e-01
SMIXI_c111_0_15 (mix_i_src_c111_0_15 mix_i_c111_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_0_15 (mix_q_src_c111_0_15 0 bpf_c111_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_0_15 (mix_q_src_c111_0_15 mix_q_c111_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c111_0 (mix_i_c111_0 0) resistor r=1G
RMIXQ_c111_0 (mix_q_c111_0 0) resistor r=1G
RINTI_c111_0 (mix_i_c111_0 Icar_c111_0) resistor r=1k
CINTI_c111_0 (Icar_c111_0 0) capacitor c=80p
RINTQ_c111_0 (mix_q_c111_0 Qcar_c111_0) resistor r=1k
CINTQ_c111_0 (Qcar_c111_0 0) capacitor c=80p

// bl111, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c111_1 (bl111 n_cbpf_c111_1) capacitor c=1.013211836423e-13
LBPF_c111_1 (n_cbpf_c111_1 bpf_c111_1) inductor l=1.000000000000e-06
RBPF_c111_1 (bpf_c111_1 0) resistor r=1.570796326795e+02
EMIXI_c111_1_00 (mix_i_src_c111_1_00 0 bpf_c111_1 0) vcvs gain=9.807852804032e-01
SMIXI_c111_1_00 (mix_i_src_c111_1_00 mix_i_c111_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_00 (mix_q_src_c111_1_00 0 bpf_c111_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_1_00 (mix_q_src_c111_1_00 mix_q_c111_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_01 (mix_i_src_c111_1_01 0 bpf_c111_1 0) vcvs gain=8.314696123025e-01
SMIXI_c111_1_01 (mix_i_src_c111_1_01 mix_i_c111_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_01 (mix_q_src_c111_1_01 0 bpf_c111_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_1_01 (mix_q_src_c111_1_01 mix_q_c111_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_02 (mix_i_src_c111_1_02 0 bpf_c111_1 0) vcvs gain=5.555702330196e-01
SMIXI_c111_1_02 (mix_i_src_c111_1_02 mix_i_c111_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_02 (mix_q_src_c111_1_02 0 bpf_c111_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_1_02 (mix_q_src_c111_1_02 mix_q_c111_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_03 (mix_i_src_c111_1_03 0 bpf_c111_1 0) vcvs gain=1.950903220161e-01
SMIXI_c111_1_03 (mix_i_src_c111_1_03 mix_i_c111_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_03 (mix_q_src_c111_1_03 0 bpf_c111_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_1_03 (mix_q_src_c111_1_03 mix_q_c111_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_04 (mix_i_src_c111_1_04 0 bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_1_04 (mix_i_src_c111_1_04 mix_i_c111_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_04 (mix_q_src_c111_1_04 0 bpf_c111_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_1_04 (mix_q_src_c111_1_04 mix_q_c111_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_05 (mix_i_src_c111_1_05 0 bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_1_05 (mix_i_src_c111_1_05 mix_i_c111_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_05 (mix_q_src_c111_1_05 0 bpf_c111_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_1_05 (mix_q_src_c111_1_05 mix_q_c111_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_06 (mix_i_src_c111_1_06 0 bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_1_06 (mix_i_src_c111_1_06 mix_i_c111_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_06 (mix_q_src_c111_1_06 0 bpf_c111_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_1_06 (mix_q_src_c111_1_06 mix_q_c111_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_07 (mix_i_src_c111_1_07 0 bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_1_07 (mix_i_src_c111_1_07 mix_i_c111_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_07 (mix_q_src_c111_1_07 0 bpf_c111_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_1_07 (mix_q_src_c111_1_07 mix_q_c111_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_08 (mix_i_src_c111_1_08 0 bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_1_08 (mix_i_src_c111_1_08 mix_i_c111_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_08 (mix_q_src_c111_1_08 0 bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_1_08 (mix_q_src_c111_1_08 mix_q_c111_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_09 (mix_i_src_c111_1_09 0 bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_1_09 (mix_i_src_c111_1_09 mix_i_c111_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_09 (mix_q_src_c111_1_09 0 bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_1_09 (mix_q_src_c111_1_09 mix_q_c111_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_10 (mix_i_src_c111_1_10 0 bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_1_10 (mix_i_src_c111_1_10 mix_i_c111_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_10 (mix_q_src_c111_1_10 0 bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_1_10 (mix_q_src_c111_1_10 mix_q_c111_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_11 (mix_i_src_c111_1_11 0 bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_1_11 (mix_i_src_c111_1_11 mix_i_c111_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_11 (mix_q_src_c111_1_11 0 bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_1_11 (mix_q_src_c111_1_11 mix_q_c111_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_12 (mix_i_src_c111_1_12 0 bpf_c111_1 0) vcvs gain=1.950903220161e-01
SMIXI_c111_1_12 (mix_i_src_c111_1_12 mix_i_c111_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_12 (mix_q_src_c111_1_12 0 bpf_c111_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_1_12 (mix_q_src_c111_1_12 mix_q_c111_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_13 (mix_i_src_c111_1_13 0 bpf_c111_1 0) vcvs gain=5.555702330196e-01
SMIXI_c111_1_13 (mix_i_src_c111_1_13 mix_i_c111_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_13 (mix_q_src_c111_1_13 0 bpf_c111_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_1_13 (mix_q_src_c111_1_13 mix_q_c111_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_14 (mix_i_src_c111_1_14 0 bpf_c111_1 0) vcvs gain=8.314696123025e-01
SMIXI_c111_1_14 (mix_i_src_c111_1_14 mix_i_c111_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_14 (mix_q_src_c111_1_14 0 bpf_c111_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_1_14 (mix_q_src_c111_1_14 mix_q_c111_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_1_15 (mix_i_src_c111_1_15 0 bpf_c111_1 0) vcvs gain=9.807852804032e-01
SMIXI_c111_1_15 (mix_i_src_c111_1_15 mix_i_c111_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_1_15 (mix_q_src_c111_1_15 0 bpf_c111_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_1_15 (mix_q_src_c111_1_15 mix_q_c111_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c111_1 (mix_i_c111_1 0) resistor r=1G
RMIXQ_c111_1 (mix_q_c111_1 0) resistor r=1G
RINTI_c111_1 (mix_i_c111_1 Icar_c111_1) resistor r=1k
CINTI_c111_1 (Icar_c111_1 0) capacitor c=80p
RINTQ_c111_1 (mix_q_c111_1 Qcar_c111_1) resistor r=1k
CINTQ_c111_1 (Qcar_c111_1 0) capacitor c=80p

// bl111, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c111_2 (bl111 n_cbpf_c111_2) capacitor c=4.503163717437e-14
LBPF_c111_2 (n_cbpf_c111_2 bpf_c111_2) inductor l=1.000000000000e-06
RBPF_c111_2 (bpf_c111_2 0) resistor r=2.356194490192e+02
EMIXI_c111_2_00 (mix_i_src_c111_2_00 0 bpf_c111_2 0) vcvs gain=9.807852804032e-01
SMIXI_c111_2_00 (mix_i_src_c111_2_00 mix_i_c111_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_00 (mix_q_src_c111_2_00 0 bpf_c111_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_2_00 (mix_q_src_c111_2_00 mix_q_c111_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_01 (mix_i_src_c111_2_01 0 bpf_c111_2 0) vcvs gain=8.314696123025e-01
SMIXI_c111_2_01 (mix_i_src_c111_2_01 mix_i_c111_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_01 (mix_q_src_c111_2_01 0 bpf_c111_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_2_01 (mix_q_src_c111_2_01 mix_q_c111_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_02 (mix_i_src_c111_2_02 0 bpf_c111_2 0) vcvs gain=5.555702330196e-01
SMIXI_c111_2_02 (mix_i_src_c111_2_02 mix_i_c111_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_02 (mix_q_src_c111_2_02 0 bpf_c111_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_2_02 (mix_q_src_c111_2_02 mix_q_c111_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_03 (mix_i_src_c111_2_03 0 bpf_c111_2 0) vcvs gain=1.950903220161e-01
SMIXI_c111_2_03 (mix_i_src_c111_2_03 mix_i_c111_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_03 (mix_q_src_c111_2_03 0 bpf_c111_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_2_03 (mix_q_src_c111_2_03 mix_q_c111_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_04 (mix_i_src_c111_2_04 0 bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_2_04 (mix_i_src_c111_2_04 mix_i_c111_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_04 (mix_q_src_c111_2_04 0 bpf_c111_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_2_04 (mix_q_src_c111_2_04 mix_q_c111_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_05 (mix_i_src_c111_2_05 0 bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_2_05 (mix_i_src_c111_2_05 mix_i_c111_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_05 (mix_q_src_c111_2_05 0 bpf_c111_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_2_05 (mix_q_src_c111_2_05 mix_q_c111_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_06 (mix_i_src_c111_2_06 0 bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_2_06 (mix_i_src_c111_2_06 mix_i_c111_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_06 (mix_q_src_c111_2_06 0 bpf_c111_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_2_06 (mix_q_src_c111_2_06 mix_q_c111_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_07 (mix_i_src_c111_2_07 0 bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_2_07 (mix_i_src_c111_2_07 mix_i_c111_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_07 (mix_q_src_c111_2_07 0 bpf_c111_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_2_07 (mix_q_src_c111_2_07 mix_q_c111_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_08 (mix_i_src_c111_2_08 0 bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_2_08 (mix_i_src_c111_2_08 mix_i_c111_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_08 (mix_q_src_c111_2_08 0 bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_2_08 (mix_q_src_c111_2_08 mix_q_c111_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_09 (mix_i_src_c111_2_09 0 bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_2_09 (mix_i_src_c111_2_09 mix_i_c111_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_09 (mix_q_src_c111_2_09 0 bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_2_09 (mix_q_src_c111_2_09 mix_q_c111_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_10 (mix_i_src_c111_2_10 0 bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_2_10 (mix_i_src_c111_2_10 mix_i_c111_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_10 (mix_q_src_c111_2_10 0 bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_2_10 (mix_q_src_c111_2_10 mix_q_c111_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_11 (mix_i_src_c111_2_11 0 bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_2_11 (mix_i_src_c111_2_11 mix_i_c111_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_11 (mix_q_src_c111_2_11 0 bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_2_11 (mix_q_src_c111_2_11 mix_q_c111_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_12 (mix_i_src_c111_2_12 0 bpf_c111_2 0) vcvs gain=1.950903220161e-01
SMIXI_c111_2_12 (mix_i_src_c111_2_12 mix_i_c111_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_12 (mix_q_src_c111_2_12 0 bpf_c111_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_2_12 (mix_q_src_c111_2_12 mix_q_c111_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_13 (mix_i_src_c111_2_13 0 bpf_c111_2 0) vcvs gain=5.555702330196e-01
SMIXI_c111_2_13 (mix_i_src_c111_2_13 mix_i_c111_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_13 (mix_q_src_c111_2_13 0 bpf_c111_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_2_13 (mix_q_src_c111_2_13 mix_q_c111_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_14 (mix_i_src_c111_2_14 0 bpf_c111_2 0) vcvs gain=8.314696123025e-01
SMIXI_c111_2_14 (mix_i_src_c111_2_14 mix_i_c111_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_14 (mix_q_src_c111_2_14 0 bpf_c111_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_2_14 (mix_q_src_c111_2_14 mix_q_c111_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_2_15 (mix_i_src_c111_2_15 0 bpf_c111_2 0) vcvs gain=9.807852804032e-01
SMIXI_c111_2_15 (mix_i_src_c111_2_15 mix_i_c111_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_2_15 (mix_q_src_c111_2_15 0 bpf_c111_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_2_15 (mix_q_src_c111_2_15 mix_q_c111_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c111_2 (mix_i_c111_2 0) resistor r=1G
RMIXQ_c111_2 (mix_q_c111_2 0) resistor r=1G
RINTI_c111_2 (mix_i_c111_2 Icar_c111_2) resistor r=1k
CINTI_c111_2 (Icar_c111_2 0) capacitor c=80p
RINTQ_c111_2 (mix_q_c111_2 Qcar_c111_2) resistor r=1k
CINTQ_c111_2 (Qcar_c111_2 0) capacitor c=80p

// bl111, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c111_3 (bl111 n_cbpf_c111_3) capacitor c=2.533029591058e-14
LBPF_c111_3 (n_cbpf_c111_3 bpf_c111_3) inductor l=1.000000000000e-06
RBPF_c111_3 (bpf_c111_3 0) resistor r=3.141592653590e+02
EMIXI_c111_3_00 (mix_i_src_c111_3_00 0 bpf_c111_3 0) vcvs gain=9.807852804032e-01
SMIXI_c111_3_00 (mix_i_src_c111_3_00 mix_i_c111_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_00 (mix_q_src_c111_3_00 0 bpf_c111_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_3_00 (mix_q_src_c111_3_00 mix_q_c111_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_01 (mix_i_src_c111_3_01 0 bpf_c111_3 0) vcvs gain=8.314696123025e-01
SMIXI_c111_3_01 (mix_i_src_c111_3_01 mix_i_c111_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_01 (mix_q_src_c111_3_01 0 bpf_c111_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_3_01 (mix_q_src_c111_3_01 mix_q_c111_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_02 (mix_i_src_c111_3_02 0 bpf_c111_3 0) vcvs gain=5.555702330196e-01
SMIXI_c111_3_02 (mix_i_src_c111_3_02 mix_i_c111_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_02 (mix_q_src_c111_3_02 0 bpf_c111_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_3_02 (mix_q_src_c111_3_02 mix_q_c111_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_03 (mix_i_src_c111_3_03 0 bpf_c111_3 0) vcvs gain=1.950903220161e-01
SMIXI_c111_3_03 (mix_i_src_c111_3_03 mix_i_c111_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_03 (mix_q_src_c111_3_03 0 bpf_c111_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_3_03 (mix_q_src_c111_3_03 mix_q_c111_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_04 (mix_i_src_c111_3_04 0 bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_3_04 (mix_i_src_c111_3_04 mix_i_c111_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_04 (mix_q_src_c111_3_04 0 bpf_c111_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c111_3_04 (mix_q_src_c111_3_04 mix_q_c111_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_05 (mix_i_src_c111_3_05 0 bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_3_05 (mix_i_src_c111_3_05 mix_i_c111_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_05 (mix_q_src_c111_3_05 0 bpf_c111_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c111_3_05 (mix_q_src_c111_3_05 mix_q_c111_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_06 (mix_i_src_c111_3_06 0 bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_3_06 (mix_i_src_c111_3_06 mix_i_c111_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_06 (mix_q_src_c111_3_06 0 bpf_c111_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c111_3_06 (mix_q_src_c111_3_06 mix_q_c111_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_07 (mix_i_src_c111_3_07 0 bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_3_07 (mix_i_src_c111_3_07 mix_i_c111_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_07 (mix_q_src_c111_3_07 0 bpf_c111_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c111_3_07 (mix_q_src_c111_3_07 mix_q_c111_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_08 (mix_i_src_c111_3_08 0 bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c111_3_08 (mix_i_src_c111_3_08 mix_i_c111_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_08 (mix_q_src_c111_3_08 0 bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_3_08 (mix_q_src_c111_3_08 mix_q_c111_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_09 (mix_i_src_c111_3_09 0 bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c111_3_09 (mix_i_src_c111_3_09 mix_i_c111_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_09 (mix_q_src_c111_3_09 0 bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_3_09 (mix_q_src_c111_3_09 mix_q_c111_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_10 (mix_i_src_c111_3_10 0 bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c111_3_10 (mix_i_src_c111_3_10 mix_i_c111_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_10 (mix_q_src_c111_3_10 0 bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_3_10 (mix_q_src_c111_3_10 mix_q_c111_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_11 (mix_i_src_c111_3_11 0 bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c111_3_11 (mix_i_src_c111_3_11 mix_i_c111_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_11 (mix_q_src_c111_3_11 0 bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_3_11 (mix_q_src_c111_3_11 mix_q_c111_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_12 (mix_i_src_c111_3_12 0 bpf_c111_3 0) vcvs gain=1.950903220161e-01
SMIXI_c111_3_12 (mix_i_src_c111_3_12 mix_i_c111_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_12 (mix_q_src_c111_3_12 0 bpf_c111_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c111_3_12 (mix_q_src_c111_3_12 mix_q_c111_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_13 (mix_i_src_c111_3_13 0 bpf_c111_3 0) vcvs gain=5.555702330196e-01
SMIXI_c111_3_13 (mix_i_src_c111_3_13 mix_i_c111_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_13 (mix_q_src_c111_3_13 0 bpf_c111_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c111_3_13 (mix_q_src_c111_3_13 mix_q_c111_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_14 (mix_i_src_c111_3_14 0 bpf_c111_3 0) vcvs gain=8.314696123025e-01
SMIXI_c111_3_14 (mix_i_src_c111_3_14 mix_i_c111_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_14 (mix_q_src_c111_3_14 0 bpf_c111_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c111_3_14 (mix_q_src_c111_3_14 mix_q_c111_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c111_3_15 (mix_i_src_c111_3_15 0 bpf_c111_3 0) vcvs gain=9.807852804032e-01
SMIXI_c111_3_15 (mix_i_src_c111_3_15 mix_i_c111_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c111_3_15 (mix_q_src_c111_3_15 0 bpf_c111_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c111_3_15 (mix_q_src_c111_3_15 mix_q_c111_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c111_3 (mix_i_c111_3 0) resistor r=1G
RMIXQ_c111_3 (mix_q_c111_3 0) resistor r=1G
RINTI_c111_3 (mix_i_c111_3 Icar_c111_3) resistor r=1k
CINTI_c111_3 (Icar_c111_3 0) capacitor c=80p
RINTQ_c111_3 (mix_q_c111_3 Qcar_c111_3) resistor r=1k
CINTQ_c111_3 (Qcar_c111_3 0) capacitor c=80p

// bl112, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c112_0 (bl112 n_cbpf_c112_0) capacitor c=4.052847345694e-13
LBPF_c112_0 (n_cbpf_c112_0 bpf_c112_0) inductor l=1.000000000000e-06
RBPF_c112_0 (bpf_c112_0 0) resistor r=7.853981633974e+01
EMIXI_c112_0_00 (mix_i_src_c112_0_00 0 bpf_c112_0 0) vcvs gain=9.807852804032e-01
SMIXI_c112_0_00 (mix_i_src_c112_0_00 mix_i_c112_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_00 (mix_q_src_c112_0_00 0 bpf_c112_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_0_00 (mix_q_src_c112_0_00 mix_q_c112_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_01 (mix_i_src_c112_0_01 0 bpf_c112_0 0) vcvs gain=8.314696123025e-01
SMIXI_c112_0_01 (mix_i_src_c112_0_01 mix_i_c112_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_01 (mix_q_src_c112_0_01 0 bpf_c112_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_0_01 (mix_q_src_c112_0_01 mix_q_c112_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_02 (mix_i_src_c112_0_02 0 bpf_c112_0 0) vcvs gain=5.555702330196e-01
SMIXI_c112_0_02 (mix_i_src_c112_0_02 mix_i_c112_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_02 (mix_q_src_c112_0_02 0 bpf_c112_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_0_02 (mix_q_src_c112_0_02 mix_q_c112_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_03 (mix_i_src_c112_0_03 0 bpf_c112_0 0) vcvs gain=1.950903220161e-01
SMIXI_c112_0_03 (mix_i_src_c112_0_03 mix_i_c112_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_03 (mix_q_src_c112_0_03 0 bpf_c112_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_0_03 (mix_q_src_c112_0_03 mix_q_c112_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_04 (mix_i_src_c112_0_04 0 bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_0_04 (mix_i_src_c112_0_04 mix_i_c112_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_04 (mix_q_src_c112_0_04 0 bpf_c112_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_0_04 (mix_q_src_c112_0_04 mix_q_c112_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_05 (mix_i_src_c112_0_05 0 bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_0_05 (mix_i_src_c112_0_05 mix_i_c112_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_05 (mix_q_src_c112_0_05 0 bpf_c112_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_0_05 (mix_q_src_c112_0_05 mix_q_c112_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_06 (mix_i_src_c112_0_06 0 bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_0_06 (mix_i_src_c112_0_06 mix_i_c112_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_06 (mix_q_src_c112_0_06 0 bpf_c112_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_0_06 (mix_q_src_c112_0_06 mix_q_c112_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_07 (mix_i_src_c112_0_07 0 bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_0_07 (mix_i_src_c112_0_07 mix_i_c112_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_07 (mix_q_src_c112_0_07 0 bpf_c112_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_0_07 (mix_q_src_c112_0_07 mix_q_c112_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_08 (mix_i_src_c112_0_08 0 bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_0_08 (mix_i_src_c112_0_08 mix_i_c112_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_08 (mix_q_src_c112_0_08 0 bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_0_08 (mix_q_src_c112_0_08 mix_q_c112_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_09 (mix_i_src_c112_0_09 0 bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_0_09 (mix_i_src_c112_0_09 mix_i_c112_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_09 (mix_q_src_c112_0_09 0 bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_0_09 (mix_q_src_c112_0_09 mix_q_c112_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_10 (mix_i_src_c112_0_10 0 bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_0_10 (mix_i_src_c112_0_10 mix_i_c112_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_10 (mix_q_src_c112_0_10 0 bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_0_10 (mix_q_src_c112_0_10 mix_q_c112_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_11 (mix_i_src_c112_0_11 0 bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_0_11 (mix_i_src_c112_0_11 mix_i_c112_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_11 (mix_q_src_c112_0_11 0 bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_0_11 (mix_q_src_c112_0_11 mix_q_c112_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_12 (mix_i_src_c112_0_12 0 bpf_c112_0 0) vcvs gain=1.950903220161e-01
SMIXI_c112_0_12 (mix_i_src_c112_0_12 mix_i_c112_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_12 (mix_q_src_c112_0_12 0 bpf_c112_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_0_12 (mix_q_src_c112_0_12 mix_q_c112_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_13 (mix_i_src_c112_0_13 0 bpf_c112_0 0) vcvs gain=5.555702330196e-01
SMIXI_c112_0_13 (mix_i_src_c112_0_13 mix_i_c112_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_13 (mix_q_src_c112_0_13 0 bpf_c112_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_0_13 (mix_q_src_c112_0_13 mix_q_c112_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_14 (mix_i_src_c112_0_14 0 bpf_c112_0 0) vcvs gain=8.314696123025e-01
SMIXI_c112_0_14 (mix_i_src_c112_0_14 mix_i_c112_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_14 (mix_q_src_c112_0_14 0 bpf_c112_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_0_14 (mix_q_src_c112_0_14 mix_q_c112_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_0_15 (mix_i_src_c112_0_15 0 bpf_c112_0 0) vcvs gain=9.807852804032e-01
SMIXI_c112_0_15 (mix_i_src_c112_0_15 mix_i_c112_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_0_15 (mix_q_src_c112_0_15 0 bpf_c112_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_0_15 (mix_q_src_c112_0_15 mix_q_c112_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c112_0 (mix_i_c112_0 0) resistor r=1G
RMIXQ_c112_0 (mix_q_c112_0 0) resistor r=1G
RINTI_c112_0 (mix_i_c112_0 Icar_c112_0) resistor r=1k
CINTI_c112_0 (Icar_c112_0 0) capacitor c=80p
RINTQ_c112_0 (mix_q_c112_0 Qcar_c112_0) resistor r=1k
CINTQ_c112_0 (Qcar_c112_0 0) capacitor c=80p

// bl112, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c112_1 (bl112 n_cbpf_c112_1) capacitor c=1.013211836423e-13
LBPF_c112_1 (n_cbpf_c112_1 bpf_c112_1) inductor l=1.000000000000e-06
RBPF_c112_1 (bpf_c112_1 0) resistor r=1.570796326795e+02
EMIXI_c112_1_00 (mix_i_src_c112_1_00 0 bpf_c112_1 0) vcvs gain=9.807852804032e-01
SMIXI_c112_1_00 (mix_i_src_c112_1_00 mix_i_c112_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_00 (mix_q_src_c112_1_00 0 bpf_c112_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_1_00 (mix_q_src_c112_1_00 mix_q_c112_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_01 (mix_i_src_c112_1_01 0 bpf_c112_1 0) vcvs gain=8.314696123025e-01
SMIXI_c112_1_01 (mix_i_src_c112_1_01 mix_i_c112_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_01 (mix_q_src_c112_1_01 0 bpf_c112_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_1_01 (mix_q_src_c112_1_01 mix_q_c112_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_02 (mix_i_src_c112_1_02 0 bpf_c112_1 0) vcvs gain=5.555702330196e-01
SMIXI_c112_1_02 (mix_i_src_c112_1_02 mix_i_c112_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_02 (mix_q_src_c112_1_02 0 bpf_c112_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_1_02 (mix_q_src_c112_1_02 mix_q_c112_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_03 (mix_i_src_c112_1_03 0 bpf_c112_1 0) vcvs gain=1.950903220161e-01
SMIXI_c112_1_03 (mix_i_src_c112_1_03 mix_i_c112_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_03 (mix_q_src_c112_1_03 0 bpf_c112_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_1_03 (mix_q_src_c112_1_03 mix_q_c112_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_04 (mix_i_src_c112_1_04 0 bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_1_04 (mix_i_src_c112_1_04 mix_i_c112_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_04 (mix_q_src_c112_1_04 0 bpf_c112_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_1_04 (mix_q_src_c112_1_04 mix_q_c112_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_05 (mix_i_src_c112_1_05 0 bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_1_05 (mix_i_src_c112_1_05 mix_i_c112_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_05 (mix_q_src_c112_1_05 0 bpf_c112_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_1_05 (mix_q_src_c112_1_05 mix_q_c112_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_06 (mix_i_src_c112_1_06 0 bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_1_06 (mix_i_src_c112_1_06 mix_i_c112_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_06 (mix_q_src_c112_1_06 0 bpf_c112_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_1_06 (mix_q_src_c112_1_06 mix_q_c112_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_07 (mix_i_src_c112_1_07 0 bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_1_07 (mix_i_src_c112_1_07 mix_i_c112_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_07 (mix_q_src_c112_1_07 0 bpf_c112_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_1_07 (mix_q_src_c112_1_07 mix_q_c112_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_08 (mix_i_src_c112_1_08 0 bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_1_08 (mix_i_src_c112_1_08 mix_i_c112_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_08 (mix_q_src_c112_1_08 0 bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_1_08 (mix_q_src_c112_1_08 mix_q_c112_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_09 (mix_i_src_c112_1_09 0 bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_1_09 (mix_i_src_c112_1_09 mix_i_c112_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_09 (mix_q_src_c112_1_09 0 bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_1_09 (mix_q_src_c112_1_09 mix_q_c112_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_10 (mix_i_src_c112_1_10 0 bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_1_10 (mix_i_src_c112_1_10 mix_i_c112_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_10 (mix_q_src_c112_1_10 0 bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_1_10 (mix_q_src_c112_1_10 mix_q_c112_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_11 (mix_i_src_c112_1_11 0 bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_1_11 (mix_i_src_c112_1_11 mix_i_c112_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_11 (mix_q_src_c112_1_11 0 bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_1_11 (mix_q_src_c112_1_11 mix_q_c112_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_12 (mix_i_src_c112_1_12 0 bpf_c112_1 0) vcvs gain=1.950903220161e-01
SMIXI_c112_1_12 (mix_i_src_c112_1_12 mix_i_c112_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_12 (mix_q_src_c112_1_12 0 bpf_c112_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_1_12 (mix_q_src_c112_1_12 mix_q_c112_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_13 (mix_i_src_c112_1_13 0 bpf_c112_1 0) vcvs gain=5.555702330196e-01
SMIXI_c112_1_13 (mix_i_src_c112_1_13 mix_i_c112_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_13 (mix_q_src_c112_1_13 0 bpf_c112_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_1_13 (mix_q_src_c112_1_13 mix_q_c112_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_14 (mix_i_src_c112_1_14 0 bpf_c112_1 0) vcvs gain=8.314696123025e-01
SMIXI_c112_1_14 (mix_i_src_c112_1_14 mix_i_c112_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_14 (mix_q_src_c112_1_14 0 bpf_c112_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_1_14 (mix_q_src_c112_1_14 mix_q_c112_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_1_15 (mix_i_src_c112_1_15 0 bpf_c112_1 0) vcvs gain=9.807852804032e-01
SMIXI_c112_1_15 (mix_i_src_c112_1_15 mix_i_c112_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_1_15 (mix_q_src_c112_1_15 0 bpf_c112_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_1_15 (mix_q_src_c112_1_15 mix_q_c112_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c112_1 (mix_i_c112_1 0) resistor r=1G
RMIXQ_c112_1 (mix_q_c112_1 0) resistor r=1G
RINTI_c112_1 (mix_i_c112_1 Icar_c112_1) resistor r=1k
CINTI_c112_1 (Icar_c112_1 0) capacitor c=80p
RINTQ_c112_1 (mix_q_c112_1 Qcar_c112_1) resistor r=1k
CINTQ_c112_1 (Qcar_c112_1 0) capacitor c=80p

// bl112, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c112_2 (bl112 n_cbpf_c112_2) capacitor c=4.503163717437e-14
LBPF_c112_2 (n_cbpf_c112_2 bpf_c112_2) inductor l=1.000000000000e-06
RBPF_c112_2 (bpf_c112_2 0) resistor r=2.356194490192e+02
EMIXI_c112_2_00 (mix_i_src_c112_2_00 0 bpf_c112_2 0) vcvs gain=9.807852804032e-01
SMIXI_c112_2_00 (mix_i_src_c112_2_00 mix_i_c112_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_00 (mix_q_src_c112_2_00 0 bpf_c112_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_2_00 (mix_q_src_c112_2_00 mix_q_c112_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_01 (mix_i_src_c112_2_01 0 bpf_c112_2 0) vcvs gain=8.314696123025e-01
SMIXI_c112_2_01 (mix_i_src_c112_2_01 mix_i_c112_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_01 (mix_q_src_c112_2_01 0 bpf_c112_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_2_01 (mix_q_src_c112_2_01 mix_q_c112_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_02 (mix_i_src_c112_2_02 0 bpf_c112_2 0) vcvs gain=5.555702330196e-01
SMIXI_c112_2_02 (mix_i_src_c112_2_02 mix_i_c112_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_02 (mix_q_src_c112_2_02 0 bpf_c112_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_2_02 (mix_q_src_c112_2_02 mix_q_c112_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_03 (mix_i_src_c112_2_03 0 bpf_c112_2 0) vcvs gain=1.950903220161e-01
SMIXI_c112_2_03 (mix_i_src_c112_2_03 mix_i_c112_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_03 (mix_q_src_c112_2_03 0 bpf_c112_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_2_03 (mix_q_src_c112_2_03 mix_q_c112_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_04 (mix_i_src_c112_2_04 0 bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_2_04 (mix_i_src_c112_2_04 mix_i_c112_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_04 (mix_q_src_c112_2_04 0 bpf_c112_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_2_04 (mix_q_src_c112_2_04 mix_q_c112_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_05 (mix_i_src_c112_2_05 0 bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_2_05 (mix_i_src_c112_2_05 mix_i_c112_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_05 (mix_q_src_c112_2_05 0 bpf_c112_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_2_05 (mix_q_src_c112_2_05 mix_q_c112_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_06 (mix_i_src_c112_2_06 0 bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_2_06 (mix_i_src_c112_2_06 mix_i_c112_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_06 (mix_q_src_c112_2_06 0 bpf_c112_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_2_06 (mix_q_src_c112_2_06 mix_q_c112_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_07 (mix_i_src_c112_2_07 0 bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_2_07 (mix_i_src_c112_2_07 mix_i_c112_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_07 (mix_q_src_c112_2_07 0 bpf_c112_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_2_07 (mix_q_src_c112_2_07 mix_q_c112_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_08 (mix_i_src_c112_2_08 0 bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_2_08 (mix_i_src_c112_2_08 mix_i_c112_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_08 (mix_q_src_c112_2_08 0 bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_2_08 (mix_q_src_c112_2_08 mix_q_c112_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_09 (mix_i_src_c112_2_09 0 bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_2_09 (mix_i_src_c112_2_09 mix_i_c112_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_09 (mix_q_src_c112_2_09 0 bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_2_09 (mix_q_src_c112_2_09 mix_q_c112_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_10 (mix_i_src_c112_2_10 0 bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_2_10 (mix_i_src_c112_2_10 mix_i_c112_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_10 (mix_q_src_c112_2_10 0 bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_2_10 (mix_q_src_c112_2_10 mix_q_c112_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_11 (mix_i_src_c112_2_11 0 bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_2_11 (mix_i_src_c112_2_11 mix_i_c112_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_11 (mix_q_src_c112_2_11 0 bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_2_11 (mix_q_src_c112_2_11 mix_q_c112_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_12 (mix_i_src_c112_2_12 0 bpf_c112_2 0) vcvs gain=1.950903220161e-01
SMIXI_c112_2_12 (mix_i_src_c112_2_12 mix_i_c112_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_12 (mix_q_src_c112_2_12 0 bpf_c112_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_2_12 (mix_q_src_c112_2_12 mix_q_c112_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_13 (mix_i_src_c112_2_13 0 bpf_c112_2 0) vcvs gain=5.555702330196e-01
SMIXI_c112_2_13 (mix_i_src_c112_2_13 mix_i_c112_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_13 (mix_q_src_c112_2_13 0 bpf_c112_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_2_13 (mix_q_src_c112_2_13 mix_q_c112_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_14 (mix_i_src_c112_2_14 0 bpf_c112_2 0) vcvs gain=8.314696123025e-01
SMIXI_c112_2_14 (mix_i_src_c112_2_14 mix_i_c112_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_14 (mix_q_src_c112_2_14 0 bpf_c112_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_2_14 (mix_q_src_c112_2_14 mix_q_c112_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_2_15 (mix_i_src_c112_2_15 0 bpf_c112_2 0) vcvs gain=9.807852804032e-01
SMIXI_c112_2_15 (mix_i_src_c112_2_15 mix_i_c112_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_2_15 (mix_q_src_c112_2_15 0 bpf_c112_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_2_15 (mix_q_src_c112_2_15 mix_q_c112_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c112_2 (mix_i_c112_2 0) resistor r=1G
RMIXQ_c112_2 (mix_q_c112_2 0) resistor r=1G
RINTI_c112_2 (mix_i_c112_2 Icar_c112_2) resistor r=1k
CINTI_c112_2 (Icar_c112_2 0) capacitor c=80p
RINTQ_c112_2 (mix_q_c112_2 Qcar_c112_2) resistor r=1k
CINTQ_c112_2 (Qcar_c112_2 0) capacitor c=80p

// bl112, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c112_3 (bl112 n_cbpf_c112_3) capacitor c=2.533029591058e-14
LBPF_c112_3 (n_cbpf_c112_3 bpf_c112_3) inductor l=1.000000000000e-06
RBPF_c112_3 (bpf_c112_3 0) resistor r=3.141592653590e+02
EMIXI_c112_3_00 (mix_i_src_c112_3_00 0 bpf_c112_3 0) vcvs gain=9.807852804032e-01
SMIXI_c112_3_00 (mix_i_src_c112_3_00 mix_i_c112_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_00 (mix_q_src_c112_3_00 0 bpf_c112_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_3_00 (mix_q_src_c112_3_00 mix_q_c112_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_01 (mix_i_src_c112_3_01 0 bpf_c112_3 0) vcvs gain=8.314696123025e-01
SMIXI_c112_3_01 (mix_i_src_c112_3_01 mix_i_c112_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_01 (mix_q_src_c112_3_01 0 bpf_c112_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_3_01 (mix_q_src_c112_3_01 mix_q_c112_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_02 (mix_i_src_c112_3_02 0 bpf_c112_3 0) vcvs gain=5.555702330196e-01
SMIXI_c112_3_02 (mix_i_src_c112_3_02 mix_i_c112_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_02 (mix_q_src_c112_3_02 0 bpf_c112_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_3_02 (mix_q_src_c112_3_02 mix_q_c112_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_03 (mix_i_src_c112_3_03 0 bpf_c112_3 0) vcvs gain=1.950903220161e-01
SMIXI_c112_3_03 (mix_i_src_c112_3_03 mix_i_c112_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_03 (mix_q_src_c112_3_03 0 bpf_c112_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_3_03 (mix_q_src_c112_3_03 mix_q_c112_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_04 (mix_i_src_c112_3_04 0 bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_3_04 (mix_i_src_c112_3_04 mix_i_c112_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_04 (mix_q_src_c112_3_04 0 bpf_c112_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c112_3_04 (mix_q_src_c112_3_04 mix_q_c112_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_05 (mix_i_src_c112_3_05 0 bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_3_05 (mix_i_src_c112_3_05 mix_i_c112_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_05 (mix_q_src_c112_3_05 0 bpf_c112_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c112_3_05 (mix_q_src_c112_3_05 mix_q_c112_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_06 (mix_i_src_c112_3_06 0 bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_3_06 (mix_i_src_c112_3_06 mix_i_c112_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_06 (mix_q_src_c112_3_06 0 bpf_c112_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c112_3_06 (mix_q_src_c112_3_06 mix_q_c112_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_07 (mix_i_src_c112_3_07 0 bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_3_07 (mix_i_src_c112_3_07 mix_i_c112_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_07 (mix_q_src_c112_3_07 0 bpf_c112_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c112_3_07 (mix_q_src_c112_3_07 mix_q_c112_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_08 (mix_i_src_c112_3_08 0 bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c112_3_08 (mix_i_src_c112_3_08 mix_i_c112_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_08 (mix_q_src_c112_3_08 0 bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_3_08 (mix_q_src_c112_3_08 mix_q_c112_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_09 (mix_i_src_c112_3_09 0 bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c112_3_09 (mix_i_src_c112_3_09 mix_i_c112_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_09 (mix_q_src_c112_3_09 0 bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_3_09 (mix_q_src_c112_3_09 mix_q_c112_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_10 (mix_i_src_c112_3_10 0 bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c112_3_10 (mix_i_src_c112_3_10 mix_i_c112_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_10 (mix_q_src_c112_3_10 0 bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_3_10 (mix_q_src_c112_3_10 mix_q_c112_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_11 (mix_i_src_c112_3_11 0 bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c112_3_11 (mix_i_src_c112_3_11 mix_i_c112_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_11 (mix_q_src_c112_3_11 0 bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_3_11 (mix_q_src_c112_3_11 mix_q_c112_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_12 (mix_i_src_c112_3_12 0 bpf_c112_3 0) vcvs gain=1.950903220161e-01
SMIXI_c112_3_12 (mix_i_src_c112_3_12 mix_i_c112_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_12 (mix_q_src_c112_3_12 0 bpf_c112_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c112_3_12 (mix_q_src_c112_3_12 mix_q_c112_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_13 (mix_i_src_c112_3_13 0 bpf_c112_3 0) vcvs gain=5.555702330196e-01
SMIXI_c112_3_13 (mix_i_src_c112_3_13 mix_i_c112_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_13 (mix_q_src_c112_3_13 0 bpf_c112_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c112_3_13 (mix_q_src_c112_3_13 mix_q_c112_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_14 (mix_i_src_c112_3_14 0 bpf_c112_3 0) vcvs gain=8.314696123025e-01
SMIXI_c112_3_14 (mix_i_src_c112_3_14 mix_i_c112_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_14 (mix_q_src_c112_3_14 0 bpf_c112_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c112_3_14 (mix_q_src_c112_3_14 mix_q_c112_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c112_3_15 (mix_i_src_c112_3_15 0 bpf_c112_3 0) vcvs gain=9.807852804032e-01
SMIXI_c112_3_15 (mix_i_src_c112_3_15 mix_i_c112_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c112_3_15 (mix_q_src_c112_3_15 0 bpf_c112_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c112_3_15 (mix_q_src_c112_3_15 mix_q_c112_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c112_3 (mix_i_c112_3 0) resistor r=1G
RMIXQ_c112_3 (mix_q_c112_3 0) resistor r=1G
RINTI_c112_3 (mix_i_c112_3 Icar_c112_3) resistor r=1k
CINTI_c112_3 (Icar_c112_3 0) capacitor c=80p
RINTQ_c112_3 (mix_q_c112_3 Qcar_c112_3) resistor r=1k
CINTQ_c112_3 (Qcar_c112_3 0) capacitor c=80p

// bl113, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c113_0 (bl113 n_cbpf_c113_0) capacitor c=4.052847345694e-13
LBPF_c113_0 (n_cbpf_c113_0 bpf_c113_0) inductor l=1.000000000000e-06
RBPF_c113_0 (bpf_c113_0 0) resistor r=7.853981633974e+01
EMIXI_c113_0_00 (mix_i_src_c113_0_00 0 bpf_c113_0 0) vcvs gain=9.807852804032e-01
SMIXI_c113_0_00 (mix_i_src_c113_0_00 mix_i_c113_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_00 (mix_q_src_c113_0_00 0 bpf_c113_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_0_00 (mix_q_src_c113_0_00 mix_q_c113_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_01 (mix_i_src_c113_0_01 0 bpf_c113_0 0) vcvs gain=8.314696123025e-01
SMIXI_c113_0_01 (mix_i_src_c113_0_01 mix_i_c113_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_01 (mix_q_src_c113_0_01 0 bpf_c113_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_0_01 (mix_q_src_c113_0_01 mix_q_c113_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_02 (mix_i_src_c113_0_02 0 bpf_c113_0 0) vcvs gain=5.555702330196e-01
SMIXI_c113_0_02 (mix_i_src_c113_0_02 mix_i_c113_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_02 (mix_q_src_c113_0_02 0 bpf_c113_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_0_02 (mix_q_src_c113_0_02 mix_q_c113_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_03 (mix_i_src_c113_0_03 0 bpf_c113_0 0) vcvs gain=1.950903220161e-01
SMIXI_c113_0_03 (mix_i_src_c113_0_03 mix_i_c113_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_03 (mix_q_src_c113_0_03 0 bpf_c113_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_0_03 (mix_q_src_c113_0_03 mix_q_c113_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_04 (mix_i_src_c113_0_04 0 bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_0_04 (mix_i_src_c113_0_04 mix_i_c113_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_04 (mix_q_src_c113_0_04 0 bpf_c113_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_0_04 (mix_q_src_c113_0_04 mix_q_c113_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_05 (mix_i_src_c113_0_05 0 bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_0_05 (mix_i_src_c113_0_05 mix_i_c113_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_05 (mix_q_src_c113_0_05 0 bpf_c113_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_0_05 (mix_q_src_c113_0_05 mix_q_c113_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_06 (mix_i_src_c113_0_06 0 bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_0_06 (mix_i_src_c113_0_06 mix_i_c113_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_06 (mix_q_src_c113_0_06 0 bpf_c113_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_0_06 (mix_q_src_c113_0_06 mix_q_c113_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_07 (mix_i_src_c113_0_07 0 bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_0_07 (mix_i_src_c113_0_07 mix_i_c113_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_07 (mix_q_src_c113_0_07 0 bpf_c113_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_0_07 (mix_q_src_c113_0_07 mix_q_c113_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_08 (mix_i_src_c113_0_08 0 bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_0_08 (mix_i_src_c113_0_08 mix_i_c113_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_08 (mix_q_src_c113_0_08 0 bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_0_08 (mix_q_src_c113_0_08 mix_q_c113_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_09 (mix_i_src_c113_0_09 0 bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_0_09 (mix_i_src_c113_0_09 mix_i_c113_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_09 (mix_q_src_c113_0_09 0 bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c113_0_09 (mix_q_src_c113_0_09 mix_q_c113_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_10 (mix_i_src_c113_0_10 0 bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_0_10 (mix_i_src_c113_0_10 mix_i_c113_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_10 (mix_q_src_c113_0_10 0 bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_0_10 (mix_q_src_c113_0_10 mix_q_c113_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_11 (mix_i_src_c113_0_11 0 bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_0_11 (mix_i_src_c113_0_11 mix_i_c113_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_11 (mix_q_src_c113_0_11 0 bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_0_11 (mix_q_src_c113_0_11 mix_q_c113_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_12 (mix_i_src_c113_0_12 0 bpf_c113_0 0) vcvs gain=1.950903220161e-01
SMIXI_c113_0_12 (mix_i_src_c113_0_12 mix_i_c113_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_12 (mix_q_src_c113_0_12 0 bpf_c113_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_0_12 (mix_q_src_c113_0_12 mix_q_c113_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_13 (mix_i_src_c113_0_13 0 bpf_c113_0 0) vcvs gain=5.555702330196e-01
SMIXI_c113_0_13 (mix_i_src_c113_0_13 mix_i_c113_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_13 (mix_q_src_c113_0_13 0 bpf_c113_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_0_13 (mix_q_src_c113_0_13 mix_q_c113_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_14 (mix_i_src_c113_0_14 0 bpf_c113_0 0) vcvs gain=8.314696123025e-01
SMIXI_c113_0_14 (mix_i_src_c113_0_14 mix_i_c113_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_14 (mix_q_src_c113_0_14 0 bpf_c113_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c113_0_14 (mix_q_src_c113_0_14 mix_q_c113_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_0_15 (mix_i_src_c113_0_15 0 bpf_c113_0 0) vcvs gain=9.807852804032e-01
SMIXI_c113_0_15 (mix_i_src_c113_0_15 mix_i_c113_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_0_15 (mix_q_src_c113_0_15 0 bpf_c113_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_0_15 (mix_q_src_c113_0_15 mix_q_c113_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c113_0 (mix_i_c113_0 0) resistor r=1G
RMIXQ_c113_0 (mix_q_c113_0 0) resistor r=1G
RINTI_c113_0 (mix_i_c113_0 Icar_c113_0) resistor r=1k
CINTI_c113_0 (Icar_c113_0 0) capacitor c=80p
RINTQ_c113_0 (mix_q_c113_0 Qcar_c113_0) resistor r=1k
CINTQ_c113_0 (Qcar_c113_0 0) capacitor c=80p

// bl113, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c113_1 (bl113 n_cbpf_c113_1) capacitor c=1.013211836423e-13
LBPF_c113_1 (n_cbpf_c113_1 bpf_c113_1) inductor l=1.000000000000e-06
RBPF_c113_1 (bpf_c113_1 0) resistor r=1.570796326795e+02
EMIXI_c113_1_00 (mix_i_src_c113_1_00 0 bpf_c113_1 0) vcvs gain=9.807852804032e-01
SMIXI_c113_1_00 (mix_i_src_c113_1_00 mix_i_c113_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_00 (mix_q_src_c113_1_00 0 bpf_c113_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_1_00 (mix_q_src_c113_1_00 mix_q_c113_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_01 (mix_i_src_c113_1_01 0 bpf_c113_1 0) vcvs gain=8.314696123025e-01
SMIXI_c113_1_01 (mix_i_src_c113_1_01 mix_i_c113_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_01 (mix_q_src_c113_1_01 0 bpf_c113_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_1_01 (mix_q_src_c113_1_01 mix_q_c113_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_02 (mix_i_src_c113_1_02 0 bpf_c113_1 0) vcvs gain=5.555702330196e-01
SMIXI_c113_1_02 (mix_i_src_c113_1_02 mix_i_c113_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_02 (mix_q_src_c113_1_02 0 bpf_c113_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_1_02 (mix_q_src_c113_1_02 mix_q_c113_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_03 (mix_i_src_c113_1_03 0 bpf_c113_1 0) vcvs gain=1.950903220161e-01
SMIXI_c113_1_03 (mix_i_src_c113_1_03 mix_i_c113_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_03 (mix_q_src_c113_1_03 0 bpf_c113_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_1_03 (mix_q_src_c113_1_03 mix_q_c113_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_04 (mix_i_src_c113_1_04 0 bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_1_04 (mix_i_src_c113_1_04 mix_i_c113_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_04 (mix_q_src_c113_1_04 0 bpf_c113_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_1_04 (mix_q_src_c113_1_04 mix_q_c113_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_05 (mix_i_src_c113_1_05 0 bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_1_05 (mix_i_src_c113_1_05 mix_i_c113_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_05 (mix_q_src_c113_1_05 0 bpf_c113_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_1_05 (mix_q_src_c113_1_05 mix_q_c113_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_06 (mix_i_src_c113_1_06 0 bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_1_06 (mix_i_src_c113_1_06 mix_i_c113_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_06 (mix_q_src_c113_1_06 0 bpf_c113_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_1_06 (mix_q_src_c113_1_06 mix_q_c113_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_07 (mix_i_src_c113_1_07 0 bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_1_07 (mix_i_src_c113_1_07 mix_i_c113_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_07 (mix_q_src_c113_1_07 0 bpf_c113_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_1_07 (mix_q_src_c113_1_07 mix_q_c113_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_08 (mix_i_src_c113_1_08 0 bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_1_08 (mix_i_src_c113_1_08 mix_i_c113_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_08 (mix_q_src_c113_1_08 0 bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_1_08 (mix_q_src_c113_1_08 mix_q_c113_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_09 (mix_i_src_c113_1_09 0 bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_1_09 (mix_i_src_c113_1_09 mix_i_c113_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_09 (mix_q_src_c113_1_09 0 bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c113_1_09 (mix_q_src_c113_1_09 mix_q_c113_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_10 (mix_i_src_c113_1_10 0 bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_1_10 (mix_i_src_c113_1_10 mix_i_c113_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_10 (mix_q_src_c113_1_10 0 bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_1_10 (mix_q_src_c113_1_10 mix_q_c113_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_11 (mix_i_src_c113_1_11 0 bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_1_11 (mix_i_src_c113_1_11 mix_i_c113_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_11 (mix_q_src_c113_1_11 0 bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_1_11 (mix_q_src_c113_1_11 mix_q_c113_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_12 (mix_i_src_c113_1_12 0 bpf_c113_1 0) vcvs gain=1.950903220161e-01
SMIXI_c113_1_12 (mix_i_src_c113_1_12 mix_i_c113_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_12 (mix_q_src_c113_1_12 0 bpf_c113_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_1_12 (mix_q_src_c113_1_12 mix_q_c113_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_13 (mix_i_src_c113_1_13 0 bpf_c113_1 0) vcvs gain=5.555702330196e-01
SMIXI_c113_1_13 (mix_i_src_c113_1_13 mix_i_c113_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_13 (mix_q_src_c113_1_13 0 bpf_c113_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_1_13 (mix_q_src_c113_1_13 mix_q_c113_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_14 (mix_i_src_c113_1_14 0 bpf_c113_1 0) vcvs gain=8.314696123025e-01
SMIXI_c113_1_14 (mix_i_src_c113_1_14 mix_i_c113_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_14 (mix_q_src_c113_1_14 0 bpf_c113_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c113_1_14 (mix_q_src_c113_1_14 mix_q_c113_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_1_15 (mix_i_src_c113_1_15 0 bpf_c113_1 0) vcvs gain=9.807852804032e-01
SMIXI_c113_1_15 (mix_i_src_c113_1_15 mix_i_c113_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_1_15 (mix_q_src_c113_1_15 0 bpf_c113_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_1_15 (mix_q_src_c113_1_15 mix_q_c113_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c113_1 (mix_i_c113_1 0) resistor r=1G
RMIXQ_c113_1 (mix_q_c113_1 0) resistor r=1G
RINTI_c113_1 (mix_i_c113_1 Icar_c113_1) resistor r=1k
CINTI_c113_1 (Icar_c113_1 0) capacitor c=80p
RINTQ_c113_1 (mix_q_c113_1 Qcar_c113_1) resistor r=1k
CINTQ_c113_1 (Qcar_c113_1 0) capacitor c=80p

// bl113, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c113_2 (bl113 n_cbpf_c113_2) capacitor c=4.503163717437e-14
LBPF_c113_2 (n_cbpf_c113_2 bpf_c113_2) inductor l=1.000000000000e-06
RBPF_c113_2 (bpf_c113_2 0) resistor r=2.356194490192e+02
EMIXI_c113_2_00 (mix_i_src_c113_2_00 0 bpf_c113_2 0) vcvs gain=9.807852804032e-01
SMIXI_c113_2_00 (mix_i_src_c113_2_00 mix_i_c113_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_00 (mix_q_src_c113_2_00 0 bpf_c113_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_2_00 (mix_q_src_c113_2_00 mix_q_c113_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_01 (mix_i_src_c113_2_01 0 bpf_c113_2 0) vcvs gain=8.314696123025e-01
SMIXI_c113_2_01 (mix_i_src_c113_2_01 mix_i_c113_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_01 (mix_q_src_c113_2_01 0 bpf_c113_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_2_01 (mix_q_src_c113_2_01 mix_q_c113_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_02 (mix_i_src_c113_2_02 0 bpf_c113_2 0) vcvs gain=5.555702330196e-01
SMIXI_c113_2_02 (mix_i_src_c113_2_02 mix_i_c113_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_02 (mix_q_src_c113_2_02 0 bpf_c113_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_2_02 (mix_q_src_c113_2_02 mix_q_c113_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_03 (mix_i_src_c113_2_03 0 bpf_c113_2 0) vcvs gain=1.950903220161e-01
SMIXI_c113_2_03 (mix_i_src_c113_2_03 mix_i_c113_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_03 (mix_q_src_c113_2_03 0 bpf_c113_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_2_03 (mix_q_src_c113_2_03 mix_q_c113_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_04 (mix_i_src_c113_2_04 0 bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_2_04 (mix_i_src_c113_2_04 mix_i_c113_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_04 (mix_q_src_c113_2_04 0 bpf_c113_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_2_04 (mix_q_src_c113_2_04 mix_q_c113_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_05 (mix_i_src_c113_2_05 0 bpf_c113_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_2_05 (mix_i_src_c113_2_05 mix_i_c113_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_05 (mix_q_src_c113_2_05 0 bpf_c113_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_2_05 (mix_q_src_c113_2_05 mix_q_c113_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_06 (mix_i_src_c113_2_06 0 bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_2_06 (mix_i_src_c113_2_06 mix_i_c113_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_06 (mix_q_src_c113_2_06 0 bpf_c113_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_2_06 (mix_q_src_c113_2_06 mix_q_c113_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_07 (mix_i_src_c113_2_07 0 bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_2_07 (mix_i_src_c113_2_07 mix_i_c113_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_07 (mix_q_src_c113_2_07 0 bpf_c113_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_2_07 (mix_q_src_c113_2_07 mix_q_c113_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_08 (mix_i_src_c113_2_08 0 bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_2_08 (mix_i_src_c113_2_08 mix_i_c113_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_08 (mix_q_src_c113_2_08 0 bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_2_08 (mix_q_src_c113_2_08 mix_q_c113_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_09 (mix_i_src_c113_2_09 0 bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_2_09 (mix_i_src_c113_2_09 mix_i_c113_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_09 (mix_q_src_c113_2_09 0 bpf_c113_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c113_2_09 (mix_q_src_c113_2_09 mix_q_c113_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_10 (mix_i_src_c113_2_10 0 bpf_c113_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_2_10 (mix_i_src_c113_2_10 mix_i_c113_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_10 (mix_q_src_c113_2_10 0 bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_2_10 (mix_q_src_c113_2_10 mix_q_c113_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_11 (mix_i_src_c113_2_11 0 bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_2_11 (mix_i_src_c113_2_11 mix_i_c113_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_11 (mix_q_src_c113_2_11 0 bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_2_11 (mix_q_src_c113_2_11 mix_q_c113_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_12 (mix_i_src_c113_2_12 0 bpf_c113_2 0) vcvs gain=1.950903220161e-01
SMIXI_c113_2_12 (mix_i_src_c113_2_12 mix_i_c113_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_12 (mix_q_src_c113_2_12 0 bpf_c113_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_2_12 (mix_q_src_c113_2_12 mix_q_c113_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_13 (mix_i_src_c113_2_13 0 bpf_c113_2 0) vcvs gain=5.555702330196e-01
SMIXI_c113_2_13 (mix_i_src_c113_2_13 mix_i_c113_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_13 (mix_q_src_c113_2_13 0 bpf_c113_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_2_13 (mix_q_src_c113_2_13 mix_q_c113_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_14 (mix_i_src_c113_2_14 0 bpf_c113_2 0) vcvs gain=8.314696123025e-01
SMIXI_c113_2_14 (mix_i_src_c113_2_14 mix_i_c113_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_14 (mix_q_src_c113_2_14 0 bpf_c113_2 0) vcvs gain=-5.555702330196e-01
