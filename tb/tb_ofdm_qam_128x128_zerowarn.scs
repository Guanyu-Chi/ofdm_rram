SMIXI_c013_3_08 (mix_i_src_c013_3_08 mix_i_c013_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_08 (mix_q_src_c013_3_08 0 bpf_c013_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c013_3_08 (mix_q_src_c013_3_08 mix_q_c013_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c013_3_09 (mix_i_src_c013_3_09 0 bpf_c013_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c013_3_09 (mix_i_src_c013_3_09 mix_i_c013_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_09 (mix_q_src_c013_3_09 0 bpf_c013_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c013_3_09 (mix_q_src_c013_3_09 mix_q_c013_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c013_3_10 (mix_i_src_c013_3_10 0 bpf_c013_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c013_3_10 (mix_i_src_c013_3_10 mix_i_c013_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_10 (mix_q_src_c013_3_10 0 bpf_c013_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c013_3_10 (mix_q_src_c013_3_10 mix_q_c013_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c013_3_11 (mix_i_src_c013_3_11 0 bpf_c013_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c013_3_11 (mix_i_src_c013_3_11 mix_i_c013_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_11 (mix_q_src_c013_3_11 0 bpf_c013_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c013_3_11 (mix_q_src_c013_3_11 mix_q_c013_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c013_3_12 (mix_i_src_c013_3_12 0 bpf_c013_3 0) vcvs gain=1.950903220161e-01
SMIXI_c013_3_12 (mix_i_src_c013_3_12 mix_i_c013_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_12 (mix_q_src_c013_3_12 0 bpf_c013_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c013_3_12 (mix_q_src_c013_3_12 mix_q_c013_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c013_3_13 (mix_i_src_c013_3_13 0 bpf_c013_3 0) vcvs gain=5.555702330196e-01
SMIXI_c013_3_13 (mix_i_src_c013_3_13 mix_i_c013_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_13 (mix_q_src_c013_3_13 0 bpf_c013_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c013_3_13 (mix_q_src_c013_3_13 mix_q_c013_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c013_3_14 (mix_i_src_c013_3_14 0 bpf_c013_3 0) vcvs gain=8.314696123025e-01
SMIXI_c013_3_14 (mix_i_src_c013_3_14 mix_i_c013_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_14 (mix_q_src_c013_3_14 0 bpf_c013_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c013_3_14 (mix_q_src_c013_3_14 mix_q_c013_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c013_3_15 (mix_i_src_c013_3_15 0 bpf_c013_3 0) vcvs gain=9.807852804032e-01
SMIXI_c013_3_15 (mix_i_src_c013_3_15 mix_i_c013_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c013_3_15 (mix_q_src_c013_3_15 0 bpf_c013_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c013_3_15 (mix_q_src_c013_3_15 mix_q_c013_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c013_3 (mix_i_c013_3 0) resistor r=1G
RMIXQ_c013_3 (mix_q_c013_3 0) resistor r=1G
RINTI_c013_3 (mix_i_c013_3 Icar_c013_3) resistor r=1k
CINTI_c013_3 (Icar_c013_3 0) capacitor c=80p
RINTQ_c013_3 (mix_q_c013_3 Qcar_c013_3) resistor r=1k
CINTQ_c013_3 (Qcar_c013_3 0) capacitor c=80p

// bl014, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c014_0 (bl014 n_cbpf_c014_0) capacitor c=4.052847345694e-13
LBPF_c014_0 (n_cbpf_c014_0 bpf_c014_0) inductor l=1.000000000000e-06
RBPF_c014_0 (bpf_c014_0 0) resistor r=7.853981633974e+01
EMIXI_c014_0_00 (mix_i_src_c014_0_00 0 bpf_c014_0 0) vcvs gain=9.807852804032e-01
SMIXI_c014_0_00 (mix_i_src_c014_0_00 mix_i_c014_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_00 (mix_q_src_c014_0_00 0 bpf_c014_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_0_00 (mix_q_src_c014_0_00 mix_q_c014_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_01 (mix_i_src_c014_0_01 0 bpf_c014_0 0) vcvs gain=8.314696123025e-01
SMIXI_c014_0_01 (mix_i_src_c014_0_01 mix_i_c014_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_01 (mix_q_src_c014_0_01 0 bpf_c014_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_0_01 (mix_q_src_c014_0_01 mix_q_c014_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_02 (mix_i_src_c014_0_02 0 bpf_c014_0 0) vcvs gain=5.555702330196e-01
SMIXI_c014_0_02 (mix_i_src_c014_0_02 mix_i_c014_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_02 (mix_q_src_c014_0_02 0 bpf_c014_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_0_02 (mix_q_src_c014_0_02 mix_q_c014_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_03 (mix_i_src_c014_0_03 0 bpf_c014_0 0) vcvs gain=1.950903220161e-01
SMIXI_c014_0_03 (mix_i_src_c014_0_03 mix_i_c014_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_03 (mix_q_src_c014_0_03 0 bpf_c014_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_0_03 (mix_q_src_c014_0_03 mix_q_c014_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_04 (mix_i_src_c014_0_04 0 bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_0_04 (mix_i_src_c014_0_04 mix_i_c014_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_04 (mix_q_src_c014_0_04 0 bpf_c014_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_0_04 (mix_q_src_c014_0_04 mix_q_c014_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_05 (mix_i_src_c014_0_05 0 bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_0_05 (mix_i_src_c014_0_05 mix_i_c014_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_05 (mix_q_src_c014_0_05 0 bpf_c014_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_0_05 (mix_q_src_c014_0_05 mix_q_c014_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_06 (mix_i_src_c014_0_06 0 bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_0_06 (mix_i_src_c014_0_06 mix_i_c014_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_06 (mix_q_src_c014_0_06 0 bpf_c014_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_0_06 (mix_q_src_c014_0_06 mix_q_c014_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_07 (mix_i_src_c014_0_07 0 bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_0_07 (mix_i_src_c014_0_07 mix_i_c014_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_07 (mix_q_src_c014_0_07 0 bpf_c014_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_0_07 (mix_q_src_c014_0_07 mix_q_c014_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_08 (mix_i_src_c014_0_08 0 bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_0_08 (mix_i_src_c014_0_08 mix_i_c014_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_08 (mix_q_src_c014_0_08 0 bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_0_08 (mix_q_src_c014_0_08 mix_q_c014_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_09 (mix_i_src_c014_0_09 0 bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_0_09 (mix_i_src_c014_0_09 mix_i_c014_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_09 (mix_q_src_c014_0_09 0 bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_0_09 (mix_q_src_c014_0_09 mix_q_c014_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_10 (mix_i_src_c014_0_10 0 bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_0_10 (mix_i_src_c014_0_10 mix_i_c014_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_10 (mix_q_src_c014_0_10 0 bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_0_10 (mix_q_src_c014_0_10 mix_q_c014_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_11 (mix_i_src_c014_0_11 0 bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_0_11 (mix_i_src_c014_0_11 mix_i_c014_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_11 (mix_q_src_c014_0_11 0 bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_0_11 (mix_q_src_c014_0_11 mix_q_c014_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_12 (mix_i_src_c014_0_12 0 bpf_c014_0 0) vcvs gain=1.950903220161e-01
SMIXI_c014_0_12 (mix_i_src_c014_0_12 mix_i_c014_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_12 (mix_q_src_c014_0_12 0 bpf_c014_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_0_12 (mix_q_src_c014_0_12 mix_q_c014_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_13 (mix_i_src_c014_0_13 0 bpf_c014_0 0) vcvs gain=5.555702330196e-01
SMIXI_c014_0_13 (mix_i_src_c014_0_13 mix_i_c014_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_13 (mix_q_src_c014_0_13 0 bpf_c014_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_0_13 (mix_q_src_c014_0_13 mix_q_c014_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_14 (mix_i_src_c014_0_14 0 bpf_c014_0 0) vcvs gain=8.314696123025e-01
SMIXI_c014_0_14 (mix_i_src_c014_0_14 mix_i_c014_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_14 (mix_q_src_c014_0_14 0 bpf_c014_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_0_14 (mix_q_src_c014_0_14 mix_q_c014_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_0_15 (mix_i_src_c014_0_15 0 bpf_c014_0 0) vcvs gain=9.807852804032e-01
SMIXI_c014_0_15 (mix_i_src_c014_0_15 mix_i_c014_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_0_15 (mix_q_src_c014_0_15 0 bpf_c014_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_0_15 (mix_q_src_c014_0_15 mix_q_c014_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c014_0 (mix_i_c014_0 0) resistor r=1G
RMIXQ_c014_0 (mix_q_c014_0 0) resistor r=1G
RINTI_c014_0 (mix_i_c014_0 Icar_c014_0) resistor r=1k
CINTI_c014_0 (Icar_c014_0 0) capacitor c=80p
RINTQ_c014_0 (mix_q_c014_0 Qcar_c014_0) resistor r=1k
CINTQ_c014_0 (Qcar_c014_0 0) capacitor c=80p

// bl014, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c014_1 (bl014 n_cbpf_c014_1) capacitor c=1.013211836423e-13
LBPF_c014_1 (n_cbpf_c014_1 bpf_c014_1) inductor l=1.000000000000e-06
RBPF_c014_1 (bpf_c014_1 0) resistor r=1.570796326795e+02
EMIXI_c014_1_00 (mix_i_src_c014_1_00 0 bpf_c014_1 0) vcvs gain=9.807852804032e-01
SMIXI_c014_1_00 (mix_i_src_c014_1_00 mix_i_c014_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_00 (mix_q_src_c014_1_00 0 bpf_c014_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_1_00 (mix_q_src_c014_1_00 mix_q_c014_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_01 (mix_i_src_c014_1_01 0 bpf_c014_1 0) vcvs gain=8.314696123025e-01
SMIXI_c014_1_01 (mix_i_src_c014_1_01 mix_i_c014_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_01 (mix_q_src_c014_1_01 0 bpf_c014_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_1_01 (mix_q_src_c014_1_01 mix_q_c014_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_02 (mix_i_src_c014_1_02 0 bpf_c014_1 0) vcvs gain=5.555702330196e-01
SMIXI_c014_1_02 (mix_i_src_c014_1_02 mix_i_c014_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_02 (mix_q_src_c014_1_02 0 bpf_c014_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_1_02 (mix_q_src_c014_1_02 mix_q_c014_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_03 (mix_i_src_c014_1_03 0 bpf_c014_1 0) vcvs gain=1.950903220161e-01
SMIXI_c014_1_03 (mix_i_src_c014_1_03 mix_i_c014_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_03 (mix_q_src_c014_1_03 0 bpf_c014_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_1_03 (mix_q_src_c014_1_03 mix_q_c014_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_04 (mix_i_src_c014_1_04 0 bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_1_04 (mix_i_src_c014_1_04 mix_i_c014_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_04 (mix_q_src_c014_1_04 0 bpf_c014_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_1_04 (mix_q_src_c014_1_04 mix_q_c014_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_05 (mix_i_src_c014_1_05 0 bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_1_05 (mix_i_src_c014_1_05 mix_i_c014_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_05 (mix_q_src_c014_1_05 0 bpf_c014_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_1_05 (mix_q_src_c014_1_05 mix_q_c014_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_06 (mix_i_src_c014_1_06 0 bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_1_06 (mix_i_src_c014_1_06 mix_i_c014_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_06 (mix_q_src_c014_1_06 0 bpf_c014_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_1_06 (mix_q_src_c014_1_06 mix_q_c014_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_07 (mix_i_src_c014_1_07 0 bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_1_07 (mix_i_src_c014_1_07 mix_i_c014_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_07 (mix_q_src_c014_1_07 0 bpf_c014_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_1_07 (mix_q_src_c014_1_07 mix_q_c014_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_08 (mix_i_src_c014_1_08 0 bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_1_08 (mix_i_src_c014_1_08 mix_i_c014_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_08 (mix_q_src_c014_1_08 0 bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_1_08 (mix_q_src_c014_1_08 mix_q_c014_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_09 (mix_i_src_c014_1_09 0 bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_1_09 (mix_i_src_c014_1_09 mix_i_c014_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_09 (mix_q_src_c014_1_09 0 bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_1_09 (mix_q_src_c014_1_09 mix_q_c014_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_10 (mix_i_src_c014_1_10 0 bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_1_10 (mix_i_src_c014_1_10 mix_i_c014_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_10 (mix_q_src_c014_1_10 0 bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_1_10 (mix_q_src_c014_1_10 mix_q_c014_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_11 (mix_i_src_c014_1_11 0 bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_1_11 (mix_i_src_c014_1_11 mix_i_c014_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_11 (mix_q_src_c014_1_11 0 bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_1_11 (mix_q_src_c014_1_11 mix_q_c014_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_12 (mix_i_src_c014_1_12 0 bpf_c014_1 0) vcvs gain=1.950903220161e-01
SMIXI_c014_1_12 (mix_i_src_c014_1_12 mix_i_c014_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_12 (mix_q_src_c014_1_12 0 bpf_c014_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_1_12 (mix_q_src_c014_1_12 mix_q_c014_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_13 (mix_i_src_c014_1_13 0 bpf_c014_1 0) vcvs gain=5.555702330196e-01
SMIXI_c014_1_13 (mix_i_src_c014_1_13 mix_i_c014_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_13 (mix_q_src_c014_1_13 0 bpf_c014_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_1_13 (mix_q_src_c014_1_13 mix_q_c014_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_14 (mix_i_src_c014_1_14 0 bpf_c014_1 0) vcvs gain=8.314696123025e-01
SMIXI_c014_1_14 (mix_i_src_c014_1_14 mix_i_c014_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_14 (mix_q_src_c014_1_14 0 bpf_c014_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_1_14 (mix_q_src_c014_1_14 mix_q_c014_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_1_15 (mix_i_src_c014_1_15 0 bpf_c014_1 0) vcvs gain=9.807852804032e-01
SMIXI_c014_1_15 (mix_i_src_c014_1_15 mix_i_c014_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_1_15 (mix_q_src_c014_1_15 0 bpf_c014_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_1_15 (mix_q_src_c014_1_15 mix_q_c014_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c014_1 (mix_i_c014_1 0) resistor r=1G
RMIXQ_c014_1 (mix_q_c014_1 0) resistor r=1G
RINTI_c014_1 (mix_i_c014_1 Icar_c014_1) resistor r=1k
CINTI_c014_1 (Icar_c014_1 0) capacitor c=80p
RINTQ_c014_1 (mix_q_c014_1 Qcar_c014_1) resistor r=1k
CINTQ_c014_1 (Qcar_c014_1 0) capacitor c=80p

// bl014, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c014_2 (bl014 n_cbpf_c014_2) capacitor c=4.503163717437e-14
LBPF_c014_2 (n_cbpf_c014_2 bpf_c014_2) inductor l=1.000000000000e-06
RBPF_c014_2 (bpf_c014_2 0) resistor r=2.356194490192e+02
EMIXI_c014_2_00 (mix_i_src_c014_2_00 0 bpf_c014_2 0) vcvs gain=9.807852804032e-01
SMIXI_c014_2_00 (mix_i_src_c014_2_00 mix_i_c014_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_00 (mix_q_src_c014_2_00 0 bpf_c014_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_2_00 (mix_q_src_c014_2_00 mix_q_c014_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_01 (mix_i_src_c014_2_01 0 bpf_c014_2 0) vcvs gain=8.314696123025e-01
SMIXI_c014_2_01 (mix_i_src_c014_2_01 mix_i_c014_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_01 (mix_q_src_c014_2_01 0 bpf_c014_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_2_01 (mix_q_src_c014_2_01 mix_q_c014_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_02 (mix_i_src_c014_2_02 0 bpf_c014_2 0) vcvs gain=5.555702330196e-01
SMIXI_c014_2_02 (mix_i_src_c014_2_02 mix_i_c014_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_02 (mix_q_src_c014_2_02 0 bpf_c014_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_2_02 (mix_q_src_c014_2_02 mix_q_c014_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_03 (mix_i_src_c014_2_03 0 bpf_c014_2 0) vcvs gain=1.950903220161e-01
SMIXI_c014_2_03 (mix_i_src_c014_2_03 mix_i_c014_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_03 (mix_q_src_c014_2_03 0 bpf_c014_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_2_03 (mix_q_src_c014_2_03 mix_q_c014_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_04 (mix_i_src_c014_2_04 0 bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_2_04 (mix_i_src_c014_2_04 mix_i_c014_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_04 (mix_q_src_c014_2_04 0 bpf_c014_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_2_04 (mix_q_src_c014_2_04 mix_q_c014_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_05 (mix_i_src_c014_2_05 0 bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_2_05 (mix_i_src_c014_2_05 mix_i_c014_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_05 (mix_q_src_c014_2_05 0 bpf_c014_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_2_05 (mix_q_src_c014_2_05 mix_q_c014_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_06 (mix_i_src_c014_2_06 0 bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_2_06 (mix_i_src_c014_2_06 mix_i_c014_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_06 (mix_q_src_c014_2_06 0 bpf_c014_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_2_06 (mix_q_src_c014_2_06 mix_q_c014_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_07 (mix_i_src_c014_2_07 0 bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_2_07 (mix_i_src_c014_2_07 mix_i_c014_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_07 (mix_q_src_c014_2_07 0 bpf_c014_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_2_07 (mix_q_src_c014_2_07 mix_q_c014_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_08 (mix_i_src_c014_2_08 0 bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_2_08 (mix_i_src_c014_2_08 mix_i_c014_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_08 (mix_q_src_c014_2_08 0 bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_2_08 (mix_q_src_c014_2_08 mix_q_c014_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_09 (mix_i_src_c014_2_09 0 bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_2_09 (mix_i_src_c014_2_09 mix_i_c014_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_09 (mix_q_src_c014_2_09 0 bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_2_09 (mix_q_src_c014_2_09 mix_q_c014_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_10 (mix_i_src_c014_2_10 0 bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_2_10 (mix_i_src_c014_2_10 mix_i_c014_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_10 (mix_q_src_c014_2_10 0 bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_2_10 (mix_q_src_c014_2_10 mix_q_c014_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_11 (mix_i_src_c014_2_11 0 bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_2_11 (mix_i_src_c014_2_11 mix_i_c014_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_11 (mix_q_src_c014_2_11 0 bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_2_11 (mix_q_src_c014_2_11 mix_q_c014_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_12 (mix_i_src_c014_2_12 0 bpf_c014_2 0) vcvs gain=1.950903220161e-01
SMIXI_c014_2_12 (mix_i_src_c014_2_12 mix_i_c014_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_12 (mix_q_src_c014_2_12 0 bpf_c014_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_2_12 (mix_q_src_c014_2_12 mix_q_c014_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_13 (mix_i_src_c014_2_13 0 bpf_c014_2 0) vcvs gain=5.555702330196e-01
SMIXI_c014_2_13 (mix_i_src_c014_2_13 mix_i_c014_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_13 (mix_q_src_c014_2_13 0 bpf_c014_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_2_13 (mix_q_src_c014_2_13 mix_q_c014_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_14 (mix_i_src_c014_2_14 0 bpf_c014_2 0) vcvs gain=8.314696123025e-01
SMIXI_c014_2_14 (mix_i_src_c014_2_14 mix_i_c014_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_14 (mix_q_src_c014_2_14 0 bpf_c014_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_2_14 (mix_q_src_c014_2_14 mix_q_c014_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_2_15 (mix_i_src_c014_2_15 0 bpf_c014_2 0) vcvs gain=9.807852804032e-01
SMIXI_c014_2_15 (mix_i_src_c014_2_15 mix_i_c014_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_2_15 (mix_q_src_c014_2_15 0 bpf_c014_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_2_15 (mix_q_src_c014_2_15 mix_q_c014_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c014_2 (mix_i_c014_2 0) resistor r=1G
RMIXQ_c014_2 (mix_q_c014_2 0) resistor r=1G
RINTI_c014_2 (mix_i_c014_2 Icar_c014_2) resistor r=1k
CINTI_c014_2 (Icar_c014_2 0) capacitor c=80p
RINTQ_c014_2 (mix_q_c014_2 Qcar_c014_2) resistor r=1k
CINTQ_c014_2 (Qcar_c014_2 0) capacitor c=80p

// bl014, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c014_3 (bl014 n_cbpf_c014_3) capacitor c=2.533029591058e-14
LBPF_c014_3 (n_cbpf_c014_3 bpf_c014_3) inductor l=1.000000000000e-06
RBPF_c014_3 (bpf_c014_3 0) resistor r=3.141592653590e+02
EMIXI_c014_3_00 (mix_i_src_c014_3_00 0 bpf_c014_3 0) vcvs gain=9.807852804032e-01
SMIXI_c014_3_00 (mix_i_src_c014_3_00 mix_i_c014_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_00 (mix_q_src_c014_3_00 0 bpf_c014_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_3_00 (mix_q_src_c014_3_00 mix_q_c014_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_01 (mix_i_src_c014_3_01 0 bpf_c014_3 0) vcvs gain=8.314696123025e-01
SMIXI_c014_3_01 (mix_i_src_c014_3_01 mix_i_c014_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_01 (mix_q_src_c014_3_01 0 bpf_c014_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_3_01 (mix_q_src_c014_3_01 mix_q_c014_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_02 (mix_i_src_c014_3_02 0 bpf_c014_3 0) vcvs gain=5.555702330196e-01
SMIXI_c014_3_02 (mix_i_src_c014_3_02 mix_i_c014_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_02 (mix_q_src_c014_3_02 0 bpf_c014_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_3_02 (mix_q_src_c014_3_02 mix_q_c014_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_03 (mix_i_src_c014_3_03 0 bpf_c014_3 0) vcvs gain=1.950903220161e-01
SMIXI_c014_3_03 (mix_i_src_c014_3_03 mix_i_c014_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_03 (mix_q_src_c014_3_03 0 bpf_c014_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_3_03 (mix_q_src_c014_3_03 mix_q_c014_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_04 (mix_i_src_c014_3_04 0 bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_3_04 (mix_i_src_c014_3_04 mix_i_c014_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_04 (mix_q_src_c014_3_04 0 bpf_c014_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c014_3_04 (mix_q_src_c014_3_04 mix_q_c014_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_05 (mix_i_src_c014_3_05 0 bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_3_05 (mix_i_src_c014_3_05 mix_i_c014_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_05 (mix_q_src_c014_3_05 0 bpf_c014_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c014_3_05 (mix_q_src_c014_3_05 mix_q_c014_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_06 (mix_i_src_c014_3_06 0 bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_3_06 (mix_i_src_c014_3_06 mix_i_c014_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_06 (mix_q_src_c014_3_06 0 bpf_c014_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c014_3_06 (mix_q_src_c014_3_06 mix_q_c014_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_07 (mix_i_src_c014_3_07 0 bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_3_07 (mix_i_src_c014_3_07 mix_i_c014_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_07 (mix_q_src_c014_3_07 0 bpf_c014_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c014_3_07 (mix_q_src_c014_3_07 mix_q_c014_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_08 (mix_i_src_c014_3_08 0 bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c014_3_08 (mix_i_src_c014_3_08 mix_i_c014_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_08 (mix_q_src_c014_3_08 0 bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_3_08 (mix_q_src_c014_3_08 mix_q_c014_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_09 (mix_i_src_c014_3_09 0 bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c014_3_09 (mix_i_src_c014_3_09 mix_i_c014_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_09 (mix_q_src_c014_3_09 0 bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_3_09 (mix_q_src_c014_3_09 mix_q_c014_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_10 (mix_i_src_c014_3_10 0 bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c014_3_10 (mix_i_src_c014_3_10 mix_i_c014_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_10 (mix_q_src_c014_3_10 0 bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_3_10 (mix_q_src_c014_3_10 mix_q_c014_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_11 (mix_i_src_c014_3_11 0 bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c014_3_11 (mix_i_src_c014_3_11 mix_i_c014_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_11 (mix_q_src_c014_3_11 0 bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_3_11 (mix_q_src_c014_3_11 mix_q_c014_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_12 (mix_i_src_c014_3_12 0 bpf_c014_3 0) vcvs gain=1.950903220161e-01
SMIXI_c014_3_12 (mix_i_src_c014_3_12 mix_i_c014_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_12 (mix_q_src_c014_3_12 0 bpf_c014_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c014_3_12 (mix_q_src_c014_3_12 mix_q_c014_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_13 (mix_i_src_c014_3_13 0 bpf_c014_3 0) vcvs gain=5.555702330196e-01
SMIXI_c014_3_13 (mix_i_src_c014_3_13 mix_i_c014_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_13 (mix_q_src_c014_3_13 0 bpf_c014_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c014_3_13 (mix_q_src_c014_3_13 mix_q_c014_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_14 (mix_i_src_c014_3_14 0 bpf_c014_3 0) vcvs gain=8.314696123025e-01
SMIXI_c014_3_14 (mix_i_src_c014_3_14 mix_i_c014_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_14 (mix_q_src_c014_3_14 0 bpf_c014_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c014_3_14 (mix_q_src_c014_3_14 mix_q_c014_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c014_3_15 (mix_i_src_c014_3_15 0 bpf_c014_3 0) vcvs gain=9.807852804032e-01
SMIXI_c014_3_15 (mix_i_src_c014_3_15 mix_i_c014_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c014_3_15 (mix_q_src_c014_3_15 0 bpf_c014_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c014_3_15 (mix_q_src_c014_3_15 mix_q_c014_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c014_3 (mix_i_c014_3 0) resistor r=1G
RMIXQ_c014_3 (mix_q_c014_3 0) resistor r=1G
RINTI_c014_3 (mix_i_c014_3 Icar_c014_3) resistor r=1k
CINTI_c014_3 (Icar_c014_3 0) capacitor c=80p
RINTQ_c014_3 (mix_q_c014_3 Qcar_c014_3) resistor r=1k
CINTQ_c014_3 (Qcar_c014_3 0) capacitor c=80p

// bl015, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c015_0 (bl015 n_cbpf_c015_0) capacitor c=4.052847345694e-13
LBPF_c015_0 (n_cbpf_c015_0 bpf_c015_0) inductor l=1.000000000000e-06
RBPF_c015_0 (bpf_c015_0 0) resistor r=7.853981633974e+01
EMIXI_c015_0_00 (mix_i_src_c015_0_00 0 bpf_c015_0 0) vcvs gain=9.807852804032e-01
SMIXI_c015_0_00 (mix_i_src_c015_0_00 mix_i_c015_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_00 (mix_q_src_c015_0_00 0 bpf_c015_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_0_00 (mix_q_src_c015_0_00 mix_q_c015_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_01 (mix_i_src_c015_0_01 0 bpf_c015_0 0) vcvs gain=8.314696123025e-01
SMIXI_c015_0_01 (mix_i_src_c015_0_01 mix_i_c015_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_01 (mix_q_src_c015_0_01 0 bpf_c015_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_0_01 (mix_q_src_c015_0_01 mix_q_c015_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_02 (mix_i_src_c015_0_02 0 bpf_c015_0 0) vcvs gain=5.555702330196e-01
SMIXI_c015_0_02 (mix_i_src_c015_0_02 mix_i_c015_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_02 (mix_q_src_c015_0_02 0 bpf_c015_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_0_02 (mix_q_src_c015_0_02 mix_q_c015_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_03 (mix_i_src_c015_0_03 0 bpf_c015_0 0) vcvs gain=1.950903220161e-01
SMIXI_c015_0_03 (mix_i_src_c015_0_03 mix_i_c015_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_03 (mix_q_src_c015_0_03 0 bpf_c015_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_0_03 (mix_q_src_c015_0_03 mix_q_c015_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_04 (mix_i_src_c015_0_04 0 bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_0_04 (mix_i_src_c015_0_04 mix_i_c015_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_04 (mix_q_src_c015_0_04 0 bpf_c015_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_0_04 (mix_q_src_c015_0_04 mix_q_c015_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_05 (mix_i_src_c015_0_05 0 bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_0_05 (mix_i_src_c015_0_05 mix_i_c015_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_05 (mix_q_src_c015_0_05 0 bpf_c015_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_0_05 (mix_q_src_c015_0_05 mix_q_c015_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_06 (mix_i_src_c015_0_06 0 bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_0_06 (mix_i_src_c015_0_06 mix_i_c015_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_06 (mix_q_src_c015_0_06 0 bpf_c015_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_0_06 (mix_q_src_c015_0_06 mix_q_c015_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_07 (mix_i_src_c015_0_07 0 bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_0_07 (mix_i_src_c015_0_07 mix_i_c015_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_07 (mix_q_src_c015_0_07 0 bpf_c015_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_0_07 (mix_q_src_c015_0_07 mix_q_c015_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_08 (mix_i_src_c015_0_08 0 bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_0_08 (mix_i_src_c015_0_08 mix_i_c015_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_08 (mix_q_src_c015_0_08 0 bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_0_08 (mix_q_src_c015_0_08 mix_q_c015_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_09 (mix_i_src_c015_0_09 0 bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_0_09 (mix_i_src_c015_0_09 mix_i_c015_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_09 (mix_q_src_c015_0_09 0 bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_0_09 (mix_q_src_c015_0_09 mix_q_c015_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_10 (mix_i_src_c015_0_10 0 bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_0_10 (mix_i_src_c015_0_10 mix_i_c015_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_10 (mix_q_src_c015_0_10 0 bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_0_10 (mix_q_src_c015_0_10 mix_q_c015_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_11 (mix_i_src_c015_0_11 0 bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_0_11 (mix_i_src_c015_0_11 mix_i_c015_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_11 (mix_q_src_c015_0_11 0 bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_0_11 (mix_q_src_c015_0_11 mix_q_c015_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_12 (mix_i_src_c015_0_12 0 bpf_c015_0 0) vcvs gain=1.950903220161e-01
SMIXI_c015_0_12 (mix_i_src_c015_0_12 mix_i_c015_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_12 (mix_q_src_c015_0_12 0 bpf_c015_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_0_12 (mix_q_src_c015_0_12 mix_q_c015_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_13 (mix_i_src_c015_0_13 0 bpf_c015_0 0) vcvs gain=5.555702330196e-01
SMIXI_c015_0_13 (mix_i_src_c015_0_13 mix_i_c015_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_13 (mix_q_src_c015_0_13 0 bpf_c015_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_0_13 (mix_q_src_c015_0_13 mix_q_c015_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_14 (mix_i_src_c015_0_14 0 bpf_c015_0 0) vcvs gain=8.314696123025e-01
SMIXI_c015_0_14 (mix_i_src_c015_0_14 mix_i_c015_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_14 (mix_q_src_c015_0_14 0 bpf_c015_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_0_14 (mix_q_src_c015_0_14 mix_q_c015_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_0_15 (mix_i_src_c015_0_15 0 bpf_c015_0 0) vcvs gain=9.807852804032e-01
SMIXI_c015_0_15 (mix_i_src_c015_0_15 mix_i_c015_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_0_15 (mix_q_src_c015_0_15 0 bpf_c015_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_0_15 (mix_q_src_c015_0_15 mix_q_c015_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c015_0 (mix_i_c015_0 0) resistor r=1G
RMIXQ_c015_0 (mix_q_c015_0 0) resistor r=1G
RINTI_c015_0 (mix_i_c015_0 Icar_c015_0) resistor r=1k
CINTI_c015_0 (Icar_c015_0 0) capacitor c=80p
RINTQ_c015_0 (mix_q_c015_0 Qcar_c015_0) resistor r=1k
CINTQ_c015_0 (Qcar_c015_0 0) capacitor c=80p

// bl015, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c015_1 (bl015 n_cbpf_c015_1) capacitor c=1.013211836423e-13
LBPF_c015_1 (n_cbpf_c015_1 bpf_c015_1) inductor l=1.000000000000e-06
RBPF_c015_1 (bpf_c015_1 0) resistor r=1.570796326795e+02
EMIXI_c015_1_00 (mix_i_src_c015_1_00 0 bpf_c015_1 0) vcvs gain=9.807852804032e-01
SMIXI_c015_1_00 (mix_i_src_c015_1_00 mix_i_c015_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_00 (mix_q_src_c015_1_00 0 bpf_c015_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_1_00 (mix_q_src_c015_1_00 mix_q_c015_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_01 (mix_i_src_c015_1_01 0 bpf_c015_1 0) vcvs gain=8.314696123025e-01
SMIXI_c015_1_01 (mix_i_src_c015_1_01 mix_i_c015_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_01 (mix_q_src_c015_1_01 0 bpf_c015_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_1_01 (mix_q_src_c015_1_01 mix_q_c015_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_02 (mix_i_src_c015_1_02 0 bpf_c015_1 0) vcvs gain=5.555702330196e-01
SMIXI_c015_1_02 (mix_i_src_c015_1_02 mix_i_c015_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_02 (mix_q_src_c015_1_02 0 bpf_c015_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_1_02 (mix_q_src_c015_1_02 mix_q_c015_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_03 (mix_i_src_c015_1_03 0 bpf_c015_1 0) vcvs gain=1.950903220161e-01
SMIXI_c015_1_03 (mix_i_src_c015_1_03 mix_i_c015_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_03 (mix_q_src_c015_1_03 0 bpf_c015_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_1_03 (mix_q_src_c015_1_03 mix_q_c015_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_04 (mix_i_src_c015_1_04 0 bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_1_04 (mix_i_src_c015_1_04 mix_i_c015_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_04 (mix_q_src_c015_1_04 0 bpf_c015_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_1_04 (mix_q_src_c015_1_04 mix_q_c015_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_05 (mix_i_src_c015_1_05 0 bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_1_05 (mix_i_src_c015_1_05 mix_i_c015_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_05 (mix_q_src_c015_1_05 0 bpf_c015_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_1_05 (mix_q_src_c015_1_05 mix_q_c015_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_06 (mix_i_src_c015_1_06 0 bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_1_06 (mix_i_src_c015_1_06 mix_i_c015_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_06 (mix_q_src_c015_1_06 0 bpf_c015_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_1_06 (mix_q_src_c015_1_06 mix_q_c015_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_07 (mix_i_src_c015_1_07 0 bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_1_07 (mix_i_src_c015_1_07 mix_i_c015_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_07 (mix_q_src_c015_1_07 0 bpf_c015_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_1_07 (mix_q_src_c015_1_07 mix_q_c015_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_08 (mix_i_src_c015_1_08 0 bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_1_08 (mix_i_src_c015_1_08 mix_i_c015_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_08 (mix_q_src_c015_1_08 0 bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_1_08 (mix_q_src_c015_1_08 mix_q_c015_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_09 (mix_i_src_c015_1_09 0 bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_1_09 (mix_i_src_c015_1_09 mix_i_c015_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_09 (mix_q_src_c015_1_09 0 bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_1_09 (mix_q_src_c015_1_09 mix_q_c015_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_10 (mix_i_src_c015_1_10 0 bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_1_10 (mix_i_src_c015_1_10 mix_i_c015_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_10 (mix_q_src_c015_1_10 0 bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_1_10 (mix_q_src_c015_1_10 mix_q_c015_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_11 (mix_i_src_c015_1_11 0 bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_1_11 (mix_i_src_c015_1_11 mix_i_c015_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_11 (mix_q_src_c015_1_11 0 bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_1_11 (mix_q_src_c015_1_11 mix_q_c015_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_12 (mix_i_src_c015_1_12 0 bpf_c015_1 0) vcvs gain=1.950903220161e-01
SMIXI_c015_1_12 (mix_i_src_c015_1_12 mix_i_c015_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_12 (mix_q_src_c015_1_12 0 bpf_c015_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_1_12 (mix_q_src_c015_1_12 mix_q_c015_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_13 (mix_i_src_c015_1_13 0 bpf_c015_1 0) vcvs gain=5.555702330196e-01
SMIXI_c015_1_13 (mix_i_src_c015_1_13 mix_i_c015_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_13 (mix_q_src_c015_1_13 0 bpf_c015_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_1_13 (mix_q_src_c015_1_13 mix_q_c015_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_14 (mix_i_src_c015_1_14 0 bpf_c015_1 0) vcvs gain=8.314696123025e-01
SMIXI_c015_1_14 (mix_i_src_c015_1_14 mix_i_c015_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_14 (mix_q_src_c015_1_14 0 bpf_c015_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_1_14 (mix_q_src_c015_1_14 mix_q_c015_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_1_15 (mix_i_src_c015_1_15 0 bpf_c015_1 0) vcvs gain=9.807852804032e-01
SMIXI_c015_1_15 (mix_i_src_c015_1_15 mix_i_c015_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_1_15 (mix_q_src_c015_1_15 0 bpf_c015_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_1_15 (mix_q_src_c015_1_15 mix_q_c015_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c015_1 (mix_i_c015_1 0) resistor r=1G
RMIXQ_c015_1 (mix_q_c015_1 0) resistor r=1G
RINTI_c015_1 (mix_i_c015_1 Icar_c015_1) resistor r=1k
CINTI_c015_1 (Icar_c015_1 0) capacitor c=80p
RINTQ_c015_1 (mix_q_c015_1 Qcar_c015_1) resistor r=1k
CINTQ_c015_1 (Qcar_c015_1 0) capacitor c=80p

// bl015, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c015_2 (bl015 n_cbpf_c015_2) capacitor c=4.503163717437e-14
LBPF_c015_2 (n_cbpf_c015_2 bpf_c015_2) inductor l=1.000000000000e-06
RBPF_c015_2 (bpf_c015_2 0) resistor r=2.356194490192e+02
EMIXI_c015_2_00 (mix_i_src_c015_2_00 0 bpf_c015_2 0) vcvs gain=9.807852804032e-01
SMIXI_c015_2_00 (mix_i_src_c015_2_00 mix_i_c015_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_00 (mix_q_src_c015_2_00 0 bpf_c015_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_2_00 (mix_q_src_c015_2_00 mix_q_c015_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_01 (mix_i_src_c015_2_01 0 bpf_c015_2 0) vcvs gain=8.314696123025e-01
SMIXI_c015_2_01 (mix_i_src_c015_2_01 mix_i_c015_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_01 (mix_q_src_c015_2_01 0 bpf_c015_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_2_01 (mix_q_src_c015_2_01 mix_q_c015_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_02 (mix_i_src_c015_2_02 0 bpf_c015_2 0) vcvs gain=5.555702330196e-01
SMIXI_c015_2_02 (mix_i_src_c015_2_02 mix_i_c015_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_02 (mix_q_src_c015_2_02 0 bpf_c015_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_2_02 (mix_q_src_c015_2_02 mix_q_c015_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_03 (mix_i_src_c015_2_03 0 bpf_c015_2 0) vcvs gain=1.950903220161e-01
SMIXI_c015_2_03 (mix_i_src_c015_2_03 mix_i_c015_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_03 (mix_q_src_c015_2_03 0 bpf_c015_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_2_03 (mix_q_src_c015_2_03 mix_q_c015_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_04 (mix_i_src_c015_2_04 0 bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_2_04 (mix_i_src_c015_2_04 mix_i_c015_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_04 (mix_q_src_c015_2_04 0 bpf_c015_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_2_04 (mix_q_src_c015_2_04 mix_q_c015_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_05 (mix_i_src_c015_2_05 0 bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_2_05 (mix_i_src_c015_2_05 mix_i_c015_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_05 (mix_q_src_c015_2_05 0 bpf_c015_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_2_05 (mix_q_src_c015_2_05 mix_q_c015_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_06 (mix_i_src_c015_2_06 0 bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_2_06 (mix_i_src_c015_2_06 mix_i_c015_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_06 (mix_q_src_c015_2_06 0 bpf_c015_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_2_06 (mix_q_src_c015_2_06 mix_q_c015_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_07 (mix_i_src_c015_2_07 0 bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_2_07 (mix_i_src_c015_2_07 mix_i_c015_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_07 (mix_q_src_c015_2_07 0 bpf_c015_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_2_07 (mix_q_src_c015_2_07 mix_q_c015_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_08 (mix_i_src_c015_2_08 0 bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_2_08 (mix_i_src_c015_2_08 mix_i_c015_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_08 (mix_q_src_c015_2_08 0 bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_2_08 (mix_q_src_c015_2_08 mix_q_c015_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_09 (mix_i_src_c015_2_09 0 bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_2_09 (mix_i_src_c015_2_09 mix_i_c015_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_09 (mix_q_src_c015_2_09 0 bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_2_09 (mix_q_src_c015_2_09 mix_q_c015_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_10 (mix_i_src_c015_2_10 0 bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_2_10 (mix_i_src_c015_2_10 mix_i_c015_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_10 (mix_q_src_c015_2_10 0 bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_2_10 (mix_q_src_c015_2_10 mix_q_c015_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_11 (mix_i_src_c015_2_11 0 bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_2_11 (mix_i_src_c015_2_11 mix_i_c015_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_11 (mix_q_src_c015_2_11 0 bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_2_11 (mix_q_src_c015_2_11 mix_q_c015_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_12 (mix_i_src_c015_2_12 0 bpf_c015_2 0) vcvs gain=1.950903220161e-01
SMIXI_c015_2_12 (mix_i_src_c015_2_12 mix_i_c015_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_12 (mix_q_src_c015_2_12 0 bpf_c015_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_2_12 (mix_q_src_c015_2_12 mix_q_c015_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_13 (mix_i_src_c015_2_13 0 bpf_c015_2 0) vcvs gain=5.555702330196e-01
SMIXI_c015_2_13 (mix_i_src_c015_2_13 mix_i_c015_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_13 (mix_q_src_c015_2_13 0 bpf_c015_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_2_13 (mix_q_src_c015_2_13 mix_q_c015_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_14 (mix_i_src_c015_2_14 0 bpf_c015_2 0) vcvs gain=8.314696123025e-01
SMIXI_c015_2_14 (mix_i_src_c015_2_14 mix_i_c015_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_14 (mix_q_src_c015_2_14 0 bpf_c015_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_2_14 (mix_q_src_c015_2_14 mix_q_c015_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_2_15 (mix_i_src_c015_2_15 0 bpf_c015_2 0) vcvs gain=9.807852804032e-01
SMIXI_c015_2_15 (mix_i_src_c015_2_15 mix_i_c015_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_2_15 (mix_q_src_c015_2_15 0 bpf_c015_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_2_15 (mix_q_src_c015_2_15 mix_q_c015_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c015_2 (mix_i_c015_2 0) resistor r=1G
RMIXQ_c015_2 (mix_q_c015_2 0) resistor r=1G
RINTI_c015_2 (mix_i_c015_2 Icar_c015_2) resistor r=1k
CINTI_c015_2 (Icar_c015_2 0) capacitor c=80p
RINTQ_c015_2 (mix_q_c015_2 Qcar_c015_2) resistor r=1k
CINTQ_c015_2 (Qcar_c015_2 0) capacitor c=80p

// bl015, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c015_3 (bl015 n_cbpf_c015_3) capacitor c=2.533029591058e-14
LBPF_c015_3 (n_cbpf_c015_3 bpf_c015_3) inductor l=1.000000000000e-06
RBPF_c015_3 (bpf_c015_3 0) resistor r=3.141592653590e+02
EMIXI_c015_3_00 (mix_i_src_c015_3_00 0 bpf_c015_3 0) vcvs gain=9.807852804032e-01
SMIXI_c015_3_00 (mix_i_src_c015_3_00 mix_i_c015_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_00 (mix_q_src_c015_3_00 0 bpf_c015_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_3_00 (mix_q_src_c015_3_00 mix_q_c015_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_01 (mix_i_src_c015_3_01 0 bpf_c015_3 0) vcvs gain=8.314696123025e-01
SMIXI_c015_3_01 (mix_i_src_c015_3_01 mix_i_c015_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_01 (mix_q_src_c015_3_01 0 bpf_c015_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_3_01 (mix_q_src_c015_3_01 mix_q_c015_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_02 (mix_i_src_c015_3_02 0 bpf_c015_3 0) vcvs gain=5.555702330196e-01
SMIXI_c015_3_02 (mix_i_src_c015_3_02 mix_i_c015_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_02 (mix_q_src_c015_3_02 0 bpf_c015_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_3_02 (mix_q_src_c015_3_02 mix_q_c015_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_03 (mix_i_src_c015_3_03 0 bpf_c015_3 0) vcvs gain=1.950903220161e-01
SMIXI_c015_3_03 (mix_i_src_c015_3_03 mix_i_c015_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_03 (mix_q_src_c015_3_03 0 bpf_c015_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_3_03 (mix_q_src_c015_3_03 mix_q_c015_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_04 (mix_i_src_c015_3_04 0 bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_3_04 (mix_i_src_c015_3_04 mix_i_c015_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_04 (mix_q_src_c015_3_04 0 bpf_c015_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c015_3_04 (mix_q_src_c015_3_04 mix_q_c015_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_05 (mix_i_src_c015_3_05 0 bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_3_05 (mix_i_src_c015_3_05 mix_i_c015_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_05 (mix_q_src_c015_3_05 0 bpf_c015_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c015_3_05 (mix_q_src_c015_3_05 mix_q_c015_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_06 (mix_i_src_c015_3_06 0 bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_3_06 (mix_i_src_c015_3_06 mix_i_c015_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_06 (mix_q_src_c015_3_06 0 bpf_c015_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c015_3_06 (mix_q_src_c015_3_06 mix_q_c015_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_07 (mix_i_src_c015_3_07 0 bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_3_07 (mix_i_src_c015_3_07 mix_i_c015_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_07 (mix_q_src_c015_3_07 0 bpf_c015_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c015_3_07 (mix_q_src_c015_3_07 mix_q_c015_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_08 (mix_i_src_c015_3_08 0 bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c015_3_08 (mix_i_src_c015_3_08 mix_i_c015_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_08 (mix_q_src_c015_3_08 0 bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_3_08 (mix_q_src_c015_3_08 mix_q_c015_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_09 (mix_i_src_c015_3_09 0 bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c015_3_09 (mix_i_src_c015_3_09 mix_i_c015_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_09 (mix_q_src_c015_3_09 0 bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_3_09 (mix_q_src_c015_3_09 mix_q_c015_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_10 (mix_i_src_c015_3_10 0 bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c015_3_10 (mix_i_src_c015_3_10 mix_i_c015_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_10 (mix_q_src_c015_3_10 0 bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_3_10 (mix_q_src_c015_3_10 mix_q_c015_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_11 (mix_i_src_c015_3_11 0 bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c015_3_11 (mix_i_src_c015_3_11 mix_i_c015_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_11 (mix_q_src_c015_3_11 0 bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_3_11 (mix_q_src_c015_3_11 mix_q_c015_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_12 (mix_i_src_c015_3_12 0 bpf_c015_3 0) vcvs gain=1.950903220161e-01
SMIXI_c015_3_12 (mix_i_src_c015_3_12 mix_i_c015_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_12 (mix_q_src_c015_3_12 0 bpf_c015_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c015_3_12 (mix_q_src_c015_3_12 mix_q_c015_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_13 (mix_i_src_c015_3_13 0 bpf_c015_3 0) vcvs gain=5.555702330196e-01
SMIXI_c015_3_13 (mix_i_src_c015_3_13 mix_i_c015_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_13 (mix_q_src_c015_3_13 0 bpf_c015_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c015_3_13 (mix_q_src_c015_3_13 mix_q_c015_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_14 (mix_i_src_c015_3_14 0 bpf_c015_3 0) vcvs gain=8.314696123025e-01
SMIXI_c015_3_14 (mix_i_src_c015_3_14 mix_i_c015_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_14 (mix_q_src_c015_3_14 0 bpf_c015_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c015_3_14 (mix_q_src_c015_3_14 mix_q_c015_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c015_3_15 (mix_i_src_c015_3_15 0 bpf_c015_3 0) vcvs gain=9.807852804032e-01
SMIXI_c015_3_15 (mix_i_src_c015_3_15 mix_i_c015_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c015_3_15 (mix_q_src_c015_3_15 0 bpf_c015_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c015_3_15 (mix_q_src_c015_3_15 mix_q_c015_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c015_3 (mix_i_c015_3 0) resistor r=1G
RMIXQ_c015_3 (mix_q_c015_3 0) resistor r=1G
RINTI_c015_3 (mix_i_c015_3 Icar_c015_3) resistor r=1k
CINTI_c015_3 (Icar_c015_3 0) capacitor c=80p
RINTQ_c015_3 (mix_q_c015_3 Qcar_c015_3) resistor r=1k
CINTQ_c015_3 (Qcar_c015_3 0) capacitor c=80p

// bl016, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c016_0 (bl016 n_cbpf_c016_0) capacitor c=4.052847345694e-13
LBPF_c016_0 (n_cbpf_c016_0 bpf_c016_0) inductor l=1.000000000000e-06
RBPF_c016_0 (bpf_c016_0 0) resistor r=7.853981633974e+01
EMIXI_c016_0_00 (mix_i_src_c016_0_00 0 bpf_c016_0 0) vcvs gain=9.807852804032e-01
SMIXI_c016_0_00 (mix_i_src_c016_0_00 mix_i_c016_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_00 (mix_q_src_c016_0_00 0 bpf_c016_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_0_00 (mix_q_src_c016_0_00 mix_q_c016_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_01 (mix_i_src_c016_0_01 0 bpf_c016_0 0) vcvs gain=8.314696123025e-01
SMIXI_c016_0_01 (mix_i_src_c016_0_01 mix_i_c016_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_01 (mix_q_src_c016_0_01 0 bpf_c016_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_0_01 (mix_q_src_c016_0_01 mix_q_c016_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_02 (mix_i_src_c016_0_02 0 bpf_c016_0 0) vcvs gain=5.555702330196e-01
SMIXI_c016_0_02 (mix_i_src_c016_0_02 mix_i_c016_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_02 (mix_q_src_c016_0_02 0 bpf_c016_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_0_02 (mix_q_src_c016_0_02 mix_q_c016_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_03 (mix_i_src_c016_0_03 0 bpf_c016_0 0) vcvs gain=1.950903220161e-01
SMIXI_c016_0_03 (mix_i_src_c016_0_03 mix_i_c016_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_03 (mix_q_src_c016_0_03 0 bpf_c016_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_0_03 (mix_q_src_c016_0_03 mix_q_c016_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_04 (mix_i_src_c016_0_04 0 bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_0_04 (mix_i_src_c016_0_04 mix_i_c016_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_04 (mix_q_src_c016_0_04 0 bpf_c016_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_0_04 (mix_q_src_c016_0_04 mix_q_c016_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_05 (mix_i_src_c016_0_05 0 bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_0_05 (mix_i_src_c016_0_05 mix_i_c016_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_05 (mix_q_src_c016_0_05 0 bpf_c016_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_0_05 (mix_q_src_c016_0_05 mix_q_c016_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_06 (mix_i_src_c016_0_06 0 bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_0_06 (mix_i_src_c016_0_06 mix_i_c016_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_06 (mix_q_src_c016_0_06 0 bpf_c016_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_0_06 (mix_q_src_c016_0_06 mix_q_c016_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_07 (mix_i_src_c016_0_07 0 bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_0_07 (mix_i_src_c016_0_07 mix_i_c016_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_07 (mix_q_src_c016_0_07 0 bpf_c016_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_0_07 (mix_q_src_c016_0_07 mix_q_c016_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_08 (mix_i_src_c016_0_08 0 bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_0_08 (mix_i_src_c016_0_08 mix_i_c016_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_08 (mix_q_src_c016_0_08 0 bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_0_08 (mix_q_src_c016_0_08 mix_q_c016_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_09 (mix_i_src_c016_0_09 0 bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_0_09 (mix_i_src_c016_0_09 mix_i_c016_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_09 (mix_q_src_c016_0_09 0 bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_0_09 (mix_q_src_c016_0_09 mix_q_c016_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_10 (mix_i_src_c016_0_10 0 bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_0_10 (mix_i_src_c016_0_10 mix_i_c016_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_10 (mix_q_src_c016_0_10 0 bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_0_10 (mix_q_src_c016_0_10 mix_q_c016_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_11 (mix_i_src_c016_0_11 0 bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_0_11 (mix_i_src_c016_0_11 mix_i_c016_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_11 (mix_q_src_c016_0_11 0 bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_0_11 (mix_q_src_c016_0_11 mix_q_c016_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_12 (mix_i_src_c016_0_12 0 bpf_c016_0 0) vcvs gain=1.950903220161e-01
SMIXI_c016_0_12 (mix_i_src_c016_0_12 mix_i_c016_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_12 (mix_q_src_c016_0_12 0 bpf_c016_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_0_12 (mix_q_src_c016_0_12 mix_q_c016_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_13 (mix_i_src_c016_0_13 0 bpf_c016_0 0) vcvs gain=5.555702330196e-01
SMIXI_c016_0_13 (mix_i_src_c016_0_13 mix_i_c016_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_13 (mix_q_src_c016_0_13 0 bpf_c016_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_0_13 (mix_q_src_c016_0_13 mix_q_c016_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_14 (mix_i_src_c016_0_14 0 bpf_c016_0 0) vcvs gain=8.314696123025e-01
SMIXI_c016_0_14 (mix_i_src_c016_0_14 mix_i_c016_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_14 (mix_q_src_c016_0_14 0 bpf_c016_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_0_14 (mix_q_src_c016_0_14 mix_q_c016_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_0_15 (mix_i_src_c016_0_15 0 bpf_c016_0 0) vcvs gain=9.807852804032e-01
SMIXI_c016_0_15 (mix_i_src_c016_0_15 mix_i_c016_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_0_15 (mix_q_src_c016_0_15 0 bpf_c016_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_0_15 (mix_q_src_c016_0_15 mix_q_c016_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c016_0 (mix_i_c016_0 0) resistor r=1G
RMIXQ_c016_0 (mix_q_c016_0 0) resistor r=1G
RINTI_c016_0 (mix_i_c016_0 Icar_c016_0) resistor r=1k
CINTI_c016_0 (Icar_c016_0 0) capacitor c=80p
RINTQ_c016_0 (mix_q_c016_0 Qcar_c016_0) resistor r=1k
CINTQ_c016_0 (Qcar_c016_0 0) capacitor c=80p

// bl016, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c016_1 (bl016 n_cbpf_c016_1) capacitor c=1.013211836423e-13
LBPF_c016_1 (n_cbpf_c016_1 bpf_c016_1) inductor l=1.000000000000e-06
RBPF_c016_1 (bpf_c016_1 0) resistor r=1.570796326795e+02
EMIXI_c016_1_00 (mix_i_src_c016_1_00 0 bpf_c016_1 0) vcvs gain=9.807852804032e-01
SMIXI_c016_1_00 (mix_i_src_c016_1_00 mix_i_c016_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_00 (mix_q_src_c016_1_00 0 bpf_c016_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_1_00 (mix_q_src_c016_1_00 mix_q_c016_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_01 (mix_i_src_c016_1_01 0 bpf_c016_1 0) vcvs gain=8.314696123025e-01
SMIXI_c016_1_01 (mix_i_src_c016_1_01 mix_i_c016_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_01 (mix_q_src_c016_1_01 0 bpf_c016_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_1_01 (mix_q_src_c016_1_01 mix_q_c016_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_02 (mix_i_src_c016_1_02 0 bpf_c016_1 0) vcvs gain=5.555702330196e-01
SMIXI_c016_1_02 (mix_i_src_c016_1_02 mix_i_c016_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_02 (mix_q_src_c016_1_02 0 bpf_c016_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_1_02 (mix_q_src_c016_1_02 mix_q_c016_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_03 (mix_i_src_c016_1_03 0 bpf_c016_1 0) vcvs gain=1.950903220161e-01
SMIXI_c016_1_03 (mix_i_src_c016_1_03 mix_i_c016_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_03 (mix_q_src_c016_1_03 0 bpf_c016_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_1_03 (mix_q_src_c016_1_03 mix_q_c016_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_04 (mix_i_src_c016_1_04 0 bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_1_04 (mix_i_src_c016_1_04 mix_i_c016_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_04 (mix_q_src_c016_1_04 0 bpf_c016_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_1_04 (mix_q_src_c016_1_04 mix_q_c016_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_05 (mix_i_src_c016_1_05 0 bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_1_05 (mix_i_src_c016_1_05 mix_i_c016_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_05 (mix_q_src_c016_1_05 0 bpf_c016_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_1_05 (mix_q_src_c016_1_05 mix_q_c016_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_06 (mix_i_src_c016_1_06 0 bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_1_06 (mix_i_src_c016_1_06 mix_i_c016_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_06 (mix_q_src_c016_1_06 0 bpf_c016_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_1_06 (mix_q_src_c016_1_06 mix_q_c016_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_07 (mix_i_src_c016_1_07 0 bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_1_07 (mix_i_src_c016_1_07 mix_i_c016_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_07 (mix_q_src_c016_1_07 0 bpf_c016_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_1_07 (mix_q_src_c016_1_07 mix_q_c016_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_08 (mix_i_src_c016_1_08 0 bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_1_08 (mix_i_src_c016_1_08 mix_i_c016_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_08 (mix_q_src_c016_1_08 0 bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_1_08 (mix_q_src_c016_1_08 mix_q_c016_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_09 (mix_i_src_c016_1_09 0 bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_1_09 (mix_i_src_c016_1_09 mix_i_c016_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_09 (mix_q_src_c016_1_09 0 bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_1_09 (mix_q_src_c016_1_09 mix_q_c016_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_10 (mix_i_src_c016_1_10 0 bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_1_10 (mix_i_src_c016_1_10 mix_i_c016_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_10 (mix_q_src_c016_1_10 0 bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_1_10 (mix_q_src_c016_1_10 mix_q_c016_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_11 (mix_i_src_c016_1_11 0 bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_1_11 (mix_i_src_c016_1_11 mix_i_c016_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_11 (mix_q_src_c016_1_11 0 bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_1_11 (mix_q_src_c016_1_11 mix_q_c016_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_12 (mix_i_src_c016_1_12 0 bpf_c016_1 0) vcvs gain=1.950903220161e-01
SMIXI_c016_1_12 (mix_i_src_c016_1_12 mix_i_c016_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_12 (mix_q_src_c016_1_12 0 bpf_c016_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_1_12 (mix_q_src_c016_1_12 mix_q_c016_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_13 (mix_i_src_c016_1_13 0 bpf_c016_1 0) vcvs gain=5.555702330196e-01
SMIXI_c016_1_13 (mix_i_src_c016_1_13 mix_i_c016_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_13 (mix_q_src_c016_1_13 0 bpf_c016_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_1_13 (mix_q_src_c016_1_13 mix_q_c016_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_14 (mix_i_src_c016_1_14 0 bpf_c016_1 0) vcvs gain=8.314696123025e-01
SMIXI_c016_1_14 (mix_i_src_c016_1_14 mix_i_c016_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_14 (mix_q_src_c016_1_14 0 bpf_c016_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_1_14 (mix_q_src_c016_1_14 mix_q_c016_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_1_15 (mix_i_src_c016_1_15 0 bpf_c016_1 0) vcvs gain=9.807852804032e-01
SMIXI_c016_1_15 (mix_i_src_c016_1_15 mix_i_c016_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_1_15 (mix_q_src_c016_1_15 0 bpf_c016_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_1_15 (mix_q_src_c016_1_15 mix_q_c016_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c016_1 (mix_i_c016_1 0) resistor r=1G
RMIXQ_c016_1 (mix_q_c016_1 0) resistor r=1G
RINTI_c016_1 (mix_i_c016_1 Icar_c016_1) resistor r=1k
CINTI_c016_1 (Icar_c016_1 0) capacitor c=80p
RINTQ_c016_1 (mix_q_c016_1 Qcar_c016_1) resistor r=1k
CINTQ_c016_1 (Qcar_c016_1 0) capacitor c=80p

// bl016, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c016_2 (bl016 n_cbpf_c016_2) capacitor c=4.503163717437e-14
LBPF_c016_2 (n_cbpf_c016_2 bpf_c016_2) inductor l=1.000000000000e-06
RBPF_c016_2 (bpf_c016_2 0) resistor r=2.356194490192e+02
EMIXI_c016_2_00 (mix_i_src_c016_2_00 0 bpf_c016_2 0) vcvs gain=9.807852804032e-01
SMIXI_c016_2_00 (mix_i_src_c016_2_00 mix_i_c016_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_00 (mix_q_src_c016_2_00 0 bpf_c016_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_2_00 (mix_q_src_c016_2_00 mix_q_c016_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_01 (mix_i_src_c016_2_01 0 bpf_c016_2 0) vcvs gain=8.314696123025e-01
SMIXI_c016_2_01 (mix_i_src_c016_2_01 mix_i_c016_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_01 (mix_q_src_c016_2_01 0 bpf_c016_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_2_01 (mix_q_src_c016_2_01 mix_q_c016_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_02 (mix_i_src_c016_2_02 0 bpf_c016_2 0) vcvs gain=5.555702330196e-01
SMIXI_c016_2_02 (mix_i_src_c016_2_02 mix_i_c016_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_02 (mix_q_src_c016_2_02 0 bpf_c016_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_2_02 (mix_q_src_c016_2_02 mix_q_c016_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_03 (mix_i_src_c016_2_03 0 bpf_c016_2 0) vcvs gain=1.950903220161e-01
SMIXI_c016_2_03 (mix_i_src_c016_2_03 mix_i_c016_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_03 (mix_q_src_c016_2_03 0 bpf_c016_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_2_03 (mix_q_src_c016_2_03 mix_q_c016_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_04 (mix_i_src_c016_2_04 0 bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_2_04 (mix_i_src_c016_2_04 mix_i_c016_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_04 (mix_q_src_c016_2_04 0 bpf_c016_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_2_04 (mix_q_src_c016_2_04 mix_q_c016_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_05 (mix_i_src_c016_2_05 0 bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_2_05 (mix_i_src_c016_2_05 mix_i_c016_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_05 (mix_q_src_c016_2_05 0 bpf_c016_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_2_05 (mix_q_src_c016_2_05 mix_q_c016_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_06 (mix_i_src_c016_2_06 0 bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_2_06 (mix_i_src_c016_2_06 mix_i_c016_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_06 (mix_q_src_c016_2_06 0 bpf_c016_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_2_06 (mix_q_src_c016_2_06 mix_q_c016_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_07 (mix_i_src_c016_2_07 0 bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_2_07 (mix_i_src_c016_2_07 mix_i_c016_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_07 (mix_q_src_c016_2_07 0 bpf_c016_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_2_07 (mix_q_src_c016_2_07 mix_q_c016_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_08 (mix_i_src_c016_2_08 0 bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_2_08 (mix_i_src_c016_2_08 mix_i_c016_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_08 (mix_q_src_c016_2_08 0 bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_2_08 (mix_q_src_c016_2_08 mix_q_c016_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_09 (mix_i_src_c016_2_09 0 bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_2_09 (mix_i_src_c016_2_09 mix_i_c016_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_09 (mix_q_src_c016_2_09 0 bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_2_09 (mix_q_src_c016_2_09 mix_q_c016_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_10 (mix_i_src_c016_2_10 0 bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_2_10 (mix_i_src_c016_2_10 mix_i_c016_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_10 (mix_q_src_c016_2_10 0 bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_2_10 (mix_q_src_c016_2_10 mix_q_c016_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_11 (mix_i_src_c016_2_11 0 bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_2_11 (mix_i_src_c016_2_11 mix_i_c016_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_11 (mix_q_src_c016_2_11 0 bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_2_11 (mix_q_src_c016_2_11 mix_q_c016_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_12 (mix_i_src_c016_2_12 0 bpf_c016_2 0) vcvs gain=1.950903220161e-01
SMIXI_c016_2_12 (mix_i_src_c016_2_12 mix_i_c016_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_12 (mix_q_src_c016_2_12 0 bpf_c016_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_2_12 (mix_q_src_c016_2_12 mix_q_c016_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_13 (mix_i_src_c016_2_13 0 bpf_c016_2 0) vcvs gain=5.555702330196e-01
SMIXI_c016_2_13 (mix_i_src_c016_2_13 mix_i_c016_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_13 (mix_q_src_c016_2_13 0 bpf_c016_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_2_13 (mix_q_src_c016_2_13 mix_q_c016_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_14 (mix_i_src_c016_2_14 0 bpf_c016_2 0) vcvs gain=8.314696123025e-01
SMIXI_c016_2_14 (mix_i_src_c016_2_14 mix_i_c016_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_14 (mix_q_src_c016_2_14 0 bpf_c016_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_2_14 (mix_q_src_c016_2_14 mix_q_c016_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_2_15 (mix_i_src_c016_2_15 0 bpf_c016_2 0) vcvs gain=9.807852804032e-01
SMIXI_c016_2_15 (mix_i_src_c016_2_15 mix_i_c016_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_2_15 (mix_q_src_c016_2_15 0 bpf_c016_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_2_15 (mix_q_src_c016_2_15 mix_q_c016_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c016_2 (mix_i_c016_2 0) resistor r=1G
RMIXQ_c016_2 (mix_q_c016_2 0) resistor r=1G
RINTI_c016_2 (mix_i_c016_2 Icar_c016_2) resistor r=1k
CINTI_c016_2 (Icar_c016_2 0) capacitor c=80p
RINTQ_c016_2 (mix_q_c016_2 Qcar_c016_2) resistor r=1k
CINTQ_c016_2 (Qcar_c016_2 0) capacitor c=80p

// bl016, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c016_3 (bl016 n_cbpf_c016_3) capacitor c=2.533029591058e-14
LBPF_c016_3 (n_cbpf_c016_3 bpf_c016_3) inductor l=1.000000000000e-06
RBPF_c016_3 (bpf_c016_3 0) resistor r=3.141592653590e+02
EMIXI_c016_3_00 (mix_i_src_c016_3_00 0 bpf_c016_3 0) vcvs gain=9.807852804032e-01
SMIXI_c016_3_00 (mix_i_src_c016_3_00 mix_i_c016_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_00 (mix_q_src_c016_3_00 0 bpf_c016_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_3_00 (mix_q_src_c016_3_00 mix_q_c016_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_01 (mix_i_src_c016_3_01 0 bpf_c016_3 0) vcvs gain=8.314696123025e-01
SMIXI_c016_3_01 (mix_i_src_c016_3_01 mix_i_c016_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_01 (mix_q_src_c016_3_01 0 bpf_c016_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_3_01 (mix_q_src_c016_3_01 mix_q_c016_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_02 (mix_i_src_c016_3_02 0 bpf_c016_3 0) vcvs gain=5.555702330196e-01
SMIXI_c016_3_02 (mix_i_src_c016_3_02 mix_i_c016_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_02 (mix_q_src_c016_3_02 0 bpf_c016_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_3_02 (mix_q_src_c016_3_02 mix_q_c016_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_03 (mix_i_src_c016_3_03 0 bpf_c016_3 0) vcvs gain=1.950903220161e-01
SMIXI_c016_3_03 (mix_i_src_c016_3_03 mix_i_c016_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_03 (mix_q_src_c016_3_03 0 bpf_c016_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_3_03 (mix_q_src_c016_3_03 mix_q_c016_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_04 (mix_i_src_c016_3_04 0 bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_3_04 (mix_i_src_c016_3_04 mix_i_c016_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_04 (mix_q_src_c016_3_04 0 bpf_c016_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c016_3_04 (mix_q_src_c016_3_04 mix_q_c016_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_05 (mix_i_src_c016_3_05 0 bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_3_05 (mix_i_src_c016_3_05 mix_i_c016_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_05 (mix_q_src_c016_3_05 0 bpf_c016_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c016_3_05 (mix_q_src_c016_3_05 mix_q_c016_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_06 (mix_i_src_c016_3_06 0 bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_3_06 (mix_i_src_c016_3_06 mix_i_c016_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_06 (mix_q_src_c016_3_06 0 bpf_c016_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c016_3_06 (mix_q_src_c016_3_06 mix_q_c016_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_07 (mix_i_src_c016_3_07 0 bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_3_07 (mix_i_src_c016_3_07 mix_i_c016_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_07 (mix_q_src_c016_3_07 0 bpf_c016_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c016_3_07 (mix_q_src_c016_3_07 mix_q_c016_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_08 (mix_i_src_c016_3_08 0 bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c016_3_08 (mix_i_src_c016_3_08 mix_i_c016_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_08 (mix_q_src_c016_3_08 0 bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_3_08 (mix_q_src_c016_3_08 mix_q_c016_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_09 (mix_i_src_c016_3_09 0 bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c016_3_09 (mix_i_src_c016_3_09 mix_i_c016_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_09 (mix_q_src_c016_3_09 0 bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_3_09 (mix_q_src_c016_3_09 mix_q_c016_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_10 (mix_i_src_c016_3_10 0 bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c016_3_10 (mix_i_src_c016_3_10 mix_i_c016_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_10 (mix_q_src_c016_3_10 0 bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_3_10 (mix_q_src_c016_3_10 mix_q_c016_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_11 (mix_i_src_c016_3_11 0 bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c016_3_11 (mix_i_src_c016_3_11 mix_i_c016_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_11 (mix_q_src_c016_3_11 0 bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_3_11 (mix_q_src_c016_3_11 mix_q_c016_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_12 (mix_i_src_c016_3_12 0 bpf_c016_3 0) vcvs gain=1.950903220161e-01
SMIXI_c016_3_12 (mix_i_src_c016_3_12 mix_i_c016_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_12 (mix_q_src_c016_3_12 0 bpf_c016_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c016_3_12 (mix_q_src_c016_3_12 mix_q_c016_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_13 (mix_i_src_c016_3_13 0 bpf_c016_3 0) vcvs gain=5.555702330196e-01
SMIXI_c016_3_13 (mix_i_src_c016_3_13 mix_i_c016_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_13 (mix_q_src_c016_3_13 0 bpf_c016_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c016_3_13 (mix_q_src_c016_3_13 mix_q_c016_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_14 (mix_i_src_c016_3_14 0 bpf_c016_3 0) vcvs gain=8.314696123025e-01
SMIXI_c016_3_14 (mix_i_src_c016_3_14 mix_i_c016_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_14 (mix_q_src_c016_3_14 0 bpf_c016_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c016_3_14 (mix_q_src_c016_3_14 mix_q_c016_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c016_3_15 (mix_i_src_c016_3_15 0 bpf_c016_3 0) vcvs gain=9.807852804032e-01
SMIXI_c016_3_15 (mix_i_src_c016_3_15 mix_i_c016_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c016_3_15 (mix_q_src_c016_3_15 0 bpf_c016_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c016_3_15 (mix_q_src_c016_3_15 mix_q_c016_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c016_3 (mix_i_c016_3 0) resistor r=1G
RMIXQ_c016_3 (mix_q_c016_3 0) resistor r=1G
RINTI_c016_3 (mix_i_c016_3 Icar_c016_3) resistor r=1k
CINTI_c016_3 (Icar_c016_3 0) capacitor c=80p
RINTQ_c016_3 (mix_q_c016_3 Qcar_c016_3) resistor r=1k
CINTQ_c016_3 (Qcar_c016_3 0) capacitor c=80p

// bl017, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c017_0 (bl017 n_cbpf_c017_0) capacitor c=4.052847345694e-13
LBPF_c017_0 (n_cbpf_c017_0 bpf_c017_0) inductor l=1.000000000000e-06
RBPF_c017_0 (bpf_c017_0 0) resistor r=7.853981633974e+01
EMIXI_c017_0_00 (mix_i_src_c017_0_00 0 bpf_c017_0 0) vcvs gain=9.807852804032e-01
SMIXI_c017_0_00 (mix_i_src_c017_0_00 mix_i_c017_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_00 (mix_q_src_c017_0_00 0 bpf_c017_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_0_00 (mix_q_src_c017_0_00 mix_q_c017_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_01 (mix_i_src_c017_0_01 0 bpf_c017_0 0) vcvs gain=8.314696123025e-01
SMIXI_c017_0_01 (mix_i_src_c017_0_01 mix_i_c017_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_01 (mix_q_src_c017_0_01 0 bpf_c017_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_0_01 (mix_q_src_c017_0_01 mix_q_c017_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_02 (mix_i_src_c017_0_02 0 bpf_c017_0 0) vcvs gain=5.555702330196e-01
SMIXI_c017_0_02 (mix_i_src_c017_0_02 mix_i_c017_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_02 (mix_q_src_c017_0_02 0 bpf_c017_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_0_02 (mix_q_src_c017_0_02 mix_q_c017_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_03 (mix_i_src_c017_0_03 0 bpf_c017_0 0) vcvs gain=1.950903220161e-01
SMIXI_c017_0_03 (mix_i_src_c017_0_03 mix_i_c017_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_03 (mix_q_src_c017_0_03 0 bpf_c017_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_0_03 (mix_q_src_c017_0_03 mix_q_c017_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_04 (mix_i_src_c017_0_04 0 bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_0_04 (mix_i_src_c017_0_04 mix_i_c017_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_04 (mix_q_src_c017_0_04 0 bpf_c017_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_0_04 (mix_q_src_c017_0_04 mix_q_c017_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_05 (mix_i_src_c017_0_05 0 bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_0_05 (mix_i_src_c017_0_05 mix_i_c017_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_05 (mix_q_src_c017_0_05 0 bpf_c017_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_0_05 (mix_q_src_c017_0_05 mix_q_c017_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_06 (mix_i_src_c017_0_06 0 bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_0_06 (mix_i_src_c017_0_06 mix_i_c017_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_06 (mix_q_src_c017_0_06 0 bpf_c017_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_0_06 (mix_q_src_c017_0_06 mix_q_c017_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_07 (mix_i_src_c017_0_07 0 bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_0_07 (mix_i_src_c017_0_07 mix_i_c017_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_07 (mix_q_src_c017_0_07 0 bpf_c017_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_0_07 (mix_q_src_c017_0_07 mix_q_c017_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_08 (mix_i_src_c017_0_08 0 bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_0_08 (mix_i_src_c017_0_08 mix_i_c017_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_08 (mix_q_src_c017_0_08 0 bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_0_08 (mix_q_src_c017_0_08 mix_q_c017_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_09 (mix_i_src_c017_0_09 0 bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_0_09 (mix_i_src_c017_0_09 mix_i_c017_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_09 (mix_q_src_c017_0_09 0 bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_0_09 (mix_q_src_c017_0_09 mix_q_c017_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_10 (mix_i_src_c017_0_10 0 bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_0_10 (mix_i_src_c017_0_10 mix_i_c017_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_10 (mix_q_src_c017_0_10 0 bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_0_10 (mix_q_src_c017_0_10 mix_q_c017_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_11 (mix_i_src_c017_0_11 0 bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_0_11 (mix_i_src_c017_0_11 mix_i_c017_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_11 (mix_q_src_c017_0_11 0 bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_0_11 (mix_q_src_c017_0_11 mix_q_c017_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_12 (mix_i_src_c017_0_12 0 bpf_c017_0 0) vcvs gain=1.950903220161e-01
SMIXI_c017_0_12 (mix_i_src_c017_0_12 mix_i_c017_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_12 (mix_q_src_c017_0_12 0 bpf_c017_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_0_12 (mix_q_src_c017_0_12 mix_q_c017_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_13 (mix_i_src_c017_0_13 0 bpf_c017_0 0) vcvs gain=5.555702330196e-01
SMIXI_c017_0_13 (mix_i_src_c017_0_13 mix_i_c017_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_13 (mix_q_src_c017_0_13 0 bpf_c017_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_0_13 (mix_q_src_c017_0_13 mix_q_c017_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_14 (mix_i_src_c017_0_14 0 bpf_c017_0 0) vcvs gain=8.314696123025e-01
SMIXI_c017_0_14 (mix_i_src_c017_0_14 mix_i_c017_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_14 (mix_q_src_c017_0_14 0 bpf_c017_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_0_14 (mix_q_src_c017_0_14 mix_q_c017_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_0_15 (mix_i_src_c017_0_15 0 bpf_c017_0 0) vcvs gain=9.807852804032e-01
SMIXI_c017_0_15 (mix_i_src_c017_0_15 mix_i_c017_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_0_15 (mix_q_src_c017_0_15 0 bpf_c017_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_0_15 (mix_q_src_c017_0_15 mix_q_c017_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c017_0 (mix_i_c017_0 0) resistor r=1G
RMIXQ_c017_0 (mix_q_c017_0 0) resistor r=1G
RINTI_c017_0 (mix_i_c017_0 Icar_c017_0) resistor r=1k
CINTI_c017_0 (Icar_c017_0 0) capacitor c=80p
RINTQ_c017_0 (mix_q_c017_0 Qcar_c017_0) resistor r=1k
CINTQ_c017_0 (Qcar_c017_0 0) capacitor c=80p

// bl017, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c017_1 (bl017 n_cbpf_c017_1) capacitor c=1.013211836423e-13
LBPF_c017_1 (n_cbpf_c017_1 bpf_c017_1) inductor l=1.000000000000e-06
RBPF_c017_1 (bpf_c017_1 0) resistor r=1.570796326795e+02
EMIXI_c017_1_00 (mix_i_src_c017_1_00 0 bpf_c017_1 0) vcvs gain=9.807852804032e-01
SMIXI_c017_1_00 (mix_i_src_c017_1_00 mix_i_c017_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_00 (mix_q_src_c017_1_00 0 bpf_c017_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_1_00 (mix_q_src_c017_1_00 mix_q_c017_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_01 (mix_i_src_c017_1_01 0 bpf_c017_1 0) vcvs gain=8.314696123025e-01
SMIXI_c017_1_01 (mix_i_src_c017_1_01 mix_i_c017_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_01 (mix_q_src_c017_1_01 0 bpf_c017_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_1_01 (mix_q_src_c017_1_01 mix_q_c017_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_02 (mix_i_src_c017_1_02 0 bpf_c017_1 0) vcvs gain=5.555702330196e-01
SMIXI_c017_1_02 (mix_i_src_c017_1_02 mix_i_c017_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_02 (mix_q_src_c017_1_02 0 bpf_c017_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_1_02 (mix_q_src_c017_1_02 mix_q_c017_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_03 (mix_i_src_c017_1_03 0 bpf_c017_1 0) vcvs gain=1.950903220161e-01
SMIXI_c017_1_03 (mix_i_src_c017_1_03 mix_i_c017_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_03 (mix_q_src_c017_1_03 0 bpf_c017_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_1_03 (mix_q_src_c017_1_03 mix_q_c017_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_04 (mix_i_src_c017_1_04 0 bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_1_04 (mix_i_src_c017_1_04 mix_i_c017_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_04 (mix_q_src_c017_1_04 0 bpf_c017_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_1_04 (mix_q_src_c017_1_04 mix_q_c017_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_05 (mix_i_src_c017_1_05 0 bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_1_05 (mix_i_src_c017_1_05 mix_i_c017_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_05 (mix_q_src_c017_1_05 0 bpf_c017_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_1_05 (mix_q_src_c017_1_05 mix_q_c017_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_06 (mix_i_src_c017_1_06 0 bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_1_06 (mix_i_src_c017_1_06 mix_i_c017_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_06 (mix_q_src_c017_1_06 0 bpf_c017_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_1_06 (mix_q_src_c017_1_06 mix_q_c017_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_07 (mix_i_src_c017_1_07 0 bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_1_07 (mix_i_src_c017_1_07 mix_i_c017_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_07 (mix_q_src_c017_1_07 0 bpf_c017_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_1_07 (mix_q_src_c017_1_07 mix_q_c017_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_08 (mix_i_src_c017_1_08 0 bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_1_08 (mix_i_src_c017_1_08 mix_i_c017_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_08 (mix_q_src_c017_1_08 0 bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_1_08 (mix_q_src_c017_1_08 mix_q_c017_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_09 (mix_i_src_c017_1_09 0 bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_1_09 (mix_i_src_c017_1_09 mix_i_c017_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_09 (mix_q_src_c017_1_09 0 bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_1_09 (mix_q_src_c017_1_09 mix_q_c017_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_10 (mix_i_src_c017_1_10 0 bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_1_10 (mix_i_src_c017_1_10 mix_i_c017_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_10 (mix_q_src_c017_1_10 0 bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_1_10 (mix_q_src_c017_1_10 mix_q_c017_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_11 (mix_i_src_c017_1_11 0 bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_1_11 (mix_i_src_c017_1_11 mix_i_c017_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_11 (mix_q_src_c017_1_11 0 bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_1_11 (mix_q_src_c017_1_11 mix_q_c017_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_12 (mix_i_src_c017_1_12 0 bpf_c017_1 0) vcvs gain=1.950903220161e-01
SMIXI_c017_1_12 (mix_i_src_c017_1_12 mix_i_c017_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_12 (mix_q_src_c017_1_12 0 bpf_c017_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_1_12 (mix_q_src_c017_1_12 mix_q_c017_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_13 (mix_i_src_c017_1_13 0 bpf_c017_1 0) vcvs gain=5.555702330196e-01
SMIXI_c017_1_13 (mix_i_src_c017_1_13 mix_i_c017_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_13 (mix_q_src_c017_1_13 0 bpf_c017_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_1_13 (mix_q_src_c017_1_13 mix_q_c017_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_14 (mix_i_src_c017_1_14 0 bpf_c017_1 0) vcvs gain=8.314696123025e-01
SMIXI_c017_1_14 (mix_i_src_c017_1_14 mix_i_c017_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_14 (mix_q_src_c017_1_14 0 bpf_c017_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_1_14 (mix_q_src_c017_1_14 mix_q_c017_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_1_15 (mix_i_src_c017_1_15 0 bpf_c017_1 0) vcvs gain=9.807852804032e-01
SMIXI_c017_1_15 (mix_i_src_c017_1_15 mix_i_c017_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_1_15 (mix_q_src_c017_1_15 0 bpf_c017_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_1_15 (mix_q_src_c017_1_15 mix_q_c017_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c017_1 (mix_i_c017_1 0) resistor r=1G
RMIXQ_c017_1 (mix_q_c017_1 0) resistor r=1G
RINTI_c017_1 (mix_i_c017_1 Icar_c017_1) resistor r=1k
CINTI_c017_1 (Icar_c017_1 0) capacitor c=80p
RINTQ_c017_1 (mix_q_c017_1 Qcar_c017_1) resistor r=1k
CINTQ_c017_1 (Qcar_c017_1 0) capacitor c=80p

// bl017, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c017_2 (bl017 n_cbpf_c017_2) capacitor c=4.503163717437e-14
LBPF_c017_2 (n_cbpf_c017_2 bpf_c017_2) inductor l=1.000000000000e-06
RBPF_c017_2 (bpf_c017_2 0) resistor r=2.356194490192e+02
EMIXI_c017_2_00 (mix_i_src_c017_2_00 0 bpf_c017_2 0) vcvs gain=9.807852804032e-01
SMIXI_c017_2_00 (mix_i_src_c017_2_00 mix_i_c017_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_00 (mix_q_src_c017_2_00 0 bpf_c017_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_2_00 (mix_q_src_c017_2_00 mix_q_c017_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_01 (mix_i_src_c017_2_01 0 bpf_c017_2 0) vcvs gain=8.314696123025e-01
SMIXI_c017_2_01 (mix_i_src_c017_2_01 mix_i_c017_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_01 (mix_q_src_c017_2_01 0 bpf_c017_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_2_01 (mix_q_src_c017_2_01 mix_q_c017_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_02 (mix_i_src_c017_2_02 0 bpf_c017_2 0) vcvs gain=5.555702330196e-01
SMIXI_c017_2_02 (mix_i_src_c017_2_02 mix_i_c017_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_02 (mix_q_src_c017_2_02 0 bpf_c017_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_2_02 (mix_q_src_c017_2_02 mix_q_c017_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_03 (mix_i_src_c017_2_03 0 bpf_c017_2 0) vcvs gain=1.950903220161e-01
SMIXI_c017_2_03 (mix_i_src_c017_2_03 mix_i_c017_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_03 (mix_q_src_c017_2_03 0 bpf_c017_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_2_03 (mix_q_src_c017_2_03 mix_q_c017_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_04 (mix_i_src_c017_2_04 0 bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_2_04 (mix_i_src_c017_2_04 mix_i_c017_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_04 (mix_q_src_c017_2_04 0 bpf_c017_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_2_04 (mix_q_src_c017_2_04 mix_q_c017_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_05 (mix_i_src_c017_2_05 0 bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_2_05 (mix_i_src_c017_2_05 mix_i_c017_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_05 (mix_q_src_c017_2_05 0 bpf_c017_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_2_05 (mix_q_src_c017_2_05 mix_q_c017_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_06 (mix_i_src_c017_2_06 0 bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_2_06 (mix_i_src_c017_2_06 mix_i_c017_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_06 (mix_q_src_c017_2_06 0 bpf_c017_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_2_06 (mix_q_src_c017_2_06 mix_q_c017_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_07 (mix_i_src_c017_2_07 0 bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_2_07 (mix_i_src_c017_2_07 mix_i_c017_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_07 (mix_q_src_c017_2_07 0 bpf_c017_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_2_07 (mix_q_src_c017_2_07 mix_q_c017_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_08 (mix_i_src_c017_2_08 0 bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_2_08 (mix_i_src_c017_2_08 mix_i_c017_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_08 (mix_q_src_c017_2_08 0 bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_2_08 (mix_q_src_c017_2_08 mix_q_c017_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_09 (mix_i_src_c017_2_09 0 bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_2_09 (mix_i_src_c017_2_09 mix_i_c017_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_09 (mix_q_src_c017_2_09 0 bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_2_09 (mix_q_src_c017_2_09 mix_q_c017_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_10 (mix_i_src_c017_2_10 0 bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_2_10 (mix_i_src_c017_2_10 mix_i_c017_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_10 (mix_q_src_c017_2_10 0 bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_2_10 (mix_q_src_c017_2_10 mix_q_c017_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_11 (mix_i_src_c017_2_11 0 bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_2_11 (mix_i_src_c017_2_11 mix_i_c017_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_11 (mix_q_src_c017_2_11 0 bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_2_11 (mix_q_src_c017_2_11 mix_q_c017_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_12 (mix_i_src_c017_2_12 0 bpf_c017_2 0) vcvs gain=1.950903220161e-01
SMIXI_c017_2_12 (mix_i_src_c017_2_12 mix_i_c017_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_12 (mix_q_src_c017_2_12 0 bpf_c017_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_2_12 (mix_q_src_c017_2_12 mix_q_c017_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_13 (mix_i_src_c017_2_13 0 bpf_c017_2 0) vcvs gain=5.555702330196e-01
SMIXI_c017_2_13 (mix_i_src_c017_2_13 mix_i_c017_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_13 (mix_q_src_c017_2_13 0 bpf_c017_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_2_13 (mix_q_src_c017_2_13 mix_q_c017_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_14 (mix_i_src_c017_2_14 0 bpf_c017_2 0) vcvs gain=8.314696123025e-01
SMIXI_c017_2_14 (mix_i_src_c017_2_14 mix_i_c017_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_14 (mix_q_src_c017_2_14 0 bpf_c017_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_2_14 (mix_q_src_c017_2_14 mix_q_c017_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_2_15 (mix_i_src_c017_2_15 0 bpf_c017_2 0) vcvs gain=9.807852804032e-01
SMIXI_c017_2_15 (mix_i_src_c017_2_15 mix_i_c017_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_2_15 (mix_q_src_c017_2_15 0 bpf_c017_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_2_15 (mix_q_src_c017_2_15 mix_q_c017_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c017_2 (mix_i_c017_2 0) resistor r=1G
RMIXQ_c017_2 (mix_q_c017_2 0) resistor r=1G
RINTI_c017_2 (mix_i_c017_2 Icar_c017_2) resistor r=1k
CINTI_c017_2 (Icar_c017_2 0) capacitor c=80p
RINTQ_c017_2 (mix_q_c017_2 Qcar_c017_2) resistor r=1k
CINTQ_c017_2 (Qcar_c017_2 0) capacitor c=80p

// bl017, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c017_3 (bl017 n_cbpf_c017_3) capacitor c=2.533029591058e-14
LBPF_c017_3 (n_cbpf_c017_3 bpf_c017_3) inductor l=1.000000000000e-06
RBPF_c017_3 (bpf_c017_3 0) resistor r=3.141592653590e+02
EMIXI_c017_3_00 (mix_i_src_c017_3_00 0 bpf_c017_3 0) vcvs gain=9.807852804032e-01
SMIXI_c017_3_00 (mix_i_src_c017_3_00 mix_i_c017_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_00 (mix_q_src_c017_3_00 0 bpf_c017_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_3_00 (mix_q_src_c017_3_00 mix_q_c017_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_01 (mix_i_src_c017_3_01 0 bpf_c017_3 0) vcvs gain=8.314696123025e-01
SMIXI_c017_3_01 (mix_i_src_c017_3_01 mix_i_c017_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_01 (mix_q_src_c017_3_01 0 bpf_c017_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_3_01 (mix_q_src_c017_3_01 mix_q_c017_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_02 (mix_i_src_c017_3_02 0 bpf_c017_3 0) vcvs gain=5.555702330196e-01
SMIXI_c017_3_02 (mix_i_src_c017_3_02 mix_i_c017_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_02 (mix_q_src_c017_3_02 0 bpf_c017_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_3_02 (mix_q_src_c017_3_02 mix_q_c017_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_03 (mix_i_src_c017_3_03 0 bpf_c017_3 0) vcvs gain=1.950903220161e-01
SMIXI_c017_3_03 (mix_i_src_c017_3_03 mix_i_c017_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_03 (mix_q_src_c017_3_03 0 bpf_c017_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_3_03 (mix_q_src_c017_3_03 mix_q_c017_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_04 (mix_i_src_c017_3_04 0 bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_3_04 (mix_i_src_c017_3_04 mix_i_c017_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_04 (mix_q_src_c017_3_04 0 bpf_c017_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c017_3_04 (mix_q_src_c017_3_04 mix_q_c017_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_05 (mix_i_src_c017_3_05 0 bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_3_05 (mix_i_src_c017_3_05 mix_i_c017_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_05 (mix_q_src_c017_3_05 0 bpf_c017_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c017_3_05 (mix_q_src_c017_3_05 mix_q_c017_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_06 (mix_i_src_c017_3_06 0 bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_3_06 (mix_i_src_c017_3_06 mix_i_c017_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_06 (mix_q_src_c017_3_06 0 bpf_c017_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c017_3_06 (mix_q_src_c017_3_06 mix_q_c017_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_07 (mix_i_src_c017_3_07 0 bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_3_07 (mix_i_src_c017_3_07 mix_i_c017_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_07 (mix_q_src_c017_3_07 0 bpf_c017_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c017_3_07 (mix_q_src_c017_3_07 mix_q_c017_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_08 (mix_i_src_c017_3_08 0 bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c017_3_08 (mix_i_src_c017_3_08 mix_i_c017_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_08 (mix_q_src_c017_3_08 0 bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_3_08 (mix_q_src_c017_3_08 mix_q_c017_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_09 (mix_i_src_c017_3_09 0 bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c017_3_09 (mix_i_src_c017_3_09 mix_i_c017_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_09 (mix_q_src_c017_3_09 0 bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_3_09 (mix_q_src_c017_3_09 mix_q_c017_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_10 (mix_i_src_c017_3_10 0 bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c017_3_10 (mix_i_src_c017_3_10 mix_i_c017_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_10 (mix_q_src_c017_3_10 0 bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_3_10 (mix_q_src_c017_3_10 mix_q_c017_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_11 (mix_i_src_c017_3_11 0 bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c017_3_11 (mix_i_src_c017_3_11 mix_i_c017_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_11 (mix_q_src_c017_3_11 0 bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_3_11 (mix_q_src_c017_3_11 mix_q_c017_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_12 (mix_i_src_c017_3_12 0 bpf_c017_3 0) vcvs gain=1.950903220161e-01
SMIXI_c017_3_12 (mix_i_src_c017_3_12 mix_i_c017_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_12 (mix_q_src_c017_3_12 0 bpf_c017_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c017_3_12 (mix_q_src_c017_3_12 mix_q_c017_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_13 (mix_i_src_c017_3_13 0 bpf_c017_3 0) vcvs gain=5.555702330196e-01
SMIXI_c017_3_13 (mix_i_src_c017_3_13 mix_i_c017_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_13 (mix_q_src_c017_3_13 0 bpf_c017_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c017_3_13 (mix_q_src_c017_3_13 mix_q_c017_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_14 (mix_i_src_c017_3_14 0 bpf_c017_3 0) vcvs gain=8.314696123025e-01
SMIXI_c017_3_14 (mix_i_src_c017_3_14 mix_i_c017_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_14 (mix_q_src_c017_3_14 0 bpf_c017_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c017_3_14 (mix_q_src_c017_3_14 mix_q_c017_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c017_3_15 (mix_i_src_c017_3_15 0 bpf_c017_3 0) vcvs gain=9.807852804032e-01
SMIXI_c017_3_15 (mix_i_src_c017_3_15 mix_i_c017_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c017_3_15 (mix_q_src_c017_3_15 0 bpf_c017_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c017_3_15 (mix_q_src_c017_3_15 mix_q_c017_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c017_3 (mix_i_c017_3 0) resistor r=1G
RMIXQ_c017_3 (mix_q_c017_3 0) resistor r=1G
RINTI_c017_3 (mix_i_c017_3 Icar_c017_3) resistor r=1k
CINTI_c017_3 (Icar_c017_3 0) capacitor c=80p
RINTQ_c017_3 (mix_q_c017_3 Qcar_c017_3) resistor r=1k
CINTQ_c017_3 (Qcar_c017_3 0) capacitor c=80p

// bl018, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c018_0 (bl018 n_cbpf_c018_0) capacitor c=4.052847345694e-13
LBPF_c018_0 (n_cbpf_c018_0 bpf_c018_0) inductor l=1.000000000000e-06
RBPF_c018_0 (bpf_c018_0 0) resistor r=7.853981633974e+01
EMIXI_c018_0_00 (mix_i_src_c018_0_00 0 bpf_c018_0 0) vcvs gain=9.807852804032e-01
SMIXI_c018_0_00 (mix_i_src_c018_0_00 mix_i_c018_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_00 (mix_q_src_c018_0_00 0 bpf_c018_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_0_00 (mix_q_src_c018_0_00 mix_q_c018_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_01 (mix_i_src_c018_0_01 0 bpf_c018_0 0) vcvs gain=8.314696123025e-01
SMIXI_c018_0_01 (mix_i_src_c018_0_01 mix_i_c018_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_01 (mix_q_src_c018_0_01 0 bpf_c018_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_0_01 (mix_q_src_c018_0_01 mix_q_c018_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_02 (mix_i_src_c018_0_02 0 bpf_c018_0 0) vcvs gain=5.555702330196e-01
SMIXI_c018_0_02 (mix_i_src_c018_0_02 mix_i_c018_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_02 (mix_q_src_c018_0_02 0 bpf_c018_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_0_02 (mix_q_src_c018_0_02 mix_q_c018_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_03 (mix_i_src_c018_0_03 0 bpf_c018_0 0) vcvs gain=1.950903220161e-01
SMIXI_c018_0_03 (mix_i_src_c018_0_03 mix_i_c018_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_03 (mix_q_src_c018_0_03 0 bpf_c018_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_0_03 (mix_q_src_c018_0_03 mix_q_c018_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_04 (mix_i_src_c018_0_04 0 bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_0_04 (mix_i_src_c018_0_04 mix_i_c018_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_04 (mix_q_src_c018_0_04 0 bpf_c018_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_0_04 (mix_q_src_c018_0_04 mix_q_c018_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_05 (mix_i_src_c018_0_05 0 bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_0_05 (mix_i_src_c018_0_05 mix_i_c018_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_05 (mix_q_src_c018_0_05 0 bpf_c018_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_0_05 (mix_q_src_c018_0_05 mix_q_c018_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_06 (mix_i_src_c018_0_06 0 bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_0_06 (mix_i_src_c018_0_06 mix_i_c018_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_06 (mix_q_src_c018_0_06 0 bpf_c018_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_0_06 (mix_q_src_c018_0_06 mix_q_c018_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_07 (mix_i_src_c018_0_07 0 bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_0_07 (mix_i_src_c018_0_07 mix_i_c018_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_07 (mix_q_src_c018_0_07 0 bpf_c018_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_0_07 (mix_q_src_c018_0_07 mix_q_c018_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_08 (mix_i_src_c018_0_08 0 bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_0_08 (mix_i_src_c018_0_08 mix_i_c018_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_08 (mix_q_src_c018_0_08 0 bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_0_08 (mix_q_src_c018_0_08 mix_q_c018_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_09 (mix_i_src_c018_0_09 0 bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_0_09 (mix_i_src_c018_0_09 mix_i_c018_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_09 (mix_q_src_c018_0_09 0 bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_0_09 (mix_q_src_c018_0_09 mix_q_c018_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_10 (mix_i_src_c018_0_10 0 bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_0_10 (mix_i_src_c018_0_10 mix_i_c018_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_10 (mix_q_src_c018_0_10 0 bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_0_10 (mix_q_src_c018_0_10 mix_q_c018_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_11 (mix_i_src_c018_0_11 0 bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_0_11 (mix_i_src_c018_0_11 mix_i_c018_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_11 (mix_q_src_c018_0_11 0 bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_0_11 (mix_q_src_c018_0_11 mix_q_c018_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_12 (mix_i_src_c018_0_12 0 bpf_c018_0 0) vcvs gain=1.950903220161e-01
SMIXI_c018_0_12 (mix_i_src_c018_0_12 mix_i_c018_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_12 (mix_q_src_c018_0_12 0 bpf_c018_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_0_12 (mix_q_src_c018_0_12 mix_q_c018_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_13 (mix_i_src_c018_0_13 0 bpf_c018_0 0) vcvs gain=5.555702330196e-01
SMIXI_c018_0_13 (mix_i_src_c018_0_13 mix_i_c018_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_13 (mix_q_src_c018_0_13 0 bpf_c018_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_0_13 (mix_q_src_c018_0_13 mix_q_c018_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_14 (mix_i_src_c018_0_14 0 bpf_c018_0 0) vcvs gain=8.314696123025e-01
SMIXI_c018_0_14 (mix_i_src_c018_0_14 mix_i_c018_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_14 (mix_q_src_c018_0_14 0 bpf_c018_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_0_14 (mix_q_src_c018_0_14 mix_q_c018_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_0_15 (mix_i_src_c018_0_15 0 bpf_c018_0 0) vcvs gain=9.807852804032e-01
SMIXI_c018_0_15 (mix_i_src_c018_0_15 mix_i_c018_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_0_15 (mix_q_src_c018_0_15 0 bpf_c018_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_0_15 (mix_q_src_c018_0_15 mix_q_c018_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c018_0 (mix_i_c018_0 0) resistor r=1G
RMIXQ_c018_0 (mix_q_c018_0 0) resistor r=1G
RINTI_c018_0 (mix_i_c018_0 Icar_c018_0) resistor r=1k
CINTI_c018_0 (Icar_c018_0 0) capacitor c=80p
RINTQ_c018_0 (mix_q_c018_0 Qcar_c018_0) resistor r=1k
CINTQ_c018_0 (Qcar_c018_0 0) capacitor c=80p

// bl018, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c018_1 (bl018 n_cbpf_c018_1) capacitor c=1.013211836423e-13
LBPF_c018_1 (n_cbpf_c018_1 bpf_c018_1) inductor l=1.000000000000e-06
RBPF_c018_1 (bpf_c018_1 0) resistor r=1.570796326795e+02
EMIXI_c018_1_00 (mix_i_src_c018_1_00 0 bpf_c018_1 0) vcvs gain=9.807852804032e-01
SMIXI_c018_1_00 (mix_i_src_c018_1_00 mix_i_c018_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_00 (mix_q_src_c018_1_00 0 bpf_c018_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_1_00 (mix_q_src_c018_1_00 mix_q_c018_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_01 (mix_i_src_c018_1_01 0 bpf_c018_1 0) vcvs gain=8.314696123025e-01
SMIXI_c018_1_01 (mix_i_src_c018_1_01 mix_i_c018_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_01 (mix_q_src_c018_1_01 0 bpf_c018_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_1_01 (mix_q_src_c018_1_01 mix_q_c018_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_02 (mix_i_src_c018_1_02 0 bpf_c018_1 0) vcvs gain=5.555702330196e-01
SMIXI_c018_1_02 (mix_i_src_c018_1_02 mix_i_c018_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_02 (mix_q_src_c018_1_02 0 bpf_c018_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_1_02 (mix_q_src_c018_1_02 mix_q_c018_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_03 (mix_i_src_c018_1_03 0 bpf_c018_1 0) vcvs gain=1.950903220161e-01
SMIXI_c018_1_03 (mix_i_src_c018_1_03 mix_i_c018_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_03 (mix_q_src_c018_1_03 0 bpf_c018_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_1_03 (mix_q_src_c018_1_03 mix_q_c018_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_04 (mix_i_src_c018_1_04 0 bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_1_04 (mix_i_src_c018_1_04 mix_i_c018_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_04 (mix_q_src_c018_1_04 0 bpf_c018_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_1_04 (mix_q_src_c018_1_04 mix_q_c018_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_05 (mix_i_src_c018_1_05 0 bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_1_05 (mix_i_src_c018_1_05 mix_i_c018_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_05 (mix_q_src_c018_1_05 0 bpf_c018_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_1_05 (mix_q_src_c018_1_05 mix_q_c018_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_06 (mix_i_src_c018_1_06 0 bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_1_06 (mix_i_src_c018_1_06 mix_i_c018_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_06 (mix_q_src_c018_1_06 0 bpf_c018_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_1_06 (mix_q_src_c018_1_06 mix_q_c018_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_07 (mix_i_src_c018_1_07 0 bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_1_07 (mix_i_src_c018_1_07 mix_i_c018_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_07 (mix_q_src_c018_1_07 0 bpf_c018_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_1_07 (mix_q_src_c018_1_07 mix_q_c018_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_08 (mix_i_src_c018_1_08 0 bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_1_08 (mix_i_src_c018_1_08 mix_i_c018_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_08 (mix_q_src_c018_1_08 0 bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_1_08 (mix_q_src_c018_1_08 mix_q_c018_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_09 (mix_i_src_c018_1_09 0 bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_1_09 (mix_i_src_c018_1_09 mix_i_c018_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_09 (mix_q_src_c018_1_09 0 bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_1_09 (mix_q_src_c018_1_09 mix_q_c018_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_10 (mix_i_src_c018_1_10 0 bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_1_10 (mix_i_src_c018_1_10 mix_i_c018_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_10 (mix_q_src_c018_1_10 0 bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_1_10 (mix_q_src_c018_1_10 mix_q_c018_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_11 (mix_i_src_c018_1_11 0 bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_1_11 (mix_i_src_c018_1_11 mix_i_c018_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_11 (mix_q_src_c018_1_11 0 bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_1_11 (mix_q_src_c018_1_11 mix_q_c018_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_12 (mix_i_src_c018_1_12 0 bpf_c018_1 0) vcvs gain=1.950903220161e-01
SMIXI_c018_1_12 (mix_i_src_c018_1_12 mix_i_c018_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_12 (mix_q_src_c018_1_12 0 bpf_c018_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_1_12 (mix_q_src_c018_1_12 mix_q_c018_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_13 (mix_i_src_c018_1_13 0 bpf_c018_1 0) vcvs gain=5.555702330196e-01
SMIXI_c018_1_13 (mix_i_src_c018_1_13 mix_i_c018_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_13 (mix_q_src_c018_1_13 0 bpf_c018_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_1_13 (mix_q_src_c018_1_13 mix_q_c018_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_14 (mix_i_src_c018_1_14 0 bpf_c018_1 0) vcvs gain=8.314696123025e-01
SMIXI_c018_1_14 (mix_i_src_c018_1_14 mix_i_c018_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_14 (mix_q_src_c018_1_14 0 bpf_c018_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_1_14 (mix_q_src_c018_1_14 mix_q_c018_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_1_15 (mix_i_src_c018_1_15 0 bpf_c018_1 0) vcvs gain=9.807852804032e-01
SMIXI_c018_1_15 (mix_i_src_c018_1_15 mix_i_c018_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_1_15 (mix_q_src_c018_1_15 0 bpf_c018_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_1_15 (mix_q_src_c018_1_15 mix_q_c018_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c018_1 (mix_i_c018_1 0) resistor r=1G
RMIXQ_c018_1 (mix_q_c018_1 0) resistor r=1G
RINTI_c018_1 (mix_i_c018_1 Icar_c018_1) resistor r=1k
CINTI_c018_1 (Icar_c018_1 0) capacitor c=80p
RINTQ_c018_1 (mix_q_c018_1 Qcar_c018_1) resistor r=1k
CINTQ_c018_1 (Qcar_c018_1 0) capacitor c=80p

// bl018, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c018_2 (bl018 n_cbpf_c018_2) capacitor c=4.503163717437e-14
LBPF_c018_2 (n_cbpf_c018_2 bpf_c018_2) inductor l=1.000000000000e-06
RBPF_c018_2 (bpf_c018_2 0) resistor r=2.356194490192e+02
EMIXI_c018_2_00 (mix_i_src_c018_2_00 0 bpf_c018_2 0) vcvs gain=9.807852804032e-01
SMIXI_c018_2_00 (mix_i_src_c018_2_00 mix_i_c018_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_00 (mix_q_src_c018_2_00 0 bpf_c018_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_2_00 (mix_q_src_c018_2_00 mix_q_c018_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_01 (mix_i_src_c018_2_01 0 bpf_c018_2 0) vcvs gain=8.314696123025e-01
SMIXI_c018_2_01 (mix_i_src_c018_2_01 mix_i_c018_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_01 (mix_q_src_c018_2_01 0 bpf_c018_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_2_01 (mix_q_src_c018_2_01 mix_q_c018_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_02 (mix_i_src_c018_2_02 0 bpf_c018_2 0) vcvs gain=5.555702330196e-01
SMIXI_c018_2_02 (mix_i_src_c018_2_02 mix_i_c018_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_02 (mix_q_src_c018_2_02 0 bpf_c018_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_2_02 (mix_q_src_c018_2_02 mix_q_c018_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_03 (mix_i_src_c018_2_03 0 bpf_c018_2 0) vcvs gain=1.950903220161e-01
SMIXI_c018_2_03 (mix_i_src_c018_2_03 mix_i_c018_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_03 (mix_q_src_c018_2_03 0 bpf_c018_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_2_03 (mix_q_src_c018_2_03 mix_q_c018_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_04 (mix_i_src_c018_2_04 0 bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_2_04 (mix_i_src_c018_2_04 mix_i_c018_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_04 (mix_q_src_c018_2_04 0 bpf_c018_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_2_04 (mix_q_src_c018_2_04 mix_q_c018_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_05 (mix_i_src_c018_2_05 0 bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_2_05 (mix_i_src_c018_2_05 mix_i_c018_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_05 (mix_q_src_c018_2_05 0 bpf_c018_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_2_05 (mix_q_src_c018_2_05 mix_q_c018_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_06 (mix_i_src_c018_2_06 0 bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_2_06 (mix_i_src_c018_2_06 mix_i_c018_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_06 (mix_q_src_c018_2_06 0 bpf_c018_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_2_06 (mix_q_src_c018_2_06 mix_q_c018_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_07 (mix_i_src_c018_2_07 0 bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_2_07 (mix_i_src_c018_2_07 mix_i_c018_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_07 (mix_q_src_c018_2_07 0 bpf_c018_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_2_07 (mix_q_src_c018_2_07 mix_q_c018_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_08 (mix_i_src_c018_2_08 0 bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_2_08 (mix_i_src_c018_2_08 mix_i_c018_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_08 (mix_q_src_c018_2_08 0 bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_2_08 (mix_q_src_c018_2_08 mix_q_c018_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_09 (mix_i_src_c018_2_09 0 bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_2_09 (mix_i_src_c018_2_09 mix_i_c018_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_09 (mix_q_src_c018_2_09 0 bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_2_09 (mix_q_src_c018_2_09 mix_q_c018_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_10 (mix_i_src_c018_2_10 0 bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_2_10 (mix_i_src_c018_2_10 mix_i_c018_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_10 (mix_q_src_c018_2_10 0 bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_2_10 (mix_q_src_c018_2_10 mix_q_c018_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_11 (mix_i_src_c018_2_11 0 bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_2_11 (mix_i_src_c018_2_11 mix_i_c018_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_11 (mix_q_src_c018_2_11 0 bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_2_11 (mix_q_src_c018_2_11 mix_q_c018_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_12 (mix_i_src_c018_2_12 0 bpf_c018_2 0) vcvs gain=1.950903220161e-01
SMIXI_c018_2_12 (mix_i_src_c018_2_12 mix_i_c018_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_12 (mix_q_src_c018_2_12 0 bpf_c018_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_2_12 (mix_q_src_c018_2_12 mix_q_c018_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_13 (mix_i_src_c018_2_13 0 bpf_c018_2 0) vcvs gain=5.555702330196e-01
SMIXI_c018_2_13 (mix_i_src_c018_2_13 mix_i_c018_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_13 (mix_q_src_c018_2_13 0 bpf_c018_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_2_13 (mix_q_src_c018_2_13 mix_q_c018_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_14 (mix_i_src_c018_2_14 0 bpf_c018_2 0) vcvs gain=8.314696123025e-01
SMIXI_c018_2_14 (mix_i_src_c018_2_14 mix_i_c018_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_14 (mix_q_src_c018_2_14 0 bpf_c018_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_2_14 (mix_q_src_c018_2_14 mix_q_c018_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_2_15 (mix_i_src_c018_2_15 0 bpf_c018_2 0) vcvs gain=9.807852804032e-01
SMIXI_c018_2_15 (mix_i_src_c018_2_15 mix_i_c018_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_2_15 (mix_q_src_c018_2_15 0 bpf_c018_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_2_15 (mix_q_src_c018_2_15 mix_q_c018_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c018_2 (mix_i_c018_2 0) resistor r=1G
RMIXQ_c018_2 (mix_q_c018_2 0) resistor r=1G
RINTI_c018_2 (mix_i_c018_2 Icar_c018_2) resistor r=1k
CINTI_c018_2 (Icar_c018_2 0) capacitor c=80p
RINTQ_c018_2 (mix_q_c018_2 Qcar_c018_2) resistor r=1k
CINTQ_c018_2 (Qcar_c018_2 0) capacitor c=80p

// bl018, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c018_3 (bl018 n_cbpf_c018_3) capacitor c=2.533029591058e-14
LBPF_c018_3 (n_cbpf_c018_3 bpf_c018_3) inductor l=1.000000000000e-06
RBPF_c018_3 (bpf_c018_3 0) resistor r=3.141592653590e+02
EMIXI_c018_3_00 (mix_i_src_c018_3_00 0 bpf_c018_3 0) vcvs gain=9.807852804032e-01
SMIXI_c018_3_00 (mix_i_src_c018_3_00 mix_i_c018_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_00 (mix_q_src_c018_3_00 0 bpf_c018_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_3_00 (mix_q_src_c018_3_00 mix_q_c018_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_01 (mix_i_src_c018_3_01 0 bpf_c018_3 0) vcvs gain=8.314696123025e-01
SMIXI_c018_3_01 (mix_i_src_c018_3_01 mix_i_c018_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_01 (mix_q_src_c018_3_01 0 bpf_c018_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_3_01 (mix_q_src_c018_3_01 mix_q_c018_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_02 (mix_i_src_c018_3_02 0 bpf_c018_3 0) vcvs gain=5.555702330196e-01
SMIXI_c018_3_02 (mix_i_src_c018_3_02 mix_i_c018_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_02 (mix_q_src_c018_3_02 0 bpf_c018_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_3_02 (mix_q_src_c018_3_02 mix_q_c018_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_03 (mix_i_src_c018_3_03 0 bpf_c018_3 0) vcvs gain=1.950903220161e-01
SMIXI_c018_3_03 (mix_i_src_c018_3_03 mix_i_c018_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_03 (mix_q_src_c018_3_03 0 bpf_c018_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_3_03 (mix_q_src_c018_3_03 mix_q_c018_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_04 (mix_i_src_c018_3_04 0 bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_3_04 (mix_i_src_c018_3_04 mix_i_c018_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_04 (mix_q_src_c018_3_04 0 bpf_c018_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c018_3_04 (mix_q_src_c018_3_04 mix_q_c018_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_05 (mix_i_src_c018_3_05 0 bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_3_05 (mix_i_src_c018_3_05 mix_i_c018_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_05 (mix_q_src_c018_3_05 0 bpf_c018_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c018_3_05 (mix_q_src_c018_3_05 mix_q_c018_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_06 (mix_i_src_c018_3_06 0 bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_3_06 (mix_i_src_c018_3_06 mix_i_c018_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_06 (mix_q_src_c018_3_06 0 bpf_c018_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c018_3_06 (mix_q_src_c018_3_06 mix_q_c018_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_07 (mix_i_src_c018_3_07 0 bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_3_07 (mix_i_src_c018_3_07 mix_i_c018_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_07 (mix_q_src_c018_3_07 0 bpf_c018_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c018_3_07 (mix_q_src_c018_3_07 mix_q_c018_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_08 (mix_i_src_c018_3_08 0 bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c018_3_08 (mix_i_src_c018_3_08 mix_i_c018_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_08 (mix_q_src_c018_3_08 0 bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_3_08 (mix_q_src_c018_3_08 mix_q_c018_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_09 (mix_i_src_c018_3_09 0 bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c018_3_09 (mix_i_src_c018_3_09 mix_i_c018_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_09 (mix_q_src_c018_3_09 0 bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_3_09 (mix_q_src_c018_3_09 mix_q_c018_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_10 (mix_i_src_c018_3_10 0 bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c018_3_10 (mix_i_src_c018_3_10 mix_i_c018_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_10 (mix_q_src_c018_3_10 0 bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_3_10 (mix_q_src_c018_3_10 mix_q_c018_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_11 (mix_i_src_c018_3_11 0 bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c018_3_11 (mix_i_src_c018_3_11 mix_i_c018_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_11 (mix_q_src_c018_3_11 0 bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_3_11 (mix_q_src_c018_3_11 mix_q_c018_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_12 (mix_i_src_c018_3_12 0 bpf_c018_3 0) vcvs gain=1.950903220161e-01
SMIXI_c018_3_12 (mix_i_src_c018_3_12 mix_i_c018_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_12 (mix_q_src_c018_3_12 0 bpf_c018_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c018_3_12 (mix_q_src_c018_3_12 mix_q_c018_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_13 (mix_i_src_c018_3_13 0 bpf_c018_3 0) vcvs gain=5.555702330196e-01
SMIXI_c018_3_13 (mix_i_src_c018_3_13 mix_i_c018_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_13 (mix_q_src_c018_3_13 0 bpf_c018_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c018_3_13 (mix_q_src_c018_3_13 mix_q_c018_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_14 (mix_i_src_c018_3_14 0 bpf_c018_3 0) vcvs gain=8.314696123025e-01
SMIXI_c018_3_14 (mix_i_src_c018_3_14 mix_i_c018_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_14 (mix_q_src_c018_3_14 0 bpf_c018_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c018_3_14 (mix_q_src_c018_3_14 mix_q_c018_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c018_3_15 (mix_i_src_c018_3_15 0 bpf_c018_3 0) vcvs gain=9.807852804032e-01
SMIXI_c018_3_15 (mix_i_src_c018_3_15 mix_i_c018_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c018_3_15 (mix_q_src_c018_3_15 0 bpf_c018_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c018_3_15 (mix_q_src_c018_3_15 mix_q_c018_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c018_3 (mix_i_c018_3 0) resistor r=1G
RMIXQ_c018_3 (mix_q_c018_3 0) resistor r=1G
RINTI_c018_3 (mix_i_c018_3 Icar_c018_3) resistor r=1k
CINTI_c018_3 (Icar_c018_3 0) capacitor c=80p
RINTQ_c018_3 (mix_q_c018_3 Qcar_c018_3) resistor r=1k
CINTQ_c018_3 (Qcar_c018_3 0) capacitor c=80p

// bl019, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c019_0 (bl019 n_cbpf_c019_0) capacitor c=4.052847345694e-13
LBPF_c019_0 (n_cbpf_c019_0 bpf_c019_0) inductor l=1.000000000000e-06
RBPF_c019_0 (bpf_c019_0 0) resistor r=7.853981633974e+01
EMIXI_c019_0_00 (mix_i_src_c019_0_00 0 bpf_c019_0 0) vcvs gain=9.807852804032e-01
SMIXI_c019_0_00 (mix_i_src_c019_0_00 mix_i_c019_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_00 (mix_q_src_c019_0_00 0 bpf_c019_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_0_00 (mix_q_src_c019_0_00 mix_q_c019_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_01 (mix_i_src_c019_0_01 0 bpf_c019_0 0) vcvs gain=8.314696123025e-01
SMIXI_c019_0_01 (mix_i_src_c019_0_01 mix_i_c019_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_01 (mix_q_src_c019_0_01 0 bpf_c019_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_0_01 (mix_q_src_c019_0_01 mix_q_c019_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_02 (mix_i_src_c019_0_02 0 bpf_c019_0 0) vcvs gain=5.555702330196e-01
SMIXI_c019_0_02 (mix_i_src_c019_0_02 mix_i_c019_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_02 (mix_q_src_c019_0_02 0 bpf_c019_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_0_02 (mix_q_src_c019_0_02 mix_q_c019_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_03 (mix_i_src_c019_0_03 0 bpf_c019_0 0) vcvs gain=1.950903220161e-01
SMIXI_c019_0_03 (mix_i_src_c019_0_03 mix_i_c019_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_03 (mix_q_src_c019_0_03 0 bpf_c019_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_0_03 (mix_q_src_c019_0_03 mix_q_c019_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_04 (mix_i_src_c019_0_04 0 bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_0_04 (mix_i_src_c019_0_04 mix_i_c019_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_04 (mix_q_src_c019_0_04 0 bpf_c019_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_0_04 (mix_q_src_c019_0_04 mix_q_c019_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_05 (mix_i_src_c019_0_05 0 bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_0_05 (mix_i_src_c019_0_05 mix_i_c019_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_05 (mix_q_src_c019_0_05 0 bpf_c019_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_0_05 (mix_q_src_c019_0_05 mix_q_c019_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_06 (mix_i_src_c019_0_06 0 bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_0_06 (mix_i_src_c019_0_06 mix_i_c019_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_06 (mix_q_src_c019_0_06 0 bpf_c019_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_0_06 (mix_q_src_c019_0_06 mix_q_c019_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_07 (mix_i_src_c019_0_07 0 bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_0_07 (mix_i_src_c019_0_07 mix_i_c019_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_07 (mix_q_src_c019_0_07 0 bpf_c019_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_0_07 (mix_q_src_c019_0_07 mix_q_c019_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_08 (mix_i_src_c019_0_08 0 bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_0_08 (mix_i_src_c019_0_08 mix_i_c019_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_08 (mix_q_src_c019_0_08 0 bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_0_08 (mix_q_src_c019_0_08 mix_q_c019_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_09 (mix_i_src_c019_0_09 0 bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_0_09 (mix_i_src_c019_0_09 mix_i_c019_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_09 (mix_q_src_c019_0_09 0 bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_0_09 (mix_q_src_c019_0_09 mix_q_c019_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_10 (mix_i_src_c019_0_10 0 bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_0_10 (mix_i_src_c019_0_10 mix_i_c019_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_10 (mix_q_src_c019_0_10 0 bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_0_10 (mix_q_src_c019_0_10 mix_q_c019_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_11 (mix_i_src_c019_0_11 0 bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_0_11 (mix_i_src_c019_0_11 mix_i_c019_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_11 (mix_q_src_c019_0_11 0 bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_0_11 (mix_q_src_c019_0_11 mix_q_c019_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_12 (mix_i_src_c019_0_12 0 bpf_c019_0 0) vcvs gain=1.950903220161e-01
SMIXI_c019_0_12 (mix_i_src_c019_0_12 mix_i_c019_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_12 (mix_q_src_c019_0_12 0 bpf_c019_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_0_12 (mix_q_src_c019_0_12 mix_q_c019_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_13 (mix_i_src_c019_0_13 0 bpf_c019_0 0) vcvs gain=5.555702330196e-01
SMIXI_c019_0_13 (mix_i_src_c019_0_13 mix_i_c019_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_13 (mix_q_src_c019_0_13 0 bpf_c019_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_0_13 (mix_q_src_c019_0_13 mix_q_c019_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_14 (mix_i_src_c019_0_14 0 bpf_c019_0 0) vcvs gain=8.314696123025e-01
SMIXI_c019_0_14 (mix_i_src_c019_0_14 mix_i_c019_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_14 (mix_q_src_c019_0_14 0 bpf_c019_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_0_14 (mix_q_src_c019_0_14 mix_q_c019_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_0_15 (mix_i_src_c019_0_15 0 bpf_c019_0 0) vcvs gain=9.807852804032e-01
SMIXI_c019_0_15 (mix_i_src_c019_0_15 mix_i_c019_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_0_15 (mix_q_src_c019_0_15 0 bpf_c019_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_0_15 (mix_q_src_c019_0_15 mix_q_c019_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c019_0 (mix_i_c019_0 0) resistor r=1G
RMIXQ_c019_0 (mix_q_c019_0 0) resistor r=1G
RINTI_c019_0 (mix_i_c019_0 Icar_c019_0) resistor r=1k
CINTI_c019_0 (Icar_c019_0 0) capacitor c=80p
RINTQ_c019_0 (mix_q_c019_0 Qcar_c019_0) resistor r=1k
CINTQ_c019_0 (Qcar_c019_0 0) capacitor c=80p

// bl019, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c019_1 (bl019 n_cbpf_c019_1) capacitor c=1.013211836423e-13
LBPF_c019_1 (n_cbpf_c019_1 bpf_c019_1) inductor l=1.000000000000e-06
RBPF_c019_1 (bpf_c019_1 0) resistor r=1.570796326795e+02
EMIXI_c019_1_00 (mix_i_src_c019_1_00 0 bpf_c019_1 0) vcvs gain=9.807852804032e-01
SMIXI_c019_1_00 (mix_i_src_c019_1_00 mix_i_c019_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_00 (mix_q_src_c019_1_00 0 bpf_c019_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_1_00 (mix_q_src_c019_1_00 mix_q_c019_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_01 (mix_i_src_c019_1_01 0 bpf_c019_1 0) vcvs gain=8.314696123025e-01
SMIXI_c019_1_01 (mix_i_src_c019_1_01 mix_i_c019_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_01 (mix_q_src_c019_1_01 0 bpf_c019_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_1_01 (mix_q_src_c019_1_01 mix_q_c019_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_02 (mix_i_src_c019_1_02 0 bpf_c019_1 0) vcvs gain=5.555702330196e-01
SMIXI_c019_1_02 (mix_i_src_c019_1_02 mix_i_c019_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_02 (mix_q_src_c019_1_02 0 bpf_c019_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_1_02 (mix_q_src_c019_1_02 mix_q_c019_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_03 (mix_i_src_c019_1_03 0 bpf_c019_1 0) vcvs gain=1.950903220161e-01
SMIXI_c019_1_03 (mix_i_src_c019_1_03 mix_i_c019_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_03 (mix_q_src_c019_1_03 0 bpf_c019_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_1_03 (mix_q_src_c019_1_03 mix_q_c019_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_04 (mix_i_src_c019_1_04 0 bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_1_04 (mix_i_src_c019_1_04 mix_i_c019_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_04 (mix_q_src_c019_1_04 0 bpf_c019_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_1_04 (mix_q_src_c019_1_04 mix_q_c019_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_05 (mix_i_src_c019_1_05 0 bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_1_05 (mix_i_src_c019_1_05 mix_i_c019_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_05 (mix_q_src_c019_1_05 0 bpf_c019_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_1_05 (mix_q_src_c019_1_05 mix_q_c019_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_06 (mix_i_src_c019_1_06 0 bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_1_06 (mix_i_src_c019_1_06 mix_i_c019_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_06 (mix_q_src_c019_1_06 0 bpf_c019_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_1_06 (mix_q_src_c019_1_06 mix_q_c019_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_07 (mix_i_src_c019_1_07 0 bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_1_07 (mix_i_src_c019_1_07 mix_i_c019_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_07 (mix_q_src_c019_1_07 0 bpf_c019_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_1_07 (mix_q_src_c019_1_07 mix_q_c019_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_08 (mix_i_src_c019_1_08 0 bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_1_08 (mix_i_src_c019_1_08 mix_i_c019_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_08 (mix_q_src_c019_1_08 0 bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_1_08 (mix_q_src_c019_1_08 mix_q_c019_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_09 (mix_i_src_c019_1_09 0 bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_1_09 (mix_i_src_c019_1_09 mix_i_c019_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_09 (mix_q_src_c019_1_09 0 bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_1_09 (mix_q_src_c019_1_09 mix_q_c019_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_10 (mix_i_src_c019_1_10 0 bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_1_10 (mix_i_src_c019_1_10 mix_i_c019_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_10 (mix_q_src_c019_1_10 0 bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_1_10 (mix_q_src_c019_1_10 mix_q_c019_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_11 (mix_i_src_c019_1_11 0 bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_1_11 (mix_i_src_c019_1_11 mix_i_c019_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_11 (mix_q_src_c019_1_11 0 bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_1_11 (mix_q_src_c019_1_11 mix_q_c019_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_12 (mix_i_src_c019_1_12 0 bpf_c019_1 0) vcvs gain=1.950903220161e-01
SMIXI_c019_1_12 (mix_i_src_c019_1_12 mix_i_c019_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_12 (mix_q_src_c019_1_12 0 bpf_c019_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_1_12 (mix_q_src_c019_1_12 mix_q_c019_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_13 (mix_i_src_c019_1_13 0 bpf_c019_1 0) vcvs gain=5.555702330196e-01
SMIXI_c019_1_13 (mix_i_src_c019_1_13 mix_i_c019_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_13 (mix_q_src_c019_1_13 0 bpf_c019_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_1_13 (mix_q_src_c019_1_13 mix_q_c019_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_14 (mix_i_src_c019_1_14 0 bpf_c019_1 0) vcvs gain=8.314696123025e-01
SMIXI_c019_1_14 (mix_i_src_c019_1_14 mix_i_c019_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_14 (mix_q_src_c019_1_14 0 bpf_c019_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_1_14 (mix_q_src_c019_1_14 mix_q_c019_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_1_15 (mix_i_src_c019_1_15 0 bpf_c019_1 0) vcvs gain=9.807852804032e-01
SMIXI_c019_1_15 (mix_i_src_c019_1_15 mix_i_c019_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_1_15 (mix_q_src_c019_1_15 0 bpf_c019_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_1_15 (mix_q_src_c019_1_15 mix_q_c019_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c019_1 (mix_i_c019_1 0) resistor r=1G
RMIXQ_c019_1 (mix_q_c019_1 0) resistor r=1G
RINTI_c019_1 (mix_i_c019_1 Icar_c019_1) resistor r=1k
CINTI_c019_1 (Icar_c019_1 0) capacitor c=80p
RINTQ_c019_1 (mix_q_c019_1 Qcar_c019_1) resistor r=1k
CINTQ_c019_1 (Qcar_c019_1 0) capacitor c=80p

// bl019, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c019_2 (bl019 n_cbpf_c019_2) capacitor c=4.503163717437e-14
LBPF_c019_2 (n_cbpf_c019_2 bpf_c019_2) inductor l=1.000000000000e-06
RBPF_c019_2 (bpf_c019_2 0) resistor r=2.356194490192e+02
EMIXI_c019_2_00 (mix_i_src_c019_2_00 0 bpf_c019_2 0) vcvs gain=9.807852804032e-01
SMIXI_c019_2_00 (mix_i_src_c019_2_00 mix_i_c019_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_00 (mix_q_src_c019_2_00 0 bpf_c019_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_2_00 (mix_q_src_c019_2_00 mix_q_c019_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_01 (mix_i_src_c019_2_01 0 bpf_c019_2 0) vcvs gain=8.314696123025e-01
SMIXI_c019_2_01 (mix_i_src_c019_2_01 mix_i_c019_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_01 (mix_q_src_c019_2_01 0 bpf_c019_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_2_01 (mix_q_src_c019_2_01 mix_q_c019_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_02 (mix_i_src_c019_2_02 0 bpf_c019_2 0) vcvs gain=5.555702330196e-01
SMIXI_c019_2_02 (mix_i_src_c019_2_02 mix_i_c019_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_02 (mix_q_src_c019_2_02 0 bpf_c019_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_2_02 (mix_q_src_c019_2_02 mix_q_c019_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_03 (mix_i_src_c019_2_03 0 bpf_c019_2 0) vcvs gain=1.950903220161e-01
SMIXI_c019_2_03 (mix_i_src_c019_2_03 mix_i_c019_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_03 (mix_q_src_c019_2_03 0 bpf_c019_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_2_03 (mix_q_src_c019_2_03 mix_q_c019_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_04 (mix_i_src_c019_2_04 0 bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_2_04 (mix_i_src_c019_2_04 mix_i_c019_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_04 (mix_q_src_c019_2_04 0 bpf_c019_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_2_04 (mix_q_src_c019_2_04 mix_q_c019_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_05 (mix_i_src_c019_2_05 0 bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_2_05 (mix_i_src_c019_2_05 mix_i_c019_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_05 (mix_q_src_c019_2_05 0 bpf_c019_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_2_05 (mix_q_src_c019_2_05 mix_q_c019_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_06 (mix_i_src_c019_2_06 0 bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_2_06 (mix_i_src_c019_2_06 mix_i_c019_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_06 (mix_q_src_c019_2_06 0 bpf_c019_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_2_06 (mix_q_src_c019_2_06 mix_q_c019_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_07 (mix_i_src_c019_2_07 0 bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_2_07 (mix_i_src_c019_2_07 mix_i_c019_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_07 (mix_q_src_c019_2_07 0 bpf_c019_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_2_07 (mix_q_src_c019_2_07 mix_q_c019_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_08 (mix_i_src_c019_2_08 0 bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_2_08 (mix_i_src_c019_2_08 mix_i_c019_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_08 (mix_q_src_c019_2_08 0 bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_2_08 (mix_q_src_c019_2_08 mix_q_c019_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_09 (mix_i_src_c019_2_09 0 bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_2_09 (mix_i_src_c019_2_09 mix_i_c019_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_09 (mix_q_src_c019_2_09 0 bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_2_09 (mix_q_src_c019_2_09 mix_q_c019_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_10 (mix_i_src_c019_2_10 0 bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_2_10 (mix_i_src_c019_2_10 mix_i_c019_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_10 (mix_q_src_c019_2_10 0 bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_2_10 (mix_q_src_c019_2_10 mix_q_c019_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_11 (mix_i_src_c019_2_11 0 bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_2_11 (mix_i_src_c019_2_11 mix_i_c019_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_11 (mix_q_src_c019_2_11 0 bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_2_11 (mix_q_src_c019_2_11 mix_q_c019_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_12 (mix_i_src_c019_2_12 0 bpf_c019_2 0) vcvs gain=1.950903220161e-01
SMIXI_c019_2_12 (mix_i_src_c019_2_12 mix_i_c019_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_12 (mix_q_src_c019_2_12 0 bpf_c019_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_2_12 (mix_q_src_c019_2_12 mix_q_c019_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_13 (mix_i_src_c019_2_13 0 bpf_c019_2 0) vcvs gain=5.555702330196e-01
SMIXI_c019_2_13 (mix_i_src_c019_2_13 mix_i_c019_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_13 (mix_q_src_c019_2_13 0 bpf_c019_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_2_13 (mix_q_src_c019_2_13 mix_q_c019_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_14 (mix_i_src_c019_2_14 0 bpf_c019_2 0) vcvs gain=8.314696123025e-01
SMIXI_c019_2_14 (mix_i_src_c019_2_14 mix_i_c019_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_14 (mix_q_src_c019_2_14 0 bpf_c019_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_2_14 (mix_q_src_c019_2_14 mix_q_c019_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_2_15 (mix_i_src_c019_2_15 0 bpf_c019_2 0) vcvs gain=9.807852804032e-01
SMIXI_c019_2_15 (mix_i_src_c019_2_15 mix_i_c019_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_2_15 (mix_q_src_c019_2_15 0 bpf_c019_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_2_15 (mix_q_src_c019_2_15 mix_q_c019_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c019_2 (mix_i_c019_2 0) resistor r=1G
RMIXQ_c019_2 (mix_q_c019_2 0) resistor r=1G
RINTI_c019_2 (mix_i_c019_2 Icar_c019_2) resistor r=1k
CINTI_c019_2 (Icar_c019_2 0) capacitor c=80p
RINTQ_c019_2 (mix_q_c019_2 Qcar_c019_2) resistor r=1k
CINTQ_c019_2 (Qcar_c019_2 0) capacitor c=80p

// bl019, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c019_3 (bl019 n_cbpf_c019_3) capacitor c=2.533029591058e-14
LBPF_c019_3 (n_cbpf_c019_3 bpf_c019_3) inductor l=1.000000000000e-06
RBPF_c019_3 (bpf_c019_3 0) resistor r=3.141592653590e+02
EMIXI_c019_3_00 (mix_i_src_c019_3_00 0 bpf_c019_3 0) vcvs gain=9.807852804032e-01
SMIXI_c019_3_00 (mix_i_src_c019_3_00 mix_i_c019_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_00 (mix_q_src_c019_3_00 0 bpf_c019_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_3_00 (mix_q_src_c019_3_00 mix_q_c019_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_01 (mix_i_src_c019_3_01 0 bpf_c019_3 0) vcvs gain=8.314696123025e-01
SMIXI_c019_3_01 (mix_i_src_c019_3_01 mix_i_c019_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_01 (mix_q_src_c019_3_01 0 bpf_c019_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_3_01 (mix_q_src_c019_3_01 mix_q_c019_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_02 (mix_i_src_c019_3_02 0 bpf_c019_3 0) vcvs gain=5.555702330196e-01
SMIXI_c019_3_02 (mix_i_src_c019_3_02 mix_i_c019_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_02 (mix_q_src_c019_3_02 0 bpf_c019_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_3_02 (mix_q_src_c019_3_02 mix_q_c019_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_03 (mix_i_src_c019_3_03 0 bpf_c019_3 0) vcvs gain=1.950903220161e-01
SMIXI_c019_3_03 (mix_i_src_c019_3_03 mix_i_c019_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_03 (mix_q_src_c019_3_03 0 bpf_c019_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_3_03 (mix_q_src_c019_3_03 mix_q_c019_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_04 (mix_i_src_c019_3_04 0 bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_3_04 (mix_i_src_c019_3_04 mix_i_c019_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_04 (mix_q_src_c019_3_04 0 bpf_c019_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c019_3_04 (mix_q_src_c019_3_04 mix_q_c019_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_05 (mix_i_src_c019_3_05 0 bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_3_05 (mix_i_src_c019_3_05 mix_i_c019_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_05 (mix_q_src_c019_3_05 0 bpf_c019_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c019_3_05 (mix_q_src_c019_3_05 mix_q_c019_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_06 (mix_i_src_c019_3_06 0 bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_3_06 (mix_i_src_c019_3_06 mix_i_c019_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_06 (mix_q_src_c019_3_06 0 bpf_c019_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c019_3_06 (mix_q_src_c019_3_06 mix_q_c019_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_07 (mix_i_src_c019_3_07 0 bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_3_07 (mix_i_src_c019_3_07 mix_i_c019_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_07 (mix_q_src_c019_3_07 0 bpf_c019_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c019_3_07 (mix_q_src_c019_3_07 mix_q_c019_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_08 (mix_i_src_c019_3_08 0 bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c019_3_08 (mix_i_src_c019_3_08 mix_i_c019_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_08 (mix_q_src_c019_3_08 0 bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_3_08 (mix_q_src_c019_3_08 mix_q_c019_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_09 (mix_i_src_c019_3_09 0 bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c019_3_09 (mix_i_src_c019_3_09 mix_i_c019_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_09 (mix_q_src_c019_3_09 0 bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_3_09 (mix_q_src_c019_3_09 mix_q_c019_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_10 (mix_i_src_c019_3_10 0 bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c019_3_10 (mix_i_src_c019_3_10 mix_i_c019_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_10 (mix_q_src_c019_3_10 0 bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_3_10 (mix_q_src_c019_3_10 mix_q_c019_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_11 (mix_i_src_c019_3_11 0 bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c019_3_11 (mix_i_src_c019_3_11 mix_i_c019_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_11 (mix_q_src_c019_3_11 0 bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_3_11 (mix_q_src_c019_3_11 mix_q_c019_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_12 (mix_i_src_c019_3_12 0 bpf_c019_3 0) vcvs gain=1.950903220161e-01
SMIXI_c019_3_12 (mix_i_src_c019_3_12 mix_i_c019_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_12 (mix_q_src_c019_3_12 0 bpf_c019_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c019_3_12 (mix_q_src_c019_3_12 mix_q_c019_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_13 (mix_i_src_c019_3_13 0 bpf_c019_3 0) vcvs gain=5.555702330196e-01
SMIXI_c019_3_13 (mix_i_src_c019_3_13 mix_i_c019_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_13 (mix_q_src_c019_3_13 0 bpf_c019_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c019_3_13 (mix_q_src_c019_3_13 mix_q_c019_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_14 (mix_i_src_c019_3_14 0 bpf_c019_3 0) vcvs gain=8.314696123025e-01
SMIXI_c019_3_14 (mix_i_src_c019_3_14 mix_i_c019_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_14 (mix_q_src_c019_3_14 0 bpf_c019_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c019_3_14 (mix_q_src_c019_3_14 mix_q_c019_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c019_3_15 (mix_i_src_c019_3_15 0 bpf_c019_3 0) vcvs gain=9.807852804032e-01
SMIXI_c019_3_15 (mix_i_src_c019_3_15 mix_i_c019_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c019_3_15 (mix_q_src_c019_3_15 0 bpf_c019_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c019_3_15 (mix_q_src_c019_3_15 mix_q_c019_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c019_3 (mix_i_c019_3 0) resistor r=1G
RMIXQ_c019_3 (mix_q_c019_3 0) resistor r=1G
RINTI_c019_3 (mix_i_c019_3 Icar_c019_3) resistor r=1k
CINTI_c019_3 (Icar_c019_3 0) capacitor c=80p
RINTQ_c019_3 (mix_q_c019_3 Qcar_c019_3) resistor r=1k
CINTQ_c019_3 (Qcar_c019_3 0) capacitor c=80p

// bl020, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c020_0 (bl020 n_cbpf_c020_0) capacitor c=4.052847345694e-13
LBPF_c020_0 (n_cbpf_c020_0 bpf_c020_0) inductor l=1.000000000000e-06
RBPF_c020_0 (bpf_c020_0 0) resistor r=7.853981633974e+01
EMIXI_c020_0_00 (mix_i_src_c020_0_00 0 bpf_c020_0 0) vcvs gain=9.807852804032e-01
SMIXI_c020_0_00 (mix_i_src_c020_0_00 mix_i_c020_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_00 (mix_q_src_c020_0_00 0 bpf_c020_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_0_00 (mix_q_src_c020_0_00 mix_q_c020_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_01 (mix_i_src_c020_0_01 0 bpf_c020_0 0) vcvs gain=8.314696123025e-01
SMIXI_c020_0_01 (mix_i_src_c020_0_01 mix_i_c020_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_01 (mix_q_src_c020_0_01 0 bpf_c020_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_0_01 (mix_q_src_c020_0_01 mix_q_c020_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_02 (mix_i_src_c020_0_02 0 bpf_c020_0 0) vcvs gain=5.555702330196e-01
SMIXI_c020_0_02 (mix_i_src_c020_0_02 mix_i_c020_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_02 (mix_q_src_c020_0_02 0 bpf_c020_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_0_02 (mix_q_src_c020_0_02 mix_q_c020_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_03 (mix_i_src_c020_0_03 0 bpf_c020_0 0) vcvs gain=1.950903220161e-01
SMIXI_c020_0_03 (mix_i_src_c020_0_03 mix_i_c020_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_03 (mix_q_src_c020_0_03 0 bpf_c020_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_0_03 (mix_q_src_c020_0_03 mix_q_c020_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_04 (mix_i_src_c020_0_04 0 bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_0_04 (mix_i_src_c020_0_04 mix_i_c020_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_04 (mix_q_src_c020_0_04 0 bpf_c020_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_0_04 (mix_q_src_c020_0_04 mix_q_c020_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_05 (mix_i_src_c020_0_05 0 bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_0_05 (mix_i_src_c020_0_05 mix_i_c020_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_05 (mix_q_src_c020_0_05 0 bpf_c020_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_0_05 (mix_q_src_c020_0_05 mix_q_c020_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_06 (mix_i_src_c020_0_06 0 bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_0_06 (mix_i_src_c020_0_06 mix_i_c020_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_06 (mix_q_src_c020_0_06 0 bpf_c020_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_0_06 (mix_q_src_c020_0_06 mix_q_c020_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_07 (mix_i_src_c020_0_07 0 bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_0_07 (mix_i_src_c020_0_07 mix_i_c020_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_07 (mix_q_src_c020_0_07 0 bpf_c020_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_0_07 (mix_q_src_c020_0_07 mix_q_c020_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_08 (mix_i_src_c020_0_08 0 bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_0_08 (mix_i_src_c020_0_08 mix_i_c020_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_08 (mix_q_src_c020_0_08 0 bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_0_08 (mix_q_src_c020_0_08 mix_q_c020_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_09 (mix_i_src_c020_0_09 0 bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_0_09 (mix_i_src_c020_0_09 mix_i_c020_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_09 (mix_q_src_c020_0_09 0 bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_0_09 (mix_q_src_c020_0_09 mix_q_c020_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_10 (mix_i_src_c020_0_10 0 bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_0_10 (mix_i_src_c020_0_10 mix_i_c020_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_10 (mix_q_src_c020_0_10 0 bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_0_10 (mix_q_src_c020_0_10 mix_q_c020_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_11 (mix_i_src_c020_0_11 0 bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_0_11 (mix_i_src_c020_0_11 mix_i_c020_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_11 (mix_q_src_c020_0_11 0 bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_0_11 (mix_q_src_c020_0_11 mix_q_c020_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_12 (mix_i_src_c020_0_12 0 bpf_c020_0 0) vcvs gain=1.950903220161e-01
SMIXI_c020_0_12 (mix_i_src_c020_0_12 mix_i_c020_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_12 (mix_q_src_c020_0_12 0 bpf_c020_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_0_12 (mix_q_src_c020_0_12 mix_q_c020_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_13 (mix_i_src_c020_0_13 0 bpf_c020_0 0) vcvs gain=5.555702330196e-01
SMIXI_c020_0_13 (mix_i_src_c020_0_13 mix_i_c020_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_13 (mix_q_src_c020_0_13 0 bpf_c020_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_0_13 (mix_q_src_c020_0_13 mix_q_c020_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_14 (mix_i_src_c020_0_14 0 bpf_c020_0 0) vcvs gain=8.314696123025e-01
SMIXI_c020_0_14 (mix_i_src_c020_0_14 mix_i_c020_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_14 (mix_q_src_c020_0_14 0 bpf_c020_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_0_14 (mix_q_src_c020_0_14 mix_q_c020_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_0_15 (mix_i_src_c020_0_15 0 bpf_c020_0 0) vcvs gain=9.807852804032e-01
SMIXI_c020_0_15 (mix_i_src_c020_0_15 mix_i_c020_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_0_15 (mix_q_src_c020_0_15 0 bpf_c020_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_0_15 (mix_q_src_c020_0_15 mix_q_c020_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c020_0 (mix_i_c020_0 0) resistor r=1G
RMIXQ_c020_0 (mix_q_c020_0 0) resistor r=1G
RINTI_c020_0 (mix_i_c020_0 Icar_c020_0) resistor r=1k
CINTI_c020_0 (Icar_c020_0 0) capacitor c=80p
RINTQ_c020_0 (mix_q_c020_0 Qcar_c020_0) resistor r=1k
CINTQ_c020_0 (Qcar_c020_0 0) capacitor c=80p

// bl020, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c020_1 (bl020 n_cbpf_c020_1) capacitor c=1.013211836423e-13
LBPF_c020_1 (n_cbpf_c020_1 bpf_c020_1) inductor l=1.000000000000e-06
RBPF_c020_1 (bpf_c020_1 0) resistor r=1.570796326795e+02
EMIXI_c020_1_00 (mix_i_src_c020_1_00 0 bpf_c020_1 0) vcvs gain=9.807852804032e-01
SMIXI_c020_1_00 (mix_i_src_c020_1_00 mix_i_c020_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_00 (mix_q_src_c020_1_00 0 bpf_c020_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_1_00 (mix_q_src_c020_1_00 mix_q_c020_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_01 (mix_i_src_c020_1_01 0 bpf_c020_1 0) vcvs gain=8.314696123025e-01
SMIXI_c020_1_01 (mix_i_src_c020_1_01 mix_i_c020_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_01 (mix_q_src_c020_1_01 0 bpf_c020_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_1_01 (mix_q_src_c020_1_01 mix_q_c020_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_02 (mix_i_src_c020_1_02 0 bpf_c020_1 0) vcvs gain=5.555702330196e-01
SMIXI_c020_1_02 (mix_i_src_c020_1_02 mix_i_c020_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_02 (mix_q_src_c020_1_02 0 bpf_c020_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_1_02 (mix_q_src_c020_1_02 mix_q_c020_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_03 (mix_i_src_c020_1_03 0 bpf_c020_1 0) vcvs gain=1.950903220161e-01
SMIXI_c020_1_03 (mix_i_src_c020_1_03 mix_i_c020_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_03 (mix_q_src_c020_1_03 0 bpf_c020_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_1_03 (mix_q_src_c020_1_03 mix_q_c020_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_04 (mix_i_src_c020_1_04 0 bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_1_04 (mix_i_src_c020_1_04 mix_i_c020_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_04 (mix_q_src_c020_1_04 0 bpf_c020_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_1_04 (mix_q_src_c020_1_04 mix_q_c020_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_05 (mix_i_src_c020_1_05 0 bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_1_05 (mix_i_src_c020_1_05 mix_i_c020_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_05 (mix_q_src_c020_1_05 0 bpf_c020_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_1_05 (mix_q_src_c020_1_05 mix_q_c020_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_06 (mix_i_src_c020_1_06 0 bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_1_06 (mix_i_src_c020_1_06 mix_i_c020_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_06 (mix_q_src_c020_1_06 0 bpf_c020_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_1_06 (mix_q_src_c020_1_06 mix_q_c020_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_07 (mix_i_src_c020_1_07 0 bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_1_07 (mix_i_src_c020_1_07 mix_i_c020_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_07 (mix_q_src_c020_1_07 0 bpf_c020_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_1_07 (mix_q_src_c020_1_07 mix_q_c020_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_08 (mix_i_src_c020_1_08 0 bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_1_08 (mix_i_src_c020_1_08 mix_i_c020_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_08 (mix_q_src_c020_1_08 0 bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_1_08 (mix_q_src_c020_1_08 mix_q_c020_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_09 (mix_i_src_c020_1_09 0 bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_1_09 (mix_i_src_c020_1_09 mix_i_c020_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_09 (mix_q_src_c020_1_09 0 bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_1_09 (mix_q_src_c020_1_09 mix_q_c020_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_10 (mix_i_src_c020_1_10 0 bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_1_10 (mix_i_src_c020_1_10 mix_i_c020_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_10 (mix_q_src_c020_1_10 0 bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_1_10 (mix_q_src_c020_1_10 mix_q_c020_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_11 (mix_i_src_c020_1_11 0 bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_1_11 (mix_i_src_c020_1_11 mix_i_c020_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_11 (mix_q_src_c020_1_11 0 bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_1_11 (mix_q_src_c020_1_11 mix_q_c020_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_12 (mix_i_src_c020_1_12 0 bpf_c020_1 0) vcvs gain=1.950903220161e-01
SMIXI_c020_1_12 (mix_i_src_c020_1_12 mix_i_c020_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_12 (mix_q_src_c020_1_12 0 bpf_c020_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_1_12 (mix_q_src_c020_1_12 mix_q_c020_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_13 (mix_i_src_c020_1_13 0 bpf_c020_1 0) vcvs gain=5.555702330196e-01
SMIXI_c020_1_13 (mix_i_src_c020_1_13 mix_i_c020_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_13 (mix_q_src_c020_1_13 0 bpf_c020_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_1_13 (mix_q_src_c020_1_13 mix_q_c020_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_14 (mix_i_src_c020_1_14 0 bpf_c020_1 0) vcvs gain=8.314696123025e-01
SMIXI_c020_1_14 (mix_i_src_c020_1_14 mix_i_c020_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_14 (mix_q_src_c020_1_14 0 bpf_c020_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_1_14 (mix_q_src_c020_1_14 mix_q_c020_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_1_15 (mix_i_src_c020_1_15 0 bpf_c020_1 0) vcvs gain=9.807852804032e-01
SMIXI_c020_1_15 (mix_i_src_c020_1_15 mix_i_c020_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_1_15 (mix_q_src_c020_1_15 0 bpf_c020_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_1_15 (mix_q_src_c020_1_15 mix_q_c020_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c020_1 (mix_i_c020_1 0) resistor r=1G
RMIXQ_c020_1 (mix_q_c020_1 0) resistor r=1G
RINTI_c020_1 (mix_i_c020_1 Icar_c020_1) resistor r=1k
CINTI_c020_1 (Icar_c020_1 0) capacitor c=80p
RINTQ_c020_1 (mix_q_c020_1 Qcar_c020_1) resistor r=1k
CINTQ_c020_1 (Qcar_c020_1 0) capacitor c=80p

// bl020, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c020_2 (bl020 n_cbpf_c020_2) capacitor c=4.503163717437e-14
LBPF_c020_2 (n_cbpf_c020_2 bpf_c020_2) inductor l=1.000000000000e-06
RBPF_c020_2 (bpf_c020_2 0) resistor r=2.356194490192e+02
EMIXI_c020_2_00 (mix_i_src_c020_2_00 0 bpf_c020_2 0) vcvs gain=9.807852804032e-01
SMIXI_c020_2_00 (mix_i_src_c020_2_00 mix_i_c020_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_00 (mix_q_src_c020_2_00 0 bpf_c020_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_2_00 (mix_q_src_c020_2_00 mix_q_c020_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_01 (mix_i_src_c020_2_01 0 bpf_c020_2 0) vcvs gain=8.314696123025e-01
SMIXI_c020_2_01 (mix_i_src_c020_2_01 mix_i_c020_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_01 (mix_q_src_c020_2_01 0 bpf_c020_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_2_01 (mix_q_src_c020_2_01 mix_q_c020_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_02 (mix_i_src_c020_2_02 0 bpf_c020_2 0) vcvs gain=5.555702330196e-01
SMIXI_c020_2_02 (mix_i_src_c020_2_02 mix_i_c020_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_02 (mix_q_src_c020_2_02 0 bpf_c020_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_2_02 (mix_q_src_c020_2_02 mix_q_c020_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_03 (mix_i_src_c020_2_03 0 bpf_c020_2 0) vcvs gain=1.950903220161e-01
SMIXI_c020_2_03 (mix_i_src_c020_2_03 mix_i_c020_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_03 (mix_q_src_c020_2_03 0 bpf_c020_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_2_03 (mix_q_src_c020_2_03 mix_q_c020_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_04 (mix_i_src_c020_2_04 0 bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_2_04 (mix_i_src_c020_2_04 mix_i_c020_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_04 (mix_q_src_c020_2_04 0 bpf_c020_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_2_04 (mix_q_src_c020_2_04 mix_q_c020_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_05 (mix_i_src_c020_2_05 0 bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_2_05 (mix_i_src_c020_2_05 mix_i_c020_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_05 (mix_q_src_c020_2_05 0 bpf_c020_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_2_05 (mix_q_src_c020_2_05 mix_q_c020_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_06 (mix_i_src_c020_2_06 0 bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_2_06 (mix_i_src_c020_2_06 mix_i_c020_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_06 (mix_q_src_c020_2_06 0 bpf_c020_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_2_06 (mix_q_src_c020_2_06 mix_q_c020_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_07 (mix_i_src_c020_2_07 0 bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_2_07 (mix_i_src_c020_2_07 mix_i_c020_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_07 (mix_q_src_c020_2_07 0 bpf_c020_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_2_07 (mix_q_src_c020_2_07 mix_q_c020_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_08 (mix_i_src_c020_2_08 0 bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_2_08 (mix_i_src_c020_2_08 mix_i_c020_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_08 (mix_q_src_c020_2_08 0 bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_2_08 (mix_q_src_c020_2_08 mix_q_c020_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_09 (mix_i_src_c020_2_09 0 bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_2_09 (mix_i_src_c020_2_09 mix_i_c020_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_09 (mix_q_src_c020_2_09 0 bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_2_09 (mix_q_src_c020_2_09 mix_q_c020_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_10 (mix_i_src_c020_2_10 0 bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_2_10 (mix_i_src_c020_2_10 mix_i_c020_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_10 (mix_q_src_c020_2_10 0 bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_2_10 (mix_q_src_c020_2_10 mix_q_c020_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_11 (mix_i_src_c020_2_11 0 bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_2_11 (mix_i_src_c020_2_11 mix_i_c020_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_11 (mix_q_src_c020_2_11 0 bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_2_11 (mix_q_src_c020_2_11 mix_q_c020_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_12 (mix_i_src_c020_2_12 0 bpf_c020_2 0) vcvs gain=1.950903220161e-01
SMIXI_c020_2_12 (mix_i_src_c020_2_12 mix_i_c020_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_12 (mix_q_src_c020_2_12 0 bpf_c020_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_2_12 (mix_q_src_c020_2_12 mix_q_c020_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_13 (mix_i_src_c020_2_13 0 bpf_c020_2 0) vcvs gain=5.555702330196e-01
SMIXI_c020_2_13 (mix_i_src_c020_2_13 mix_i_c020_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_13 (mix_q_src_c020_2_13 0 bpf_c020_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_2_13 (mix_q_src_c020_2_13 mix_q_c020_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_14 (mix_i_src_c020_2_14 0 bpf_c020_2 0) vcvs gain=8.314696123025e-01
SMIXI_c020_2_14 (mix_i_src_c020_2_14 mix_i_c020_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_14 (mix_q_src_c020_2_14 0 bpf_c020_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_2_14 (mix_q_src_c020_2_14 mix_q_c020_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_2_15 (mix_i_src_c020_2_15 0 bpf_c020_2 0) vcvs gain=9.807852804032e-01
SMIXI_c020_2_15 (mix_i_src_c020_2_15 mix_i_c020_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_2_15 (mix_q_src_c020_2_15 0 bpf_c020_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_2_15 (mix_q_src_c020_2_15 mix_q_c020_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c020_2 (mix_i_c020_2 0) resistor r=1G
RMIXQ_c020_2 (mix_q_c020_2 0) resistor r=1G
RINTI_c020_2 (mix_i_c020_2 Icar_c020_2) resistor r=1k
CINTI_c020_2 (Icar_c020_2 0) capacitor c=80p
RINTQ_c020_2 (mix_q_c020_2 Qcar_c020_2) resistor r=1k
CINTQ_c020_2 (Qcar_c020_2 0) capacitor c=80p

// bl020, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c020_3 (bl020 n_cbpf_c020_3) capacitor c=2.533029591058e-14
LBPF_c020_3 (n_cbpf_c020_3 bpf_c020_3) inductor l=1.000000000000e-06
RBPF_c020_3 (bpf_c020_3 0) resistor r=3.141592653590e+02
EMIXI_c020_3_00 (mix_i_src_c020_3_00 0 bpf_c020_3 0) vcvs gain=9.807852804032e-01
SMIXI_c020_3_00 (mix_i_src_c020_3_00 mix_i_c020_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_00 (mix_q_src_c020_3_00 0 bpf_c020_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_3_00 (mix_q_src_c020_3_00 mix_q_c020_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_01 (mix_i_src_c020_3_01 0 bpf_c020_3 0) vcvs gain=8.314696123025e-01
SMIXI_c020_3_01 (mix_i_src_c020_3_01 mix_i_c020_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_01 (mix_q_src_c020_3_01 0 bpf_c020_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_3_01 (mix_q_src_c020_3_01 mix_q_c020_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_02 (mix_i_src_c020_3_02 0 bpf_c020_3 0) vcvs gain=5.555702330196e-01
SMIXI_c020_3_02 (mix_i_src_c020_3_02 mix_i_c020_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_02 (mix_q_src_c020_3_02 0 bpf_c020_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_3_02 (mix_q_src_c020_3_02 mix_q_c020_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_03 (mix_i_src_c020_3_03 0 bpf_c020_3 0) vcvs gain=1.950903220161e-01
SMIXI_c020_3_03 (mix_i_src_c020_3_03 mix_i_c020_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_03 (mix_q_src_c020_3_03 0 bpf_c020_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_3_03 (mix_q_src_c020_3_03 mix_q_c020_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_04 (mix_i_src_c020_3_04 0 bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_3_04 (mix_i_src_c020_3_04 mix_i_c020_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_04 (mix_q_src_c020_3_04 0 bpf_c020_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c020_3_04 (mix_q_src_c020_3_04 mix_q_c020_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_05 (mix_i_src_c020_3_05 0 bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_3_05 (mix_i_src_c020_3_05 mix_i_c020_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_05 (mix_q_src_c020_3_05 0 bpf_c020_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c020_3_05 (mix_q_src_c020_3_05 mix_q_c020_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_06 (mix_i_src_c020_3_06 0 bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_3_06 (mix_i_src_c020_3_06 mix_i_c020_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_06 (mix_q_src_c020_3_06 0 bpf_c020_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c020_3_06 (mix_q_src_c020_3_06 mix_q_c020_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_07 (mix_i_src_c020_3_07 0 bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_3_07 (mix_i_src_c020_3_07 mix_i_c020_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_07 (mix_q_src_c020_3_07 0 bpf_c020_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c020_3_07 (mix_q_src_c020_3_07 mix_q_c020_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_08 (mix_i_src_c020_3_08 0 bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c020_3_08 (mix_i_src_c020_3_08 mix_i_c020_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_08 (mix_q_src_c020_3_08 0 bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_3_08 (mix_q_src_c020_3_08 mix_q_c020_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_09 (mix_i_src_c020_3_09 0 bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c020_3_09 (mix_i_src_c020_3_09 mix_i_c020_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_09 (mix_q_src_c020_3_09 0 bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_3_09 (mix_q_src_c020_3_09 mix_q_c020_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_10 (mix_i_src_c020_3_10 0 bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c020_3_10 (mix_i_src_c020_3_10 mix_i_c020_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_10 (mix_q_src_c020_3_10 0 bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_3_10 (mix_q_src_c020_3_10 mix_q_c020_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_11 (mix_i_src_c020_3_11 0 bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c020_3_11 (mix_i_src_c020_3_11 mix_i_c020_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_11 (mix_q_src_c020_3_11 0 bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_3_11 (mix_q_src_c020_3_11 mix_q_c020_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_12 (mix_i_src_c020_3_12 0 bpf_c020_3 0) vcvs gain=1.950903220161e-01
SMIXI_c020_3_12 (mix_i_src_c020_3_12 mix_i_c020_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_12 (mix_q_src_c020_3_12 0 bpf_c020_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c020_3_12 (mix_q_src_c020_3_12 mix_q_c020_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_13 (mix_i_src_c020_3_13 0 bpf_c020_3 0) vcvs gain=5.555702330196e-01
SMIXI_c020_3_13 (mix_i_src_c020_3_13 mix_i_c020_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_13 (mix_q_src_c020_3_13 0 bpf_c020_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c020_3_13 (mix_q_src_c020_3_13 mix_q_c020_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_14 (mix_i_src_c020_3_14 0 bpf_c020_3 0) vcvs gain=8.314696123025e-01
SMIXI_c020_3_14 (mix_i_src_c020_3_14 mix_i_c020_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_14 (mix_q_src_c020_3_14 0 bpf_c020_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c020_3_14 (mix_q_src_c020_3_14 mix_q_c020_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c020_3_15 (mix_i_src_c020_3_15 0 bpf_c020_3 0) vcvs gain=9.807852804032e-01
SMIXI_c020_3_15 (mix_i_src_c020_3_15 mix_i_c020_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c020_3_15 (mix_q_src_c020_3_15 0 bpf_c020_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c020_3_15 (mix_q_src_c020_3_15 mix_q_c020_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c020_3 (mix_i_c020_3 0) resistor r=1G
RMIXQ_c020_3 (mix_q_c020_3 0) resistor r=1G
RINTI_c020_3 (mix_i_c020_3 Icar_c020_3) resistor r=1k
CINTI_c020_3 (Icar_c020_3 0) capacitor c=80p
RINTQ_c020_3 (mix_q_c020_3 Qcar_c020_3) resistor r=1k
CINTQ_c020_3 (Qcar_c020_3 0) capacitor c=80p

// bl021, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c021_0 (bl021 n_cbpf_c021_0) capacitor c=4.052847345694e-13
LBPF_c021_0 (n_cbpf_c021_0 bpf_c021_0) inductor l=1.000000000000e-06
RBPF_c021_0 (bpf_c021_0 0) resistor r=7.853981633974e+01
EMIXI_c021_0_00 (mix_i_src_c021_0_00 0 bpf_c021_0 0) vcvs gain=9.807852804032e-01
SMIXI_c021_0_00 (mix_i_src_c021_0_00 mix_i_c021_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_00 (mix_q_src_c021_0_00 0 bpf_c021_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_0_00 (mix_q_src_c021_0_00 mix_q_c021_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_01 (mix_i_src_c021_0_01 0 bpf_c021_0 0) vcvs gain=8.314696123025e-01
SMIXI_c021_0_01 (mix_i_src_c021_0_01 mix_i_c021_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_01 (mix_q_src_c021_0_01 0 bpf_c021_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_0_01 (mix_q_src_c021_0_01 mix_q_c021_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_02 (mix_i_src_c021_0_02 0 bpf_c021_0 0) vcvs gain=5.555702330196e-01
SMIXI_c021_0_02 (mix_i_src_c021_0_02 mix_i_c021_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_02 (mix_q_src_c021_0_02 0 bpf_c021_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_0_02 (mix_q_src_c021_0_02 mix_q_c021_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_03 (mix_i_src_c021_0_03 0 bpf_c021_0 0) vcvs gain=1.950903220161e-01
SMIXI_c021_0_03 (mix_i_src_c021_0_03 mix_i_c021_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_03 (mix_q_src_c021_0_03 0 bpf_c021_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_0_03 (mix_q_src_c021_0_03 mix_q_c021_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_04 (mix_i_src_c021_0_04 0 bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_0_04 (mix_i_src_c021_0_04 mix_i_c021_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_04 (mix_q_src_c021_0_04 0 bpf_c021_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_0_04 (mix_q_src_c021_0_04 mix_q_c021_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_05 (mix_i_src_c021_0_05 0 bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_0_05 (mix_i_src_c021_0_05 mix_i_c021_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_05 (mix_q_src_c021_0_05 0 bpf_c021_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_0_05 (mix_q_src_c021_0_05 mix_q_c021_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_06 (mix_i_src_c021_0_06 0 bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_0_06 (mix_i_src_c021_0_06 mix_i_c021_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_06 (mix_q_src_c021_0_06 0 bpf_c021_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_0_06 (mix_q_src_c021_0_06 mix_q_c021_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_07 (mix_i_src_c021_0_07 0 bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_0_07 (mix_i_src_c021_0_07 mix_i_c021_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_07 (mix_q_src_c021_0_07 0 bpf_c021_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_0_07 (mix_q_src_c021_0_07 mix_q_c021_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_08 (mix_i_src_c021_0_08 0 bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_0_08 (mix_i_src_c021_0_08 mix_i_c021_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_08 (mix_q_src_c021_0_08 0 bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_0_08 (mix_q_src_c021_0_08 mix_q_c021_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_09 (mix_i_src_c021_0_09 0 bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_0_09 (mix_i_src_c021_0_09 mix_i_c021_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_09 (mix_q_src_c021_0_09 0 bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_0_09 (mix_q_src_c021_0_09 mix_q_c021_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_10 (mix_i_src_c021_0_10 0 bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_0_10 (mix_i_src_c021_0_10 mix_i_c021_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_10 (mix_q_src_c021_0_10 0 bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_0_10 (mix_q_src_c021_0_10 mix_q_c021_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_11 (mix_i_src_c021_0_11 0 bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_0_11 (mix_i_src_c021_0_11 mix_i_c021_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_11 (mix_q_src_c021_0_11 0 bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_0_11 (mix_q_src_c021_0_11 mix_q_c021_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_12 (mix_i_src_c021_0_12 0 bpf_c021_0 0) vcvs gain=1.950903220161e-01
SMIXI_c021_0_12 (mix_i_src_c021_0_12 mix_i_c021_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_12 (mix_q_src_c021_0_12 0 bpf_c021_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_0_12 (mix_q_src_c021_0_12 mix_q_c021_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_13 (mix_i_src_c021_0_13 0 bpf_c021_0 0) vcvs gain=5.555702330196e-01
SMIXI_c021_0_13 (mix_i_src_c021_0_13 mix_i_c021_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_13 (mix_q_src_c021_0_13 0 bpf_c021_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_0_13 (mix_q_src_c021_0_13 mix_q_c021_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_14 (mix_i_src_c021_0_14 0 bpf_c021_0 0) vcvs gain=8.314696123025e-01
SMIXI_c021_0_14 (mix_i_src_c021_0_14 mix_i_c021_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_14 (mix_q_src_c021_0_14 0 bpf_c021_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_0_14 (mix_q_src_c021_0_14 mix_q_c021_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_0_15 (mix_i_src_c021_0_15 0 bpf_c021_0 0) vcvs gain=9.807852804032e-01
SMIXI_c021_0_15 (mix_i_src_c021_0_15 mix_i_c021_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_0_15 (mix_q_src_c021_0_15 0 bpf_c021_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_0_15 (mix_q_src_c021_0_15 mix_q_c021_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c021_0 (mix_i_c021_0 0) resistor r=1G
RMIXQ_c021_0 (mix_q_c021_0 0) resistor r=1G
RINTI_c021_0 (mix_i_c021_0 Icar_c021_0) resistor r=1k
CINTI_c021_0 (Icar_c021_0 0) capacitor c=80p
RINTQ_c021_0 (mix_q_c021_0 Qcar_c021_0) resistor r=1k
CINTQ_c021_0 (Qcar_c021_0 0) capacitor c=80p

// bl021, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c021_1 (bl021 n_cbpf_c021_1) capacitor c=1.013211836423e-13
LBPF_c021_1 (n_cbpf_c021_1 bpf_c021_1) inductor l=1.000000000000e-06
RBPF_c021_1 (bpf_c021_1 0) resistor r=1.570796326795e+02
EMIXI_c021_1_00 (mix_i_src_c021_1_00 0 bpf_c021_1 0) vcvs gain=9.807852804032e-01
SMIXI_c021_1_00 (mix_i_src_c021_1_00 mix_i_c021_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_00 (mix_q_src_c021_1_00 0 bpf_c021_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_1_00 (mix_q_src_c021_1_00 mix_q_c021_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_01 (mix_i_src_c021_1_01 0 bpf_c021_1 0) vcvs gain=8.314696123025e-01
SMIXI_c021_1_01 (mix_i_src_c021_1_01 mix_i_c021_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_01 (mix_q_src_c021_1_01 0 bpf_c021_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_1_01 (mix_q_src_c021_1_01 mix_q_c021_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_02 (mix_i_src_c021_1_02 0 bpf_c021_1 0) vcvs gain=5.555702330196e-01
SMIXI_c021_1_02 (mix_i_src_c021_1_02 mix_i_c021_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_02 (mix_q_src_c021_1_02 0 bpf_c021_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_1_02 (mix_q_src_c021_1_02 mix_q_c021_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_03 (mix_i_src_c021_1_03 0 bpf_c021_1 0) vcvs gain=1.950903220161e-01
SMIXI_c021_1_03 (mix_i_src_c021_1_03 mix_i_c021_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_03 (mix_q_src_c021_1_03 0 bpf_c021_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_1_03 (mix_q_src_c021_1_03 mix_q_c021_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_04 (mix_i_src_c021_1_04 0 bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_1_04 (mix_i_src_c021_1_04 mix_i_c021_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_04 (mix_q_src_c021_1_04 0 bpf_c021_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_1_04 (mix_q_src_c021_1_04 mix_q_c021_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_05 (mix_i_src_c021_1_05 0 bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_1_05 (mix_i_src_c021_1_05 mix_i_c021_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_05 (mix_q_src_c021_1_05 0 bpf_c021_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_1_05 (mix_q_src_c021_1_05 mix_q_c021_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_06 (mix_i_src_c021_1_06 0 bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_1_06 (mix_i_src_c021_1_06 mix_i_c021_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_06 (mix_q_src_c021_1_06 0 bpf_c021_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_1_06 (mix_q_src_c021_1_06 mix_q_c021_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_07 (mix_i_src_c021_1_07 0 bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_1_07 (mix_i_src_c021_1_07 mix_i_c021_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_07 (mix_q_src_c021_1_07 0 bpf_c021_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_1_07 (mix_q_src_c021_1_07 mix_q_c021_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_08 (mix_i_src_c021_1_08 0 bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_1_08 (mix_i_src_c021_1_08 mix_i_c021_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_08 (mix_q_src_c021_1_08 0 bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_1_08 (mix_q_src_c021_1_08 mix_q_c021_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_09 (mix_i_src_c021_1_09 0 bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_1_09 (mix_i_src_c021_1_09 mix_i_c021_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_09 (mix_q_src_c021_1_09 0 bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_1_09 (mix_q_src_c021_1_09 mix_q_c021_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_10 (mix_i_src_c021_1_10 0 bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_1_10 (mix_i_src_c021_1_10 mix_i_c021_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_10 (mix_q_src_c021_1_10 0 bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_1_10 (mix_q_src_c021_1_10 mix_q_c021_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_11 (mix_i_src_c021_1_11 0 bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_1_11 (mix_i_src_c021_1_11 mix_i_c021_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_11 (mix_q_src_c021_1_11 0 bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_1_11 (mix_q_src_c021_1_11 mix_q_c021_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_12 (mix_i_src_c021_1_12 0 bpf_c021_1 0) vcvs gain=1.950903220161e-01
SMIXI_c021_1_12 (mix_i_src_c021_1_12 mix_i_c021_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_12 (mix_q_src_c021_1_12 0 bpf_c021_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_1_12 (mix_q_src_c021_1_12 mix_q_c021_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_13 (mix_i_src_c021_1_13 0 bpf_c021_1 0) vcvs gain=5.555702330196e-01
SMIXI_c021_1_13 (mix_i_src_c021_1_13 mix_i_c021_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_13 (mix_q_src_c021_1_13 0 bpf_c021_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_1_13 (mix_q_src_c021_1_13 mix_q_c021_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_14 (mix_i_src_c021_1_14 0 bpf_c021_1 0) vcvs gain=8.314696123025e-01
SMIXI_c021_1_14 (mix_i_src_c021_1_14 mix_i_c021_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_14 (mix_q_src_c021_1_14 0 bpf_c021_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_1_14 (mix_q_src_c021_1_14 mix_q_c021_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_1_15 (mix_i_src_c021_1_15 0 bpf_c021_1 0) vcvs gain=9.807852804032e-01
SMIXI_c021_1_15 (mix_i_src_c021_1_15 mix_i_c021_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_1_15 (mix_q_src_c021_1_15 0 bpf_c021_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_1_15 (mix_q_src_c021_1_15 mix_q_c021_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c021_1 (mix_i_c021_1 0) resistor r=1G
RMIXQ_c021_1 (mix_q_c021_1 0) resistor r=1G
RINTI_c021_1 (mix_i_c021_1 Icar_c021_1) resistor r=1k
CINTI_c021_1 (Icar_c021_1 0) capacitor c=80p
RINTQ_c021_1 (mix_q_c021_1 Qcar_c021_1) resistor r=1k
CINTQ_c021_1 (Qcar_c021_1 0) capacitor c=80p

// bl021, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c021_2 (bl021 n_cbpf_c021_2) capacitor c=4.503163717437e-14
LBPF_c021_2 (n_cbpf_c021_2 bpf_c021_2) inductor l=1.000000000000e-06
RBPF_c021_2 (bpf_c021_2 0) resistor r=2.356194490192e+02
EMIXI_c021_2_00 (mix_i_src_c021_2_00 0 bpf_c021_2 0) vcvs gain=9.807852804032e-01
SMIXI_c021_2_00 (mix_i_src_c021_2_00 mix_i_c021_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_00 (mix_q_src_c021_2_00 0 bpf_c021_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_2_00 (mix_q_src_c021_2_00 mix_q_c021_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_01 (mix_i_src_c021_2_01 0 bpf_c021_2 0) vcvs gain=8.314696123025e-01
SMIXI_c021_2_01 (mix_i_src_c021_2_01 mix_i_c021_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_01 (mix_q_src_c021_2_01 0 bpf_c021_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_2_01 (mix_q_src_c021_2_01 mix_q_c021_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_02 (mix_i_src_c021_2_02 0 bpf_c021_2 0) vcvs gain=5.555702330196e-01
SMIXI_c021_2_02 (mix_i_src_c021_2_02 mix_i_c021_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_02 (mix_q_src_c021_2_02 0 bpf_c021_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_2_02 (mix_q_src_c021_2_02 mix_q_c021_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_03 (mix_i_src_c021_2_03 0 bpf_c021_2 0) vcvs gain=1.950903220161e-01
SMIXI_c021_2_03 (mix_i_src_c021_2_03 mix_i_c021_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_03 (mix_q_src_c021_2_03 0 bpf_c021_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_2_03 (mix_q_src_c021_2_03 mix_q_c021_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_04 (mix_i_src_c021_2_04 0 bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_2_04 (mix_i_src_c021_2_04 mix_i_c021_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_04 (mix_q_src_c021_2_04 0 bpf_c021_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_2_04 (mix_q_src_c021_2_04 mix_q_c021_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_05 (mix_i_src_c021_2_05 0 bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_2_05 (mix_i_src_c021_2_05 mix_i_c021_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_05 (mix_q_src_c021_2_05 0 bpf_c021_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_2_05 (mix_q_src_c021_2_05 mix_q_c021_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_06 (mix_i_src_c021_2_06 0 bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_2_06 (mix_i_src_c021_2_06 mix_i_c021_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_06 (mix_q_src_c021_2_06 0 bpf_c021_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_2_06 (mix_q_src_c021_2_06 mix_q_c021_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_07 (mix_i_src_c021_2_07 0 bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_2_07 (mix_i_src_c021_2_07 mix_i_c021_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_07 (mix_q_src_c021_2_07 0 bpf_c021_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_2_07 (mix_q_src_c021_2_07 mix_q_c021_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_08 (mix_i_src_c021_2_08 0 bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_2_08 (mix_i_src_c021_2_08 mix_i_c021_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_08 (mix_q_src_c021_2_08 0 bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_2_08 (mix_q_src_c021_2_08 mix_q_c021_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_09 (mix_i_src_c021_2_09 0 bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_2_09 (mix_i_src_c021_2_09 mix_i_c021_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_09 (mix_q_src_c021_2_09 0 bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_2_09 (mix_q_src_c021_2_09 mix_q_c021_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_10 (mix_i_src_c021_2_10 0 bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_2_10 (mix_i_src_c021_2_10 mix_i_c021_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_10 (mix_q_src_c021_2_10 0 bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_2_10 (mix_q_src_c021_2_10 mix_q_c021_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_11 (mix_i_src_c021_2_11 0 bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_2_11 (mix_i_src_c021_2_11 mix_i_c021_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_11 (mix_q_src_c021_2_11 0 bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_2_11 (mix_q_src_c021_2_11 mix_q_c021_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_12 (mix_i_src_c021_2_12 0 bpf_c021_2 0) vcvs gain=1.950903220161e-01
SMIXI_c021_2_12 (mix_i_src_c021_2_12 mix_i_c021_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_12 (mix_q_src_c021_2_12 0 bpf_c021_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_2_12 (mix_q_src_c021_2_12 mix_q_c021_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_13 (mix_i_src_c021_2_13 0 bpf_c021_2 0) vcvs gain=5.555702330196e-01
SMIXI_c021_2_13 (mix_i_src_c021_2_13 mix_i_c021_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_13 (mix_q_src_c021_2_13 0 bpf_c021_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_2_13 (mix_q_src_c021_2_13 mix_q_c021_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_14 (mix_i_src_c021_2_14 0 bpf_c021_2 0) vcvs gain=8.314696123025e-01
SMIXI_c021_2_14 (mix_i_src_c021_2_14 mix_i_c021_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_14 (mix_q_src_c021_2_14 0 bpf_c021_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_2_14 (mix_q_src_c021_2_14 mix_q_c021_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_2_15 (mix_i_src_c021_2_15 0 bpf_c021_2 0) vcvs gain=9.807852804032e-01
SMIXI_c021_2_15 (mix_i_src_c021_2_15 mix_i_c021_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_2_15 (mix_q_src_c021_2_15 0 bpf_c021_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_2_15 (mix_q_src_c021_2_15 mix_q_c021_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c021_2 (mix_i_c021_2 0) resistor r=1G
RMIXQ_c021_2 (mix_q_c021_2 0) resistor r=1G
RINTI_c021_2 (mix_i_c021_2 Icar_c021_2) resistor r=1k
CINTI_c021_2 (Icar_c021_2 0) capacitor c=80p
RINTQ_c021_2 (mix_q_c021_2 Qcar_c021_2) resistor r=1k
CINTQ_c021_2 (Qcar_c021_2 0) capacitor c=80p

// bl021, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c021_3 (bl021 n_cbpf_c021_3) capacitor c=2.533029591058e-14
LBPF_c021_3 (n_cbpf_c021_3 bpf_c021_3) inductor l=1.000000000000e-06
RBPF_c021_3 (bpf_c021_3 0) resistor r=3.141592653590e+02
EMIXI_c021_3_00 (mix_i_src_c021_3_00 0 bpf_c021_3 0) vcvs gain=9.807852804032e-01
SMIXI_c021_3_00 (mix_i_src_c021_3_00 mix_i_c021_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_00 (mix_q_src_c021_3_00 0 bpf_c021_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_3_00 (mix_q_src_c021_3_00 mix_q_c021_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_01 (mix_i_src_c021_3_01 0 bpf_c021_3 0) vcvs gain=8.314696123025e-01
SMIXI_c021_3_01 (mix_i_src_c021_3_01 mix_i_c021_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_01 (mix_q_src_c021_3_01 0 bpf_c021_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_3_01 (mix_q_src_c021_3_01 mix_q_c021_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_02 (mix_i_src_c021_3_02 0 bpf_c021_3 0) vcvs gain=5.555702330196e-01
SMIXI_c021_3_02 (mix_i_src_c021_3_02 mix_i_c021_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_02 (mix_q_src_c021_3_02 0 bpf_c021_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_3_02 (mix_q_src_c021_3_02 mix_q_c021_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_03 (mix_i_src_c021_3_03 0 bpf_c021_3 0) vcvs gain=1.950903220161e-01
SMIXI_c021_3_03 (mix_i_src_c021_3_03 mix_i_c021_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_03 (mix_q_src_c021_3_03 0 bpf_c021_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_3_03 (mix_q_src_c021_3_03 mix_q_c021_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_04 (mix_i_src_c021_3_04 0 bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_3_04 (mix_i_src_c021_3_04 mix_i_c021_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_04 (mix_q_src_c021_3_04 0 bpf_c021_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c021_3_04 (mix_q_src_c021_3_04 mix_q_c021_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_05 (mix_i_src_c021_3_05 0 bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_3_05 (mix_i_src_c021_3_05 mix_i_c021_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_05 (mix_q_src_c021_3_05 0 bpf_c021_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c021_3_05 (mix_q_src_c021_3_05 mix_q_c021_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_06 (mix_i_src_c021_3_06 0 bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_3_06 (mix_i_src_c021_3_06 mix_i_c021_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_06 (mix_q_src_c021_3_06 0 bpf_c021_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c021_3_06 (mix_q_src_c021_3_06 mix_q_c021_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_07 (mix_i_src_c021_3_07 0 bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_3_07 (mix_i_src_c021_3_07 mix_i_c021_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_07 (mix_q_src_c021_3_07 0 bpf_c021_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c021_3_07 (mix_q_src_c021_3_07 mix_q_c021_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_08 (mix_i_src_c021_3_08 0 bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c021_3_08 (mix_i_src_c021_3_08 mix_i_c021_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_08 (mix_q_src_c021_3_08 0 bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_3_08 (mix_q_src_c021_3_08 mix_q_c021_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_09 (mix_i_src_c021_3_09 0 bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c021_3_09 (mix_i_src_c021_3_09 mix_i_c021_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_09 (mix_q_src_c021_3_09 0 bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_3_09 (mix_q_src_c021_3_09 mix_q_c021_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_10 (mix_i_src_c021_3_10 0 bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c021_3_10 (mix_i_src_c021_3_10 mix_i_c021_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_10 (mix_q_src_c021_3_10 0 bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_3_10 (mix_q_src_c021_3_10 mix_q_c021_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_11 (mix_i_src_c021_3_11 0 bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c021_3_11 (mix_i_src_c021_3_11 mix_i_c021_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_11 (mix_q_src_c021_3_11 0 bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_3_11 (mix_q_src_c021_3_11 mix_q_c021_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_12 (mix_i_src_c021_3_12 0 bpf_c021_3 0) vcvs gain=1.950903220161e-01
SMIXI_c021_3_12 (mix_i_src_c021_3_12 mix_i_c021_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_12 (mix_q_src_c021_3_12 0 bpf_c021_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c021_3_12 (mix_q_src_c021_3_12 mix_q_c021_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_13 (mix_i_src_c021_3_13 0 bpf_c021_3 0) vcvs gain=5.555702330196e-01
SMIXI_c021_3_13 (mix_i_src_c021_3_13 mix_i_c021_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_13 (mix_q_src_c021_3_13 0 bpf_c021_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c021_3_13 (mix_q_src_c021_3_13 mix_q_c021_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_14 (mix_i_src_c021_3_14 0 bpf_c021_3 0) vcvs gain=8.314696123025e-01
SMIXI_c021_3_14 (mix_i_src_c021_3_14 mix_i_c021_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_14 (mix_q_src_c021_3_14 0 bpf_c021_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c021_3_14 (mix_q_src_c021_3_14 mix_q_c021_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c021_3_15 (mix_i_src_c021_3_15 0 bpf_c021_3 0) vcvs gain=9.807852804032e-01
SMIXI_c021_3_15 (mix_i_src_c021_3_15 mix_i_c021_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c021_3_15 (mix_q_src_c021_3_15 0 bpf_c021_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c021_3_15 (mix_q_src_c021_3_15 mix_q_c021_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c021_3 (mix_i_c021_3 0) resistor r=1G
RMIXQ_c021_3 (mix_q_c021_3 0) resistor r=1G
RINTI_c021_3 (mix_i_c021_3 Icar_c021_3) resistor r=1k
CINTI_c021_3 (Icar_c021_3 0) capacitor c=80p
RINTQ_c021_3 (mix_q_c021_3 Qcar_c021_3) resistor r=1k
CINTQ_c021_3 (Qcar_c021_3 0) capacitor c=80p

// bl022, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c022_0 (bl022 n_cbpf_c022_0) capacitor c=4.052847345694e-13
LBPF_c022_0 (n_cbpf_c022_0 bpf_c022_0) inductor l=1.000000000000e-06
RBPF_c022_0 (bpf_c022_0 0) resistor r=7.853981633974e+01
EMIXI_c022_0_00 (mix_i_src_c022_0_00 0 bpf_c022_0 0) vcvs gain=9.807852804032e-01
SMIXI_c022_0_00 (mix_i_src_c022_0_00 mix_i_c022_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_00 (mix_q_src_c022_0_00 0 bpf_c022_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_0_00 (mix_q_src_c022_0_00 mix_q_c022_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_01 (mix_i_src_c022_0_01 0 bpf_c022_0 0) vcvs gain=8.314696123025e-01
SMIXI_c022_0_01 (mix_i_src_c022_0_01 mix_i_c022_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_01 (mix_q_src_c022_0_01 0 bpf_c022_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_0_01 (mix_q_src_c022_0_01 mix_q_c022_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_02 (mix_i_src_c022_0_02 0 bpf_c022_0 0) vcvs gain=5.555702330196e-01
SMIXI_c022_0_02 (mix_i_src_c022_0_02 mix_i_c022_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_02 (mix_q_src_c022_0_02 0 bpf_c022_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_0_02 (mix_q_src_c022_0_02 mix_q_c022_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_03 (mix_i_src_c022_0_03 0 bpf_c022_0 0) vcvs gain=1.950903220161e-01
SMIXI_c022_0_03 (mix_i_src_c022_0_03 mix_i_c022_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_03 (mix_q_src_c022_0_03 0 bpf_c022_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_0_03 (mix_q_src_c022_0_03 mix_q_c022_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_04 (mix_i_src_c022_0_04 0 bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_0_04 (mix_i_src_c022_0_04 mix_i_c022_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_04 (mix_q_src_c022_0_04 0 bpf_c022_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_0_04 (mix_q_src_c022_0_04 mix_q_c022_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_05 (mix_i_src_c022_0_05 0 bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_0_05 (mix_i_src_c022_0_05 mix_i_c022_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_05 (mix_q_src_c022_0_05 0 bpf_c022_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_0_05 (mix_q_src_c022_0_05 mix_q_c022_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_06 (mix_i_src_c022_0_06 0 bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_0_06 (mix_i_src_c022_0_06 mix_i_c022_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_06 (mix_q_src_c022_0_06 0 bpf_c022_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_0_06 (mix_q_src_c022_0_06 mix_q_c022_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_07 (mix_i_src_c022_0_07 0 bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_0_07 (mix_i_src_c022_0_07 mix_i_c022_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_07 (mix_q_src_c022_0_07 0 bpf_c022_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_0_07 (mix_q_src_c022_0_07 mix_q_c022_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_08 (mix_i_src_c022_0_08 0 bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_0_08 (mix_i_src_c022_0_08 mix_i_c022_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_08 (mix_q_src_c022_0_08 0 bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_0_08 (mix_q_src_c022_0_08 mix_q_c022_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_09 (mix_i_src_c022_0_09 0 bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_0_09 (mix_i_src_c022_0_09 mix_i_c022_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_09 (mix_q_src_c022_0_09 0 bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_0_09 (mix_q_src_c022_0_09 mix_q_c022_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_10 (mix_i_src_c022_0_10 0 bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_0_10 (mix_i_src_c022_0_10 mix_i_c022_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_10 (mix_q_src_c022_0_10 0 bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_0_10 (mix_q_src_c022_0_10 mix_q_c022_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_11 (mix_i_src_c022_0_11 0 bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_0_11 (mix_i_src_c022_0_11 mix_i_c022_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_11 (mix_q_src_c022_0_11 0 bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_0_11 (mix_q_src_c022_0_11 mix_q_c022_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_12 (mix_i_src_c022_0_12 0 bpf_c022_0 0) vcvs gain=1.950903220161e-01
SMIXI_c022_0_12 (mix_i_src_c022_0_12 mix_i_c022_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_12 (mix_q_src_c022_0_12 0 bpf_c022_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_0_12 (mix_q_src_c022_0_12 mix_q_c022_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_13 (mix_i_src_c022_0_13 0 bpf_c022_0 0) vcvs gain=5.555702330196e-01
SMIXI_c022_0_13 (mix_i_src_c022_0_13 mix_i_c022_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_13 (mix_q_src_c022_0_13 0 bpf_c022_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_0_13 (mix_q_src_c022_0_13 mix_q_c022_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_14 (mix_i_src_c022_0_14 0 bpf_c022_0 0) vcvs gain=8.314696123025e-01
SMIXI_c022_0_14 (mix_i_src_c022_0_14 mix_i_c022_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_14 (mix_q_src_c022_0_14 0 bpf_c022_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_0_14 (mix_q_src_c022_0_14 mix_q_c022_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_0_15 (mix_i_src_c022_0_15 0 bpf_c022_0 0) vcvs gain=9.807852804032e-01
SMIXI_c022_0_15 (mix_i_src_c022_0_15 mix_i_c022_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_0_15 (mix_q_src_c022_0_15 0 bpf_c022_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_0_15 (mix_q_src_c022_0_15 mix_q_c022_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c022_0 (mix_i_c022_0 0) resistor r=1G
RMIXQ_c022_0 (mix_q_c022_0 0) resistor r=1G
RINTI_c022_0 (mix_i_c022_0 Icar_c022_0) resistor r=1k
CINTI_c022_0 (Icar_c022_0 0) capacitor c=80p
RINTQ_c022_0 (mix_q_c022_0 Qcar_c022_0) resistor r=1k
CINTQ_c022_0 (Qcar_c022_0 0) capacitor c=80p

// bl022, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c022_1 (bl022 n_cbpf_c022_1) capacitor c=1.013211836423e-13
LBPF_c022_1 (n_cbpf_c022_1 bpf_c022_1) inductor l=1.000000000000e-06
RBPF_c022_1 (bpf_c022_1 0) resistor r=1.570796326795e+02
EMIXI_c022_1_00 (mix_i_src_c022_1_00 0 bpf_c022_1 0) vcvs gain=9.807852804032e-01
SMIXI_c022_1_00 (mix_i_src_c022_1_00 mix_i_c022_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_00 (mix_q_src_c022_1_00 0 bpf_c022_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_1_00 (mix_q_src_c022_1_00 mix_q_c022_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_01 (mix_i_src_c022_1_01 0 bpf_c022_1 0) vcvs gain=8.314696123025e-01
SMIXI_c022_1_01 (mix_i_src_c022_1_01 mix_i_c022_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_01 (mix_q_src_c022_1_01 0 bpf_c022_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_1_01 (mix_q_src_c022_1_01 mix_q_c022_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_02 (mix_i_src_c022_1_02 0 bpf_c022_1 0) vcvs gain=5.555702330196e-01
SMIXI_c022_1_02 (mix_i_src_c022_1_02 mix_i_c022_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_02 (mix_q_src_c022_1_02 0 bpf_c022_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_1_02 (mix_q_src_c022_1_02 mix_q_c022_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_03 (mix_i_src_c022_1_03 0 bpf_c022_1 0) vcvs gain=1.950903220161e-01
SMIXI_c022_1_03 (mix_i_src_c022_1_03 mix_i_c022_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_03 (mix_q_src_c022_1_03 0 bpf_c022_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_1_03 (mix_q_src_c022_1_03 mix_q_c022_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_04 (mix_i_src_c022_1_04 0 bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_1_04 (mix_i_src_c022_1_04 mix_i_c022_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_04 (mix_q_src_c022_1_04 0 bpf_c022_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_1_04 (mix_q_src_c022_1_04 mix_q_c022_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_05 (mix_i_src_c022_1_05 0 bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_1_05 (mix_i_src_c022_1_05 mix_i_c022_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_05 (mix_q_src_c022_1_05 0 bpf_c022_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_1_05 (mix_q_src_c022_1_05 mix_q_c022_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_06 (mix_i_src_c022_1_06 0 bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_1_06 (mix_i_src_c022_1_06 mix_i_c022_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_06 (mix_q_src_c022_1_06 0 bpf_c022_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_1_06 (mix_q_src_c022_1_06 mix_q_c022_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_07 (mix_i_src_c022_1_07 0 bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_1_07 (mix_i_src_c022_1_07 mix_i_c022_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_07 (mix_q_src_c022_1_07 0 bpf_c022_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_1_07 (mix_q_src_c022_1_07 mix_q_c022_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_08 (mix_i_src_c022_1_08 0 bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_1_08 (mix_i_src_c022_1_08 mix_i_c022_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_08 (mix_q_src_c022_1_08 0 bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_1_08 (mix_q_src_c022_1_08 mix_q_c022_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_09 (mix_i_src_c022_1_09 0 bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_1_09 (mix_i_src_c022_1_09 mix_i_c022_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_09 (mix_q_src_c022_1_09 0 bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_1_09 (mix_q_src_c022_1_09 mix_q_c022_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_10 (mix_i_src_c022_1_10 0 bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_1_10 (mix_i_src_c022_1_10 mix_i_c022_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_10 (mix_q_src_c022_1_10 0 bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_1_10 (mix_q_src_c022_1_10 mix_q_c022_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_11 (mix_i_src_c022_1_11 0 bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_1_11 (mix_i_src_c022_1_11 mix_i_c022_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_11 (mix_q_src_c022_1_11 0 bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_1_11 (mix_q_src_c022_1_11 mix_q_c022_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_12 (mix_i_src_c022_1_12 0 bpf_c022_1 0) vcvs gain=1.950903220161e-01
SMIXI_c022_1_12 (mix_i_src_c022_1_12 mix_i_c022_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_12 (mix_q_src_c022_1_12 0 bpf_c022_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_1_12 (mix_q_src_c022_1_12 mix_q_c022_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_13 (mix_i_src_c022_1_13 0 bpf_c022_1 0) vcvs gain=5.555702330196e-01
SMIXI_c022_1_13 (mix_i_src_c022_1_13 mix_i_c022_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_13 (mix_q_src_c022_1_13 0 bpf_c022_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_1_13 (mix_q_src_c022_1_13 mix_q_c022_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_14 (mix_i_src_c022_1_14 0 bpf_c022_1 0) vcvs gain=8.314696123025e-01
SMIXI_c022_1_14 (mix_i_src_c022_1_14 mix_i_c022_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_14 (mix_q_src_c022_1_14 0 bpf_c022_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_1_14 (mix_q_src_c022_1_14 mix_q_c022_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_1_15 (mix_i_src_c022_1_15 0 bpf_c022_1 0) vcvs gain=9.807852804032e-01
SMIXI_c022_1_15 (mix_i_src_c022_1_15 mix_i_c022_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_1_15 (mix_q_src_c022_1_15 0 bpf_c022_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_1_15 (mix_q_src_c022_1_15 mix_q_c022_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c022_1 (mix_i_c022_1 0) resistor r=1G
RMIXQ_c022_1 (mix_q_c022_1 0) resistor r=1G
RINTI_c022_1 (mix_i_c022_1 Icar_c022_1) resistor r=1k
CINTI_c022_1 (Icar_c022_1 0) capacitor c=80p
RINTQ_c022_1 (mix_q_c022_1 Qcar_c022_1) resistor r=1k
CINTQ_c022_1 (Qcar_c022_1 0) capacitor c=80p

// bl022, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c022_2 (bl022 n_cbpf_c022_2) capacitor c=4.503163717437e-14
LBPF_c022_2 (n_cbpf_c022_2 bpf_c022_2) inductor l=1.000000000000e-06
RBPF_c022_2 (bpf_c022_2 0) resistor r=2.356194490192e+02
EMIXI_c022_2_00 (mix_i_src_c022_2_00 0 bpf_c022_2 0) vcvs gain=9.807852804032e-01
SMIXI_c022_2_00 (mix_i_src_c022_2_00 mix_i_c022_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_00 (mix_q_src_c022_2_00 0 bpf_c022_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_2_00 (mix_q_src_c022_2_00 mix_q_c022_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_01 (mix_i_src_c022_2_01 0 bpf_c022_2 0) vcvs gain=8.314696123025e-01
SMIXI_c022_2_01 (mix_i_src_c022_2_01 mix_i_c022_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_01 (mix_q_src_c022_2_01 0 bpf_c022_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_2_01 (mix_q_src_c022_2_01 mix_q_c022_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_02 (mix_i_src_c022_2_02 0 bpf_c022_2 0) vcvs gain=5.555702330196e-01
SMIXI_c022_2_02 (mix_i_src_c022_2_02 mix_i_c022_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_02 (mix_q_src_c022_2_02 0 bpf_c022_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_2_02 (mix_q_src_c022_2_02 mix_q_c022_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_03 (mix_i_src_c022_2_03 0 bpf_c022_2 0) vcvs gain=1.950903220161e-01
SMIXI_c022_2_03 (mix_i_src_c022_2_03 mix_i_c022_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_03 (mix_q_src_c022_2_03 0 bpf_c022_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_2_03 (mix_q_src_c022_2_03 mix_q_c022_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_04 (mix_i_src_c022_2_04 0 bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_2_04 (mix_i_src_c022_2_04 mix_i_c022_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_04 (mix_q_src_c022_2_04 0 bpf_c022_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_2_04 (mix_q_src_c022_2_04 mix_q_c022_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_05 (mix_i_src_c022_2_05 0 bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_2_05 (mix_i_src_c022_2_05 mix_i_c022_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_05 (mix_q_src_c022_2_05 0 bpf_c022_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_2_05 (mix_q_src_c022_2_05 mix_q_c022_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_06 (mix_i_src_c022_2_06 0 bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_2_06 (mix_i_src_c022_2_06 mix_i_c022_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_06 (mix_q_src_c022_2_06 0 bpf_c022_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_2_06 (mix_q_src_c022_2_06 mix_q_c022_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_07 (mix_i_src_c022_2_07 0 bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_2_07 (mix_i_src_c022_2_07 mix_i_c022_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_07 (mix_q_src_c022_2_07 0 bpf_c022_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_2_07 (mix_q_src_c022_2_07 mix_q_c022_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_08 (mix_i_src_c022_2_08 0 bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_2_08 (mix_i_src_c022_2_08 mix_i_c022_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_08 (mix_q_src_c022_2_08 0 bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_2_08 (mix_q_src_c022_2_08 mix_q_c022_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_09 (mix_i_src_c022_2_09 0 bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_2_09 (mix_i_src_c022_2_09 mix_i_c022_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_09 (mix_q_src_c022_2_09 0 bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_2_09 (mix_q_src_c022_2_09 mix_q_c022_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_10 (mix_i_src_c022_2_10 0 bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_2_10 (mix_i_src_c022_2_10 mix_i_c022_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_10 (mix_q_src_c022_2_10 0 bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_2_10 (mix_q_src_c022_2_10 mix_q_c022_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_11 (mix_i_src_c022_2_11 0 bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_2_11 (mix_i_src_c022_2_11 mix_i_c022_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_11 (mix_q_src_c022_2_11 0 bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_2_11 (mix_q_src_c022_2_11 mix_q_c022_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_12 (mix_i_src_c022_2_12 0 bpf_c022_2 0) vcvs gain=1.950903220161e-01
SMIXI_c022_2_12 (mix_i_src_c022_2_12 mix_i_c022_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_12 (mix_q_src_c022_2_12 0 bpf_c022_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_2_12 (mix_q_src_c022_2_12 mix_q_c022_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_13 (mix_i_src_c022_2_13 0 bpf_c022_2 0) vcvs gain=5.555702330196e-01
SMIXI_c022_2_13 (mix_i_src_c022_2_13 mix_i_c022_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_13 (mix_q_src_c022_2_13 0 bpf_c022_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_2_13 (mix_q_src_c022_2_13 mix_q_c022_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_14 (mix_i_src_c022_2_14 0 bpf_c022_2 0) vcvs gain=8.314696123025e-01
SMIXI_c022_2_14 (mix_i_src_c022_2_14 mix_i_c022_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_14 (mix_q_src_c022_2_14 0 bpf_c022_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_2_14 (mix_q_src_c022_2_14 mix_q_c022_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_2_15 (mix_i_src_c022_2_15 0 bpf_c022_2 0) vcvs gain=9.807852804032e-01
SMIXI_c022_2_15 (mix_i_src_c022_2_15 mix_i_c022_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_2_15 (mix_q_src_c022_2_15 0 bpf_c022_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_2_15 (mix_q_src_c022_2_15 mix_q_c022_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c022_2 (mix_i_c022_2 0) resistor r=1G
RMIXQ_c022_2 (mix_q_c022_2 0) resistor r=1G
RINTI_c022_2 (mix_i_c022_2 Icar_c022_2) resistor r=1k
CINTI_c022_2 (Icar_c022_2 0) capacitor c=80p
RINTQ_c022_2 (mix_q_c022_2 Qcar_c022_2) resistor r=1k
CINTQ_c022_2 (Qcar_c022_2 0) capacitor c=80p

// bl022, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c022_3 (bl022 n_cbpf_c022_3) capacitor c=2.533029591058e-14
LBPF_c022_3 (n_cbpf_c022_3 bpf_c022_3) inductor l=1.000000000000e-06
RBPF_c022_3 (bpf_c022_3 0) resistor r=3.141592653590e+02
EMIXI_c022_3_00 (mix_i_src_c022_3_00 0 bpf_c022_3 0) vcvs gain=9.807852804032e-01
SMIXI_c022_3_00 (mix_i_src_c022_3_00 mix_i_c022_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_00 (mix_q_src_c022_3_00 0 bpf_c022_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_3_00 (mix_q_src_c022_3_00 mix_q_c022_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_01 (mix_i_src_c022_3_01 0 bpf_c022_3 0) vcvs gain=8.314696123025e-01
SMIXI_c022_3_01 (mix_i_src_c022_3_01 mix_i_c022_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_01 (mix_q_src_c022_3_01 0 bpf_c022_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_3_01 (mix_q_src_c022_3_01 mix_q_c022_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_02 (mix_i_src_c022_3_02 0 bpf_c022_3 0) vcvs gain=5.555702330196e-01
SMIXI_c022_3_02 (mix_i_src_c022_3_02 mix_i_c022_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_02 (mix_q_src_c022_3_02 0 bpf_c022_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_3_02 (mix_q_src_c022_3_02 mix_q_c022_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_03 (mix_i_src_c022_3_03 0 bpf_c022_3 0) vcvs gain=1.950903220161e-01
SMIXI_c022_3_03 (mix_i_src_c022_3_03 mix_i_c022_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_03 (mix_q_src_c022_3_03 0 bpf_c022_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_3_03 (mix_q_src_c022_3_03 mix_q_c022_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_04 (mix_i_src_c022_3_04 0 bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_3_04 (mix_i_src_c022_3_04 mix_i_c022_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_04 (mix_q_src_c022_3_04 0 bpf_c022_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c022_3_04 (mix_q_src_c022_3_04 mix_q_c022_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_05 (mix_i_src_c022_3_05 0 bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_3_05 (mix_i_src_c022_3_05 mix_i_c022_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_05 (mix_q_src_c022_3_05 0 bpf_c022_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c022_3_05 (mix_q_src_c022_3_05 mix_q_c022_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_06 (mix_i_src_c022_3_06 0 bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_3_06 (mix_i_src_c022_3_06 mix_i_c022_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_06 (mix_q_src_c022_3_06 0 bpf_c022_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c022_3_06 (mix_q_src_c022_3_06 mix_q_c022_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_07 (mix_i_src_c022_3_07 0 bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_3_07 (mix_i_src_c022_3_07 mix_i_c022_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_07 (mix_q_src_c022_3_07 0 bpf_c022_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c022_3_07 (mix_q_src_c022_3_07 mix_q_c022_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_08 (mix_i_src_c022_3_08 0 bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c022_3_08 (mix_i_src_c022_3_08 mix_i_c022_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_08 (mix_q_src_c022_3_08 0 bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_3_08 (mix_q_src_c022_3_08 mix_q_c022_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_09 (mix_i_src_c022_3_09 0 bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c022_3_09 (mix_i_src_c022_3_09 mix_i_c022_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_09 (mix_q_src_c022_3_09 0 bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_3_09 (mix_q_src_c022_3_09 mix_q_c022_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_10 (mix_i_src_c022_3_10 0 bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c022_3_10 (mix_i_src_c022_3_10 mix_i_c022_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_10 (mix_q_src_c022_3_10 0 bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_3_10 (mix_q_src_c022_3_10 mix_q_c022_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_11 (mix_i_src_c022_3_11 0 bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c022_3_11 (mix_i_src_c022_3_11 mix_i_c022_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_11 (mix_q_src_c022_3_11 0 bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_3_11 (mix_q_src_c022_3_11 mix_q_c022_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_12 (mix_i_src_c022_3_12 0 bpf_c022_3 0) vcvs gain=1.950903220161e-01
SMIXI_c022_3_12 (mix_i_src_c022_3_12 mix_i_c022_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_12 (mix_q_src_c022_3_12 0 bpf_c022_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c022_3_12 (mix_q_src_c022_3_12 mix_q_c022_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_13 (mix_i_src_c022_3_13 0 bpf_c022_3 0) vcvs gain=5.555702330196e-01
SMIXI_c022_3_13 (mix_i_src_c022_3_13 mix_i_c022_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_13 (mix_q_src_c022_3_13 0 bpf_c022_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c022_3_13 (mix_q_src_c022_3_13 mix_q_c022_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_14 (mix_i_src_c022_3_14 0 bpf_c022_3 0) vcvs gain=8.314696123025e-01
SMIXI_c022_3_14 (mix_i_src_c022_3_14 mix_i_c022_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_14 (mix_q_src_c022_3_14 0 bpf_c022_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c022_3_14 (mix_q_src_c022_3_14 mix_q_c022_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c022_3_15 (mix_i_src_c022_3_15 0 bpf_c022_3 0) vcvs gain=9.807852804032e-01
SMIXI_c022_3_15 (mix_i_src_c022_3_15 mix_i_c022_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c022_3_15 (mix_q_src_c022_3_15 0 bpf_c022_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c022_3_15 (mix_q_src_c022_3_15 mix_q_c022_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c022_3 (mix_i_c022_3 0) resistor r=1G
RMIXQ_c022_3 (mix_q_c022_3 0) resistor r=1G
RINTI_c022_3 (mix_i_c022_3 Icar_c022_3) resistor r=1k
CINTI_c022_3 (Icar_c022_3 0) capacitor c=80p
RINTQ_c022_3 (mix_q_c022_3 Qcar_c022_3) resistor r=1k
CINTQ_c022_3 (Qcar_c022_3 0) capacitor c=80p

// bl023, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c023_0 (bl023 n_cbpf_c023_0) capacitor c=4.052847345694e-13
LBPF_c023_0 (n_cbpf_c023_0 bpf_c023_0) inductor l=1.000000000000e-06
RBPF_c023_0 (bpf_c023_0 0) resistor r=7.853981633974e+01
EMIXI_c023_0_00 (mix_i_src_c023_0_00 0 bpf_c023_0 0) vcvs gain=9.807852804032e-01
SMIXI_c023_0_00 (mix_i_src_c023_0_00 mix_i_c023_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_00 (mix_q_src_c023_0_00 0 bpf_c023_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_0_00 (mix_q_src_c023_0_00 mix_q_c023_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_01 (mix_i_src_c023_0_01 0 bpf_c023_0 0) vcvs gain=8.314696123025e-01
SMIXI_c023_0_01 (mix_i_src_c023_0_01 mix_i_c023_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_01 (mix_q_src_c023_0_01 0 bpf_c023_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_0_01 (mix_q_src_c023_0_01 mix_q_c023_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_02 (mix_i_src_c023_0_02 0 bpf_c023_0 0) vcvs gain=5.555702330196e-01
SMIXI_c023_0_02 (mix_i_src_c023_0_02 mix_i_c023_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_02 (mix_q_src_c023_0_02 0 bpf_c023_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_0_02 (mix_q_src_c023_0_02 mix_q_c023_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_03 (mix_i_src_c023_0_03 0 bpf_c023_0 0) vcvs gain=1.950903220161e-01
SMIXI_c023_0_03 (mix_i_src_c023_0_03 mix_i_c023_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_03 (mix_q_src_c023_0_03 0 bpf_c023_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_0_03 (mix_q_src_c023_0_03 mix_q_c023_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_04 (mix_i_src_c023_0_04 0 bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_0_04 (mix_i_src_c023_0_04 mix_i_c023_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_04 (mix_q_src_c023_0_04 0 bpf_c023_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_0_04 (mix_q_src_c023_0_04 mix_q_c023_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_05 (mix_i_src_c023_0_05 0 bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_0_05 (mix_i_src_c023_0_05 mix_i_c023_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_05 (mix_q_src_c023_0_05 0 bpf_c023_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_0_05 (mix_q_src_c023_0_05 mix_q_c023_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_06 (mix_i_src_c023_0_06 0 bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_0_06 (mix_i_src_c023_0_06 mix_i_c023_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_06 (mix_q_src_c023_0_06 0 bpf_c023_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_0_06 (mix_q_src_c023_0_06 mix_q_c023_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_07 (mix_i_src_c023_0_07 0 bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_0_07 (mix_i_src_c023_0_07 mix_i_c023_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_07 (mix_q_src_c023_0_07 0 bpf_c023_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_0_07 (mix_q_src_c023_0_07 mix_q_c023_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_08 (mix_i_src_c023_0_08 0 bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_0_08 (mix_i_src_c023_0_08 mix_i_c023_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_08 (mix_q_src_c023_0_08 0 bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_0_08 (mix_q_src_c023_0_08 mix_q_c023_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_09 (mix_i_src_c023_0_09 0 bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_0_09 (mix_i_src_c023_0_09 mix_i_c023_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_09 (mix_q_src_c023_0_09 0 bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_0_09 (mix_q_src_c023_0_09 mix_q_c023_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_10 (mix_i_src_c023_0_10 0 bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_0_10 (mix_i_src_c023_0_10 mix_i_c023_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_10 (mix_q_src_c023_0_10 0 bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_0_10 (mix_q_src_c023_0_10 mix_q_c023_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_11 (mix_i_src_c023_0_11 0 bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_0_11 (mix_i_src_c023_0_11 mix_i_c023_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_11 (mix_q_src_c023_0_11 0 bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_0_11 (mix_q_src_c023_0_11 mix_q_c023_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_12 (mix_i_src_c023_0_12 0 bpf_c023_0 0) vcvs gain=1.950903220161e-01
SMIXI_c023_0_12 (mix_i_src_c023_0_12 mix_i_c023_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_12 (mix_q_src_c023_0_12 0 bpf_c023_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_0_12 (mix_q_src_c023_0_12 mix_q_c023_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_13 (mix_i_src_c023_0_13 0 bpf_c023_0 0) vcvs gain=5.555702330196e-01
SMIXI_c023_0_13 (mix_i_src_c023_0_13 mix_i_c023_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_13 (mix_q_src_c023_0_13 0 bpf_c023_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_0_13 (mix_q_src_c023_0_13 mix_q_c023_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_14 (mix_i_src_c023_0_14 0 bpf_c023_0 0) vcvs gain=8.314696123025e-01
SMIXI_c023_0_14 (mix_i_src_c023_0_14 mix_i_c023_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_14 (mix_q_src_c023_0_14 0 bpf_c023_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_0_14 (mix_q_src_c023_0_14 mix_q_c023_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_0_15 (mix_i_src_c023_0_15 0 bpf_c023_0 0) vcvs gain=9.807852804032e-01
SMIXI_c023_0_15 (mix_i_src_c023_0_15 mix_i_c023_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_0_15 (mix_q_src_c023_0_15 0 bpf_c023_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_0_15 (mix_q_src_c023_0_15 mix_q_c023_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c023_0 (mix_i_c023_0 0) resistor r=1G
RMIXQ_c023_0 (mix_q_c023_0 0) resistor r=1G
RINTI_c023_0 (mix_i_c023_0 Icar_c023_0) resistor r=1k
CINTI_c023_0 (Icar_c023_0 0) capacitor c=80p
RINTQ_c023_0 (mix_q_c023_0 Qcar_c023_0) resistor r=1k
CINTQ_c023_0 (Qcar_c023_0 0) capacitor c=80p

// bl023, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c023_1 (bl023 n_cbpf_c023_1) capacitor c=1.013211836423e-13
LBPF_c023_1 (n_cbpf_c023_1 bpf_c023_1) inductor l=1.000000000000e-06
RBPF_c023_1 (bpf_c023_1 0) resistor r=1.570796326795e+02
EMIXI_c023_1_00 (mix_i_src_c023_1_00 0 bpf_c023_1 0) vcvs gain=9.807852804032e-01
SMIXI_c023_1_00 (mix_i_src_c023_1_00 mix_i_c023_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_00 (mix_q_src_c023_1_00 0 bpf_c023_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_1_00 (mix_q_src_c023_1_00 mix_q_c023_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_01 (mix_i_src_c023_1_01 0 bpf_c023_1 0) vcvs gain=8.314696123025e-01
SMIXI_c023_1_01 (mix_i_src_c023_1_01 mix_i_c023_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_01 (mix_q_src_c023_1_01 0 bpf_c023_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_1_01 (mix_q_src_c023_1_01 mix_q_c023_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_02 (mix_i_src_c023_1_02 0 bpf_c023_1 0) vcvs gain=5.555702330196e-01
SMIXI_c023_1_02 (mix_i_src_c023_1_02 mix_i_c023_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_02 (mix_q_src_c023_1_02 0 bpf_c023_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_1_02 (mix_q_src_c023_1_02 mix_q_c023_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_03 (mix_i_src_c023_1_03 0 bpf_c023_1 0) vcvs gain=1.950903220161e-01
SMIXI_c023_1_03 (mix_i_src_c023_1_03 mix_i_c023_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_03 (mix_q_src_c023_1_03 0 bpf_c023_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_1_03 (mix_q_src_c023_1_03 mix_q_c023_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_04 (mix_i_src_c023_1_04 0 bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_1_04 (mix_i_src_c023_1_04 mix_i_c023_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_04 (mix_q_src_c023_1_04 0 bpf_c023_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_1_04 (mix_q_src_c023_1_04 mix_q_c023_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_05 (mix_i_src_c023_1_05 0 bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_1_05 (mix_i_src_c023_1_05 mix_i_c023_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_05 (mix_q_src_c023_1_05 0 bpf_c023_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_1_05 (mix_q_src_c023_1_05 mix_q_c023_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_06 (mix_i_src_c023_1_06 0 bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_1_06 (mix_i_src_c023_1_06 mix_i_c023_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_06 (mix_q_src_c023_1_06 0 bpf_c023_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_1_06 (mix_q_src_c023_1_06 mix_q_c023_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_07 (mix_i_src_c023_1_07 0 bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_1_07 (mix_i_src_c023_1_07 mix_i_c023_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_07 (mix_q_src_c023_1_07 0 bpf_c023_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_1_07 (mix_q_src_c023_1_07 mix_q_c023_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_08 (mix_i_src_c023_1_08 0 bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_1_08 (mix_i_src_c023_1_08 mix_i_c023_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_08 (mix_q_src_c023_1_08 0 bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_1_08 (mix_q_src_c023_1_08 mix_q_c023_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_09 (mix_i_src_c023_1_09 0 bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_1_09 (mix_i_src_c023_1_09 mix_i_c023_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_09 (mix_q_src_c023_1_09 0 bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_1_09 (mix_q_src_c023_1_09 mix_q_c023_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_10 (mix_i_src_c023_1_10 0 bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_1_10 (mix_i_src_c023_1_10 mix_i_c023_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_10 (mix_q_src_c023_1_10 0 bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_1_10 (mix_q_src_c023_1_10 mix_q_c023_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_11 (mix_i_src_c023_1_11 0 bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_1_11 (mix_i_src_c023_1_11 mix_i_c023_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_11 (mix_q_src_c023_1_11 0 bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_1_11 (mix_q_src_c023_1_11 mix_q_c023_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_12 (mix_i_src_c023_1_12 0 bpf_c023_1 0) vcvs gain=1.950903220161e-01
SMIXI_c023_1_12 (mix_i_src_c023_1_12 mix_i_c023_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_12 (mix_q_src_c023_1_12 0 bpf_c023_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_1_12 (mix_q_src_c023_1_12 mix_q_c023_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_13 (mix_i_src_c023_1_13 0 bpf_c023_1 0) vcvs gain=5.555702330196e-01
SMIXI_c023_1_13 (mix_i_src_c023_1_13 mix_i_c023_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_13 (mix_q_src_c023_1_13 0 bpf_c023_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_1_13 (mix_q_src_c023_1_13 mix_q_c023_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_14 (mix_i_src_c023_1_14 0 bpf_c023_1 0) vcvs gain=8.314696123025e-01
SMIXI_c023_1_14 (mix_i_src_c023_1_14 mix_i_c023_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_14 (mix_q_src_c023_1_14 0 bpf_c023_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_1_14 (mix_q_src_c023_1_14 mix_q_c023_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_1_15 (mix_i_src_c023_1_15 0 bpf_c023_1 0) vcvs gain=9.807852804032e-01
SMIXI_c023_1_15 (mix_i_src_c023_1_15 mix_i_c023_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_1_15 (mix_q_src_c023_1_15 0 bpf_c023_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_1_15 (mix_q_src_c023_1_15 mix_q_c023_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c023_1 (mix_i_c023_1 0) resistor r=1G
RMIXQ_c023_1 (mix_q_c023_1 0) resistor r=1G
RINTI_c023_1 (mix_i_c023_1 Icar_c023_1) resistor r=1k
CINTI_c023_1 (Icar_c023_1 0) capacitor c=80p
RINTQ_c023_1 (mix_q_c023_1 Qcar_c023_1) resistor r=1k
CINTQ_c023_1 (Qcar_c023_1 0) capacitor c=80p

// bl023, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c023_2 (bl023 n_cbpf_c023_2) capacitor c=4.503163717437e-14
LBPF_c023_2 (n_cbpf_c023_2 bpf_c023_2) inductor l=1.000000000000e-06
RBPF_c023_2 (bpf_c023_2 0) resistor r=2.356194490192e+02
EMIXI_c023_2_00 (mix_i_src_c023_2_00 0 bpf_c023_2 0) vcvs gain=9.807852804032e-01
SMIXI_c023_2_00 (mix_i_src_c023_2_00 mix_i_c023_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_00 (mix_q_src_c023_2_00 0 bpf_c023_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_2_00 (mix_q_src_c023_2_00 mix_q_c023_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_01 (mix_i_src_c023_2_01 0 bpf_c023_2 0) vcvs gain=8.314696123025e-01
SMIXI_c023_2_01 (mix_i_src_c023_2_01 mix_i_c023_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_01 (mix_q_src_c023_2_01 0 bpf_c023_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_2_01 (mix_q_src_c023_2_01 mix_q_c023_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_02 (mix_i_src_c023_2_02 0 bpf_c023_2 0) vcvs gain=5.555702330196e-01
SMIXI_c023_2_02 (mix_i_src_c023_2_02 mix_i_c023_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_02 (mix_q_src_c023_2_02 0 bpf_c023_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_2_02 (mix_q_src_c023_2_02 mix_q_c023_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_03 (mix_i_src_c023_2_03 0 bpf_c023_2 0) vcvs gain=1.950903220161e-01
SMIXI_c023_2_03 (mix_i_src_c023_2_03 mix_i_c023_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_03 (mix_q_src_c023_2_03 0 bpf_c023_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_2_03 (mix_q_src_c023_2_03 mix_q_c023_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_04 (mix_i_src_c023_2_04 0 bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_2_04 (mix_i_src_c023_2_04 mix_i_c023_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_04 (mix_q_src_c023_2_04 0 bpf_c023_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_2_04 (mix_q_src_c023_2_04 mix_q_c023_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_05 (mix_i_src_c023_2_05 0 bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_2_05 (mix_i_src_c023_2_05 mix_i_c023_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_05 (mix_q_src_c023_2_05 0 bpf_c023_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_2_05 (mix_q_src_c023_2_05 mix_q_c023_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_06 (mix_i_src_c023_2_06 0 bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_2_06 (mix_i_src_c023_2_06 mix_i_c023_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_06 (mix_q_src_c023_2_06 0 bpf_c023_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_2_06 (mix_q_src_c023_2_06 mix_q_c023_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_07 (mix_i_src_c023_2_07 0 bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_2_07 (mix_i_src_c023_2_07 mix_i_c023_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_07 (mix_q_src_c023_2_07 0 bpf_c023_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_2_07 (mix_q_src_c023_2_07 mix_q_c023_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_08 (mix_i_src_c023_2_08 0 bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_2_08 (mix_i_src_c023_2_08 mix_i_c023_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_08 (mix_q_src_c023_2_08 0 bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_2_08 (mix_q_src_c023_2_08 mix_q_c023_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_09 (mix_i_src_c023_2_09 0 bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_2_09 (mix_i_src_c023_2_09 mix_i_c023_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_09 (mix_q_src_c023_2_09 0 bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_2_09 (mix_q_src_c023_2_09 mix_q_c023_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_10 (mix_i_src_c023_2_10 0 bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_2_10 (mix_i_src_c023_2_10 mix_i_c023_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_10 (mix_q_src_c023_2_10 0 bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_2_10 (mix_q_src_c023_2_10 mix_q_c023_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_11 (mix_i_src_c023_2_11 0 bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_2_11 (mix_i_src_c023_2_11 mix_i_c023_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_11 (mix_q_src_c023_2_11 0 bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_2_11 (mix_q_src_c023_2_11 mix_q_c023_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_12 (mix_i_src_c023_2_12 0 bpf_c023_2 0) vcvs gain=1.950903220161e-01
SMIXI_c023_2_12 (mix_i_src_c023_2_12 mix_i_c023_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_12 (mix_q_src_c023_2_12 0 bpf_c023_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_2_12 (mix_q_src_c023_2_12 mix_q_c023_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_13 (mix_i_src_c023_2_13 0 bpf_c023_2 0) vcvs gain=5.555702330196e-01
SMIXI_c023_2_13 (mix_i_src_c023_2_13 mix_i_c023_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_13 (mix_q_src_c023_2_13 0 bpf_c023_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_2_13 (mix_q_src_c023_2_13 mix_q_c023_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_14 (mix_i_src_c023_2_14 0 bpf_c023_2 0) vcvs gain=8.314696123025e-01
SMIXI_c023_2_14 (mix_i_src_c023_2_14 mix_i_c023_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_14 (mix_q_src_c023_2_14 0 bpf_c023_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_2_14 (mix_q_src_c023_2_14 mix_q_c023_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_2_15 (mix_i_src_c023_2_15 0 bpf_c023_2 0) vcvs gain=9.807852804032e-01
SMIXI_c023_2_15 (mix_i_src_c023_2_15 mix_i_c023_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_2_15 (mix_q_src_c023_2_15 0 bpf_c023_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_2_15 (mix_q_src_c023_2_15 mix_q_c023_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c023_2 (mix_i_c023_2 0) resistor r=1G
RMIXQ_c023_2 (mix_q_c023_2 0) resistor r=1G
RINTI_c023_2 (mix_i_c023_2 Icar_c023_2) resistor r=1k
CINTI_c023_2 (Icar_c023_2 0) capacitor c=80p
RINTQ_c023_2 (mix_q_c023_2 Qcar_c023_2) resistor r=1k
CINTQ_c023_2 (Qcar_c023_2 0) capacitor c=80p

// bl023, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c023_3 (bl023 n_cbpf_c023_3) capacitor c=2.533029591058e-14
LBPF_c023_3 (n_cbpf_c023_3 bpf_c023_3) inductor l=1.000000000000e-06
RBPF_c023_3 (bpf_c023_3 0) resistor r=3.141592653590e+02
EMIXI_c023_3_00 (mix_i_src_c023_3_00 0 bpf_c023_3 0) vcvs gain=9.807852804032e-01
SMIXI_c023_3_00 (mix_i_src_c023_3_00 mix_i_c023_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_00 (mix_q_src_c023_3_00 0 bpf_c023_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_3_00 (mix_q_src_c023_3_00 mix_q_c023_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_01 (mix_i_src_c023_3_01 0 bpf_c023_3 0) vcvs gain=8.314696123025e-01
SMIXI_c023_3_01 (mix_i_src_c023_3_01 mix_i_c023_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_01 (mix_q_src_c023_3_01 0 bpf_c023_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_3_01 (mix_q_src_c023_3_01 mix_q_c023_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_02 (mix_i_src_c023_3_02 0 bpf_c023_3 0) vcvs gain=5.555702330196e-01
SMIXI_c023_3_02 (mix_i_src_c023_3_02 mix_i_c023_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_02 (mix_q_src_c023_3_02 0 bpf_c023_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_3_02 (mix_q_src_c023_3_02 mix_q_c023_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_03 (mix_i_src_c023_3_03 0 bpf_c023_3 0) vcvs gain=1.950903220161e-01
SMIXI_c023_3_03 (mix_i_src_c023_3_03 mix_i_c023_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_03 (mix_q_src_c023_3_03 0 bpf_c023_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_3_03 (mix_q_src_c023_3_03 mix_q_c023_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_04 (mix_i_src_c023_3_04 0 bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_3_04 (mix_i_src_c023_3_04 mix_i_c023_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_04 (mix_q_src_c023_3_04 0 bpf_c023_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c023_3_04 (mix_q_src_c023_3_04 mix_q_c023_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_05 (mix_i_src_c023_3_05 0 bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_3_05 (mix_i_src_c023_3_05 mix_i_c023_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_05 (mix_q_src_c023_3_05 0 bpf_c023_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c023_3_05 (mix_q_src_c023_3_05 mix_q_c023_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_06 (mix_i_src_c023_3_06 0 bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_3_06 (mix_i_src_c023_3_06 mix_i_c023_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_06 (mix_q_src_c023_3_06 0 bpf_c023_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c023_3_06 (mix_q_src_c023_3_06 mix_q_c023_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_07 (mix_i_src_c023_3_07 0 bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_3_07 (mix_i_src_c023_3_07 mix_i_c023_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_07 (mix_q_src_c023_3_07 0 bpf_c023_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c023_3_07 (mix_q_src_c023_3_07 mix_q_c023_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_08 (mix_i_src_c023_3_08 0 bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c023_3_08 (mix_i_src_c023_3_08 mix_i_c023_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_08 (mix_q_src_c023_3_08 0 bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_3_08 (mix_q_src_c023_3_08 mix_q_c023_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_09 (mix_i_src_c023_3_09 0 bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c023_3_09 (mix_i_src_c023_3_09 mix_i_c023_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_09 (mix_q_src_c023_3_09 0 bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_3_09 (mix_q_src_c023_3_09 mix_q_c023_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_10 (mix_i_src_c023_3_10 0 bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c023_3_10 (mix_i_src_c023_3_10 mix_i_c023_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_10 (mix_q_src_c023_3_10 0 bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_3_10 (mix_q_src_c023_3_10 mix_q_c023_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_11 (mix_i_src_c023_3_11 0 bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c023_3_11 (mix_i_src_c023_3_11 mix_i_c023_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_11 (mix_q_src_c023_3_11 0 bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_3_11 (mix_q_src_c023_3_11 mix_q_c023_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_12 (mix_i_src_c023_3_12 0 bpf_c023_3 0) vcvs gain=1.950903220161e-01
SMIXI_c023_3_12 (mix_i_src_c023_3_12 mix_i_c023_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_12 (mix_q_src_c023_3_12 0 bpf_c023_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c023_3_12 (mix_q_src_c023_3_12 mix_q_c023_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_13 (mix_i_src_c023_3_13 0 bpf_c023_3 0) vcvs gain=5.555702330196e-01
SMIXI_c023_3_13 (mix_i_src_c023_3_13 mix_i_c023_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_13 (mix_q_src_c023_3_13 0 bpf_c023_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c023_3_13 (mix_q_src_c023_3_13 mix_q_c023_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_14 (mix_i_src_c023_3_14 0 bpf_c023_3 0) vcvs gain=8.314696123025e-01
SMIXI_c023_3_14 (mix_i_src_c023_3_14 mix_i_c023_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_14 (mix_q_src_c023_3_14 0 bpf_c023_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c023_3_14 (mix_q_src_c023_3_14 mix_q_c023_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c023_3_15 (mix_i_src_c023_3_15 0 bpf_c023_3 0) vcvs gain=9.807852804032e-01
SMIXI_c023_3_15 (mix_i_src_c023_3_15 mix_i_c023_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c023_3_15 (mix_q_src_c023_3_15 0 bpf_c023_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c023_3_15 (mix_q_src_c023_3_15 mix_q_c023_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c023_3 (mix_i_c023_3 0) resistor r=1G
RMIXQ_c023_3 (mix_q_c023_3 0) resistor r=1G
RINTI_c023_3 (mix_i_c023_3 Icar_c023_3) resistor r=1k
CINTI_c023_3 (Icar_c023_3 0) capacitor c=80p
RINTQ_c023_3 (mix_q_c023_3 Qcar_c023_3) resistor r=1k
CINTQ_c023_3 (Qcar_c023_3 0) capacitor c=80p

// bl024, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c024_0 (bl024 n_cbpf_c024_0) capacitor c=4.052847345694e-13
LBPF_c024_0 (n_cbpf_c024_0 bpf_c024_0) inductor l=1.000000000000e-06
RBPF_c024_0 (bpf_c024_0 0) resistor r=7.853981633974e+01
EMIXI_c024_0_00 (mix_i_src_c024_0_00 0 bpf_c024_0 0) vcvs gain=9.807852804032e-01
SMIXI_c024_0_00 (mix_i_src_c024_0_00 mix_i_c024_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_00 (mix_q_src_c024_0_00 0 bpf_c024_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_0_00 (mix_q_src_c024_0_00 mix_q_c024_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_01 (mix_i_src_c024_0_01 0 bpf_c024_0 0) vcvs gain=8.314696123025e-01
SMIXI_c024_0_01 (mix_i_src_c024_0_01 mix_i_c024_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_01 (mix_q_src_c024_0_01 0 bpf_c024_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_0_01 (mix_q_src_c024_0_01 mix_q_c024_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_02 (mix_i_src_c024_0_02 0 bpf_c024_0 0) vcvs gain=5.555702330196e-01
SMIXI_c024_0_02 (mix_i_src_c024_0_02 mix_i_c024_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_02 (mix_q_src_c024_0_02 0 bpf_c024_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_0_02 (mix_q_src_c024_0_02 mix_q_c024_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_03 (mix_i_src_c024_0_03 0 bpf_c024_0 0) vcvs gain=1.950903220161e-01
SMIXI_c024_0_03 (mix_i_src_c024_0_03 mix_i_c024_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_03 (mix_q_src_c024_0_03 0 bpf_c024_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_0_03 (mix_q_src_c024_0_03 mix_q_c024_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_04 (mix_i_src_c024_0_04 0 bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_0_04 (mix_i_src_c024_0_04 mix_i_c024_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_04 (mix_q_src_c024_0_04 0 bpf_c024_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_0_04 (mix_q_src_c024_0_04 mix_q_c024_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_05 (mix_i_src_c024_0_05 0 bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_0_05 (mix_i_src_c024_0_05 mix_i_c024_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_05 (mix_q_src_c024_0_05 0 bpf_c024_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_0_05 (mix_q_src_c024_0_05 mix_q_c024_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_06 (mix_i_src_c024_0_06 0 bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_0_06 (mix_i_src_c024_0_06 mix_i_c024_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_06 (mix_q_src_c024_0_06 0 bpf_c024_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_0_06 (mix_q_src_c024_0_06 mix_q_c024_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_07 (mix_i_src_c024_0_07 0 bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_0_07 (mix_i_src_c024_0_07 mix_i_c024_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_07 (mix_q_src_c024_0_07 0 bpf_c024_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_0_07 (mix_q_src_c024_0_07 mix_q_c024_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_08 (mix_i_src_c024_0_08 0 bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_0_08 (mix_i_src_c024_0_08 mix_i_c024_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_08 (mix_q_src_c024_0_08 0 bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_0_08 (mix_q_src_c024_0_08 mix_q_c024_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_09 (mix_i_src_c024_0_09 0 bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_0_09 (mix_i_src_c024_0_09 mix_i_c024_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_09 (mix_q_src_c024_0_09 0 bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_0_09 (mix_q_src_c024_0_09 mix_q_c024_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_10 (mix_i_src_c024_0_10 0 bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_0_10 (mix_i_src_c024_0_10 mix_i_c024_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_10 (mix_q_src_c024_0_10 0 bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_0_10 (mix_q_src_c024_0_10 mix_q_c024_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_11 (mix_i_src_c024_0_11 0 bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_0_11 (mix_i_src_c024_0_11 mix_i_c024_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_11 (mix_q_src_c024_0_11 0 bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_0_11 (mix_q_src_c024_0_11 mix_q_c024_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_12 (mix_i_src_c024_0_12 0 bpf_c024_0 0) vcvs gain=1.950903220161e-01
SMIXI_c024_0_12 (mix_i_src_c024_0_12 mix_i_c024_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_12 (mix_q_src_c024_0_12 0 bpf_c024_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_0_12 (mix_q_src_c024_0_12 mix_q_c024_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_13 (mix_i_src_c024_0_13 0 bpf_c024_0 0) vcvs gain=5.555702330196e-01
SMIXI_c024_0_13 (mix_i_src_c024_0_13 mix_i_c024_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_13 (mix_q_src_c024_0_13 0 bpf_c024_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_0_13 (mix_q_src_c024_0_13 mix_q_c024_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_14 (mix_i_src_c024_0_14 0 bpf_c024_0 0) vcvs gain=8.314696123025e-01
SMIXI_c024_0_14 (mix_i_src_c024_0_14 mix_i_c024_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_14 (mix_q_src_c024_0_14 0 bpf_c024_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_0_14 (mix_q_src_c024_0_14 mix_q_c024_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_0_15 (mix_i_src_c024_0_15 0 bpf_c024_0 0) vcvs gain=9.807852804032e-01
SMIXI_c024_0_15 (mix_i_src_c024_0_15 mix_i_c024_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_0_15 (mix_q_src_c024_0_15 0 bpf_c024_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_0_15 (mix_q_src_c024_0_15 mix_q_c024_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c024_0 (mix_i_c024_0 0) resistor r=1G
RMIXQ_c024_0 (mix_q_c024_0 0) resistor r=1G
RINTI_c024_0 (mix_i_c024_0 Icar_c024_0) resistor r=1k
CINTI_c024_0 (Icar_c024_0 0) capacitor c=80p
RINTQ_c024_0 (mix_q_c024_0 Qcar_c024_0) resistor r=1k
CINTQ_c024_0 (Qcar_c024_0 0) capacitor c=80p

// bl024, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c024_1 (bl024 n_cbpf_c024_1) capacitor c=1.013211836423e-13
LBPF_c024_1 (n_cbpf_c024_1 bpf_c024_1) inductor l=1.000000000000e-06
RBPF_c024_1 (bpf_c024_1 0) resistor r=1.570796326795e+02
EMIXI_c024_1_00 (mix_i_src_c024_1_00 0 bpf_c024_1 0) vcvs gain=9.807852804032e-01
SMIXI_c024_1_00 (mix_i_src_c024_1_00 mix_i_c024_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_00 (mix_q_src_c024_1_00 0 bpf_c024_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_1_00 (mix_q_src_c024_1_00 mix_q_c024_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_01 (mix_i_src_c024_1_01 0 bpf_c024_1 0) vcvs gain=8.314696123025e-01
SMIXI_c024_1_01 (mix_i_src_c024_1_01 mix_i_c024_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_01 (mix_q_src_c024_1_01 0 bpf_c024_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_1_01 (mix_q_src_c024_1_01 mix_q_c024_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_02 (mix_i_src_c024_1_02 0 bpf_c024_1 0) vcvs gain=5.555702330196e-01
SMIXI_c024_1_02 (mix_i_src_c024_1_02 mix_i_c024_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_02 (mix_q_src_c024_1_02 0 bpf_c024_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_1_02 (mix_q_src_c024_1_02 mix_q_c024_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_03 (mix_i_src_c024_1_03 0 bpf_c024_1 0) vcvs gain=1.950903220161e-01
SMIXI_c024_1_03 (mix_i_src_c024_1_03 mix_i_c024_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_03 (mix_q_src_c024_1_03 0 bpf_c024_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_1_03 (mix_q_src_c024_1_03 mix_q_c024_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_04 (mix_i_src_c024_1_04 0 bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_1_04 (mix_i_src_c024_1_04 mix_i_c024_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_04 (mix_q_src_c024_1_04 0 bpf_c024_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_1_04 (mix_q_src_c024_1_04 mix_q_c024_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_05 (mix_i_src_c024_1_05 0 bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_1_05 (mix_i_src_c024_1_05 mix_i_c024_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_05 (mix_q_src_c024_1_05 0 bpf_c024_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_1_05 (mix_q_src_c024_1_05 mix_q_c024_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_06 (mix_i_src_c024_1_06 0 bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_1_06 (mix_i_src_c024_1_06 mix_i_c024_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_06 (mix_q_src_c024_1_06 0 bpf_c024_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_1_06 (mix_q_src_c024_1_06 mix_q_c024_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_07 (mix_i_src_c024_1_07 0 bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_1_07 (mix_i_src_c024_1_07 mix_i_c024_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_07 (mix_q_src_c024_1_07 0 bpf_c024_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_1_07 (mix_q_src_c024_1_07 mix_q_c024_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_08 (mix_i_src_c024_1_08 0 bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_1_08 (mix_i_src_c024_1_08 mix_i_c024_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_08 (mix_q_src_c024_1_08 0 bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_1_08 (mix_q_src_c024_1_08 mix_q_c024_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_09 (mix_i_src_c024_1_09 0 bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_1_09 (mix_i_src_c024_1_09 mix_i_c024_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_09 (mix_q_src_c024_1_09 0 bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_1_09 (mix_q_src_c024_1_09 mix_q_c024_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_10 (mix_i_src_c024_1_10 0 bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_1_10 (mix_i_src_c024_1_10 mix_i_c024_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_10 (mix_q_src_c024_1_10 0 bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_1_10 (mix_q_src_c024_1_10 mix_q_c024_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_11 (mix_i_src_c024_1_11 0 bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_1_11 (mix_i_src_c024_1_11 mix_i_c024_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_11 (mix_q_src_c024_1_11 0 bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_1_11 (mix_q_src_c024_1_11 mix_q_c024_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_12 (mix_i_src_c024_1_12 0 bpf_c024_1 0) vcvs gain=1.950903220161e-01
SMIXI_c024_1_12 (mix_i_src_c024_1_12 mix_i_c024_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_12 (mix_q_src_c024_1_12 0 bpf_c024_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_1_12 (mix_q_src_c024_1_12 mix_q_c024_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_13 (mix_i_src_c024_1_13 0 bpf_c024_1 0) vcvs gain=5.555702330196e-01
SMIXI_c024_1_13 (mix_i_src_c024_1_13 mix_i_c024_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_13 (mix_q_src_c024_1_13 0 bpf_c024_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_1_13 (mix_q_src_c024_1_13 mix_q_c024_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_14 (mix_i_src_c024_1_14 0 bpf_c024_1 0) vcvs gain=8.314696123025e-01
SMIXI_c024_1_14 (mix_i_src_c024_1_14 mix_i_c024_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_14 (mix_q_src_c024_1_14 0 bpf_c024_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_1_14 (mix_q_src_c024_1_14 mix_q_c024_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_1_15 (mix_i_src_c024_1_15 0 bpf_c024_1 0) vcvs gain=9.807852804032e-01
SMIXI_c024_1_15 (mix_i_src_c024_1_15 mix_i_c024_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_1_15 (mix_q_src_c024_1_15 0 bpf_c024_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_1_15 (mix_q_src_c024_1_15 mix_q_c024_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c024_1 (mix_i_c024_1 0) resistor r=1G
RMIXQ_c024_1 (mix_q_c024_1 0) resistor r=1G
RINTI_c024_1 (mix_i_c024_1 Icar_c024_1) resistor r=1k
CINTI_c024_1 (Icar_c024_1 0) capacitor c=80p
RINTQ_c024_1 (mix_q_c024_1 Qcar_c024_1) resistor r=1k
CINTQ_c024_1 (Qcar_c024_1 0) capacitor c=80p

// bl024, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c024_2 (bl024 n_cbpf_c024_2) capacitor c=4.503163717437e-14
LBPF_c024_2 (n_cbpf_c024_2 bpf_c024_2) inductor l=1.000000000000e-06
RBPF_c024_2 (bpf_c024_2 0) resistor r=2.356194490192e+02
EMIXI_c024_2_00 (mix_i_src_c024_2_00 0 bpf_c024_2 0) vcvs gain=9.807852804032e-01
SMIXI_c024_2_00 (mix_i_src_c024_2_00 mix_i_c024_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_00 (mix_q_src_c024_2_00 0 bpf_c024_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_2_00 (mix_q_src_c024_2_00 mix_q_c024_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_01 (mix_i_src_c024_2_01 0 bpf_c024_2 0) vcvs gain=8.314696123025e-01
SMIXI_c024_2_01 (mix_i_src_c024_2_01 mix_i_c024_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_01 (mix_q_src_c024_2_01 0 bpf_c024_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_2_01 (mix_q_src_c024_2_01 mix_q_c024_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_02 (mix_i_src_c024_2_02 0 bpf_c024_2 0) vcvs gain=5.555702330196e-01
SMIXI_c024_2_02 (mix_i_src_c024_2_02 mix_i_c024_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_02 (mix_q_src_c024_2_02 0 bpf_c024_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_2_02 (mix_q_src_c024_2_02 mix_q_c024_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_03 (mix_i_src_c024_2_03 0 bpf_c024_2 0) vcvs gain=1.950903220161e-01
SMIXI_c024_2_03 (mix_i_src_c024_2_03 mix_i_c024_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_03 (mix_q_src_c024_2_03 0 bpf_c024_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_2_03 (mix_q_src_c024_2_03 mix_q_c024_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_04 (mix_i_src_c024_2_04 0 bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_2_04 (mix_i_src_c024_2_04 mix_i_c024_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_04 (mix_q_src_c024_2_04 0 bpf_c024_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_2_04 (mix_q_src_c024_2_04 mix_q_c024_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_05 (mix_i_src_c024_2_05 0 bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_2_05 (mix_i_src_c024_2_05 mix_i_c024_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_05 (mix_q_src_c024_2_05 0 bpf_c024_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_2_05 (mix_q_src_c024_2_05 mix_q_c024_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_06 (mix_i_src_c024_2_06 0 bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_2_06 (mix_i_src_c024_2_06 mix_i_c024_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_06 (mix_q_src_c024_2_06 0 bpf_c024_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_2_06 (mix_q_src_c024_2_06 mix_q_c024_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_07 (mix_i_src_c024_2_07 0 bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_2_07 (mix_i_src_c024_2_07 mix_i_c024_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_07 (mix_q_src_c024_2_07 0 bpf_c024_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_2_07 (mix_q_src_c024_2_07 mix_q_c024_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_08 (mix_i_src_c024_2_08 0 bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_2_08 (mix_i_src_c024_2_08 mix_i_c024_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_08 (mix_q_src_c024_2_08 0 bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_2_08 (mix_q_src_c024_2_08 mix_q_c024_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_09 (mix_i_src_c024_2_09 0 bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_2_09 (mix_i_src_c024_2_09 mix_i_c024_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_09 (mix_q_src_c024_2_09 0 bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_2_09 (mix_q_src_c024_2_09 mix_q_c024_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_10 (mix_i_src_c024_2_10 0 bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_2_10 (mix_i_src_c024_2_10 mix_i_c024_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_10 (mix_q_src_c024_2_10 0 bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_2_10 (mix_q_src_c024_2_10 mix_q_c024_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_11 (mix_i_src_c024_2_11 0 bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_2_11 (mix_i_src_c024_2_11 mix_i_c024_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_11 (mix_q_src_c024_2_11 0 bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_2_11 (mix_q_src_c024_2_11 mix_q_c024_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_12 (mix_i_src_c024_2_12 0 bpf_c024_2 0) vcvs gain=1.950903220161e-01
SMIXI_c024_2_12 (mix_i_src_c024_2_12 mix_i_c024_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_12 (mix_q_src_c024_2_12 0 bpf_c024_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_2_12 (mix_q_src_c024_2_12 mix_q_c024_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_13 (mix_i_src_c024_2_13 0 bpf_c024_2 0) vcvs gain=5.555702330196e-01
SMIXI_c024_2_13 (mix_i_src_c024_2_13 mix_i_c024_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_13 (mix_q_src_c024_2_13 0 bpf_c024_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_2_13 (mix_q_src_c024_2_13 mix_q_c024_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_14 (mix_i_src_c024_2_14 0 bpf_c024_2 0) vcvs gain=8.314696123025e-01
SMIXI_c024_2_14 (mix_i_src_c024_2_14 mix_i_c024_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_14 (mix_q_src_c024_2_14 0 bpf_c024_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_2_14 (mix_q_src_c024_2_14 mix_q_c024_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_2_15 (mix_i_src_c024_2_15 0 bpf_c024_2 0) vcvs gain=9.807852804032e-01
SMIXI_c024_2_15 (mix_i_src_c024_2_15 mix_i_c024_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_2_15 (mix_q_src_c024_2_15 0 bpf_c024_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_2_15 (mix_q_src_c024_2_15 mix_q_c024_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c024_2 (mix_i_c024_2 0) resistor r=1G
RMIXQ_c024_2 (mix_q_c024_2 0) resistor r=1G
RINTI_c024_2 (mix_i_c024_2 Icar_c024_2) resistor r=1k
CINTI_c024_2 (Icar_c024_2 0) capacitor c=80p
RINTQ_c024_2 (mix_q_c024_2 Qcar_c024_2) resistor r=1k
CINTQ_c024_2 (Qcar_c024_2 0) capacitor c=80p

// bl024, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c024_3 (bl024 n_cbpf_c024_3) capacitor c=2.533029591058e-14
LBPF_c024_3 (n_cbpf_c024_3 bpf_c024_3) inductor l=1.000000000000e-06
RBPF_c024_3 (bpf_c024_3 0) resistor r=3.141592653590e+02
EMIXI_c024_3_00 (mix_i_src_c024_3_00 0 bpf_c024_3 0) vcvs gain=9.807852804032e-01
SMIXI_c024_3_00 (mix_i_src_c024_3_00 mix_i_c024_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_00 (mix_q_src_c024_3_00 0 bpf_c024_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_3_00 (mix_q_src_c024_3_00 mix_q_c024_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_01 (mix_i_src_c024_3_01 0 bpf_c024_3 0) vcvs gain=8.314696123025e-01
SMIXI_c024_3_01 (mix_i_src_c024_3_01 mix_i_c024_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_01 (mix_q_src_c024_3_01 0 bpf_c024_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_3_01 (mix_q_src_c024_3_01 mix_q_c024_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_02 (mix_i_src_c024_3_02 0 bpf_c024_3 0) vcvs gain=5.555702330196e-01
SMIXI_c024_3_02 (mix_i_src_c024_3_02 mix_i_c024_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_02 (mix_q_src_c024_3_02 0 bpf_c024_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_3_02 (mix_q_src_c024_3_02 mix_q_c024_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_03 (mix_i_src_c024_3_03 0 bpf_c024_3 0) vcvs gain=1.950903220161e-01
SMIXI_c024_3_03 (mix_i_src_c024_3_03 mix_i_c024_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_03 (mix_q_src_c024_3_03 0 bpf_c024_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_3_03 (mix_q_src_c024_3_03 mix_q_c024_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_04 (mix_i_src_c024_3_04 0 bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_3_04 (mix_i_src_c024_3_04 mix_i_c024_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_04 (mix_q_src_c024_3_04 0 bpf_c024_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c024_3_04 (mix_q_src_c024_3_04 mix_q_c024_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_05 (mix_i_src_c024_3_05 0 bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_3_05 (mix_i_src_c024_3_05 mix_i_c024_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_05 (mix_q_src_c024_3_05 0 bpf_c024_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c024_3_05 (mix_q_src_c024_3_05 mix_q_c024_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_06 (mix_i_src_c024_3_06 0 bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_3_06 (mix_i_src_c024_3_06 mix_i_c024_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_06 (mix_q_src_c024_3_06 0 bpf_c024_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c024_3_06 (mix_q_src_c024_3_06 mix_q_c024_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_07 (mix_i_src_c024_3_07 0 bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_3_07 (mix_i_src_c024_3_07 mix_i_c024_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_07 (mix_q_src_c024_3_07 0 bpf_c024_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c024_3_07 (mix_q_src_c024_3_07 mix_q_c024_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_08 (mix_i_src_c024_3_08 0 bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c024_3_08 (mix_i_src_c024_3_08 mix_i_c024_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_08 (mix_q_src_c024_3_08 0 bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_3_08 (mix_q_src_c024_3_08 mix_q_c024_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_09 (mix_i_src_c024_3_09 0 bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c024_3_09 (mix_i_src_c024_3_09 mix_i_c024_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_09 (mix_q_src_c024_3_09 0 bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_3_09 (mix_q_src_c024_3_09 mix_q_c024_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_10 (mix_i_src_c024_3_10 0 bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c024_3_10 (mix_i_src_c024_3_10 mix_i_c024_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_10 (mix_q_src_c024_3_10 0 bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_3_10 (mix_q_src_c024_3_10 mix_q_c024_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_11 (mix_i_src_c024_3_11 0 bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c024_3_11 (mix_i_src_c024_3_11 mix_i_c024_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_11 (mix_q_src_c024_3_11 0 bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_3_11 (mix_q_src_c024_3_11 mix_q_c024_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_12 (mix_i_src_c024_3_12 0 bpf_c024_3 0) vcvs gain=1.950903220161e-01
SMIXI_c024_3_12 (mix_i_src_c024_3_12 mix_i_c024_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_12 (mix_q_src_c024_3_12 0 bpf_c024_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c024_3_12 (mix_q_src_c024_3_12 mix_q_c024_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_13 (mix_i_src_c024_3_13 0 bpf_c024_3 0) vcvs gain=5.555702330196e-01
SMIXI_c024_3_13 (mix_i_src_c024_3_13 mix_i_c024_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_13 (mix_q_src_c024_3_13 0 bpf_c024_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c024_3_13 (mix_q_src_c024_3_13 mix_q_c024_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_14 (mix_i_src_c024_3_14 0 bpf_c024_3 0) vcvs gain=8.314696123025e-01
SMIXI_c024_3_14 (mix_i_src_c024_3_14 mix_i_c024_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_14 (mix_q_src_c024_3_14 0 bpf_c024_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c024_3_14 (mix_q_src_c024_3_14 mix_q_c024_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c024_3_15 (mix_i_src_c024_3_15 0 bpf_c024_3 0) vcvs gain=9.807852804032e-01
SMIXI_c024_3_15 (mix_i_src_c024_3_15 mix_i_c024_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c024_3_15 (mix_q_src_c024_3_15 0 bpf_c024_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c024_3_15 (mix_q_src_c024_3_15 mix_q_c024_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c024_3 (mix_i_c024_3 0) resistor r=1G
RMIXQ_c024_3 (mix_q_c024_3 0) resistor r=1G
RINTI_c024_3 (mix_i_c024_3 Icar_c024_3) resistor r=1k
CINTI_c024_3 (Icar_c024_3 0) capacitor c=80p
RINTQ_c024_3 (mix_q_c024_3 Qcar_c024_3) resistor r=1k
CINTQ_c024_3 (Qcar_c024_3 0) capacitor c=80p

// bl025, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c025_0 (bl025 n_cbpf_c025_0) capacitor c=4.052847345694e-13
LBPF_c025_0 (n_cbpf_c025_0 bpf_c025_0) inductor l=1.000000000000e-06
RBPF_c025_0 (bpf_c025_0 0) resistor r=7.853981633974e+01
EMIXI_c025_0_00 (mix_i_src_c025_0_00 0 bpf_c025_0 0) vcvs gain=9.807852804032e-01
SMIXI_c025_0_00 (mix_i_src_c025_0_00 mix_i_c025_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_00 (mix_q_src_c025_0_00 0 bpf_c025_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_0_00 (mix_q_src_c025_0_00 mix_q_c025_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_01 (mix_i_src_c025_0_01 0 bpf_c025_0 0) vcvs gain=8.314696123025e-01
SMIXI_c025_0_01 (mix_i_src_c025_0_01 mix_i_c025_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_01 (mix_q_src_c025_0_01 0 bpf_c025_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_0_01 (mix_q_src_c025_0_01 mix_q_c025_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_02 (mix_i_src_c025_0_02 0 bpf_c025_0 0) vcvs gain=5.555702330196e-01
SMIXI_c025_0_02 (mix_i_src_c025_0_02 mix_i_c025_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_02 (mix_q_src_c025_0_02 0 bpf_c025_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_0_02 (mix_q_src_c025_0_02 mix_q_c025_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_03 (mix_i_src_c025_0_03 0 bpf_c025_0 0) vcvs gain=1.950903220161e-01
SMIXI_c025_0_03 (mix_i_src_c025_0_03 mix_i_c025_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_03 (mix_q_src_c025_0_03 0 bpf_c025_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_0_03 (mix_q_src_c025_0_03 mix_q_c025_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_04 (mix_i_src_c025_0_04 0 bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_0_04 (mix_i_src_c025_0_04 mix_i_c025_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_04 (mix_q_src_c025_0_04 0 bpf_c025_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_0_04 (mix_q_src_c025_0_04 mix_q_c025_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_05 (mix_i_src_c025_0_05 0 bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_0_05 (mix_i_src_c025_0_05 mix_i_c025_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_05 (mix_q_src_c025_0_05 0 bpf_c025_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_0_05 (mix_q_src_c025_0_05 mix_q_c025_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_06 (mix_i_src_c025_0_06 0 bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_0_06 (mix_i_src_c025_0_06 mix_i_c025_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_06 (mix_q_src_c025_0_06 0 bpf_c025_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_0_06 (mix_q_src_c025_0_06 mix_q_c025_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_07 (mix_i_src_c025_0_07 0 bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_0_07 (mix_i_src_c025_0_07 mix_i_c025_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_07 (mix_q_src_c025_0_07 0 bpf_c025_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_0_07 (mix_q_src_c025_0_07 mix_q_c025_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_08 (mix_i_src_c025_0_08 0 bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_0_08 (mix_i_src_c025_0_08 mix_i_c025_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_08 (mix_q_src_c025_0_08 0 bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_0_08 (mix_q_src_c025_0_08 mix_q_c025_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_09 (mix_i_src_c025_0_09 0 bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_0_09 (mix_i_src_c025_0_09 mix_i_c025_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_09 (mix_q_src_c025_0_09 0 bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_0_09 (mix_q_src_c025_0_09 mix_q_c025_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_10 (mix_i_src_c025_0_10 0 bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_0_10 (mix_i_src_c025_0_10 mix_i_c025_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_10 (mix_q_src_c025_0_10 0 bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_0_10 (mix_q_src_c025_0_10 mix_q_c025_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_11 (mix_i_src_c025_0_11 0 bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_0_11 (mix_i_src_c025_0_11 mix_i_c025_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_11 (mix_q_src_c025_0_11 0 bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_0_11 (mix_q_src_c025_0_11 mix_q_c025_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_12 (mix_i_src_c025_0_12 0 bpf_c025_0 0) vcvs gain=1.950903220161e-01
SMIXI_c025_0_12 (mix_i_src_c025_0_12 mix_i_c025_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_12 (mix_q_src_c025_0_12 0 bpf_c025_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_0_12 (mix_q_src_c025_0_12 mix_q_c025_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_13 (mix_i_src_c025_0_13 0 bpf_c025_0 0) vcvs gain=5.555702330196e-01
SMIXI_c025_0_13 (mix_i_src_c025_0_13 mix_i_c025_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_13 (mix_q_src_c025_0_13 0 bpf_c025_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_0_13 (mix_q_src_c025_0_13 mix_q_c025_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_14 (mix_i_src_c025_0_14 0 bpf_c025_0 0) vcvs gain=8.314696123025e-01
SMIXI_c025_0_14 (mix_i_src_c025_0_14 mix_i_c025_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_14 (mix_q_src_c025_0_14 0 bpf_c025_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_0_14 (mix_q_src_c025_0_14 mix_q_c025_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_0_15 (mix_i_src_c025_0_15 0 bpf_c025_0 0) vcvs gain=9.807852804032e-01
SMIXI_c025_0_15 (mix_i_src_c025_0_15 mix_i_c025_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_0_15 (mix_q_src_c025_0_15 0 bpf_c025_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_0_15 (mix_q_src_c025_0_15 mix_q_c025_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c025_0 (mix_i_c025_0 0) resistor r=1G
RMIXQ_c025_0 (mix_q_c025_0 0) resistor r=1G
RINTI_c025_0 (mix_i_c025_0 Icar_c025_0) resistor r=1k
CINTI_c025_0 (Icar_c025_0 0) capacitor c=80p
RINTQ_c025_0 (mix_q_c025_0 Qcar_c025_0) resistor r=1k
CINTQ_c025_0 (Qcar_c025_0 0) capacitor c=80p

// bl025, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c025_1 (bl025 n_cbpf_c025_1) capacitor c=1.013211836423e-13
LBPF_c025_1 (n_cbpf_c025_1 bpf_c025_1) inductor l=1.000000000000e-06
RBPF_c025_1 (bpf_c025_1 0) resistor r=1.570796326795e+02
EMIXI_c025_1_00 (mix_i_src_c025_1_00 0 bpf_c025_1 0) vcvs gain=9.807852804032e-01
SMIXI_c025_1_00 (mix_i_src_c025_1_00 mix_i_c025_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_00 (mix_q_src_c025_1_00 0 bpf_c025_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_1_00 (mix_q_src_c025_1_00 mix_q_c025_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_01 (mix_i_src_c025_1_01 0 bpf_c025_1 0) vcvs gain=8.314696123025e-01
SMIXI_c025_1_01 (mix_i_src_c025_1_01 mix_i_c025_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_01 (mix_q_src_c025_1_01 0 bpf_c025_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_1_01 (mix_q_src_c025_1_01 mix_q_c025_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_02 (mix_i_src_c025_1_02 0 bpf_c025_1 0) vcvs gain=5.555702330196e-01
SMIXI_c025_1_02 (mix_i_src_c025_1_02 mix_i_c025_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_02 (mix_q_src_c025_1_02 0 bpf_c025_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_1_02 (mix_q_src_c025_1_02 mix_q_c025_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_03 (mix_i_src_c025_1_03 0 bpf_c025_1 0) vcvs gain=1.950903220161e-01
SMIXI_c025_1_03 (mix_i_src_c025_1_03 mix_i_c025_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_03 (mix_q_src_c025_1_03 0 bpf_c025_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_1_03 (mix_q_src_c025_1_03 mix_q_c025_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_04 (mix_i_src_c025_1_04 0 bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_1_04 (mix_i_src_c025_1_04 mix_i_c025_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_04 (mix_q_src_c025_1_04 0 bpf_c025_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_1_04 (mix_q_src_c025_1_04 mix_q_c025_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_05 (mix_i_src_c025_1_05 0 bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_1_05 (mix_i_src_c025_1_05 mix_i_c025_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_05 (mix_q_src_c025_1_05 0 bpf_c025_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_1_05 (mix_q_src_c025_1_05 mix_q_c025_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_06 (mix_i_src_c025_1_06 0 bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_1_06 (mix_i_src_c025_1_06 mix_i_c025_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_06 (mix_q_src_c025_1_06 0 bpf_c025_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_1_06 (mix_q_src_c025_1_06 mix_q_c025_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_07 (mix_i_src_c025_1_07 0 bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_1_07 (mix_i_src_c025_1_07 mix_i_c025_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_07 (mix_q_src_c025_1_07 0 bpf_c025_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_1_07 (mix_q_src_c025_1_07 mix_q_c025_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_08 (mix_i_src_c025_1_08 0 bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_1_08 (mix_i_src_c025_1_08 mix_i_c025_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_08 (mix_q_src_c025_1_08 0 bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_1_08 (mix_q_src_c025_1_08 mix_q_c025_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_09 (mix_i_src_c025_1_09 0 bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_1_09 (mix_i_src_c025_1_09 mix_i_c025_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_09 (mix_q_src_c025_1_09 0 bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_1_09 (mix_q_src_c025_1_09 mix_q_c025_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_10 (mix_i_src_c025_1_10 0 bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_1_10 (mix_i_src_c025_1_10 mix_i_c025_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_10 (mix_q_src_c025_1_10 0 bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_1_10 (mix_q_src_c025_1_10 mix_q_c025_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_11 (mix_i_src_c025_1_11 0 bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_1_11 (mix_i_src_c025_1_11 mix_i_c025_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_11 (mix_q_src_c025_1_11 0 bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_1_11 (mix_q_src_c025_1_11 mix_q_c025_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_12 (mix_i_src_c025_1_12 0 bpf_c025_1 0) vcvs gain=1.950903220161e-01
SMIXI_c025_1_12 (mix_i_src_c025_1_12 mix_i_c025_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_12 (mix_q_src_c025_1_12 0 bpf_c025_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_1_12 (mix_q_src_c025_1_12 mix_q_c025_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_13 (mix_i_src_c025_1_13 0 bpf_c025_1 0) vcvs gain=5.555702330196e-01
SMIXI_c025_1_13 (mix_i_src_c025_1_13 mix_i_c025_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_13 (mix_q_src_c025_1_13 0 bpf_c025_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_1_13 (mix_q_src_c025_1_13 mix_q_c025_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_14 (mix_i_src_c025_1_14 0 bpf_c025_1 0) vcvs gain=8.314696123025e-01
SMIXI_c025_1_14 (mix_i_src_c025_1_14 mix_i_c025_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_14 (mix_q_src_c025_1_14 0 bpf_c025_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_1_14 (mix_q_src_c025_1_14 mix_q_c025_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_1_15 (mix_i_src_c025_1_15 0 bpf_c025_1 0) vcvs gain=9.807852804032e-01
SMIXI_c025_1_15 (mix_i_src_c025_1_15 mix_i_c025_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_1_15 (mix_q_src_c025_1_15 0 bpf_c025_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_1_15 (mix_q_src_c025_1_15 mix_q_c025_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c025_1 (mix_i_c025_1 0) resistor r=1G
RMIXQ_c025_1 (mix_q_c025_1 0) resistor r=1G
RINTI_c025_1 (mix_i_c025_1 Icar_c025_1) resistor r=1k
CINTI_c025_1 (Icar_c025_1 0) capacitor c=80p
RINTQ_c025_1 (mix_q_c025_1 Qcar_c025_1) resistor r=1k
CINTQ_c025_1 (Qcar_c025_1 0) capacitor c=80p

// bl025, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c025_2 (bl025 n_cbpf_c025_2) capacitor c=4.503163717437e-14
LBPF_c025_2 (n_cbpf_c025_2 bpf_c025_2) inductor l=1.000000000000e-06
RBPF_c025_2 (bpf_c025_2 0) resistor r=2.356194490192e+02
EMIXI_c025_2_00 (mix_i_src_c025_2_00 0 bpf_c025_2 0) vcvs gain=9.807852804032e-01
SMIXI_c025_2_00 (mix_i_src_c025_2_00 mix_i_c025_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_00 (mix_q_src_c025_2_00 0 bpf_c025_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_2_00 (mix_q_src_c025_2_00 mix_q_c025_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_01 (mix_i_src_c025_2_01 0 bpf_c025_2 0) vcvs gain=8.314696123025e-01
SMIXI_c025_2_01 (mix_i_src_c025_2_01 mix_i_c025_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_01 (mix_q_src_c025_2_01 0 bpf_c025_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_2_01 (mix_q_src_c025_2_01 mix_q_c025_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_02 (mix_i_src_c025_2_02 0 bpf_c025_2 0) vcvs gain=5.555702330196e-01
SMIXI_c025_2_02 (mix_i_src_c025_2_02 mix_i_c025_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_02 (mix_q_src_c025_2_02 0 bpf_c025_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_2_02 (mix_q_src_c025_2_02 mix_q_c025_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_03 (mix_i_src_c025_2_03 0 bpf_c025_2 0) vcvs gain=1.950903220161e-01
SMIXI_c025_2_03 (mix_i_src_c025_2_03 mix_i_c025_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_03 (mix_q_src_c025_2_03 0 bpf_c025_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_2_03 (mix_q_src_c025_2_03 mix_q_c025_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_04 (mix_i_src_c025_2_04 0 bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_2_04 (mix_i_src_c025_2_04 mix_i_c025_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_04 (mix_q_src_c025_2_04 0 bpf_c025_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_2_04 (mix_q_src_c025_2_04 mix_q_c025_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_05 (mix_i_src_c025_2_05 0 bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_2_05 (mix_i_src_c025_2_05 mix_i_c025_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_05 (mix_q_src_c025_2_05 0 bpf_c025_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_2_05 (mix_q_src_c025_2_05 mix_q_c025_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_06 (mix_i_src_c025_2_06 0 bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_2_06 (mix_i_src_c025_2_06 mix_i_c025_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_06 (mix_q_src_c025_2_06 0 bpf_c025_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_2_06 (mix_q_src_c025_2_06 mix_q_c025_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_07 (mix_i_src_c025_2_07 0 bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_2_07 (mix_i_src_c025_2_07 mix_i_c025_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_07 (mix_q_src_c025_2_07 0 bpf_c025_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_2_07 (mix_q_src_c025_2_07 mix_q_c025_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_08 (mix_i_src_c025_2_08 0 bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_2_08 (mix_i_src_c025_2_08 mix_i_c025_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_08 (mix_q_src_c025_2_08 0 bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_2_08 (mix_q_src_c025_2_08 mix_q_c025_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_09 (mix_i_src_c025_2_09 0 bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_2_09 (mix_i_src_c025_2_09 mix_i_c025_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_09 (mix_q_src_c025_2_09 0 bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_2_09 (mix_q_src_c025_2_09 mix_q_c025_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_10 (mix_i_src_c025_2_10 0 bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_2_10 (mix_i_src_c025_2_10 mix_i_c025_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_10 (mix_q_src_c025_2_10 0 bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_2_10 (mix_q_src_c025_2_10 mix_q_c025_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_11 (mix_i_src_c025_2_11 0 bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_2_11 (mix_i_src_c025_2_11 mix_i_c025_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_11 (mix_q_src_c025_2_11 0 bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_2_11 (mix_q_src_c025_2_11 mix_q_c025_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_12 (mix_i_src_c025_2_12 0 bpf_c025_2 0) vcvs gain=1.950903220161e-01
SMIXI_c025_2_12 (mix_i_src_c025_2_12 mix_i_c025_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_12 (mix_q_src_c025_2_12 0 bpf_c025_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_2_12 (mix_q_src_c025_2_12 mix_q_c025_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_13 (mix_i_src_c025_2_13 0 bpf_c025_2 0) vcvs gain=5.555702330196e-01
SMIXI_c025_2_13 (mix_i_src_c025_2_13 mix_i_c025_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_13 (mix_q_src_c025_2_13 0 bpf_c025_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_2_13 (mix_q_src_c025_2_13 mix_q_c025_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_14 (mix_i_src_c025_2_14 0 bpf_c025_2 0) vcvs gain=8.314696123025e-01
SMIXI_c025_2_14 (mix_i_src_c025_2_14 mix_i_c025_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_14 (mix_q_src_c025_2_14 0 bpf_c025_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_2_14 (mix_q_src_c025_2_14 mix_q_c025_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_2_15 (mix_i_src_c025_2_15 0 bpf_c025_2 0) vcvs gain=9.807852804032e-01
SMIXI_c025_2_15 (mix_i_src_c025_2_15 mix_i_c025_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_2_15 (mix_q_src_c025_2_15 0 bpf_c025_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_2_15 (mix_q_src_c025_2_15 mix_q_c025_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c025_2 (mix_i_c025_2 0) resistor r=1G
RMIXQ_c025_2 (mix_q_c025_2 0) resistor r=1G
RINTI_c025_2 (mix_i_c025_2 Icar_c025_2) resistor r=1k
CINTI_c025_2 (Icar_c025_2 0) capacitor c=80p
RINTQ_c025_2 (mix_q_c025_2 Qcar_c025_2) resistor r=1k
CINTQ_c025_2 (Qcar_c025_2 0) capacitor c=80p

// bl025, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c025_3 (bl025 n_cbpf_c025_3) capacitor c=2.533029591058e-14
LBPF_c025_3 (n_cbpf_c025_3 bpf_c025_3) inductor l=1.000000000000e-06
RBPF_c025_3 (bpf_c025_3 0) resistor r=3.141592653590e+02
EMIXI_c025_3_00 (mix_i_src_c025_3_00 0 bpf_c025_3 0) vcvs gain=9.807852804032e-01
SMIXI_c025_3_00 (mix_i_src_c025_3_00 mix_i_c025_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_00 (mix_q_src_c025_3_00 0 bpf_c025_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_3_00 (mix_q_src_c025_3_00 mix_q_c025_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_01 (mix_i_src_c025_3_01 0 bpf_c025_3 0) vcvs gain=8.314696123025e-01
SMIXI_c025_3_01 (mix_i_src_c025_3_01 mix_i_c025_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_01 (mix_q_src_c025_3_01 0 bpf_c025_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_3_01 (mix_q_src_c025_3_01 mix_q_c025_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_02 (mix_i_src_c025_3_02 0 bpf_c025_3 0) vcvs gain=5.555702330196e-01
SMIXI_c025_3_02 (mix_i_src_c025_3_02 mix_i_c025_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_02 (mix_q_src_c025_3_02 0 bpf_c025_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_3_02 (mix_q_src_c025_3_02 mix_q_c025_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_03 (mix_i_src_c025_3_03 0 bpf_c025_3 0) vcvs gain=1.950903220161e-01
SMIXI_c025_3_03 (mix_i_src_c025_3_03 mix_i_c025_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_03 (mix_q_src_c025_3_03 0 bpf_c025_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_3_03 (mix_q_src_c025_3_03 mix_q_c025_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_04 (mix_i_src_c025_3_04 0 bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_3_04 (mix_i_src_c025_3_04 mix_i_c025_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_04 (mix_q_src_c025_3_04 0 bpf_c025_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c025_3_04 (mix_q_src_c025_3_04 mix_q_c025_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_05 (mix_i_src_c025_3_05 0 bpf_c025_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_3_05 (mix_i_src_c025_3_05 mix_i_c025_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_05 (mix_q_src_c025_3_05 0 bpf_c025_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c025_3_05 (mix_q_src_c025_3_05 mix_q_c025_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_06 (mix_i_src_c025_3_06 0 bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_3_06 (mix_i_src_c025_3_06 mix_i_c025_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_06 (mix_q_src_c025_3_06 0 bpf_c025_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c025_3_06 (mix_q_src_c025_3_06 mix_q_c025_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_07 (mix_i_src_c025_3_07 0 bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_3_07 (mix_i_src_c025_3_07 mix_i_c025_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_07 (mix_q_src_c025_3_07 0 bpf_c025_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c025_3_07 (mix_q_src_c025_3_07 mix_q_c025_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_08 (mix_i_src_c025_3_08 0 bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c025_3_08 (mix_i_src_c025_3_08 mix_i_c025_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_08 (mix_q_src_c025_3_08 0 bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_3_08 (mix_q_src_c025_3_08 mix_q_c025_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_09 (mix_i_src_c025_3_09 0 bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c025_3_09 (mix_i_src_c025_3_09 mix_i_c025_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_09 (mix_q_src_c025_3_09 0 bpf_c025_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_3_09 (mix_q_src_c025_3_09 mix_q_c025_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_10 (mix_i_src_c025_3_10 0 bpf_c025_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c025_3_10 (mix_i_src_c025_3_10 mix_i_c025_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_10 (mix_q_src_c025_3_10 0 bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_3_10 (mix_q_src_c025_3_10 mix_q_c025_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_11 (mix_i_src_c025_3_11 0 bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c025_3_11 (mix_i_src_c025_3_11 mix_i_c025_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_11 (mix_q_src_c025_3_11 0 bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_3_11 (mix_q_src_c025_3_11 mix_q_c025_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_12 (mix_i_src_c025_3_12 0 bpf_c025_3 0) vcvs gain=1.950903220161e-01
SMIXI_c025_3_12 (mix_i_src_c025_3_12 mix_i_c025_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_12 (mix_q_src_c025_3_12 0 bpf_c025_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c025_3_12 (mix_q_src_c025_3_12 mix_q_c025_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_13 (mix_i_src_c025_3_13 0 bpf_c025_3 0) vcvs gain=5.555702330196e-01
SMIXI_c025_3_13 (mix_i_src_c025_3_13 mix_i_c025_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_13 (mix_q_src_c025_3_13 0 bpf_c025_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c025_3_13 (mix_q_src_c025_3_13 mix_q_c025_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_14 (mix_i_src_c025_3_14 0 bpf_c025_3 0) vcvs gain=8.314696123025e-01
SMIXI_c025_3_14 (mix_i_src_c025_3_14 mix_i_c025_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_14 (mix_q_src_c025_3_14 0 bpf_c025_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c025_3_14 (mix_q_src_c025_3_14 mix_q_c025_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c025_3_15 (mix_i_src_c025_3_15 0 bpf_c025_3 0) vcvs gain=9.807852804032e-01
SMIXI_c025_3_15 (mix_i_src_c025_3_15 mix_i_c025_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c025_3_15 (mix_q_src_c025_3_15 0 bpf_c025_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c025_3_15 (mix_q_src_c025_3_15 mix_q_c025_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c025_3 (mix_i_c025_3 0) resistor r=1G
RMIXQ_c025_3 (mix_q_c025_3 0) resistor r=1G
RINTI_c025_3 (mix_i_c025_3 Icar_c025_3) resistor r=1k
CINTI_c025_3 (Icar_c025_3 0) capacitor c=80p
RINTQ_c025_3 (mix_q_c025_3 Qcar_c025_3) resistor r=1k
CINTQ_c025_3 (Qcar_c025_3 0) capacitor c=80p

// bl026, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c026_0 (bl026 n_cbpf_c026_0) capacitor c=4.052847345694e-13
LBPF_c026_0 (n_cbpf_c026_0 bpf_c026_0) inductor l=1.000000000000e-06
RBPF_c026_0 (bpf_c026_0 0) resistor r=7.853981633974e+01
EMIXI_c026_0_00 (mix_i_src_c026_0_00 0 bpf_c026_0 0) vcvs gain=9.807852804032e-01
SMIXI_c026_0_00 (mix_i_src_c026_0_00 mix_i_c026_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_00 (mix_q_src_c026_0_00 0 bpf_c026_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_0_00 (mix_q_src_c026_0_00 mix_q_c026_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_01 (mix_i_src_c026_0_01 0 bpf_c026_0 0) vcvs gain=8.314696123025e-01
SMIXI_c026_0_01 (mix_i_src_c026_0_01 mix_i_c026_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_01 (mix_q_src_c026_0_01 0 bpf_c026_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_0_01 (mix_q_src_c026_0_01 mix_q_c026_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_02 (mix_i_src_c026_0_02 0 bpf_c026_0 0) vcvs gain=5.555702330196e-01
SMIXI_c026_0_02 (mix_i_src_c026_0_02 mix_i_c026_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_02 (mix_q_src_c026_0_02 0 bpf_c026_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_0_02 (mix_q_src_c026_0_02 mix_q_c026_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_03 (mix_i_src_c026_0_03 0 bpf_c026_0 0) vcvs gain=1.950903220161e-01
SMIXI_c026_0_03 (mix_i_src_c026_0_03 mix_i_c026_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_03 (mix_q_src_c026_0_03 0 bpf_c026_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_0_03 (mix_q_src_c026_0_03 mix_q_c026_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_04 (mix_i_src_c026_0_04 0 bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_0_04 (mix_i_src_c026_0_04 mix_i_c026_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_04 (mix_q_src_c026_0_04 0 bpf_c026_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_0_04 (mix_q_src_c026_0_04 mix_q_c026_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_05 (mix_i_src_c026_0_05 0 bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_0_05 (mix_i_src_c026_0_05 mix_i_c026_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_05 (mix_q_src_c026_0_05 0 bpf_c026_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_0_05 (mix_q_src_c026_0_05 mix_q_c026_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_06 (mix_i_src_c026_0_06 0 bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_0_06 (mix_i_src_c026_0_06 mix_i_c026_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_06 (mix_q_src_c026_0_06 0 bpf_c026_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_0_06 (mix_q_src_c026_0_06 mix_q_c026_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_07 (mix_i_src_c026_0_07 0 bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_0_07 (mix_i_src_c026_0_07 mix_i_c026_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_07 (mix_q_src_c026_0_07 0 bpf_c026_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_0_07 (mix_q_src_c026_0_07 mix_q_c026_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_08 (mix_i_src_c026_0_08 0 bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_0_08 (mix_i_src_c026_0_08 mix_i_c026_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_08 (mix_q_src_c026_0_08 0 bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_0_08 (mix_q_src_c026_0_08 mix_q_c026_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_09 (mix_i_src_c026_0_09 0 bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_0_09 (mix_i_src_c026_0_09 mix_i_c026_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_09 (mix_q_src_c026_0_09 0 bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_0_09 (mix_q_src_c026_0_09 mix_q_c026_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_10 (mix_i_src_c026_0_10 0 bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_0_10 (mix_i_src_c026_0_10 mix_i_c026_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_10 (mix_q_src_c026_0_10 0 bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_0_10 (mix_q_src_c026_0_10 mix_q_c026_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_11 (mix_i_src_c026_0_11 0 bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_0_11 (mix_i_src_c026_0_11 mix_i_c026_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_11 (mix_q_src_c026_0_11 0 bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_0_11 (mix_q_src_c026_0_11 mix_q_c026_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_12 (mix_i_src_c026_0_12 0 bpf_c026_0 0) vcvs gain=1.950903220161e-01
SMIXI_c026_0_12 (mix_i_src_c026_0_12 mix_i_c026_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_12 (mix_q_src_c026_0_12 0 bpf_c026_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_0_12 (mix_q_src_c026_0_12 mix_q_c026_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_13 (mix_i_src_c026_0_13 0 bpf_c026_0 0) vcvs gain=5.555702330196e-01
SMIXI_c026_0_13 (mix_i_src_c026_0_13 mix_i_c026_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_13 (mix_q_src_c026_0_13 0 bpf_c026_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_0_13 (mix_q_src_c026_0_13 mix_q_c026_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_14 (mix_i_src_c026_0_14 0 bpf_c026_0 0) vcvs gain=8.314696123025e-01
SMIXI_c026_0_14 (mix_i_src_c026_0_14 mix_i_c026_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_14 (mix_q_src_c026_0_14 0 bpf_c026_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_0_14 (mix_q_src_c026_0_14 mix_q_c026_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_0_15 (mix_i_src_c026_0_15 0 bpf_c026_0 0) vcvs gain=9.807852804032e-01
SMIXI_c026_0_15 (mix_i_src_c026_0_15 mix_i_c026_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_0_15 (mix_q_src_c026_0_15 0 bpf_c026_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_0_15 (mix_q_src_c026_0_15 mix_q_c026_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c026_0 (mix_i_c026_0 0) resistor r=1G
RMIXQ_c026_0 (mix_q_c026_0 0) resistor r=1G
RINTI_c026_0 (mix_i_c026_0 Icar_c026_0) resistor r=1k
CINTI_c026_0 (Icar_c026_0 0) capacitor c=80p
RINTQ_c026_0 (mix_q_c026_0 Qcar_c026_0) resistor r=1k
CINTQ_c026_0 (Qcar_c026_0 0) capacitor c=80p

// bl026, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c026_1 (bl026 n_cbpf_c026_1) capacitor c=1.013211836423e-13
LBPF_c026_1 (n_cbpf_c026_1 bpf_c026_1) inductor l=1.000000000000e-06
RBPF_c026_1 (bpf_c026_1 0) resistor r=1.570796326795e+02
EMIXI_c026_1_00 (mix_i_src_c026_1_00 0 bpf_c026_1 0) vcvs gain=9.807852804032e-01
SMIXI_c026_1_00 (mix_i_src_c026_1_00 mix_i_c026_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_00 (mix_q_src_c026_1_00 0 bpf_c026_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_1_00 (mix_q_src_c026_1_00 mix_q_c026_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_01 (mix_i_src_c026_1_01 0 bpf_c026_1 0) vcvs gain=8.314696123025e-01
SMIXI_c026_1_01 (mix_i_src_c026_1_01 mix_i_c026_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_01 (mix_q_src_c026_1_01 0 bpf_c026_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_1_01 (mix_q_src_c026_1_01 mix_q_c026_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_02 (mix_i_src_c026_1_02 0 bpf_c026_1 0) vcvs gain=5.555702330196e-01
SMIXI_c026_1_02 (mix_i_src_c026_1_02 mix_i_c026_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_02 (mix_q_src_c026_1_02 0 bpf_c026_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_1_02 (mix_q_src_c026_1_02 mix_q_c026_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_03 (mix_i_src_c026_1_03 0 bpf_c026_1 0) vcvs gain=1.950903220161e-01
SMIXI_c026_1_03 (mix_i_src_c026_1_03 mix_i_c026_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_03 (mix_q_src_c026_1_03 0 bpf_c026_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_1_03 (mix_q_src_c026_1_03 mix_q_c026_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_04 (mix_i_src_c026_1_04 0 bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_1_04 (mix_i_src_c026_1_04 mix_i_c026_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_04 (mix_q_src_c026_1_04 0 bpf_c026_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_1_04 (mix_q_src_c026_1_04 mix_q_c026_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_05 (mix_i_src_c026_1_05 0 bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_1_05 (mix_i_src_c026_1_05 mix_i_c026_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_05 (mix_q_src_c026_1_05 0 bpf_c026_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_1_05 (mix_q_src_c026_1_05 mix_q_c026_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_06 (mix_i_src_c026_1_06 0 bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_1_06 (mix_i_src_c026_1_06 mix_i_c026_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_06 (mix_q_src_c026_1_06 0 bpf_c026_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_1_06 (mix_q_src_c026_1_06 mix_q_c026_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_07 (mix_i_src_c026_1_07 0 bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_1_07 (mix_i_src_c026_1_07 mix_i_c026_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_07 (mix_q_src_c026_1_07 0 bpf_c026_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_1_07 (mix_q_src_c026_1_07 mix_q_c026_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_08 (mix_i_src_c026_1_08 0 bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_1_08 (mix_i_src_c026_1_08 mix_i_c026_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_08 (mix_q_src_c026_1_08 0 bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_1_08 (mix_q_src_c026_1_08 mix_q_c026_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_09 (mix_i_src_c026_1_09 0 bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_1_09 (mix_i_src_c026_1_09 mix_i_c026_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_09 (mix_q_src_c026_1_09 0 bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_1_09 (mix_q_src_c026_1_09 mix_q_c026_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_10 (mix_i_src_c026_1_10 0 bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_1_10 (mix_i_src_c026_1_10 mix_i_c026_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_10 (mix_q_src_c026_1_10 0 bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_1_10 (mix_q_src_c026_1_10 mix_q_c026_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_11 (mix_i_src_c026_1_11 0 bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_1_11 (mix_i_src_c026_1_11 mix_i_c026_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_11 (mix_q_src_c026_1_11 0 bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_1_11 (mix_q_src_c026_1_11 mix_q_c026_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_12 (mix_i_src_c026_1_12 0 bpf_c026_1 0) vcvs gain=1.950903220161e-01
SMIXI_c026_1_12 (mix_i_src_c026_1_12 mix_i_c026_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_12 (mix_q_src_c026_1_12 0 bpf_c026_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_1_12 (mix_q_src_c026_1_12 mix_q_c026_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_13 (mix_i_src_c026_1_13 0 bpf_c026_1 0) vcvs gain=5.555702330196e-01
SMIXI_c026_1_13 (mix_i_src_c026_1_13 mix_i_c026_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_13 (mix_q_src_c026_1_13 0 bpf_c026_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_1_13 (mix_q_src_c026_1_13 mix_q_c026_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_14 (mix_i_src_c026_1_14 0 bpf_c026_1 0) vcvs gain=8.314696123025e-01
SMIXI_c026_1_14 (mix_i_src_c026_1_14 mix_i_c026_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_14 (mix_q_src_c026_1_14 0 bpf_c026_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_1_14 (mix_q_src_c026_1_14 mix_q_c026_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_1_15 (mix_i_src_c026_1_15 0 bpf_c026_1 0) vcvs gain=9.807852804032e-01
SMIXI_c026_1_15 (mix_i_src_c026_1_15 mix_i_c026_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_1_15 (mix_q_src_c026_1_15 0 bpf_c026_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_1_15 (mix_q_src_c026_1_15 mix_q_c026_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c026_1 (mix_i_c026_1 0) resistor r=1G
RMIXQ_c026_1 (mix_q_c026_1 0) resistor r=1G
RINTI_c026_1 (mix_i_c026_1 Icar_c026_1) resistor r=1k
CINTI_c026_1 (Icar_c026_1 0) capacitor c=80p
RINTQ_c026_1 (mix_q_c026_1 Qcar_c026_1) resistor r=1k
CINTQ_c026_1 (Qcar_c026_1 0) capacitor c=80p

// bl026, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c026_2 (bl026 n_cbpf_c026_2) capacitor c=4.503163717437e-14
LBPF_c026_2 (n_cbpf_c026_2 bpf_c026_2) inductor l=1.000000000000e-06
RBPF_c026_2 (bpf_c026_2 0) resistor r=2.356194490192e+02
EMIXI_c026_2_00 (mix_i_src_c026_2_00 0 bpf_c026_2 0) vcvs gain=9.807852804032e-01
SMIXI_c026_2_00 (mix_i_src_c026_2_00 mix_i_c026_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_00 (mix_q_src_c026_2_00 0 bpf_c026_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_2_00 (mix_q_src_c026_2_00 mix_q_c026_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_01 (mix_i_src_c026_2_01 0 bpf_c026_2 0) vcvs gain=8.314696123025e-01
SMIXI_c026_2_01 (mix_i_src_c026_2_01 mix_i_c026_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_01 (mix_q_src_c026_2_01 0 bpf_c026_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_2_01 (mix_q_src_c026_2_01 mix_q_c026_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_02 (mix_i_src_c026_2_02 0 bpf_c026_2 0) vcvs gain=5.555702330196e-01
SMIXI_c026_2_02 (mix_i_src_c026_2_02 mix_i_c026_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_02 (mix_q_src_c026_2_02 0 bpf_c026_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_2_02 (mix_q_src_c026_2_02 mix_q_c026_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_03 (mix_i_src_c026_2_03 0 bpf_c026_2 0) vcvs gain=1.950903220161e-01
SMIXI_c026_2_03 (mix_i_src_c026_2_03 mix_i_c026_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_03 (mix_q_src_c026_2_03 0 bpf_c026_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_2_03 (mix_q_src_c026_2_03 mix_q_c026_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_04 (mix_i_src_c026_2_04 0 bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_2_04 (mix_i_src_c026_2_04 mix_i_c026_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_04 (mix_q_src_c026_2_04 0 bpf_c026_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_2_04 (mix_q_src_c026_2_04 mix_q_c026_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_05 (mix_i_src_c026_2_05 0 bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_2_05 (mix_i_src_c026_2_05 mix_i_c026_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_05 (mix_q_src_c026_2_05 0 bpf_c026_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_2_05 (mix_q_src_c026_2_05 mix_q_c026_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_06 (mix_i_src_c026_2_06 0 bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_2_06 (mix_i_src_c026_2_06 mix_i_c026_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_06 (mix_q_src_c026_2_06 0 bpf_c026_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_2_06 (mix_q_src_c026_2_06 mix_q_c026_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_07 (mix_i_src_c026_2_07 0 bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_2_07 (mix_i_src_c026_2_07 mix_i_c026_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_07 (mix_q_src_c026_2_07 0 bpf_c026_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_2_07 (mix_q_src_c026_2_07 mix_q_c026_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_08 (mix_i_src_c026_2_08 0 bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_2_08 (mix_i_src_c026_2_08 mix_i_c026_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_08 (mix_q_src_c026_2_08 0 bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_2_08 (mix_q_src_c026_2_08 mix_q_c026_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_09 (mix_i_src_c026_2_09 0 bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_2_09 (mix_i_src_c026_2_09 mix_i_c026_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_09 (mix_q_src_c026_2_09 0 bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_2_09 (mix_q_src_c026_2_09 mix_q_c026_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_10 (mix_i_src_c026_2_10 0 bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_2_10 (mix_i_src_c026_2_10 mix_i_c026_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_10 (mix_q_src_c026_2_10 0 bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_2_10 (mix_q_src_c026_2_10 mix_q_c026_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_11 (mix_i_src_c026_2_11 0 bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_2_11 (mix_i_src_c026_2_11 mix_i_c026_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_11 (mix_q_src_c026_2_11 0 bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_2_11 (mix_q_src_c026_2_11 mix_q_c026_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_12 (mix_i_src_c026_2_12 0 bpf_c026_2 0) vcvs gain=1.950903220161e-01
SMIXI_c026_2_12 (mix_i_src_c026_2_12 mix_i_c026_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_12 (mix_q_src_c026_2_12 0 bpf_c026_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_2_12 (mix_q_src_c026_2_12 mix_q_c026_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_13 (mix_i_src_c026_2_13 0 bpf_c026_2 0) vcvs gain=5.555702330196e-01
SMIXI_c026_2_13 (mix_i_src_c026_2_13 mix_i_c026_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_13 (mix_q_src_c026_2_13 0 bpf_c026_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_2_13 (mix_q_src_c026_2_13 mix_q_c026_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_14 (mix_i_src_c026_2_14 0 bpf_c026_2 0) vcvs gain=8.314696123025e-01
SMIXI_c026_2_14 (mix_i_src_c026_2_14 mix_i_c026_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_14 (mix_q_src_c026_2_14 0 bpf_c026_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_2_14 (mix_q_src_c026_2_14 mix_q_c026_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_2_15 (mix_i_src_c026_2_15 0 bpf_c026_2 0) vcvs gain=9.807852804032e-01
SMIXI_c026_2_15 (mix_i_src_c026_2_15 mix_i_c026_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_2_15 (mix_q_src_c026_2_15 0 bpf_c026_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_2_15 (mix_q_src_c026_2_15 mix_q_c026_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c026_2 (mix_i_c026_2 0) resistor r=1G
RMIXQ_c026_2 (mix_q_c026_2 0) resistor r=1G
RINTI_c026_2 (mix_i_c026_2 Icar_c026_2) resistor r=1k
CINTI_c026_2 (Icar_c026_2 0) capacitor c=80p
RINTQ_c026_2 (mix_q_c026_2 Qcar_c026_2) resistor r=1k
CINTQ_c026_2 (Qcar_c026_2 0) capacitor c=80p

// bl026, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c026_3 (bl026 n_cbpf_c026_3) capacitor c=2.533029591058e-14
LBPF_c026_3 (n_cbpf_c026_3 bpf_c026_3) inductor l=1.000000000000e-06
RBPF_c026_3 (bpf_c026_3 0) resistor r=3.141592653590e+02
EMIXI_c026_3_00 (mix_i_src_c026_3_00 0 bpf_c026_3 0) vcvs gain=9.807852804032e-01
SMIXI_c026_3_00 (mix_i_src_c026_3_00 mix_i_c026_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_00 (mix_q_src_c026_3_00 0 bpf_c026_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_3_00 (mix_q_src_c026_3_00 mix_q_c026_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_01 (mix_i_src_c026_3_01 0 bpf_c026_3 0) vcvs gain=8.314696123025e-01
SMIXI_c026_3_01 (mix_i_src_c026_3_01 mix_i_c026_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_01 (mix_q_src_c026_3_01 0 bpf_c026_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_3_01 (mix_q_src_c026_3_01 mix_q_c026_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_02 (mix_i_src_c026_3_02 0 bpf_c026_3 0) vcvs gain=5.555702330196e-01
SMIXI_c026_3_02 (mix_i_src_c026_3_02 mix_i_c026_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_02 (mix_q_src_c026_3_02 0 bpf_c026_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_3_02 (mix_q_src_c026_3_02 mix_q_c026_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_03 (mix_i_src_c026_3_03 0 bpf_c026_3 0) vcvs gain=1.950903220161e-01
SMIXI_c026_3_03 (mix_i_src_c026_3_03 mix_i_c026_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_03 (mix_q_src_c026_3_03 0 bpf_c026_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_3_03 (mix_q_src_c026_3_03 mix_q_c026_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_04 (mix_i_src_c026_3_04 0 bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_3_04 (mix_i_src_c026_3_04 mix_i_c026_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_04 (mix_q_src_c026_3_04 0 bpf_c026_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c026_3_04 (mix_q_src_c026_3_04 mix_q_c026_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_05 (mix_i_src_c026_3_05 0 bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_3_05 (mix_i_src_c026_3_05 mix_i_c026_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_05 (mix_q_src_c026_3_05 0 bpf_c026_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c026_3_05 (mix_q_src_c026_3_05 mix_q_c026_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_06 (mix_i_src_c026_3_06 0 bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_3_06 (mix_i_src_c026_3_06 mix_i_c026_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_06 (mix_q_src_c026_3_06 0 bpf_c026_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c026_3_06 (mix_q_src_c026_3_06 mix_q_c026_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_07 (mix_i_src_c026_3_07 0 bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_3_07 (mix_i_src_c026_3_07 mix_i_c026_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_07 (mix_q_src_c026_3_07 0 bpf_c026_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c026_3_07 (mix_q_src_c026_3_07 mix_q_c026_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_08 (mix_i_src_c026_3_08 0 bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c026_3_08 (mix_i_src_c026_3_08 mix_i_c026_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_08 (mix_q_src_c026_3_08 0 bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_3_08 (mix_q_src_c026_3_08 mix_q_c026_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_09 (mix_i_src_c026_3_09 0 bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c026_3_09 (mix_i_src_c026_3_09 mix_i_c026_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_09 (mix_q_src_c026_3_09 0 bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_3_09 (mix_q_src_c026_3_09 mix_q_c026_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_10 (mix_i_src_c026_3_10 0 bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c026_3_10 (mix_i_src_c026_3_10 mix_i_c026_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_10 (mix_q_src_c026_3_10 0 bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_3_10 (mix_q_src_c026_3_10 mix_q_c026_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_11 (mix_i_src_c026_3_11 0 bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c026_3_11 (mix_i_src_c026_3_11 mix_i_c026_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_11 (mix_q_src_c026_3_11 0 bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_3_11 (mix_q_src_c026_3_11 mix_q_c026_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_12 (mix_i_src_c026_3_12 0 bpf_c026_3 0) vcvs gain=1.950903220161e-01
SMIXI_c026_3_12 (mix_i_src_c026_3_12 mix_i_c026_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_12 (mix_q_src_c026_3_12 0 bpf_c026_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c026_3_12 (mix_q_src_c026_3_12 mix_q_c026_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_13 (mix_i_src_c026_3_13 0 bpf_c026_3 0) vcvs gain=5.555702330196e-01
SMIXI_c026_3_13 (mix_i_src_c026_3_13 mix_i_c026_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_13 (mix_q_src_c026_3_13 0 bpf_c026_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c026_3_13 (mix_q_src_c026_3_13 mix_q_c026_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_14 (mix_i_src_c026_3_14 0 bpf_c026_3 0) vcvs gain=8.314696123025e-01
SMIXI_c026_3_14 (mix_i_src_c026_3_14 mix_i_c026_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_14 (mix_q_src_c026_3_14 0 bpf_c026_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c026_3_14 (mix_q_src_c026_3_14 mix_q_c026_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c026_3_15 (mix_i_src_c026_3_15 0 bpf_c026_3 0) vcvs gain=9.807852804032e-01
SMIXI_c026_3_15 (mix_i_src_c026_3_15 mix_i_c026_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c026_3_15 (mix_q_src_c026_3_15 0 bpf_c026_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c026_3_15 (mix_q_src_c026_3_15 mix_q_c026_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c026_3 (mix_i_c026_3 0) resistor r=1G
RMIXQ_c026_3 (mix_q_c026_3 0) resistor r=1G
RINTI_c026_3 (mix_i_c026_3 Icar_c026_3) resistor r=1k
CINTI_c026_3 (Icar_c026_3 0) capacitor c=80p
RINTQ_c026_3 (mix_q_c026_3 Qcar_c026_3) resistor r=1k
CINTQ_c026_3 (Qcar_c026_3 0) capacitor c=80p

// bl027, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c027_0 (bl027 n_cbpf_c027_0) capacitor c=4.052847345694e-13
LBPF_c027_0 (n_cbpf_c027_0 bpf_c027_0) inductor l=1.000000000000e-06
RBPF_c027_0 (bpf_c027_0 0) resistor r=7.853981633974e+01
EMIXI_c027_0_00 (mix_i_src_c027_0_00 0 bpf_c027_0 0) vcvs gain=9.807852804032e-01
SMIXI_c027_0_00 (mix_i_src_c027_0_00 mix_i_c027_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_00 (mix_q_src_c027_0_00 0 bpf_c027_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_0_00 (mix_q_src_c027_0_00 mix_q_c027_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_01 (mix_i_src_c027_0_01 0 bpf_c027_0 0) vcvs gain=8.314696123025e-01
SMIXI_c027_0_01 (mix_i_src_c027_0_01 mix_i_c027_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_01 (mix_q_src_c027_0_01 0 bpf_c027_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_0_01 (mix_q_src_c027_0_01 mix_q_c027_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_02 (mix_i_src_c027_0_02 0 bpf_c027_0 0) vcvs gain=5.555702330196e-01
SMIXI_c027_0_02 (mix_i_src_c027_0_02 mix_i_c027_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_02 (mix_q_src_c027_0_02 0 bpf_c027_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_0_02 (mix_q_src_c027_0_02 mix_q_c027_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_03 (mix_i_src_c027_0_03 0 bpf_c027_0 0) vcvs gain=1.950903220161e-01
SMIXI_c027_0_03 (mix_i_src_c027_0_03 mix_i_c027_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_03 (mix_q_src_c027_0_03 0 bpf_c027_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_0_03 (mix_q_src_c027_0_03 mix_q_c027_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_04 (mix_i_src_c027_0_04 0 bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_0_04 (mix_i_src_c027_0_04 mix_i_c027_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_04 (mix_q_src_c027_0_04 0 bpf_c027_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_0_04 (mix_q_src_c027_0_04 mix_q_c027_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_05 (mix_i_src_c027_0_05 0 bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_0_05 (mix_i_src_c027_0_05 mix_i_c027_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_05 (mix_q_src_c027_0_05 0 bpf_c027_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_0_05 (mix_q_src_c027_0_05 mix_q_c027_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_06 (mix_i_src_c027_0_06 0 bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_0_06 (mix_i_src_c027_0_06 mix_i_c027_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_06 (mix_q_src_c027_0_06 0 bpf_c027_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_0_06 (mix_q_src_c027_0_06 mix_q_c027_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_07 (mix_i_src_c027_0_07 0 bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_0_07 (mix_i_src_c027_0_07 mix_i_c027_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_07 (mix_q_src_c027_0_07 0 bpf_c027_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_0_07 (mix_q_src_c027_0_07 mix_q_c027_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_08 (mix_i_src_c027_0_08 0 bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_0_08 (mix_i_src_c027_0_08 mix_i_c027_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_08 (mix_q_src_c027_0_08 0 bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_0_08 (mix_q_src_c027_0_08 mix_q_c027_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_09 (mix_i_src_c027_0_09 0 bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_0_09 (mix_i_src_c027_0_09 mix_i_c027_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_09 (mix_q_src_c027_0_09 0 bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_0_09 (mix_q_src_c027_0_09 mix_q_c027_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_10 (mix_i_src_c027_0_10 0 bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_0_10 (mix_i_src_c027_0_10 mix_i_c027_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_10 (mix_q_src_c027_0_10 0 bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_0_10 (mix_q_src_c027_0_10 mix_q_c027_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_11 (mix_i_src_c027_0_11 0 bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_0_11 (mix_i_src_c027_0_11 mix_i_c027_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_11 (mix_q_src_c027_0_11 0 bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_0_11 (mix_q_src_c027_0_11 mix_q_c027_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_12 (mix_i_src_c027_0_12 0 bpf_c027_0 0) vcvs gain=1.950903220161e-01
SMIXI_c027_0_12 (mix_i_src_c027_0_12 mix_i_c027_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_12 (mix_q_src_c027_0_12 0 bpf_c027_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_0_12 (mix_q_src_c027_0_12 mix_q_c027_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_13 (mix_i_src_c027_0_13 0 bpf_c027_0 0) vcvs gain=5.555702330196e-01
SMIXI_c027_0_13 (mix_i_src_c027_0_13 mix_i_c027_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_13 (mix_q_src_c027_0_13 0 bpf_c027_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_0_13 (mix_q_src_c027_0_13 mix_q_c027_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_14 (mix_i_src_c027_0_14 0 bpf_c027_0 0) vcvs gain=8.314696123025e-01
SMIXI_c027_0_14 (mix_i_src_c027_0_14 mix_i_c027_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_14 (mix_q_src_c027_0_14 0 bpf_c027_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_0_14 (mix_q_src_c027_0_14 mix_q_c027_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_0_15 (mix_i_src_c027_0_15 0 bpf_c027_0 0) vcvs gain=9.807852804032e-01
SMIXI_c027_0_15 (mix_i_src_c027_0_15 mix_i_c027_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_0_15 (mix_q_src_c027_0_15 0 bpf_c027_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_0_15 (mix_q_src_c027_0_15 mix_q_c027_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c027_0 (mix_i_c027_0 0) resistor r=1G
RMIXQ_c027_0 (mix_q_c027_0 0) resistor r=1G
RINTI_c027_0 (mix_i_c027_0 Icar_c027_0) resistor r=1k
CINTI_c027_0 (Icar_c027_0 0) capacitor c=80p
RINTQ_c027_0 (mix_q_c027_0 Qcar_c027_0) resistor r=1k
CINTQ_c027_0 (Qcar_c027_0 0) capacitor c=80p

// bl027, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c027_1 (bl027 n_cbpf_c027_1) capacitor c=1.013211836423e-13
LBPF_c027_1 (n_cbpf_c027_1 bpf_c027_1) inductor l=1.000000000000e-06
RBPF_c027_1 (bpf_c027_1 0) resistor r=1.570796326795e+02
EMIXI_c027_1_00 (mix_i_src_c027_1_00 0 bpf_c027_1 0) vcvs gain=9.807852804032e-01
SMIXI_c027_1_00 (mix_i_src_c027_1_00 mix_i_c027_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_00 (mix_q_src_c027_1_00 0 bpf_c027_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_1_00 (mix_q_src_c027_1_00 mix_q_c027_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_01 (mix_i_src_c027_1_01 0 bpf_c027_1 0) vcvs gain=8.314696123025e-01
SMIXI_c027_1_01 (mix_i_src_c027_1_01 mix_i_c027_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_01 (mix_q_src_c027_1_01 0 bpf_c027_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_1_01 (mix_q_src_c027_1_01 mix_q_c027_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_02 (mix_i_src_c027_1_02 0 bpf_c027_1 0) vcvs gain=5.555702330196e-01
SMIXI_c027_1_02 (mix_i_src_c027_1_02 mix_i_c027_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_02 (mix_q_src_c027_1_02 0 bpf_c027_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_1_02 (mix_q_src_c027_1_02 mix_q_c027_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_03 (mix_i_src_c027_1_03 0 bpf_c027_1 0) vcvs gain=1.950903220161e-01
SMIXI_c027_1_03 (mix_i_src_c027_1_03 mix_i_c027_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_03 (mix_q_src_c027_1_03 0 bpf_c027_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_1_03 (mix_q_src_c027_1_03 mix_q_c027_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_04 (mix_i_src_c027_1_04 0 bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_1_04 (mix_i_src_c027_1_04 mix_i_c027_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_04 (mix_q_src_c027_1_04 0 bpf_c027_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_1_04 (mix_q_src_c027_1_04 mix_q_c027_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_05 (mix_i_src_c027_1_05 0 bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_1_05 (mix_i_src_c027_1_05 mix_i_c027_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_05 (mix_q_src_c027_1_05 0 bpf_c027_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_1_05 (mix_q_src_c027_1_05 mix_q_c027_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_06 (mix_i_src_c027_1_06 0 bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_1_06 (mix_i_src_c027_1_06 mix_i_c027_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_06 (mix_q_src_c027_1_06 0 bpf_c027_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_1_06 (mix_q_src_c027_1_06 mix_q_c027_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_07 (mix_i_src_c027_1_07 0 bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_1_07 (mix_i_src_c027_1_07 mix_i_c027_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_07 (mix_q_src_c027_1_07 0 bpf_c027_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_1_07 (mix_q_src_c027_1_07 mix_q_c027_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_08 (mix_i_src_c027_1_08 0 bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_1_08 (mix_i_src_c027_1_08 mix_i_c027_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_08 (mix_q_src_c027_1_08 0 bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_1_08 (mix_q_src_c027_1_08 mix_q_c027_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_09 (mix_i_src_c027_1_09 0 bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_1_09 (mix_i_src_c027_1_09 mix_i_c027_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_09 (mix_q_src_c027_1_09 0 bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_1_09 (mix_q_src_c027_1_09 mix_q_c027_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_10 (mix_i_src_c027_1_10 0 bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_1_10 (mix_i_src_c027_1_10 mix_i_c027_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_10 (mix_q_src_c027_1_10 0 bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_1_10 (mix_q_src_c027_1_10 mix_q_c027_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_11 (mix_i_src_c027_1_11 0 bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_1_11 (mix_i_src_c027_1_11 mix_i_c027_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_11 (mix_q_src_c027_1_11 0 bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_1_11 (mix_q_src_c027_1_11 mix_q_c027_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_12 (mix_i_src_c027_1_12 0 bpf_c027_1 0) vcvs gain=1.950903220161e-01
SMIXI_c027_1_12 (mix_i_src_c027_1_12 mix_i_c027_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_12 (mix_q_src_c027_1_12 0 bpf_c027_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_1_12 (mix_q_src_c027_1_12 mix_q_c027_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_13 (mix_i_src_c027_1_13 0 bpf_c027_1 0) vcvs gain=5.555702330196e-01
SMIXI_c027_1_13 (mix_i_src_c027_1_13 mix_i_c027_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_13 (mix_q_src_c027_1_13 0 bpf_c027_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_1_13 (mix_q_src_c027_1_13 mix_q_c027_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_14 (mix_i_src_c027_1_14 0 bpf_c027_1 0) vcvs gain=8.314696123025e-01
SMIXI_c027_1_14 (mix_i_src_c027_1_14 mix_i_c027_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_14 (mix_q_src_c027_1_14 0 bpf_c027_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_1_14 (mix_q_src_c027_1_14 mix_q_c027_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_1_15 (mix_i_src_c027_1_15 0 bpf_c027_1 0) vcvs gain=9.807852804032e-01
SMIXI_c027_1_15 (mix_i_src_c027_1_15 mix_i_c027_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_1_15 (mix_q_src_c027_1_15 0 bpf_c027_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_1_15 (mix_q_src_c027_1_15 mix_q_c027_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c027_1 (mix_i_c027_1 0) resistor r=1G
RMIXQ_c027_1 (mix_q_c027_1 0) resistor r=1G
RINTI_c027_1 (mix_i_c027_1 Icar_c027_1) resistor r=1k
CINTI_c027_1 (Icar_c027_1 0) capacitor c=80p
RINTQ_c027_1 (mix_q_c027_1 Qcar_c027_1) resistor r=1k
CINTQ_c027_1 (Qcar_c027_1 0) capacitor c=80p

// bl027, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c027_2 (bl027 n_cbpf_c027_2) capacitor c=4.503163717437e-14
LBPF_c027_2 (n_cbpf_c027_2 bpf_c027_2) inductor l=1.000000000000e-06
RBPF_c027_2 (bpf_c027_2 0) resistor r=2.356194490192e+02
EMIXI_c027_2_00 (mix_i_src_c027_2_00 0 bpf_c027_2 0) vcvs gain=9.807852804032e-01
SMIXI_c027_2_00 (mix_i_src_c027_2_00 mix_i_c027_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_00 (mix_q_src_c027_2_00 0 bpf_c027_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_2_00 (mix_q_src_c027_2_00 mix_q_c027_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_01 (mix_i_src_c027_2_01 0 bpf_c027_2 0) vcvs gain=8.314696123025e-01
SMIXI_c027_2_01 (mix_i_src_c027_2_01 mix_i_c027_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_01 (mix_q_src_c027_2_01 0 bpf_c027_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_2_01 (mix_q_src_c027_2_01 mix_q_c027_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_02 (mix_i_src_c027_2_02 0 bpf_c027_2 0) vcvs gain=5.555702330196e-01
SMIXI_c027_2_02 (mix_i_src_c027_2_02 mix_i_c027_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_02 (mix_q_src_c027_2_02 0 bpf_c027_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_2_02 (mix_q_src_c027_2_02 mix_q_c027_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_03 (mix_i_src_c027_2_03 0 bpf_c027_2 0) vcvs gain=1.950903220161e-01
SMIXI_c027_2_03 (mix_i_src_c027_2_03 mix_i_c027_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_03 (mix_q_src_c027_2_03 0 bpf_c027_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_2_03 (mix_q_src_c027_2_03 mix_q_c027_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_04 (mix_i_src_c027_2_04 0 bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_2_04 (mix_i_src_c027_2_04 mix_i_c027_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_04 (mix_q_src_c027_2_04 0 bpf_c027_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_2_04 (mix_q_src_c027_2_04 mix_q_c027_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_05 (mix_i_src_c027_2_05 0 bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_2_05 (mix_i_src_c027_2_05 mix_i_c027_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_05 (mix_q_src_c027_2_05 0 bpf_c027_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_2_05 (mix_q_src_c027_2_05 mix_q_c027_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_06 (mix_i_src_c027_2_06 0 bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_2_06 (mix_i_src_c027_2_06 mix_i_c027_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_06 (mix_q_src_c027_2_06 0 bpf_c027_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_2_06 (mix_q_src_c027_2_06 mix_q_c027_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_07 (mix_i_src_c027_2_07 0 bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_2_07 (mix_i_src_c027_2_07 mix_i_c027_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_07 (mix_q_src_c027_2_07 0 bpf_c027_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_2_07 (mix_q_src_c027_2_07 mix_q_c027_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_08 (mix_i_src_c027_2_08 0 bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_2_08 (mix_i_src_c027_2_08 mix_i_c027_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_08 (mix_q_src_c027_2_08 0 bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_2_08 (mix_q_src_c027_2_08 mix_q_c027_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_09 (mix_i_src_c027_2_09 0 bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_2_09 (mix_i_src_c027_2_09 mix_i_c027_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_09 (mix_q_src_c027_2_09 0 bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_2_09 (mix_q_src_c027_2_09 mix_q_c027_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_10 (mix_i_src_c027_2_10 0 bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_2_10 (mix_i_src_c027_2_10 mix_i_c027_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_10 (mix_q_src_c027_2_10 0 bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_2_10 (mix_q_src_c027_2_10 mix_q_c027_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_11 (mix_i_src_c027_2_11 0 bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_2_11 (mix_i_src_c027_2_11 mix_i_c027_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_11 (mix_q_src_c027_2_11 0 bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_2_11 (mix_q_src_c027_2_11 mix_q_c027_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_12 (mix_i_src_c027_2_12 0 bpf_c027_2 0) vcvs gain=1.950903220161e-01
SMIXI_c027_2_12 (mix_i_src_c027_2_12 mix_i_c027_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_12 (mix_q_src_c027_2_12 0 bpf_c027_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_2_12 (mix_q_src_c027_2_12 mix_q_c027_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_13 (mix_i_src_c027_2_13 0 bpf_c027_2 0) vcvs gain=5.555702330196e-01
SMIXI_c027_2_13 (mix_i_src_c027_2_13 mix_i_c027_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_13 (mix_q_src_c027_2_13 0 bpf_c027_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_2_13 (mix_q_src_c027_2_13 mix_q_c027_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_14 (mix_i_src_c027_2_14 0 bpf_c027_2 0) vcvs gain=8.314696123025e-01
SMIXI_c027_2_14 (mix_i_src_c027_2_14 mix_i_c027_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_14 (mix_q_src_c027_2_14 0 bpf_c027_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_2_14 (mix_q_src_c027_2_14 mix_q_c027_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_2_15 (mix_i_src_c027_2_15 0 bpf_c027_2 0) vcvs gain=9.807852804032e-01
SMIXI_c027_2_15 (mix_i_src_c027_2_15 mix_i_c027_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_2_15 (mix_q_src_c027_2_15 0 bpf_c027_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_2_15 (mix_q_src_c027_2_15 mix_q_c027_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c027_2 (mix_i_c027_2 0) resistor r=1G
RMIXQ_c027_2 (mix_q_c027_2 0) resistor r=1G
RINTI_c027_2 (mix_i_c027_2 Icar_c027_2) resistor r=1k
CINTI_c027_2 (Icar_c027_2 0) capacitor c=80p
RINTQ_c027_2 (mix_q_c027_2 Qcar_c027_2) resistor r=1k
CINTQ_c027_2 (Qcar_c027_2 0) capacitor c=80p

// bl027, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c027_3 (bl027 n_cbpf_c027_3) capacitor c=2.533029591058e-14
LBPF_c027_3 (n_cbpf_c027_3 bpf_c027_3) inductor l=1.000000000000e-06
RBPF_c027_3 (bpf_c027_3 0) resistor r=3.141592653590e+02
EMIXI_c027_3_00 (mix_i_src_c027_3_00 0 bpf_c027_3 0) vcvs gain=9.807852804032e-01
SMIXI_c027_3_00 (mix_i_src_c027_3_00 mix_i_c027_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_00 (mix_q_src_c027_3_00 0 bpf_c027_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_3_00 (mix_q_src_c027_3_00 mix_q_c027_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_01 (mix_i_src_c027_3_01 0 bpf_c027_3 0) vcvs gain=8.314696123025e-01
SMIXI_c027_3_01 (mix_i_src_c027_3_01 mix_i_c027_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_01 (mix_q_src_c027_3_01 0 bpf_c027_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_3_01 (mix_q_src_c027_3_01 mix_q_c027_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_02 (mix_i_src_c027_3_02 0 bpf_c027_3 0) vcvs gain=5.555702330196e-01
SMIXI_c027_3_02 (mix_i_src_c027_3_02 mix_i_c027_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_02 (mix_q_src_c027_3_02 0 bpf_c027_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_3_02 (mix_q_src_c027_3_02 mix_q_c027_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_03 (mix_i_src_c027_3_03 0 bpf_c027_3 0) vcvs gain=1.950903220161e-01
SMIXI_c027_3_03 (mix_i_src_c027_3_03 mix_i_c027_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_03 (mix_q_src_c027_3_03 0 bpf_c027_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_3_03 (mix_q_src_c027_3_03 mix_q_c027_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_04 (mix_i_src_c027_3_04 0 bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_3_04 (mix_i_src_c027_3_04 mix_i_c027_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_04 (mix_q_src_c027_3_04 0 bpf_c027_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c027_3_04 (mix_q_src_c027_3_04 mix_q_c027_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_05 (mix_i_src_c027_3_05 0 bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_3_05 (mix_i_src_c027_3_05 mix_i_c027_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_05 (mix_q_src_c027_3_05 0 bpf_c027_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c027_3_05 (mix_q_src_c027_3_05 mix_q_c027_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_06 (mix_i_src_c027_3_06 0 bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_3_06 (mix_i_src_c027_3_06 mix_i_c027_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_06 (mix_q_src_c027_3_06 0 bpf_c027_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c027_3_06 (mix_q_src_c027_3_06 mix_q_c027_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_07 (mix_i_src_c027_3_07 0 bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_3_07 (mix_i_src_c027_3_07 mix_i_c027_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_07 (mix_q_src_c027_3_07 0 bpf_c027_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c027_3_07 (mix_q_src_c027_3_07 mix_q_c027_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_08 (mix_i_src_c027_3_08 0 bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c027_3_08 (mix_i_src_c027_3_08 mix_i_c027_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_08 (mix_q_src_c027_3_08 0 bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_3_08 (mix_q_src_c027_3_08 mix_q_c027_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_09 (mix_i_src_c027_3_09 0 bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c027_3_09 (mix_i_src_c027_3_09 mix_i_c027_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_09 (mix_q_src_c027_3_09 0 bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_3_09 (mix_q_src_c027_3_09 mix_q_c027_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_10 (mix_i_src_c027_3_10 0 bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c027_3_10 (mix_i_src_c027_3_10 mix_i_c027_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_10 (mix_q_src_c027_3_10 0 bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_3_10 (mix_q_src_c027_3_10 mix_q_c027_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_11 (mix_i_src_c027_3_11 0 bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c027_3_11 (mix_i_src_c027_3_11 mix_i_c027_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_11 (mix_q_src_c027_3_11 0 bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_3_11 (mix_q_src_c027_3_11 mix_q_c027_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_12 (mix_i_src_c027_3_12 0 bpf_c027_3 0) vcvs gain=1.950903220161e-01
SMIXI_c027_3_12 (mix_i_src_c027_3_12 mix_i_c027_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_12 (mix_q_src_c027_3_12 0 bpf_c027_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c027_3_12 (mix_q_src_c027_3_12 mix_q_c027_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_13 (mix_i_src_c027_3_13 0 bpf_c027_3 0) vcvs gain=5.555702330196e-01
SMIXI_c027_3_13 (mix_i_src_c027_3_13 mix_i_c027_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_13 (mix_q_src_c027_3_13 0 bpf_c027_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c027_3_13 (mix_q_src_c027_3_13 mix_q_c027_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_14 (mix_i_src_c027_3_14 0 bpf_c027_3 0) vcvs gain=8.314696123025e-01
SMIXI_c027_3_14 (mix_i_src_c027_3_14 mix_i_c027_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_14 (mix_q_src_c027_3_14 0 bpf_c027_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c027_3_14 (mix_q_src_c027_3_14 mix_q_c027_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c027_3_15 (mix_i_src_c027_3_15 0 bpf_c027_3 0) vcvs gain=9.807852804032e-01
SMIXI_c027_3_15 (mix_i_src_c027_3_15 mix_i_c027_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c027_3_15 (mix_q_src_c027_3_15 0 bpf_c027_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c027_3_15 (mix_q_src_c027_3_15 mix_q_c027_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c027_3 (mix_i_c027_3 0) resistor r=1G
RMIXQ_c027_3 (mix_q_c027_3 0) resistor r=1G
RINTI_c027_3 (mix_i_c027_3 Icar_c027_3) resistor r=1k
CINTI_c027_3 (Icar_c027_3 0) capacitor c=80p
RINTQ_c027_3 (mix_q_c027_3 Qcar_c027_3) resistor r=1k
CINTQ_c027_3 (Qcar_c027_3 0) capacitor c=80p

// bl028, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c028_0 (bl028 n_cbpf_c028_0) capacitor c=4.052847345694e-13
LBPF_c028_0 (n_cbpf_c028_0 bpf_c028_0) inductor l=1.000000000000e-06
RBPF_c028_0 (bpf_c028_0 0) resistor r=7.853981633974e+01
EMIXI_c028_0_00 (mix_i_src_c028_0_00 0 bpf_c028_0 0) vcvs gain=9.807852804032e-01
SMIXI_c028_0_00 (mix_i_src_c028_0_00 mix_i_c028_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_00 (mix_q_src_c028_0_00 0 bpf_c028_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_0_00 (mix_q_src_c028_0_00 mix_q_c028_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_01 (mix_i_src_c028_0_01 0 bpf_c028_0 0) vcvs gain=8.314696123025e-01
SMIXI_c028_0_01 (mix_i_src_c028_0_01 mix_i_c028_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_01 (mix_q_src_c028_0_01 0 bpf_c028_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_0_01 (mix_q_src_c028_0_01 mix_q_c028_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_02 (mix_i_src_c028_0_02 0 bpf_c028_0 0) vcvs gain=5.555702330196e-01
SMIXI_c028_0_02 (mix_i_src_c028_0_02 mix_i_c028_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_02 (mix_q_src_c028_0_02 0 bpf_c028_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_0_02 (mix_q_src_c028_0_02 mix_q_c028_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_03 (mix_i_src_c028_0_03 0 bpf_c028_0 0) vcvs gain=1.950903220161e-01
SMIXI_c028_0_03 (mix_i_src_c028_0_03 mix_i_c028_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_03 (mix_q_src_c028_0_03 0 bpf_c028_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_0_03 (mix_q_src_c028_0_03 mix_q_c028_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_04 (mix_i_src_c028_0_04 0 bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_0_04 (mix_i_src_c028_0_04 mix_i_c028_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_04 (mix_q_src_c028_0_04 0 bpf_c028_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_0_04 (mix_q_src_c028_0_04 mix_q_c028_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_05 (mix_i_src_c028_0_05 0 bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_0_05 (mix_i_src_c028_0_05 mix_i_c028_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_05 (mix_q_src_c028_0_05 0 bpf_c028_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_0_05 (mix_q_src_c028_0_05 mix_q_c028_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_06 (mix_i_src_c028_0_06 0 bpf_c028_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c028_0_06 (mix_i_src_c028_0_06 mix_i_c028_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_06 (mix_q_src_c028_0_06 0 bpf_c028_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_0_06 (mix_q_src_c028_0_06 mix_q_c028_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_07 (mix_i_src_c028_0_07 0 bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_0_07 (mix_i_src_c028_0_07 mix_i_c028_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_07 (mix_q_src_c028_0_07 0 bpf_c028_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_0_07 (mix_q_src_c028_0_07 mix_q_c028_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_08 (mix_i_src_c028_0_08 0 bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_0_08 (mix_i_src_c028_0_08 mix_i_c028_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_08 (mix_q_src_c028_0_08 0 bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_0_08 (mix_q_src_c028_0_08 mix_q_c028_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_09 (mix_i_src_c028_0_09 0 bpf_c028_0 0) vcvs gain=-8.314696123025e-01
