SMIXI_c127_3_15 (mix_i_src_c127_3_15 mix_i_c127_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_15 (mix_q_src_c127_3_15 0 bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_3_15 (mix_q_src_c127_3_15 mix_q_c127_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c127_3 (mix_i_c127_3 0) resistor r=1G
RMIXQ_c127_3 (mix_q_c127_3 0) resistor r=1G
RINTI_c127_3 (mix_i_c127_3 Icar_c127_3) resistor r=1k
CINTI_c127_3 (Icar_c127_3 0) capacitor c=80p
RINTQ_c127_3 (mix_q_c127_3 Qcar_c127_3) resistor r=1k
CINTQ_c127_3 (Qcar_c127_3 0) capacitor c=80p
save bpf_c127_3 Icar_c127_3 Qcar_c127_3

tbtran tran stop=80n maxstep=5p
