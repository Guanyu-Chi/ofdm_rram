SMIXQ_c085_0_12 (mix_q_src_c085_0_12 mix_q_c085_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_13 (mix_i_src_c085_0_13 0 bpf_c085_0 0) vcvs gain=5.555702330196e-01
SMIXI_c085_0_13 (mix_i_src_c085_0_13 mix_i_c085_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_13 (mix_q_src_c085_0_13 0 bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_0_13 (mix_q_src_c085_0_13 mix_q_c085_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_14 (mix_i_src_c085_0_14 0 bpf_c085_0 0) vcvs gain=8.314696123025e-01
SMIXI_c085_0_14 (mix_i_src_c085_0_14 mix_i_c085_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_14 (mix_q_src_c085_0_14 0 bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_0_14 (mix_q_src_c085_0_14 mix_q_c085_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_15 (mix_i_src_c085_0_15 0 bpf_c085_0 0) vcvs gain=9.807852804032e-01
SMIXI_c085_0_15 (mix_i_src_c085_0_15 mix_i_c085_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_15 (mix_q_src_c085_0_15 0 bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_0_15 (mix_q_src_c085_0_15 mix_q_c085_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c085_0 (mix_i_c085_0 0) resistor r=1G
RMIXQ_c085_0 (mix_q_c085_0 0) resistor r=1G
RINTI_c085_0 (mix_i_c085_0 Icar_c085_0) resistor r=1k
CINTI_c085_0 (Icar_c085_0 0) capacitor c=80p
RINTQ_c085_0 (mix_q_c085_0 Qcar_c085_0) resistor r=1k
CINTQ_c085_0 (Qcar_c085_0 0) capacitor c=80p

// bl085, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c085_1 (bl085 n_cbpf_c085_1) capacitor c=1.013211836423e-13
LBPF_c085_1 (n_cbpf_c085_1 bpf_c085_1) inductor l=1.000000000000e-06
RBPF_c085_1 (bpf_c085_1 0) resistor r=1.570796326795e+02
EMIXI_c085_1_00 (mix_i_src_c085_1_00 0 bpf_c085_1 0) vcvs gain=9.807852804032e-01
SMIXI_c085_1_00 (mix_i_src_c085_1_00 mix_i_c085_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_00 (mix_q_src_c085_1_00 0 bpf_c085_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_1_00 (mix_q_src_c085_1_00 mix_q_c085_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_01 (mix_i_src_c085_1_01 0 bpf_c085_1 0) vcvs gain=8.314696123025e-01
SMIXI_c085_1_01 (mix_i_src_c085_1_01 mix_i_c085_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_01 (mix_q_src_c085_1_01 0 bpf_c085_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_1_01 (mix_q_src_c085_1_01 mix_q_c085_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_02 (mix_i_src_c085_1_02 0 bpf_c085_1 0) vcvs gain=5.555702330196e-01
SMIXI_c085_1_02 (mix_i_src_c085_1_02 mix_i_c085_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_02 (mix_q_src_c085_1_02 0 bpf_c085_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_1_02 (mix_q_src_c085_1_02 mix_q_c085_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_03 (mix_i_src_c085_1_03 0 bpf_c085_1 0) vcvs gain=1.950903220161e-01
SMIXI_c085_1_03 (mix_i_src_c085_1_03 mix_i_c085_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_03 (mix_q_src_c085_1_03 0 bpf_c085_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_1_03 (mix_q_src_c085_1_03 mix_q_c085_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_04 (mix_i_src_c085_1_04 0 bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_1_04 (mix_i_src_c085_1_04 mix_i_c085_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_04 (mix_q_src_c085_1_04 0 bpf_c085_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_1_04 (mix_q_src_c085_1_04 mix_q_c085_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_05 (mix_i_src_c085_1_05 0 bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_1_05 (mix_i_src_c085_1_05 mix_i_c085_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_05 (mix_q_src_c085_1_05 0 bpf_c085_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_1_05 (mix_q_src_c085_1_05 mix_q_c085_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_06 (mix_i_src_c085_1_06 0 bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_1_06 (mix_i_src_c085_1_06 mix_i_c085_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_06 (mix_q_src_c085_1_06 0 bpf_c085_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_1_06 (mix_q_src_c085_1_06 mix_q_c085_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_07 (mix_i_src_c085_1_07 0 bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_1_07 (mix_i_src_c085_1_07 mix_i_c085_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_07 (mix_q_src_c085_1_07 0 bpf_c085_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_1_07 (mix_q_src_c085_1_07 mix_q_c085_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_08 (mix_i_src_c085_1_08 0 bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_1_08 (mix_i_src_c085_1_08 mix_i_c085_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_08 (mix_q_src_c085_1_08 0 bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_1_08 (mix_q_src_c085_1_08 mix_q_c085_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_09 (mix_i_src_c085_1_09 0 bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_1_09 (mix_i_src_c085_1_09 mix_i_c085_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_09 (mix_q_src_c085_1_09 0 bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_1_09 (mix_q_src_c085_1_09 mix_q_c085_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_10 (mix_i_src_c085_1_10 0 bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_1_10 (mix_i_src_c085_1_10 mix_i_c085_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_10 (mix_q_src_c085_1_10 0 bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_1_10 (mix_q_src_c085_1_10 mix_q_c085_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_11 (mix_i_src_c085_1_11 0 bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_1_11 (mix_i_src_c085_1_11 mix_i_c085_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_11 (mix_q_src_c085_1_11 0 bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c085_1_11 (mix_q_src_c085_1_11 mix_q_c085_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_12 (mix_i_src_c085_1_12 0 bpf_c085_1 0) vcvs gain=1.950903220161e-01
SMIXI_c085_1_12 (mix_i_src_c085_1_12 mix_i_c085_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_12 (mix_q_src_c085_1_12 0 bpf_c085_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c085_1_12 (mix_q_src_c085_1_12 mix_q_c085_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_13 (mix_i_src_c085_1_13 0 bpf_c085_1 0) vcvs gain=5.555702330196e-01
SMIXI_c085_1_13 (mix_i_src_c085_1_13 mix_i_c085_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_13 (mix_q_src_c085_1_13 0 bpf_c085_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_1_13 (mix_q_src_c085_1_13 mix_q_c085_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_14 (mix_i_src_c085_1_14 0 bpf_c085_1 0) vcvs gain=8.314696123025e-01
SMIXI_c085_1_14 (mix_i_src_c085_1_14 mix_i_c085_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_14 (mix_q_src_c085_1_14 0 bpf_c085_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_1_14 (mix_q_src_c085_1_14 mix_q_c085_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_1_15 (mix_i_src_c085_1_15 0 bpf_c085_1 0) vcvs gain=9.807852804032e-01
SMIXI_c085_1_15 (mix_i_src_c085_1_15 mix_i_c085_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_1_15 (mix_q_src_c085_1_15 0 bpf_c085_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_1_15 (mix_q_src_c085_1_15 mix_q_c085_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c085_1 (mix_i_c085_1 0) resistor r=1G
RMIXQ_c085_1 (mix_q_c085_1 0) resistor r=1G
RINTI_c085_1 (mix_i_c085_1 Icar_c085_1) resistor r=1k
CINTI_c085_1 (Icar_c085_1 0) capacitor c=80p
RINTQ_c085_1 (mix_q_c085_1 Qcar_c085_1) resistor r=1k
CINTQ_c085_1 (Qcar_c085_1 0) capacitor c=80p

// bl085, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c085_2 (bl085 n_cbpf_c085_2) capacitor c=4.503163717437e-14
LBPF_c085_2 (n_cbpf_c085_2 bpf_c085_2) inductor l=1.000000000000e-06
RBPF_c085_2 (bpf_c085_2 0) resistor r=2.356194490192e+02
EMIXI_c085_2_00 (mix_i_src_c085_2_00 0 bpf_c085_2 0) vcvs gain=9.807852804032e-01
SMIXI_c085_2_00 (mix_i_src_c085_2_00 mix_i_c085_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_00 (mix_q_src_c085_2_00 0 bpf_c085_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_2_00 (mix_q_src_c085_2_00 mix_q_c085_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_01 (mix_i_src_c085_2_01 0 bpf_c085_2 0) vcvs gain=8.314696123025e-01
SMIXI_c085_2_01 (mix_i_src_c085_2_01 mix_i_c085_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_01 (mix_q_src_c085_2_01 0 bpf_c085_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_2_01 (mix_q_src_c085_2_01 mix_q_c085_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_02 (mix_i_src_c085_2_02 0 bpf_c085_2 0) vcvs gain=5.555702330196e-01
SMIXI_c085_2_02 (mix_i_src_c085_2_02 mix_i_c085_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_02 (mix_q_src_c085_2_02 0 bpf_c085_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_2_02 (mix_q_src_c085_2_02 mix_q_c085_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_03 (mix_i_src_c085_2_03 0 bpf_c085_2 0) vcvs gain=1.950903220161e-01
SMIXI_c085_2_03 (mix_i_src_c085_2_03 mix_i_c085_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_03 (mix_q_src_c085_2_03 0 bpf_c085_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_2_03 (mix_q_src_c085_2_03 mix_q_c085_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_04 (mix_i_src_c085_2_04 0 bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_2_04 (mix_i_src_c085_2_04 mix_i_c085_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_04 (mix_q_src_c085_2_04 0 bpf_c085_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_2_04 (mix_q_src_c085_2_04 mix_q_c085_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_05 (mix_i_src_c085_2_05 0 bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_2_05 (mix_i_src_c085_2_05 mix_i_c085_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_05 (mix_q_src_c085_2_05 0 bpf_c085_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_2_05 (mix_q_src_c085_2_05 mix_q_c085_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_06 (mix_i_src_c085_2_06 0 bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_2_06 (mix_i_src_c085_2_06 mix_i_c085_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_06 (mix_q_src_c085_2_06 0 bpf_c085_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_2_06 (mix_q_src_c085_2_06 mix_q_c085_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_07 (mix_i_src_c085_2_07 0 bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_2_07 (mix_i_src_c085_2_07 mix_i_c085_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_07 (mix_q_src_c085_2_07 0 bpf_c085_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_2_07 (mix_q_src_c085_2_07 mix_q_c085_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_08 (mix_i_src_c085_2_08 0 bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_2_08 (mix_i_src_c085_2_08 mix_i_c085_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_08 (mix_q_src_c085_2_08 0 bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_2_08 (mix_q_src_c085_2_08 mix_q_c085_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_09 (mix_i_src_c085_2_09 0 bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_2_09 (mix_i_src_c085_2_09 mix_i_c085_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_09 (mix_q_src_c085_2_09 0 bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_2_09 (mix_q_src_c085_2_09 mix_q_c085_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_10 (mix_i_src_c085_2_10 0 bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_2_10 (mix_i_src_c085_2_10 mix_i_c085_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_10 (mix_q_src_c085_2_10 0 bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_2_10 (mix_q_src_c085_2_10 mix_q_c085_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_11 (mix_i_src_c085_2_11 0 bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_2_11 (mix_i_src_c085_2_11 mix_i_c085_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_11 (mix_q_src_c085_2_11 0 bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c085_2_11 (mix_q_src_c085_2_11 mix_q_c085_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_12 (mix_i_src_c085_2_12 0 bpf_c085_2 0) vcvs gain=1.950903220161e-01
SMIXI_c085_2_12 (mix_i_src_c085_2_12 mix_i_c085_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_12 (mix_q_src_c085_2_12 0 bpf_c085_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c085_2_12 (mix_q_src_c085_2_12 mix_q_c085_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_13 (mix_i_src_c085_2_13 0 bpf_c085_2 0) vcvs gain=5.555702330196e-01
SMIXI_c085_2_13 (mix_i_src_c085_2_13 mix_i_c085_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_13 (mix_q_src_c085_2_13 0 bpf_c085_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_2_13 (mix_q_src_c085_2_13 mix_q_c085_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_14 (mix_i_src_c085_2_14 0 bpf_c085_2 0) vcvs gain=8.314696123025e-01
SMIXI_c085_2_14 (mix_i_src_c085_2_14 mix_i_c085_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_14 (mix_q_src_c085_2_14 0 bpf_c085_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_2_14 (mix_q_src_c085_2_14 mix_q_c085_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_2_15 (mix_i_src_c085_2_15 0 bpf_c085_2 0) vcvs gain=9.807852804032e-01
SMIXI_c085_2_15 (mix_i_src_c085_2_15 mix_i_c085_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_2_15 (mix_q_src_c085_2_15 0 bpf_c085_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_2_15 (mix_q_src_c085_2_15 mix_q_c085_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c085_2 (mix_i_c085_2 0) resistor r=1G
RMIXQ_c085_2 (mix_q_c085_2 0) resistor r=1G
RINTI_c085_2 (mix_i_c085_2 Icar_c085_2) resistor r=1k
CINTI_c085_2 (Icar_c085_2 0) capacitor c=80p
RINTQ_c085_2 (mix_q_c085_2 Qcar_c085_2) resistor r=1k
CINTQ_c085_2 (Qcar_c085_2 0) capacitor c=80p

// bl085, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c085_3 (bl085 n_cbpf_c085_3) capacitor c=2.533029591058e-14
LBPF_c085_3 (n_cbpf_c085_3 bpf_c085_3) inductor l=1.000000000000e-06
RBPF_c085_3 (bpf_c085_3 0) resistor r=3.141592653590e+02
EMIXI_c085_3_00 (mix_i_src_c085_3_00 0 bpf_c085_3 0) vcvs gain=9.807852804032e-01
SMIXI_c085_3_00 (mix_i_src_c085_3_00 mix_i_c085_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_00 (mix_q_src_c085_3_00 0 bpf_c085_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_3_00 (mix_q_src_c085_3_00 mix_q_c085_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_01 (mix_i_src_c085_3_01 0 bpf_c085_3 0) vcvs gain=8.314696123025e-01
SMIXI_c085_3_01 (mix_i_src_c085_3_01 mix_i_c085_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_01 (mix_q_src_c085_3_01 0 bpf_c085_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_3_01 (mix_q_src_c085_3_01 mix_q_c085_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_02 (mix_i_src_c085_3_02 0 bpf_c085_3 0) vcvs gain=5.555702330196e-01
SMIXI_c085_3_02 (mix_i_src_c085_3_02 mix_i_c085_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_02 (mix_q_src_c085_3_02 0 bpf_c085_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_3_02 (mix_q_src_c085_3_02 mix_q_c085_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_03 (mix_i_src_c085_3_03 0 bpf_c085_3 0) vcvs gain=1.950903220161e-01
SMIXI_c085_3_03 (mix_i_src_c085_3_03 mix_i_c085_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_03 (mix_q_src_c085_3_03 0 bpf_c085_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_3_03 (mix_q_src_c085_3_03 mix_q_c085_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_04 (mix_i_src_c085_3_04 0 bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_3_04 (mix_i_src_c085_3_04 mix_i_c085_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_04 (mix_q_src_c085_3_04 0 bpf_c085_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_3_04 (mix_q_src_c085_3_04 mix_q_c085_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_05 (mix_i_src_c085_3_05 0 bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_3_05 (mix_i_src_c085_3_05 mix_i_c085_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_05 (mix_q_src_c085_3_05 0 bpf_c085_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_3_05 (mix_q_src_c085_3_05 mix_q_c085_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_06 (mix_i_src_c085_3_06 0 bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_3_06 (mix_i_src_c085_3_06 mix_i_c085_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_06 (mix_q_src_c085_3_06 0 bpf_c085_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_3_06 (mix_q_src_c085_3_06 mix_q_c085_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_07 (mix_i_src_c085_3_07 0 bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_3_07 (mix_i_src_c085_3_07 mix_i_c085_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_07 (mix_q_src_c085_3_07 0 bpf_c085_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_3_07 (mix_q_src_c085_3_07 mix_q_c085_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_08 (mix_i_src_c085_3_08 0 bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_3_08 (mix_i_src_c085_3_08 mix_i_c085_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_08 (mix_q_src_c085_3_08 0 bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_3_08 (mix_q_src_c085_3_08 mix_q_c085_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_09 (mix_i_src_c085_3_09 0 bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_3_09 (mix_i_src_c085_3_09 mix_i_c085_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_09 (mix_q_src_c085_3_09 0 bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_3_09 (mix_q_src_c085_3_09 mix_q_c085_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_10 (mix_i_src_c085_3_10 0 bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_3_10 (mix_i_src_c085_3_10 mix_i_c085_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_10 (mix_q_src_c085_3_10 0 bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_3_10 (mix_q_src_c085_3_10 mix_q_c085_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_11 (mix_i_src_c085_3_11 0 bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_3_11 (mix_i_src_c085_3_11 mix_i_c085_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_11 (mix_q_src_c085_3_11 0 bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c085_3_11 (mix_q_src_c085_3_11 mix_q_c085_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_12 (mix_i_src_c085_3_12 0 bpf_c085_3 0) vcvs gain=1.950903220161e-01
SMIXI_c085_3_12 (mix_i_src_c085_3_12 mix_i_c085_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_12 (mix_q_src_c085_3_12 0 bpf_c085_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c085_3_12 (mix_q_src_c085_3_12 mix_q_c085_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_13 (mix_i_src_c085_3_13 0 bpf_c085_3 0) vcvs gain=5.555702330196e-01
SMIXI_c085_3_13 (mix_i_src_c085_3_13 mix_i_c085_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_13 (mix_q_src_c085_3_13 0 bpf_c085_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_3_13 (mix_q_src_c085_3_13 mix_q_c085_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_14 (mix_i_src_c085_3_14 0 bpf_c085_3 0) vcvs gain=8.314696123025e-01
SMIXI_c085_3_14 (mix_i_src_c085_3_14 mix_i_c085_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_14 (mix_q_src_c085_3_14 0 bpf_c085_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_3_14 (mix_q_src_c085_3_14 mix_q_c085_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_3_15 (mix_i_src_c085_3_15 0 bpf_c085_3 0) vcvs gain=9.807852804032e-01
SMIXI_c085_3_15 (mix_i_src_c085_3_15 mix_i_c085_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_3_15 (mix_q_src_c085_3_15 0 bpf_c085_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_3_15 (mix_q_src_c085_3_15 mix_q_c085_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c085_3 (mix_i_c085_3 0) resistor r=1G
RMIXQ_c085_3 (mix_q_c085_3 0) resistor r=1G
RINTI_c085_3 (mix_i_c085_3 Icar_c085_3) resistor r=1k
CINTI_c085_3 (Icar_c085_3 0) capacitor c=80p
RINTQ_c085_3 (mix_q_c085_3 Qcar_c085_3) resistor r=1k
CINTQ_c085_3 (Qcar_c085_3 0) capacitor c=80p

// bl086, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c086_0 (bl086 n_cbpf_c086_0) capacitor c=4.052847345694e-13
LBPF_c086_0 (n_cbpf_c086_0 bpf_c086_0) inductor l=1.000000000000e-06
RBPF_c086_0 (bpf_c086_0 0) resistor r=7.853981633974e+01
EMIXI_c086_0_00 (mix_i_src_c086_0_00 0 bpf_c086_0 0) vcvs gain=9.807852804032e-01
SMIXI_c086_0_00 (mix_i_src_c086_0_00 mix_i_c086_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_00 (mix_q_src_c086_0_00 0 bpf_c086_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_0_00 (mix_q_src_c086_0_00 mix_q_c086_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_01 (mix_i_src_c086_0_01 0 bpf_c086_0 0) vcvs gain=8.314696123025e-01
SMIXI_c086_0_01 (mix_i_src_c086_0_01 mix_i_c086_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_01 (mix_q_src_c086_0_01 0 bpf_c086_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_0_01 (mix_q_src_c086_0_01 mix_q_c086_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_02 (mix_i_src_c086_0_02 0 bpf_c086_0 0) vcvs gain=5.555702330196e-01
SMIXI_c086_0_02 (mix_i_src_c086_0_02 mix_i_c086_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_02 (mix_q_src_c086_0_02 0 bpf_c086_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_0_02 (mix_q_src_c086_0_02 mix_q_c086_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_03 (mix_i_src_c086_0_03 0 bpf_c086_0 0) vcvs gain=1.950903220161e-01
SMIXI_c086_0_03 (mix_i_src_c086_0_03 mix_i_c086_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_03 (mix_q_src_c086_0_03 0 bpf_c086_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_0_03 (mix_q_src_c086_0_03 mix_q_c086_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_04 (mix_i_src_c086_0_04 0 bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_0_04 (mix_i_src_c086_0_04 mix_i_c086_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_04 (mix_q_src_c086_0_04 0 bpf_c086_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_0_04 (mix_q_src_c086_0_04 mix_q_c086_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_05 (mix_i_src_c086_0_05 0 bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_0_05 (mix_i_src_c086_0_05 mix_i_c086_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_05 (mix_q_src_c086_0_05 0 bpf_c086_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_0_05 (mix_q_src_c086_0_05 mix_q_c086_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_06 (mix_i_src_c086_0_06 0 bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_0_06 (mix_i_src_c086_0_06 mix_i_c086_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_06 (mix_q_src_c086_0_06 0 bpf_c086_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_0_06 (mix_q_src_c086_0_06 mix_q_c086_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_07 (mix_i_src_c086_0_07 0 bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_0_07 (mix_i_src_c086_0_07 mix_i_c086_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_07 (mix_q_src_c086_0_07 0 bpf_c086_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_0_07 (mix_q_src_c086_0_07 mix_q_c086_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_08 (mix_i_src_c086_0_08 0 bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_0_08 (mix_i_src_c086_0_08 mix_i_c086_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_08 (mix_q_src_c086_0_08 0 bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_0_08 (mix_q_src_c086_0_08 mix_q_c086_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_09 (mix_i_src_c086_0_09 0 bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_0_09 (mix_i_src_c086_0_09 mix_i_c086_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_09 (mix_q_src_c086_0_09 0 bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_0_09 (mix_q_src_c086_0_09 mix_q_c086_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_10 (mix_i_src_c086_0_10 0 bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_0_10 (mix_i_src_c086_0_10 mix_i_c086_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_10 (mix_q_src_c086_0_10 0 bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_0_10 (mix_q_src_c086_0_10 mix_q_c086_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_11 (mix_i_src_c086_0_11 0 bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_0_11 (mix_i_src_c086_0_11 mix_i_c086_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_11 (mix_q_src_c086_0_11 0 bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_0_11 (mix_q_src_c086_0_11 mix_q_c086_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_12 (mix_i_src_c086_0_12 0 bpf_c086_0 0) vcvs gain=1.950903220161e-01
SMIXI_c086_0_12 (mix_i_src_c086_0_12 mix_i_c086_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_12 (mix_q_src_c086_0_12 0 bpf_c086_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_0_12 (mix_q_src_c086_0_12 mix_q_c086_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_13 (mix_i_src_c086_0_13 0 bpf_c086_0 0) vcvs gain=5.555702330196e-01
SMIXI_c086_0_13 (mix_i_src_c086_0_13 mix_i_c086_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_13 (mix_q_src_c086_0_13 0 bpf_c086_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_0_13 (mix_q_src_c086_0_13 mix_q_c086_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_14 (mix_i_src_c086_0_14 0 bpf_c086_0 0) vcvs gain=8.314696123025e-01
SMIXI_c086_0_14 (mix_i_src_c086_0_14 mix_i_c086_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_14 (mix_q_src_c086_0_14 0 bpf_c086_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_0_14 (mix_q_src_c086_0_14 mix_q_c086_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_0_15 (mix_i_src_c086_0_15 0 bpf_c086_0 0) vcvs gain=9.807852804032e-01
SMIXI_c086_0_15 (mix_i_src_c086_0_15 mix_i_c086_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_0_15 (mix_q_src_c086_0_15 0 bpf_c086_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_0_15 (mix_q_src_c086_0_15 mix_q_c086_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c086_0 (mix_i_c086_0 0) resistor r=1G
RMIXQ_c086_0 (mix_q_c086_0 0) resistor r=1G
RINTI_c086_0 (mix_i_c086_0 Icar_c086_0) resistor r=1k
CINTI_c086_0 (Icar_c086_0 0) capacitor c=80p
RINTQ_c086_0 (mix_q_c086_0 Qcar_c086_0) resistor r=1k
CINTQ_c086_0 (Qcar_c086_0 0) capacitor c=80p

// bl086, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c086_1 (bl086 n_cbpf_c086_1) capacitor c=1.013211836423e-13
LBPF_c086_1 (n_cbpf_c086_1 bpf_c086_1) inductor l=1.000000000000e-06
RBPF_c086_1 (bpf_c086_1 0) resistor r=1.570796326795e+02
EMIXI_c086_1_00 (mix_i_src_c086_1_00 0 bpf_c086_1 0) vcvs gain=9.807852804032e-01
SMIXI_c086_1_00 (mix_i_src_c086_1_00 mix_i_c086_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_00 (mix_q_src_c086_1_00 0 bpf_c086_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_1_00 (mix_q_src_c086_1_00 mix_q_c086_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_01 (mix_i_src_c086_1_01 0 bpf_c086_1 0) vcvs gain=8.314696123025e-01
SMIXI_c086_1_01 (mix_i_src_c086_1_01 mix_i_c086_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_01 (mix_q_src_c086_1_01 0 bpf_c086_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_1_01 (mix_q_src_c086_1_01 mix_q_c086_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_02 (mix_i_src_c086_1_02 0 bpf_c086_1 0) vcvs gain=5.555702330196e-01
SMIXI_c086_1_02 (mix_i_src_c086_1_02 mix_i_c086_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_02 (mix_q_src_c086_1_02 0 bpf_c086_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_1_02 (mix_q_src_c086_1_02 mix_q_c086_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_03 (mix_i_src_c086_1_03 0 bpf_c086_1 0) vcvs gain=1.950903220161e-01
SMIXI_c086_1_03 (mix_i_src_c086_1_03 mix_i_c086_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_03 (mix_q_src_c086_1_03 0 bpf_c086_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_1_03 (mix_q_src_c086_1_03 mix_q_c086_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_04 (mix_i_src_c086_1_04 0 bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_1_04 (mix_i_src_c086_1_04 mix_i_c086_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_04 (mix_q_src_c086_1_04 0 bpf_c086_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_1_04 (mix_q_src_c086_1_04 mix_q_c086_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_05 (mix_i_src_c086_1_05 0 bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_1_05 (mix_i_src_c086_1_05 mix_i_c086_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_05 (mix_q_src_c086_1_05 0 bpf_c086_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_1_05 (mix_q_src_c086_1_05 mix_q_c086_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_06 (mix_i_src_c086_1_06 0 bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_1_06 (mix_i_src_c086_1_06 mix_i_c086_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_06 (mix_q_src_c086_1_06 0 bpf_c086_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_1_06 (mix_q_src_c086_1_06 mix_q_c086_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_07 (mix_i_src_c086_1_07 0 bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_1_07 (mix_i_src_c086_1_07 mix_i_c086_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_07 (mix_q_src_c086_1_07 0 bpf_c086_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_1_07 (mix_q_src_c086_1_07 mix_q_c086_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_08 (mix_i_src_c086_1_08 0 bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_1_08 (mix_i_src_c086_1_08 mix_i_c086_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_08 (mix_q_src_c086_1_08 0 bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_1_08 (mix_q_src_c086_1_08 mix_q_c086_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_09 (mix_i_src_c086_1_09 0 bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_1_09 (mix_i_src_c086_1_09 mix_i_c086_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_09 (mix_q_src_c086_1_09 0 bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_1_09 (mix_q_src_c086_1_09 mix_q_c086_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_10 (mix_i_src_c086_1_10 0 bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_1_10 (mix_i_src_c086_1_10 mix_i_c086_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_10 (mix_q_src_c086_1_10 0 bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_1_10 (mix_q_src_c086_1_10 mix_q_c086_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_11 (mix_i_src_c086_1_11 0 bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_1_11 (mix_i_src_c086_1_11 mix_i_c086_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_11 (mix_q_src_c086_1_11 0 bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_1_11 (mix_q_src_c086_1_11 mix_q_c086_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_12 (mix_i_src_c086_1_12 0 bpf_c086_1 0) vcvs gain=1.950903220161e-01
SMIXI_c086_1_12 (mix_i_src_c086_1_12 mix_i_c086_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_12 (mix_q_src_c086_1_12 0 bpf_c086_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_1_12 (mix_q_src_c086_1_12 mix_q_c086_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_13 (mix_i_src_c086_1_13 0 bpf_c086_1 0) vcvs gain=5.555702330196e-01
SMIXI_c086_1_13 (mix_i_src_c086_1_13 mix_i_c086_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_13 (mix_q_src_c086_1_13 0 bpf_c086_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_1_13 (mix_q_src_c086_1_13 mix_q_c086_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_14 (mix_i_src_c086_1_14 0 bpf_c086_1 0) vcvs gain=8.314696123025e-01
SMIXI_c086_1_14 (mix_i_src_c086_1_14 mix_i_c086_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_14 (mix_q_src_c086_1_14 0 bpf_c086_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_1_14 (mix_q_src_c086_1_14 mix_q_c086_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_1_15 (mix_i_src_c086_1_15 0 bpf_c086_1 0) vcvs gain=9.807852804032e-01
SMIXI_c086_1_15 (mix_i_src_c086_1_15 mix_i_c086_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_1_15 (mix_q_src_c086_1_15 0 bpf_c086_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_1_15 (mix_q_src_c086_1_15 mix_q_c086_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c086_1 (mix_i_c086_1 0) resistor r=1G
RMIXQ_c086_1 (mix_q_c086_1 0) resistor r=1G
RINTI_c086_1 (mix_i_c086_1 Icar_c086_1) resistor r=1k
CINTI_c086_1 (Icar_c086_1 0) capacitor c=80p
RINTQ_c086_1 (mix_q_c086_1 Qcar_c086_1) resistor r=1k
CINTQ_c086_1 (Qcar_c086_1 0) capacitor c=80p

// bl086, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c086_2 (bl086 n_cbpf_c086_2) capacitor c=4.503163717437e-14
LBPF_c086_2 (n_cbpf_c086_2 bpf_c086_2) inductor l=1.000000000000e-06
RBPF_c086_2 (bpf_c086_2 0) resistor r=2.356194490192e+02
EMIXI_c086_2_00 (mix_i_src_c086_2_00 0 bpf_c086_2 0) vcvs gain=9.807852804032e-01
SMIXI_c086_2_00 (mix_i_src_c086_2_00 mix_i_c086_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_00 (mix_q_src_c086_2_00 0 bpf_c086_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_2_00 (mix_q_src_c086_2_00 mix_q_c086_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_01 (mix_i_src_c086_2_01 0 bpf_c086_2 0) vcvs gain=8.314696123025e-01
SMIXI_c086_2_01 (mix_i_src_c086_2_01 mix_i_c086_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_01 (mix_q_src_c086_2_01 0 bpf_c086_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_2_01 (mix_q_src_c086_2_01 mix_q_c086_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_02 (mix_i_src_c086_2_02 0 bpf_c086_2 0) vcvs gain=5.555702330196e-01
SMIXI_c086_2_02 (mix_i_src_c086_2_02 mix_i_c086_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_02 (mix_q_src_c086_2_02 0 bpf_c086_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_2_02 (mix_q_src_c086_2_02 mix_q_c086_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_03 (mix_i_src_c086_2_03 0 bpf_c086_2 0) vcvs gain=1.950903220161e-01
SMIXI_c086_2_03 (mix_i_src_c086_2_03 mix_i_c086_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_03 (mix_q_src_c086_2_03 0 bpf_c086_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_2_03 (mix_q_src_c086_2_03 mix_q_c086_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_04 (mix_i_src_c086_2_04 0 bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_2_04 (mix_i_src_c086_2_04 mix_i_c086_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_04 (mix_q_src_c086_2_04 0 bpf_c086_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_2_04 (mix_q_src_c086_2_04 mix_q_c086_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_05 (mix_i_src_c086_2_05 0 bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_2_05 (mix_i_src_c086_2_05 mix_i_c086_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_05 (mix_q_src_c086_2_05 0 bpf_c086_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_2_05 (mix_q_src_c086_2_05 mix_q_c086_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_06 (mix_i_src_c086_2_06 0 bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_2_06 (mix_i_src_c086_2_06 mix_i_c086_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_06 (mix_q_src_c086_2_06 0 bpf_c086_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_2_06 (mix_q_src_c086_2_06 mix_q_c086_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_07 (mix_i_src_c086_2_07 0 bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_2_07 (mix_i_src_c086_2_07 mix_i_c086_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_07 (mix_q_src_c086_2_07 0 bpf_c086_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_2_07 (mix_q_src_c086_2_07 mix_q_c086_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_08 (mix_i_src_c086_2_08 0 bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_2_08 (mix_i_src_c086_2_08 mix_i_c086_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_08 (mix_q_src_c086_2_08 0 bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_2_08 (mix_q_src_c086_2_08 mix_q_c086_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_09 (mix_i_src_c086_2_09 0 bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_2_09 (mix_i_src_c086_2_09 mix_i_c086_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_09 (mix_q_src_c086_2_09 0 bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_2_09 (mix_q_src_c086_2_09 mix_q_c086_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_10 (mix_i_src_c086_2_10 0 bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_2_10 (mix_i_src_c086_2_10 mix_i_c086_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_10 (mix_q_src_c086_2_10 0 bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_2_10 (mix_q_src_c086_2_10 mix_q_c086_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_11 (mix_i_src_c086_2_11 0 bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_2_11 (mix_i_src_c086_2_11 mix_i_c086_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_11 (mix_q_src_c086_2_11 0 bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_2_11 (mix_q_src_c086_2_11 mix_q_c086_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_12 (mix_i_src_c086_2_12 0 bpf_c086_2 0) vcvs gain=1.950903220161e-01
SMIXI_c086_2_12 (mix_i_src_c086_2_12 mix_i_c086_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_12 (mix_q_src_c086_2_12 0 bpf_c086_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_2_12 (mix_q_src_c086_2_12 mix_q_c086_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_13 (mix_i_src_c086_2_13 0 bpf_c086_2 0) vcvs gain=5.555702330196e-01
SMIXI_c086_2_13 (mix_i_src_c086_2_13 mix_i_c086_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_13 (mix_q_src_c086_2_13 0 bpf_c086_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_2_13 (mix_q_src_c086_2_13 mix_q_c086_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_14 (mix_i_src_c086_2_14 0 bpf_c086_2 0) vcvs gain=8.314696123025e-01
SMIXI_c086_2_14 (mix_i_src_c086_2_14 mix_i_c086_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_14 (mix_q_src_c086_2_14 0 bpf_c086_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_2_14 (mix_q_src_c086_2_14 mix_q_c086_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_2_15 (mix_i_src_c086_2_15 0 bpf_c086_2 0) vcvs gain=9.807852804032e-01
SMIXI_c086_2_15 (mix_i_src_c086_2_15 mix_i_c086_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_2_15 (mix_q_src_c086_2_15 0 bpf_c086_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_2_15 (mix_q_src_c086_2_15 mix_q_c086_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c086_2 (mix_i_c086_2 0) resistor r=1G
RMIXQ_c086_2 (mix_q_c086_2 0) resistor r=1G
RINTI_c086_2 (mix_i_c086_2 Icar_c086_2) resistor r=1k
CINTI_c086_2 (Icar_c086_2 0) capacitor c=80p
RINTQ_c086_2 (mix_q_c086_2 Qcar_c086_2) resistor r=1k
CINTQ_c086_2 (Qcar_c086_2 0) capacitor c=80p

// bl086, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c086_3 (bl086 n_cbpf_c086_3) capacitor c=2.533029591058e-14
LBPF_c086_3 (n_cbpf_c086_3 bpf_c086_3) inductor l=1.000000000000e-06
RBPF_c086_3 (bpf_c086_3 0) resistor r=3.141592653590e+02
EMIXI_c086_3_00 (mix_i_src_c086_3_00 0 bpf_c086_3 0) vcvs gain=9.807852804032e-01
SMIXI_c086_3_00 (mix_i_src_c086_3_00 mix_i_c086_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_00 (mix_q_src_c086_3_00 0 bpf_c086_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_3_00 (mix_q_src_c086_3_00 mix_q_c086_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_01 (mix_i_src_c086_3_01 0 bpf_c086_3 0) vcvs gain=8.314696123025e-01
SMIXI_c086_3_01 (mix_i_src_c086_3_01 mix_i_c086_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_01 (mix_q_src_c086_3_01 0 bpf_c086_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_3_01 (mix_q_src_c086_3_01 mix_q_c086_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_02 (mix_i_src_c086_3_02 0 bpf_c086_3 0) vcvs gain=5.555702330196e-01
SMIXI_c086_3_02 (mix_i_src_c086_3_02 mix_i_c086_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_02 (mix_q_src_c086_3_02 0 bpf_c086_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_3_02 (mix_q_src_c086_3_02 mix_q_c086_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_03 (mix_i_src_c086_3_03 0 bpf_c086_3 0) vcvs gain=1.950903220161e-01
SMIXI_c086_3_03 (mix_i_src_c086_3_03 mix_i_c086_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_03 (mix_q_src_c086_3_03 0 bpf_c086_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_3_03 (mix_q_src_c086_3_03 mix_q_c086_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_04 (mix_i_src_c086_3_04 0 bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_3_04 (mix_i_src_c086_3_04 mix_i_c086_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_04 (mix_q_src_c086_3_04 0 bpf_c086_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c086_3_04 (mix_q_src_c086_3_04 mix_q_c086_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_05 (mix_i_src_c086_3_05 0 bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_3_05 (mix_i_src_c086_3_05 mix_i_c086_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_05 (mix_q_src_c086_3_05 0 bpf_c086_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c086_3_05 (mix_q_src_c086_3_05 mix_q_c086_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_06 (mix_i_src_c086_3_06 0 bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_3_06 (mix_i_src_c086_3_06 mix_i_c086_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_06 (mix_q_src_c086_3_06 0 bpf_c086_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c086_3_06 (mix_q_src_c086_3_06 mix_q_c086_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_07 (mix_i_src_c086_3_07 0 bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_3_07 (mix_i_src_c086_3_07 mix_i_c086_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_07 (mix_q_src_c086_3_07 0 bpf_c086_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c086_3_07 (mix_q_src_c086_3_07 mix_q_c086_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_08 (mix_i_src_c086_3_08 0 bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c086_3_08 (mix_i_src_c086_3_08 mix_i_c086_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_08 (mix_q_src_c086_3_08 0 bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_3_08 (mix_q_src_c086_3_08 mix_q_c086_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_09 (mix_i_src_c086_3_09 0 bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c086_3_09 (mix_i_src_c086_3_09 mix_i_c086_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_09 (mix_q_src_c086_3_09 0 bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_3_09 (mix_q_src_c086_3_09 mix_q_c086_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_10 (mix_i_src_c086_3_10 0 bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c086_3_10 (mix_i_src_c086_3_10 mix_i_c086_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_10 (mix_q_src_c086_3_10 0 bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_3_10 (mix_q_src_c086_3_10 mix_q_c086_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_11 (mix_i_src_c086_3_11 0 bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c086_3_11 (mix_i_src_c086_3_11 mix_i_c086_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_11 (mix_q_src_c086_3_11 0 bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_3_11 (mix_q_src_c086_3_11 mix_q_c086_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_12 (mix_i_src_c086_3_12 0 bpf_c086_3 0) vcvs gain=1.950903220161e-01
SMIXI_c086_3_12 (mix_i_src_c086_3_12 mix_i_c086_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_12 (mix_q_src_c086_3_12 0 bpf_c086_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c086_3_12 (mix_q_src_c086_3_12 mix_q_c086_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_13 (mix_i_src_c086_3_13 0 bpf_c086_3 0) vcvs gain=5.555702330196e-01
SMIXI_c086_3_13 (mix_i_src_c086_3_13 mix_i_c086_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_13 (mix_q_src_c086_3_13 0 bpf_c086_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c086_3_13 (mix_q_src_c086_3_13 mix_q_c086_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_14 (mix_i_src_c086_3_14 0 bpf_c086_3 0) vcvs gain=8.314696123025e-01
SMIXI_c086_3_14 (mix_i_src_c086_3_14 mix_i_c086_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_14 (mix_q_src_c086_3_14 0 bpf_c086_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c086_3_14 (mix_q_src_c086_3_14 mix_q_c086_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c086_3_15 (mix_i_src_c086_3_15 0 bpf_c086_3 0) vcvs gain=9.807852804032e-01
SMIXI_c086_3_15 (mix_i_src_c086_3_15 mix_i_c086_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c086_3_15 (mix_q_src_c086_3_15 0 bpf_c086_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c086_3_15 (mix_q_src_c086_3_15 mix_q_c086_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c086_3 (mix_i_c086_3 0) resistor r=1G
RMIXQ_c086_3 (mix_q_c086_3 0) resistor r=1G
RINTI_c086_3 (mix_i_c086_3 Icar_c086_3) resistor r=1k
CINTI_c086_3 (Icar_c086_3 0) capacitor c=80p
RINTQ_c086_3 (mix_q_c086_3 Qcar_c086_3) resistor r=1k
CINTQ_c086_3 (Qcar_c086_3 0) capacitor c=80p

// bl087, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c087_0 (bl087 n_cbpf_c087_0) capacitor c=4.052847345694e-13
LBPF_c087_0 (n_cbpf_c087_0 bpf_c087_0) inductor l=1.000000000000e-06
RBPF_c087_0 (bpf_c087_0 0) resistor r=7.853981633974e+01
EMIXI_c087_0_00 (mix_i_src_c087_0_00 0 bpf_c087_0 0) vcvs gain=9.807852804032e-01
SMIXI_c087_0_00 (mix_i_src_c087_0_00 mix_i_c087_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_00 (mix_q_src_c087_0_00 0 bpf_c087_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_0_00 (mix_q_src_c087_0_00 mix_q_c087_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_01 (mix_i_src_c087_0_01 0 bpf_c087_0 0) vcvs gain=8.314696123025e-01
SMIXI_c087_0_01 (mix_i_src_c087_0_01 mix_i_c087_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_01 (mix_q_src_c087_0_01 0 bpf_c087_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_0_01 (mix_q_src_c087_0_01 mix_q_c087_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_02 (mix_i_src_c087_0_02 0 bpf_c087_0 0) vcvs gain=5.555702330196e-01
SMIXI_c087_0_02 (mix_i_src_c087_0_02 mix_i_c087_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_02 (mix_q_src_c087_0_02 0 bpf_c087_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_0_02 (mix_q_src_c087_0_02 mix_q_c087_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_03 (mix_i_src_c087_0_03 0 bpf_c087_0 0) vcvs gain=1.950903220161e-01
SMIXI_c087_0_03 (mix_i_src_c087_0_03 mix_i_c087_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_03 (mix_q_src_c087_0_03 0 bpf_c087_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_0_03 (mix_q_src_c087_0_03 mix_q_c087_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_04 (mix_i_src_c087_0_04 0 bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_0_04 (mix_i_src_c087_0_04 mix_i_c087_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_04 (mix_q_src_c087_0_04 0 bpf_c087_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_0_04 (mix_q_src_c087_0_04 mix_q_c087_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_05 (mix_i_src_c087_0_05 0 bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_0_05 (mix_i_src_c087_0_05 mix_i_c087_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_05 (mix_q_src_c087_0_05 0 bpf_c087_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_0_05 (mix_q_src_c087_0_05 mix_q_c087_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_06 (mix_i_src_c087_0_06 0 bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_0_06 (mix_i_src_c087_0_06 mix_i_c087_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_06 (mix_q_src_c087_0_06 0 bpf_c087_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_0_06 (mix_q_src_c087_0_06 mix_q_c087_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_07 (mix_i_src_c087_0_07 0 bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_0_07 (mix_i_src_c087_0_07 mix_i_c087_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_07 (mix_q_src_c087_0_07 0 bpf_c087_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_0_07 (mix_q_src_c087_0_07 mix_q_c087_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_08 (mix_i_src_c087_0_08 0 bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_0_08 (mix_i_src_c087_0_08 mix_i_c087_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_08 (mix_q_src_c087_0_08 0 bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_0_08 (mix_q_src_c087_0_08 mix_q_c087_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_09 (mix_i_src_c087_0_09 0 bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_0_09 (mix_i_src_c087_0_09 mix_i_c087_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_09 (mix_q_src_c087_0_09 0 bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_0_09 (mix_q_src_c087_0_09 mix_q_c087_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_10 (mix_i_src_c087_0_10 0 bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_0_10 (mix_i_src_c087_0_10 mix_i_c087_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_10 (mix_q_src_c087_0_10 0 bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_0_10 (mix_q_src_c087_0_10 mix_q_c087_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_11 (mix_i_src_c087_0_11 0 bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_0_11 (mix_i_src_c087_0_11 mix_i_c087_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_11 (mix_q_src_c087_0_11 0 bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_0_11 (mix_q_src_c087_0_11 mix_q_c087_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_12 (mix_i_src_c087_0_12 0 bpf_c087_0 0) vcvs gain=1.950903220161e-01
SMIXI_c087_0_12 (mix_i_src_c087_0_12 mix_i_c087_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_12 (mix_q_src_c087_0_12 0 bpf_c087_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_0_12 (mix_q_src_c087_0_12 mix_q_c087_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_13 (mix_i_src_c087_0_13 0 bpf_c087_0 0) vcvs gain=5.555702330196e-01
SMIXI_c087_0_13 (mix_i_src_c087_0_13 mix_i_c087_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_13 (mix_q_src_c087_0_13 0 bpf_c087_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_0_13 (mix_q_src_c087_0_13 mix_q_c087_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_14 (mix_i_src_c087_0_14 0 bpf_c087_0 0) vcvs gain=8.314696123025e-01
SMIXI_c087_0_14 (mix_i_src_c087_0_14 mix_i_c087_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_14 (mix_q_src_c087_0_14 0 bpf_c087_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_0_14 (mix_q_src_c087_0_14 mix_q_c087_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_0_15 (mix_i_src_c087_0_15 0 bpf_c087_0 0) vcvs gain=9.807852804032e-01
SMIXI_c087_0_15 (mix_i_src_c087_0_15 mix_i_c087_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_0_15 (mix_q_src_c087_0_15 0 bpf_c087_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_0_15 (mix_q_src_c087_0_15 mix_q_c087_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c087_0 (mix_i_c087_0 0) resistor r=1G
RMIXQ_c087_0 (mix_q_c087_0 0) resistor r=1G
RINTI_c087_0 (mix_i_c087_0 Icar_c087_0) resistor r=1k
CINTI_c087_0 (Icar_c087_0 0) capacitor c=80p
RINTQ_c087_0 (mix_q_c087_0 Qcar_c087_0) resistor r=1k
CINTQ_c087_0 (Qcar_c087_0 0) capacitor c=80p

// bl087, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c087_1 (bl087 n_cbpf_c087_1) capacitor c=1.013211836423e-13
LBPF_c087_1 (n_cbpf_c087_1 bpf_c087_1) inductor l=1.000000000000e-06
RBPF_c087_1 (bpf_c087_1 0) resistor r=1.570796326795e+02
EMIXI_c087_1_00 (mix_i_src_c087_1_00 0 bpf_c087_1 0) vcvs gain=9.807852804032e-01
SMIXI_c087_1_00 (mix_i_src_c087_1_00 mix_i_c087_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_00 (mix_q_src_c087_1_00 0 bpf_c087_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_1_00 (mix_q_src_c087_1_00 mix_q_c087_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_01 (mix_i_src_c087_1_01 0 bpf_c087_1 0) vcvs gain=8.314696123025e-01
SMIXI_c087_1_01 (mix_i_src_c087_1_01 mix_i_c087_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_01 (mix_q_src_c087_1_01 0 bpf_c087_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_1_01 (mix_q_src_c087_1_01 mix_q_c087_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_02 (mix_i_src_c087_1_02 0 bpf_c087_1 0) vcvs gain=5.555702330196e-01
SMIXI_c087_1_02 (mix_i_src_c087_1_02 mix_i_c087_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_02 (mix_q_src_c087_1_02 0 bpf_c087_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_1_02 (mix_q_src_c087_1_02 mix_q_c087_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_03 (mix_i_src_c087_1_03 0 bpf_c087_1 0) vcvs gain=1.950903220161e-01
SMIXI_c087_1_03 (mix_i_src_c087_1_03 mix_i_c087_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_03 (mix_q_src_c087_1_03 0 bpf_c087_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_1_03 (mix_q_src_c087_1_03 mix_q_c087_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_04 (mix_i_src_c087_1_04 0 bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_1_04 (mix_i_src_c087_1_04 mix_i_c087_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_04 (mix_q_src_c087_1_04 0 bpf_c087_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_1_04 (mix_q_src_c087_1_04 mix_q_c087_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_05 (mix_i_src_c087_1_05 0 bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_1_05 (mix_i_src_c087_1_05 mix_i_c087_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_05 (mix_q_src_c087_1_05 0 bpf_c087_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_1_05 (mix_q_src_c087_1_05 mix_q_c087_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_06 (mix_i_src_c087_1_06 0 bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_1_06 (mix_i_src_c087_1_06 mix_i_c087_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_06 (mix_q_src_c087_1_06 0 bpf_c087_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_1_06 (mix_q_src_c087_1_06 mix_q_c087_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_07 (mix_i_src_c087_1_07 0 bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_1_07 (mix_i_src_c087_1_07 mix_i_c087_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_07 (mix_q_src_c087_1_07 0 bpf_c087_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_1_07 (mix_q_src_c087_1_07 mix_q_c087_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_08 (mix_i_src_c087_1_08 0 bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_1_08 (mix_i_src_c087_1_08 mix_i_c087_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_08 (mix_q_src_c087_1_08 0 bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_1_08 (mix_q_src_c087_1_08 mix_q_c087_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_09 (mix_i_src_c087_1_09 0 bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_1_09 (mix_i_src_c087_1_09 mix_i_c087_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_09 (mix_q_src_c087_1_09 0 bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_1_09 (mix_q_src_c087_1_09 mix_q_c087_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_10 (mix_i_src_c087_1_10 0 bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_1_10 (mix_i_src_c087_1_10 mix_i_c087_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_10 (mix_q_src_c087_1_10 0 bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_1_10 (mix_q_src_c087_1_10 mix_q_c087_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_11 (mix_i_src_c087_1_11 0 bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_1_11 (mix_i_src_c087_1_11 mix_i_c087_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_11 (mix_q_src_c087_1_11 0 bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_1_11 (mix_q_src_c087_1_11 mix_q_c087_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_12 (mix_i_src_c087_1_12 0 bpf_c087_1 0) vcvs gain=1.950903220161e-01
SMIXI_c087_1_12 (mix_i_src_c087_1_12 mix_i_c087_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_12 (mix_q_src_c087_1_12 0 bpf_c087_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_1_12 (mix_q_src_c087_1_12 mix_q_c087_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_13 (mix_i_src_c087_1_13 0 bpf_c087_1 0) vcvs gain=5.555702330196e-01
SMIXI_c087_1_13 (mix_i_src_c087_1_13 mix_i_c087_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_13 (mix_q_src_c087_1_13 0 bpf_c087_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_1_13 (mix_q_src_c087_1_13 mix_q_c087_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_14 (mix_i_src_c087_1_14 0 bpf_c087_1 0) vcvs gain=8.314696123025e-01
SMIXI_c087_1_14 (mix_i_src_c087_1_14 mix_i_c087_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_14 (mix_q_src_c087_1_14 0 bpf_c087_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_1_14 (mix_q_src_c087_1_14 mix_q_c087_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_1_15 (mix_i_src_c087_1_15 0 bpf_c087_1 0) vcvs gain=9.807852804032e-01
SMIXI_c087_1_15 (mix_i_src_c087_1_15 mix_i_c087_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_1_15 (mix_q_src_c087_1_15 0 bpf_c087_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_1_15 (mix_q_src_c087_1_15 mix_q_c087_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c087_1 (mix_i_c087_1 0) resistor r=1G
RMIXQ_c087_1 (mix_q_c087_1 0) resistor r=1G
RINTI_c087_1 (mix_i_c087_1 Icar_c087_1) resistor r=1k
CINTI_c087_1 (Icar_c087_1 0) capacitor c=80p
RINTQ_c087_1 (mix_q_c087_1 Qcar_c087_1) resistor r=1k
CINTQ_c087_1 (Qcar_c087_1 0) capacitor c=80p

// bl087, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c087_2 (bl087 n_cbpf_c087_2) capacitor c=4.503163717437e-14
LBPF_c087_2 (n_cbpf_c087_2 bpf_c087_2) inductor l=1.000000000000e-06
RBPF_c087_2 (bpf_c087_2 0) resistor r=2.356194490192e+02
EMIXI_c087_2_00 (mix_i_src_c087_2_00 0 bpf_c087_2 0) vcvs gain=9.807852804032e-01
SMIXI_c087_2_00 (mix_i_src_c087_2_00 mix_i_c087_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_00 (mix_q_src_c087_2_00 0 bpf_c087_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_2_00 (mix_q_src_c087_2_00 mix_q_c087_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_01 (mix_i_src_c087_2_01 0 bpf_c087_2 0) vcvs gain=8.314696123025e-01
SMIXI_c087_2_01 (mix_i_src_c087_2_01 mix_i_c087_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_01 (mix_q_src_c087_2_01 0 bpf_c087_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_2_01 (mix_q_src_c087_2_01 mix_q_c087_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_02 (mix_i_src_c087_2_02 0 bpf_c087_2 0) vcvs gain=5.555702330196e-01
SMIXI_c087_2_02 (mix_i_src_c087_2_02 mix_i_c087_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_02 (mix_q_src_c087_2_02 0 bpf_c087_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_2_02 (mix_q_src_c087_2_02 mix_q_c087_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_03 (mix_i_src_c087_2_03 0 bpf_c087_2 0) vcvs gain=1.950903220161e-01
SMIXI_c087_2_03 (mix_i_src_c087_2_03 mix_i_c087_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_03 (mix_q_src_c087_2_03 0 bpf_c087_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_2_03 (mix_q_src_c087_2_03 mix_q_c087_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_04 (mix_i_src_c087_2_04 0 bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_2_04 (mix_i_src_c087_2_04 mix_i_c087_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_04 (mix_q_src_c087_2_04 0 bpf_c087_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_2_04 (mix_q_src_c087_2_04 mix_q_c087_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_05 (mix_i_src_c087_2_05 0 bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_2_05 (mix_i_src_c087_2_05 mix_i_c087_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_05 (mix_q_src_c087_2_05 0 bpf_c087_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_2_05 (mix_q_src_c087_2_05 mix_q_c087_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_06 (mix_i_src_c087_2_06 0 bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_2_06 (mix_i_src_c087_2_06 mix_i_c087_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_06 (mix_q_src_c087_2_06 0 bpf_c087_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_2_06 (mix_q_src_c087_2_06 mix_q_c087_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_07 (mix_i_src_c087_2_07 0 bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_2_07 (mix_i_src_c087_2_07 mix_i_c087_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_07 (mix_q_src_c087_2_07 0 bpf_c087_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_2_07 (mix_q_src_c087_2_07 mix_q_c087_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_08 (mix_i_src_c087_2_08 0 bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_2_08 (mix_i_src_c087_2_08 mix_i_c087_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_08 (mix_q_src_c087_2_08 0 bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_2_08 (mix_q_src_c087_2_08 mix_q_c087_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_09 (mix_i_src_c087_2_09 0 bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_2_09 (mix_i_src_c087_2_09 mix_i_c087_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_09 (mix_q_src_c087_2_09 0 bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_2_09 (mix_q_src_c087_2_09 mix_q_c087_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_10 (mix_i_src_c087_2_10 0 bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_2_10 (mix_i_src_c087_2_10 mix_i_c087_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_10 (mix_q_src_c087_2_10 0 bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_2_10 (mix_q_src_c087_2_10 mix_q_c087_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_11 (mix_i_src_c087_2_11 0 bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_2_11 (mix_i_src_c087_2_11 mix_i_c087_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_11 (mix_q_src_c087_2_11 0 bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_2_11 (mix_q_src_c087_2_11 mix_q_c087_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_12 (mix_i_src_c087_2_12 0 bpf_c087_2 0) vcvs gain=1.950903220161e-01
SMIXI_c087_2_12 (mix_i_src_c087_2_12 mix_i_c087_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_12 (mix_q_src_c087_2_12 0 bpf_c087_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_2_12 (mix_q_src_c087_2_12 mix_q_c087_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_13 (mix_i_src_c087_2_13 0 bpf_c087_2 0) vcvs gain=5.555702330196e-01
SMIXI_c087_2_13 (mix_i_src_c087_2_13 mix_i_c087_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_13 (mix_q_src_c087_2_13 0 bpf_c087_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_2_13 (mix_q_src_c087_2_13 mix_q_c087_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_14 (mix_i_src_c087_2_14 0 bpf_c087_2 0) vcvs gain=8.314696123025e-01
SMIXI_c087_2_14 (mix_i_src_c087_2_14 mix_i_c087_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_14 (mix_q_src_c087_2_14 0 bpf_c087_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_2_14 (mix_q_src_c087_2_14 mix_q_c087_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_2_15 (mix_i_src_c087_2_15 0 bpf_c087_2 0) vcvs gain=9.807852804032e-01
SMIXI_c087_2_15 (mix_i_src_c087_2_15 mix_i_c087_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_2_15 (mix_q_src_c087_2_15 0 bpf_c087_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_2_15 (mix_q_src_c087_2_15 mix_q_c087_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c087_2 (mix_i_c087_2 0) resistor r=1G
RMIXQ_c087_2 (mix_q_c087_2 0) resistor r=1G
RINTI_c087_2 (mix_i_c087_2 Icar_c087_2) resistor r=1k
CINTI_c087_2 (Icar_c087_2 0) capacitor c=80p
RINTQ_c087_2 (mix_q_c087_2 Qcar_c087_2) resistor r=1k
CINTQ_c087_2 (Qcar_c087_2 0) capacitor c=80p

// bl087, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c087_3 (bl087 n_cbpf_c087_3) capacitor c=2.533029591058e-14
LBPF_c087_3 (n_cbpf_c087_3 bpf_c087_3) inductor l=1.000000000000e-06
RBPF_c087_3 (bpf_c087_3 0) resistor r=3.141592653590e+02
EMIXI_c087_3_00 (mix_i_src_c087_3_00 0 bpf_c087_3 0) vcvs gain=9.807852804032e-01
SMIXI_c087_3_00 (mix_i_src_c087_3_00 mix_i_c087_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_00 (mix_q_src_c087_3_00 0 bpf_c087_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_3_00 (mix_q_src_c087_3_00 mix_q_c087_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_01 (mix_i_src_c087_3_01 0 bpf_c087_3 0) vcvs gain=8.314696123025e-01
SMIXI_c087_3_01 (mix_i_src_c087_3_01 mix_i_c087_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_01 (mix_q_src_c087_3_01 0 bpf_c087_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_3_01 (mix_q_src_c087_3_01 mix_q_c087_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_02 (mix_i_src_c087_3_02 0 bpf_c087_3 0) vcvs gain=5.555702330196e-01
SMIXI_c087_3_02 (mix_i_src_c087_3_02 mix_i_c087_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_02 (mix_q_src_c087_3_02 0 bpf_c087_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_3_02 (mix_q_src_c087_3_02 mix_q_c087_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_03 (mix_i_src_c087_3_03 0 bpf_c087_3 0) vcvs gain=1.950903220161e-01
SMIXI_c087_3_03 (mix_i_src_c087_3_03 mix_i_c087_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_03 (mix_q_src_c087_3_03 0 bpf_c087_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_3_03 (mix_q_src_c087_3_03 mix_q_c087_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_04 (mix_i_src_c087_3_04 0 bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_3_04 (mix_i_src_c087_3_04 mix_i_c087_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_04 (mix_q_src_c087_3_04 0 bpf_c087_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c087_3_04 (mix_q_src_c087_3_04 mix_q_c087_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_05 (mix_i_src_c087_3_05 0 bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_3_05 (mix_i_src_c087_3_05 mix_i_c087_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_05 (mix_q_src_c087_3_05 0 bpf_c087_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c087_3_05 (mix_q_src_c087_3_05 mix_q_c087_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_06 (mix_i_src_c087_3_06 0 bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_3_06 (mix_i_src_c087_3_06 mix_i_c087_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_06 (mix_q_src_c087_3_06 0 bpf_c087_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c087_3_06 (mix_q_src_c087_3_06 mix_q_c087_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_07 (mix_i_src_c087_3_07 0 bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_3_07 (mix_i_src_c087_3_07 mix_i_c087_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_07 (mix_q_src_c087_3_07 0 bpf_c087_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c087_3_07 (mix_q_src_c087_3_07 mix_q_c087_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_08 (mix_i_src_c087_3_08 0 bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c087_3_08 (mix_i_src_c087_3_08 mix_i_c087_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_08 (mix_q_src_c087_3_08 0 bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_3_08 (mix_q_src_c087_3_08 mix_q_c087_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_09 (mix_i_src_c087_3_09 0 bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c087_3_09 (mix_i_src_c087_3_09 mix_i_c087_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_09 (mix_q_src_c087_3_09 0 bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_3_09 (mix_q_src_c087_3_09 mix_q_c087_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_10 (mix_i_src_c087_3_10 0 bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c087_3_10 (mix_i_src_c087_3_10 mix_i_c087_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_10 (mix_q_src_c087_3_10 0 bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_3_10 (mix_q_src_c087_3_10 mix_q_c087_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_11 (mix_i_src_c087_3_11 0 bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c087_3_11 (mix_i_src_c087_3_11 mix_i_c087_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_11 (mix_q_src_c087_3_11 0 bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_3_11 (mix_q_src_c087_3_11 mix_q_c087_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_12 (mix_i_src_c087_3_12 0 bpf_c087_3 0) vcvs gain=1.950903220161e-01
SMIXI_c087_3_12 (mix_i_src_c087_3_12 mix_i_c087_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_12 (mix_q_src_c087_3_12 0 bpf_c087_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c087_3_12 (mix_q_src_c087_3_12 mix_q_c087_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_13 (mix_i_src_c087_3_13 0 bpf_c087_3 0) vcvs gain=5.555702330196e-01
SMIXI_c087_3_13 (mix_i_src_c087_3_13 mix_i_c087_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_13 (mix_q_src_c087_3_13 0 bpf_c087_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c087_3_13 (mix_q_src_c087_3_13 mix_q_c087_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_14 (mix_i_src_c087_3_14 0 bpf_c087_3 0) vcvs gain=8.314696123025e-01
SMIXI_c087_3_14 (mix_i_src_c087_3_14 mix_i_c087_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_14 (mix_q_src_c087_3_14 0 bpf_c087_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c087_3_14 (mix_q_src_c087_3_14 mix_q_c087_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c087_3_15 (mix_i_src_c087_3_15 0 bpf_c087_3 0) vcvs gain=9.807852804032e-01
SMIXI_c087_3_15 (mix_i_src_c087_3_15 mix_i_c087_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c087_3_15 (mix_q_src_c087_3_15 0 bpf_c087_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c087_3_15 (mix_q_src_c087_3_15 mix_q_c087_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c087_3 (mix_i_c087_3 0) resistor r=1G
RMIXQ_c087_3 (mix_q_c087_3 0) resistor r=1G
RINTI_c087_3 (mix_i_c087_3 Icar_c087_3) resistor r=1k
CINTI_c087_3 (Icar_c087_3 0) capacitor c=80p
RINTQ_c087_3 (mix_q_c087_3 Qcar_c087_3) resistor r=1k
CINTQ_c087_3 (Qcar_c087_3 0) capacitor c=80p

// bl088, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c088_0 (bl088 n_cbpf_c088_0) capacitor c=4.052847345694e-13
LBPF_c088_0 (n_cbpf_c088_0 bpf_c088_0) inductor l=1.000000000000e-06
RBPF_c088_0 (bpf_c088_0 0) resistor r=7.853981633974e+01
EMIXI_c088_0_00 (mix_i_src_c088_0_00 0 bpf_c088_0 0) vcvs gain=9.807852804032e-01
SMIXI_c088_0_00 (mix_i_src_c088_0_00 mix_i_c088_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_00 (mix_q_src_c088_0_00 0 bpf_c088_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_0_00 (mix_q_src_c088_0_00 mix_q_c088_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_01 (mix_i_src_c088_0_01 0 bpf_c088_0 0) vcvs gain=8.314696123025e-01
SMIXI_c088_0_01 (mix_i_src_c088_0_01 mix_i_c088_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_01 (mix_q_src_c088_0_01 0 bpf_c088_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_0_01 (mix_q_src_c088_0_01 mix_q_c088_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_02 (mix_i_src_c088_0_02 0 bpf_c088_0 0) vcvs gain=5.555702330196e-01
SMIXI_c088_0_02 (mix_i_src_c088_0_02 mix_i_c088_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_02 (mix_q_src_c088_0_02 0 bpf_c088_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_0_02 (mix_q_src_c088_0_02 mix_q_c088_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_03 (mix_i_src_c088_0_03 0 bpf_c088_0 0) vcvs gain=1.950903220161e-01
SMIXI_c088_0_03 (mix_i_src_c088_0_03 mix_i_c088_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_03 (mix_q_src_c088_0_03 0 bpf_c088_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_0_03 (mix_q_src_c088_0_03 mix_q_c088_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_04 (mix_i_src_c088_0_04 0 bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_0_04 (mix_i_src_c088_0_04 mix_i_c088_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_04 (mix_q_src_c088_0_04 0 bpf_c088_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_0_04 (mix_q_src_c088_0_04 mix_q_c088_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_05 (mix_i_src_c088_0_05 0 bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_0_05 (mix_i_src_c088_0_05 mix_i_c088_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_05 (mix_q_src_c088_0_05 0 bpf_c088_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_0_05 (mix_q_src_c088_0_05 mix_q_c088_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_06 (mix_i_src_c088_0_06 0 bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_0_06 (mix_i_src_c088_0_06 mix_i_c088_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_06 (mix_q_src_c088_0_06 0 bpf_c088_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_0_06 (mix_q_src_c088_0_06 mix_q_c088_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_07 (mix_i_src_c088_0_07 0 bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_0_07 (mix_i_src_c088_0_07 mix_i_c088_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_07 (mix_q_src_c088_0_07 0 bpf_c088_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_0_07 (mix_q_src_c088_0_07 mix_q_c088_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_08 (mix_i_src_c088_0_08 0 bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_0_08 (mix_i_src_c088_0_08 mix_i_c088_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_08 (mix_q_src_c088_0_08 0 bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_0_08 (mix_q_src_c088_0_08 mix_q_c088_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_09 (mix_i_src_c088_0_09 0 bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_0_09 (mix_i_src_c088_0_09 mix_i_c088_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_09 (mix_q_src_c088_0_09 0 bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_0_09 (mix_q_src_c088_0_09 mix_q_c088_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_10 (mix_i_src_c088_0_10 0 bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_0_10 (mix_i_src_c088_0_10 mix_i_c088_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_10 (mix_q_src_c088_0_10 0 bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_0_10 (mix_q_src_c088_0_10 mix_q_c088_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_11 (mix_i_src_c088_0_11 0 bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_0_11 (mix_i_src_c088_0_11 mix_i_c088_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_11 (mix_q_src_c088_0_11 0 bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_0_11 (mix_q_src_c088_0_11 mix_q_c088_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_12 (mix_i_src_c088_0_12 0 bpf_c088_0 0) vcvs gain=1.950903220161e-01
SMIXI_c088_0_12 (mix_i_src_c088_0_12 mix_i_c088_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_12 (mix_q_src_c088_0_12 0 bpf_c088_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_0_12 (mix_q_src_c088_0_12 mix_q_c088_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_13 (mix_i_src_c088_0_13 0 bpf_c088_0 0) vcvs gain=5.555702330196e-01
SMIXI_c088_0_13 (mix_i_src_c088_0_13 mix_i_c088_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_13 (mix_q_src_c088_0_13 0 bpf_c088_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_0_13 (mix_q_src_c088_0_13 mix_q_c088_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_14 (mix_i_src_c088_0_14 0 bpf_c088_0 0) vcvs gain=8.314696123025e-01
SMIXI_c088_0_14 (mix_i_src_c088_0_14 mix_i_c088_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_14 (mix_q_src_c088_0_14 0 bpf_c088_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_0_14 (mix_q_src_c088_0_14 mix_q_c088_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_0_15 (mix_i_src_c088_0_15 0 bpf_c088_0 0) vcvs gain=9.807852804032e-01
SMIXI_c088_0_15 (mix_i_src_c088_0_15 mix_i_c088_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_0_15 (mix_q_src_c088_0_15 0 bpf_c088_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_0_15 (mix_q_src_c088_0_15 mix_q_c088_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c088_0 (mix_i_c088_0 0) resistor r=1G
RMIXQ_c088_0 (mix_q_c088_0 0) resistor r=1G
RINTI_c088_0 (mix_i_c088_0 Icar_c088_0) resistor r=1k
CINTI_c088_0 (Icar_c088_0 0) capacitor c=80p
RINTQ_c088_0 (mix_q_c088_0 Qcar_c088_0) resistor r=1k
CINTQ_c088_0 (Qcar_c088_0 0) capacitor c=80p

// bl088, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c088_1 (bl088 n_cbpf_c088_1) capacitor c=1.013211836423e-13
LBPF_c088_1 (n_cbpf_c088_1 bpf_c088_1) inductor l=1.000000000000e-06
RBPF_c088_1 (bpf_c088_1 0) resistor r=1.570796326795e+02
EMIXI_c088_1_00 (mix_i_src_c088_1_00 0 bpf_c088_1 0) vcvs gain=9.807852804032e-01
SMIXI_c088_1_00 (mix_i_src_c088_1_00 mix_i_c088_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_00 (mix_q_src_c088_1_00 0 bpf_c088_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_1_00 (mix_q_src_c088_1_00 mix_q_c088_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_01 (mix_i_src_c088_1_01 0 bpf_c088_1 0) vcvs gain=8.314696123025e-01
SMIXI_c088_1_01 (mix_i_src_c088_1_01 mix_i_c088_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_01 (mix_q_src_c088_1_01 0 bpf_c088_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_1_01 (mix_q_src_c088_1_01 mix_q_c088_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_02 (mix_i_src_c088_1_02 0 bpf_c088_1 0) vcvs gain=5.555702330196e-01
SMIXI_c088_1_02 (mix_i_src_c088_1_02 mix_i_c088_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_02 (mix_q_src_c088_1_02 0 bpf_c088_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_1_02 (mix_q_src_c088_1_02 mix_q_c088_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_03 (mix_i_src_c088_1_03 0 bpf_c088_1 0) vcvs gain=1.950903220161e-01
SMIXI_c088_1_03 (mix_i_src_c088_1_03 mix_i_c088_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_03 (mix_q_src_c088_1_03 0 bpf_c088_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_1_03 (mix_q_src_c088_1_03 mix_q_c088_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_04 (mix_i_src_c088_1_04 0 bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_1_04 (mix_i_src_c088_1_04 mix_i_c088_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_04 (mix_q_src_c088_1_04 0 bpf_c088_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_1_04 (mix_q_src_c088_1_04 mix_q_c088_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_05 (mix_i_src_c088_1_05 0 bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_1_05 (mix_i_src_c088_1_05 mix_i_c088_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_05 (mix_q_src_c088_1_05 0 bpf_c088_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_1_05 (mix_q_src_c088_1_05 mix_q_c088_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_06 (mix_i_src_c088_1_06 0 bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_1_06 (mix_i_src_c088_1_06 mix_i_c088_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_06 (mix_q_src_c088_1_06 0 bpf_c088_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_1_06 (mix_q_src_c088_1_06 mix_q_c088_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_07 (mix_i_src_c088_1_07 0 bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_1_07 (mix_i_src_c088_1_07 mix_i_c088_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_07 (mix_q_src_c088_1_07 0 bpf_c088_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_1_07 (mix_q_src_c088_1_07 mix_q_c088_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_08 (mix_i_src_c088_1_08 0 bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_1_08 (mix_i_src_c088_1_08 mix_i_c088_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_08 (mix_q_src_c088_1_08 0 bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_1_08 (mix_q_src_c088_1_08 mix_q_c088_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_09 (mix_i_src_c088_1_09 0 bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_1_09 (mix_i_src_c088_1_09 mix_i_c088_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_09 (mix_q_src_c088_1_09 0 bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_1_09 (mix_q_src_c088_1_09 mix_q_c088_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_10 (mix_i_src_c088_1_10 0 bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_1_10 (mix_i_src_c088_1_10 mix_i_c088_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_10 (mix_q_src_c088_1_10 0 bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_1_10 (mix_q_src_c088_1_10 mix_q_c088_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_11 (mix_i_src_c088_1_11 0 bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_1_11 (mix_i_src_c088_1_11 mix_i_c088_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_11 (mix_q_src_c088_1_11 0 bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_1_11 (mix_q_src_c088_1_11 mix_q_c088_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_12 (mix_i_src_c088_1_12 0 bpf_c088_1 0) vcvs gain=1.950903220161e-01
SMIXI_c088_1_12 (mix_i_src_c088_1_12 mix_i_c088_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_12 (mix_q_src_c088_1_12 0 bpf_c088_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_1_12 (mix_q_src_c088_1_12 mix_q_c088_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_13 (mix_i_src_c088_1_13 0 bpf_c088_1 0) vcvs gain=5.555702330196e-01
SMIXI_c088_1_13 (mix_i_src_c088_1_13 mix_i_c088_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_13 (mix_q_src_c088_1_13 0 bpf_c088_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_1_13 (mix_q_src_c088_1_13 mix_q_c088_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_14 (mix_i_src_c088_1_14 0 bpf_c088_1 0) vcvs gain=8.314696123025e-01
SMIXI_c088_1_14 (mix_i_src_c088_1_14 mix_i_c088_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_14 (mix_q_src_c088_1_14 0 bpf_c088_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_1_14 (mix_q_src_c088_1_14 mix_q_c088_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_1_15 (mix_i_src_c088_1_15 0 bpf_c088_1 0) vcvs gain=9.807852804032e-01
SMIXI_c088_1_15 (mix_i_src_c088_1_15 mix_i_c088_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_1_15 (mix_q_src_c088_1_15 0 bpf_c088_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_1_15 (mix_q_src_c088_1_15 mix_q_c088_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c088_1 (mix_i_c088_1 0) resistor r=1G
RMIXQ_c088_1 (mix_q_c088_1 0) resistor r=1G
RINTI_c088_1 (mix_i_c088_1 Icar_c088_1) resistor r=1k
CINTI_c088_1 (Icar_c088_1 0) capacitor c=80p
RINTQ_c088_1 (mix_q_c088_1 Qcar_c088_1) resistor r=1k
CINTQ_c088_1 (Qcar_c088_1 0) capacitor c=80p

// bl088, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c088_2 (bl088 n_cbpf_c088_2) capacitor c=4.503163717437e-14
LBPF_c088_2 (n_cbpf_c088_2 bpf_c088_2) inductor l=1.000000000000e-06
RBPF_c088_2 (bpf_c088_2 0) resistor r=2.356194490192e+02
EMIXI_c088_2_00 (mix_i_src_c088_2_00 0 bpf_c088_2 0) vcvs gain=9.807852804032e-01
SMIXI_c088_2_00 (mix_i_src_c088_2_00 mix_i_c088_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_00 (mix_q_src_c088_2_00 0 bpf_c088_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_2_00 (mix_q_src_c088_2_00 mix_q_c088_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_01 (mix_i_src_c088_2_01 0 bpf_c088_2 0) vcvs gain=8.314696123025e-01
SMIXI_c088_2_01 (mix_i_src_c088_2_01 mix_i_c088_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_01 (mix_q_src_c088_2_01 0 bpf_c088_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_2_01 (mix_q_src_c088_2_01 mix_q_c088_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_02 (mix_i_src_c088_2_02 0 bpf_c088_2 0) vcvs gain=5.555702330196e-01
SMIXI_c088_2_02 (mix_i_src_c088_2_02 mix_i_c088_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_02 (mix_q_src_c088_2_02 0 bpf_c088_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_2_02 (mix_q_src_c088_2_02 mix_q_c088_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_03 (mix_i_src_c088_2_03 0 bpf_c088_2 0) vcvs gain=1.950903220161e-01
SMIXI_c088_2_03 (mix_i_src_c088_2_03 mix_i_c088_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_03 (mix_q_src_c088_2_03 0 bpf_c088_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_2_03 (mix_q_src_c088_2_03 mix_q_c088_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_04 (mix_i_src_c088_2_04 0 bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_2_04 (mix_i_src_c088_2_04 mix_i_c088_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_04 (mix_q_src_c088_2_04 0 bpf_c088_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_2_04 (mix_q_src_c088_2_04 mix_q_c088_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_05 (mix_i_src_c088_2_05 0 bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_2_05 (mix_i_src_c088_2_05 mix_i_c088_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_05 (mix_q_src_c088_2_05 0 bpf_c088_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_2_05 (mix_q_src_c088_2_05 mix_q_c088_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_06 (mix_i_src_c088_2_06 0 bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_2_06 (mix_i_src_c088_2_06 mix_i_c088_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_06 (mix_q_src_c088_2_06 0 bpf_c088_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_2_06 (mix_q_src_c088_2_06 mix_q_c088_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_07 (mix_i_src_c088_2_07 0 bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_2_07 (mix_i_src_c088_2_07 mix_i_c088_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_07 (mix_q_src_c088_2_07 0 bpf_c088_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_2_07 (mix_q_src_c088_2_07 mix_q_c088_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_08 (mix_i_src_c088_2_08 0 bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_2_08 (mix_i_src_c088_2_08 mix_i_c088_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_08 (mix_q_src_c088_2_08 0 bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_2_08 (mix_q_src_c088_2_08 mix_q_c088_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_09 (mix_i_src_c088_2_09 0 bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_2_09 (mix_i_src_c088_2_09 mix_i_c088_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_09 (mix_q_src_c088_2_09 0 bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_2_09 (mix_q_src_c088_2_09 mix_q_c088_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_10 (mix_i_src_c088_2_10 0 bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_2_10 (mix_i_src_c088_2_10 mix_i_c088_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_10 (mix_q_src_c088_2_10 0 bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_2_10 (mix_q_src_c088_2_10 mix_q_c088_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_11 (mix_i_src_c088_2_11 0 bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_2_11 (mix_i_src_c088_2_11 mix_i_c088_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_11 (mix_q_src_c088_2_11 0 bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_2_11 (mix_q_src_c088_2_11 mix_q_c088_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_12 (mix_i_src_c088_2_12 0 bpf_c088_2 0) vcvs gain=1.950903220161e-01
SMIXI_c088_2_12 (mix_i_src_c088_2_12 mix_i_c088_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_12 (mix_q_src_c088_2_12 0 bpf_c088_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_2_12 (mix_q_src_c088_2_12 mix_q_c088_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_13 (mix_i_src_c088_2_13 0 bpf_c088_2 0) vcvs gain=5.555702330196e-01
SMIXI_c088_2_13 (mix_i_src_c088_2_13 mix_i_c088_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_13 (mix_q_src_c088_2_13 0 bpf_c088_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_2_13 (mix_q_src_c088_2_13 mix_q_c088_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_14 (mix_i_src_c088_2_14 0 bpf_c088_2 0) vcvs gain=8.314696123025e-01
SMIXI_c088_2_14 (mix_i_src_c088_2_14 mix_i_c088_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_14 (mix_q_src_c088_2_14 0 bpf_c088_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_2_14 (mix_q_src_c088_2_14 mix_q_c088_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_2_15 (mix_i_src_c088_2_15 0 bpf_c088_2 0) vcvs gain=9.807852804032e-01
SMIXI_c088_2_15 (mix_i_src_c088_2_15 mix_i_c088_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_2_15 (mix_q_src_c088_2_15 0 bpf_c088_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_2_15 (mix_q_src_c088_2_15 mix_q_c088_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c088_2 (mix_i_c088_2 0) resistor r=1G
RMIXQ_c088_2 (mix_q_c088_2 0) resistor r=1G
RINTI_c088_2 (mix_i_c088_2 Icar_c088_2) resistor r=1k
CINTI_c088_2 (Icar_c088_2 0) capacitor c=80p
RINTQ_c088_2 (mix_q_c088_2 Qcar_c088_2) resistor r=1k
CINTQ_c088_2 (Qcar_c088_2 0) capacitor c=80p

// bl088, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c088_3 (bl088 n_cbpf_c088_3) capacitor c=2.533029591058e-14
LBPF_c088_3 (n_cbpf_c088_3 bpf_c088_3) inductor l=1.000000000000e-06
RBPF_c088_3 (bpf_c088_3 0) resistor r=3.141592653590e+02
EMIXI_c088_3_00 (mix_i_src_c088_3_00 0 bpf_c088_3 0) vcvs gain=9.807852804032e-01
SMIXI_c088_3_00 (mix_i_src_c088_3_00 mix_i_c088_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_00 (mix_q_src_c088_3_00 0 bpf_c088_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_3_00 (mix_q_src_c088_3_00 mix_q_c088_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_01 (mix_i_src_c088_3_01 0 bpf_c088_3 0) vcvs gain=8.314696123025e-01
SMIXI_c088_3_01 (mix_i_src_c088_3_01 mix_i_c088_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_01 (mix_q_src_c088_3_01 0 bpf_c088_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_3_01 (mix_q_src_c088_3_01 mix_q_c088_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_02 (mix_i_src_c088_3_02 0 bpf_c088_3 0) vcvs gain=5.555702330196e-01
SMIXI_c088_3_02 (mix_i_src_c088_3_02 mix_i_c088_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_02 (mix_q_src_c088_3_02 0 bpf_c088_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_3_02 (mix_q_src_c088_3_02 mix_q_c088_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_03 (mix_i_src_c088_3_03 0 bpf_c088_3 0) vcvs gain=1.950903220161e-01
SMIXI_c088_3_03 (mix_i_src_c088_3_03 mix_i_c088_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_03 (mix_q_src_c088_3_03 0 bpf_c088_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_3_03 (mix_q_src_c088_3_03 mix_q_c088_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_04 (mix_i_src_c088_3_04 0 bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_3_04 (mix_i_src_c088_3_04 mix_i_c088_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_04 (mix_q_src_c088_3_04 0 bpf_c088_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c088_3_04 (mix_q_src_c088_3_04 mix_q_c088_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_05 (mix_i_src_c088_3_05 0 bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_3_05 (mix_i_src_c088_3_05 mix_i_c088_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_05 (mix_q_src_c088_3_05 0 bpf_c088_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c088_3_05 (mix_q_src_c088_3_05 mix_q_c088_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_06 (mix_i_src_c088_3_06 0 bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_3_06 (mix_i_src_c088_3_06 mix_i_c088_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_06 (mix_q_src_c088_3_06 0 bpf_c088_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c088_3_06 (mix_q_src_c088_3_06 mix_q_c088_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_07 (mix_i_src_c088_3_07 0 bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_3_07 (mix_i_src_c088_3_07 mix_i_c088_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_07 (mix_q_src_c088_3_07 0 bpf_c088_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c088_3_07 (mix_q_src_c088_3_07 mix_q_c088_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_08 (mix_i_src_c088_3_08 0 bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c088_3_08 (mix_i_src_c088_3_08 mix_i_c088_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_08 (mix_q_src_c088_3_08 0 bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_3_08 (mix_q_src_c088_3_08 mix_q_c088_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_09 (mix_i_src_c088_3_09 0 bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c088_3_09 (mix_i_src_c088_3_09 mix_i_c088_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_09 (mix_q_src_c088_3_09 0 bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_3_09 (mix_q_src_c088_3_09 mix_q_c088_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_10 (mix_i_src_c088_3_10 0 bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c088_3_10 (mix_i_src_c088_3_10 mix_i_c088_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_10 (mix_q_src_c088_3_10 0 bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_3_10 (mix_q_src_c088_3_10 mix_q_c088_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_11 (mix_i_src_c088_3_11 0 bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c088_3_11 (mix_i_src_c088_3_11 mix_i_c088_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_11 (mix_q_src_c088_3_11 0 bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_3_11 (mix_q_src_c088_3_11 mix_q_c088_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_12 (mix_i_src_c088_3_12 0 bpf_c088_3 0) vcvs gain=1.950903220161e-01
SMIXI_c088_3_12 (mix_i_src_c088_3_12 mix_i_c088_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_12 (mix_q_src_c088_3_12 0 bpf_c088_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c088_3_12 (mix_q_src_c088_3_12 mix_q_c088_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_13 (mix_i_src_c088_3_13 0 bpf_c088_3 0) vcvs gain=5.555702330196e-01
SMIXI_c088_3_13 (mix_i_src_c088_3_13 mix_i_c088_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_13 (mix_q_src_c088_3_13 0 bpf_c088_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c088_3_13 (mix_q_src_c088_3_13 mix_q_c088_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_14 (mix_i_src_c088_3_14 0 bpf_c088_3 0) vcvs gain=8.314696123025e-01
SMIXI_c088_3_14 (mix_i_src_c088_3_14 mix_i_c088_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_14 (mix_q_src_c088_3_14 0 bpf_c088_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c088_3_14 (mix_q_src_c088_3_14 mix_q_c088_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c088_3_15 (mix_i_src_c088_3_15 0 bpf_c088_3 0) vcvs gain=9.807852804032e-01
SMIXI_c088_3_15 (mix_i_src_c088_3_15 mix_i_c088_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c088_3_15 (mix_q_src_c088_3_15 0 bpf_c088_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c088_3_15 (mix_q_src_c088_3_15 mix_q_c088_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c088_3 (mix_i_c088_3 0) resistor r=1G
RMIXQ_c088_3 (mix_q_c088_3 0) resistor r=1G
RINTI_c088_3 (mix_i_c088_3 Icar_c088_3) resistor r=1k
CINTI_c088_3 (Icar_c088_3 0) capacitor c=80p
RINTQ_c088_3 (mix_q_c088_3 Qcar_c088_3) resistor r=1k
CINTQ_c088_3 (Qcar_c088_3 0) capacitor c=80p

// bl089, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c089_0 (bl089 n_cbpf_c089_0) capacitor c=4.052847345694e-13
LBPF_c089_0 (n_cbpf_c089_0 bpf_c089_0) inductor l=1.000000000000e-06
RBPF_c089_0 (bpf_c089_0 0) resistor r=7.853981633974e+01
EMIXI_c089_0_00 (mix_i_src_c089_0_00 0 bpf_c089_0 0) vcvs gain=9.807852804032e-01
SMIXI_c089_0_00 (mix_i_src_c089_0_00 mix_i_c089_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_00 (mix_q_src_c089_0_00 0 bpf_c089_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_0_00 (mix_q_src_c089_0_00 mix_q_c089_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_01 (mix_i_src_c089_0_01 0 bpf_c089_0 0) vcvs gain=8.314696123025e-01
SMIXI_c089_0_01 (mix_i_src_c089_0_01 mix_i_c089_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_01 (mix_q_src_c089_0_01 0 bpf_c089_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_0_01 (mix_q_src_c089_0_01 mix_q_c089_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_02 (mix_i_src_c089_0_02 0 bpf_c089_0 0) vcvs gain=5.555702330196e-01
SMIXI_c089_0_02 (mix_i_src_c089_0_02 mix_i_c089_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_02 (mix_q_src_c089_0_02 0 bpf_c089_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_0_02 (mix_q_src_c089_0_02 mix_q_c089_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_03 (mix_i_src_c089_0_03 0 bpf_c089_0 0) vcvs gain=1.950903220161e-01
SMIXI_c089_0_03 (mix_i_src_c089_0_03 mix_i_c089_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_03 (mix_q_src_c089_0_03 0 bpf_c089_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_0_03 (mix_q_src_c089_0_03 mix_q_c089_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_04 (mix_i_src_c089_0_04 0 bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_0_04 (mix_i_src_c089_0_04 mix_i_c089_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_04 (mix_q_src_c089_0_04 0 bpf_c089_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_0_04 (mix_q_src_c089_0_04 mix_q_c089_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_05 (mix_i_src_c089_0_05 0 bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_0_05 (mix_i_src_c089_0_05 mix_i_c089_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_05 (mix_q_src_c089_0_05 0 bpf_c089_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_0_05 (mix_q_src_c089_0_05 mix_q_c089_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_06 (mix_i_src_c089_0_06 0 bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_0_06 (mix_i_src_c089_0_06 mix_i_c089_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_06 (mix_q_src_c089_0_06 0 bpf_c089_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_0_06 (mix_q_src_c089_0_06 mix_q_c089_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_07 (mix_i_src_c089_0_07 0 bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_0_07 (mix_i_src_c089_0_07 mix_i_c089_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_07 (mix_q_src_c089_0_07 0 bpf_c089_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_0_07 (mix_q_src_c089_0_07 mix_q_c089_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_08 (mix_i_src_c089_0_08 0 bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_0_08 (mix_i_src_c089_0_08 mix_i_c089_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_08 (mix_q_src_c089_0_08 0 bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_0_08 (mix_q_src_c089_0_08 mix_q_c089_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_09 (mix_i_src_c089_0_09 0 bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_0_09 (mix_i_src_c089_0_09 mix_i_c089_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_09 (mix_q_src_c089_0_09 0 bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_0_09 (mix_q_src_c089_0_09 mix_q_c089_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_10 (mix_i_src_c089_0_10 0 bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_0_10 (mix_i_src_c089_0_10 mix_i_c089_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_10 (mix_q_src_c089_0_10 0 bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_0_10 (mix_q_src_c089_0_10 mix_q_c089_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_11 (mix_i_src_c089_0_11 0 bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_0_11 (mix_i_src_c089_0_11 mix_i_c089_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_11 (mix_q_src_c089_0_11 0 bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_0_11 (mix_q_src_c089_0_11 mix_q_c089_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_12 (mix_i_src_c089_0_12 0 bpf_c089_0 0) vcvs gain=1.950903220161e-01
SMIXI_c089_0_12 (mix_i_src_c089_0_12 mix_i_c089_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_12 (mix_q_src_c089_0_12 0 bpf_c089_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_0_12 (mix_q_src_c089_0_12 mix_q_c089_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_13 (mix_i_src_c089_0_13 0 bpf_c089_0 0) vcvs gain=5.555702330196e-01
SMIXI_c089_0_13 (mix_i_src_c089_0_13 mix_i_c089_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_13 (mix_q_src_c089_0_13 0 bpf_c089_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_0_13 (mix_q_src_c089_0_13 mix_q_c089_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_14 (mix_i_src_c089_0_14 0 bpf_c089_0 0) vcvs gain=8.314696123025e-01
SMIXI_c089_0_14 (mix_i_src_c089_0_14 mix_i_c089_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_14 (mix_q_src_c089_0_14 0 bpf_c089_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_0_14 (mix_q_src_c089_0_14 mix_q_c089_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_0_15 (mix_i_src_c089_0_15 0 bpf_c089_0 0) vcvs gain=9.807852804032e-01
SMIXI_c089_0_15 (mix_i_src_c089_0_15 mix_i_c089_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_0_15 (mix_q_src_c089_0_15 0 bpf_c089_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_0_15 (mix_q_src_c089_0_15 mix_q_c089_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c089_0 (mix_i_c089_0 0) resistor r=1G
RMIXQ_c089_0 (mix_q_c089_0 0) resistor r=1G
RINTI_c089_0 (mix_i_c089_0 Icar_c089_0) resistor r=1k
CINTI_c089_0 (Icar_c089_0 0) capacitor c=80p
RINTQ_c089_0 (mix_q_c089_0 Qcar_c089_0) resistor r=1k
CINTQ_c089_0 (Qcar_c089_0 0) capacitor c=80p

// bl089, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c089_1 (bl089 n_cbpf_c089_1) capacitor c=1.013211836423e-13
LBPF_c089_1 (n_cbpf_c089_1 bpf_c089_1) inductor l=1.000000000000e-06
RBPF_c089_1 (bpf_c089_1 0) resistor r=1.570796326795e+02
EMIXI_c089_1_00 (mix_i_src_c089_1_00 0 bpf_c089_1 0) vcvs gain=9.807852804032e-01
SMIXI_c089_1_00 (mix_i_src_c089_1_00 mix_i_c089_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_00 (mix_q_src_c089_1_00 0 bpf_c089_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_1_00 (mix_q_src_c089_1_00 mix_q_c089_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_01 (mix_i_src_c089_1_01 0 bpf_c089_1 0) vcvs gain=8.314696123025e-01
SMIXI_c089_1_01 (mix_i_src_c089_1_01 mix_i_c089_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_01 (mix_q_src_c089_1_01 0 bpf_c089_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_1_01 (mix_q_src_c089_1_01 mix_q_c089_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_02 (mix_i_src_c089_1_02 0 bpf_c089_1 0) vcvs gain=5.555702330196e-01
SMIXI_c089_1_02 (mix_i_src_c089_1_02 mix_i_c089_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_02 (mix_q_src_c089_1_02 0 bpf_c089_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_1_02 (mix_q_src_c089_1_02 mix_q_c089_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_03 (mix_i_src_c089_1_03 0 bpf_c089_1 0) vcvs gain=1.950903220161e-01
SMIXI_c089_1_03 (mix_i_src_c089_1_03 mix_i_c089_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_03 (mix_q_src_c089_1_03 0 bpf_c089_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_1_03 (mix_q_src_c089_1_03 mix_q_c089_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_04 (mix_i_src_c089_1_04 0 bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_1_04 (mix_i_src_c089_1_04 mix_i_c089_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_04 (mix_q_src_c089_1_04 0 bpf_c089_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_1_04 (mix_q_src_c089_1_04 mix_q_c089_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_05 (mix_i_src_c089_1_05 0 bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_1_05 (mix_i_src_c089_1_05 mix_i_c089_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_05 (mix_q_src_c089_1_05 0 bpf_c089_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_1_05 (mix_q_src_c089_1_05 mix_q_c089_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_06 (mix_i_src_c089_1_06 0 bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_1_06 (mix_i_src_c089_1_06 mix_i_c089_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_06 (mix_q_src_c089_1_06 0 bpf_c089_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_1_06 (mix_q_src_c089_1_06 mix_q_c089_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_07 (mix_i_src_c089_1_07 0 bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_1_07 (mix_i_src_c089_1_07 mix_i_c089_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_07 (mix_q_src_c089_1_07 0 bpf_c089_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_1_07 (mix_q_src_c089_1_07 mix_q_c089_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_08 (mix_i_src_c089_1_08 0 bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_1_08 (mix_i_src_c089_1_08 mix_i_c089_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_08 (mix_q_src_c089_1_08 0 bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_1_08 (mix_q_src_c089_1_08 mix_q_c089_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_09 (mix_i_src_c089_1_09 0 bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_1_09 (mix_i_src_c089_1_09 mix_i_c089_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_09 (mix_q_src_c089_1_09 0 bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_1_09 (mix_q_src_c089_1_09 mix_q_c089_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_10 (mix_i_src_c089_1_10 0 bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_1_10 (mix_i_src_c089_1_10 mix_i_c089_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_10 (mix_q_src_c089_1_10 0 bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_1_10 (mix_q_src_c089_1_10 mix_q_c089_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_11 (mix_i_src_c089_1_11 0 bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_1_11 (mix_i_src_c089_1_11 mix_i_c089_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_11 (mix_q_src_c089_1_11 0 bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_1_11 (mix_q_src_c089_1_11 mix_q_c089_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_12 (mix_i_src_c089_1_12 0 bpf_c089_1 0) vcvs gain=1.950903220161e-01
SMIXI_c089_1_12 (mix_i_src_c089_1_12 mix_i_c089_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_12 (mix_q_src_c089_1_12 0 bpf_c089_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_1_12 (mix_q_src_c089_1_12 mix_q_c089_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_13 (mix_i_src_c089_1_13 0 bpf_c089_1 0) vcvs gain=5.555702330196e-01
SMIXI_c089_1_13 (mix_i_src_c089_1_13 mix_i_c089_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_13 (mix_q_src_c089_1_13 0 bpf_c089_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_1_13 (mix_q_src_c089_1_13 mix_q_c089_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_14 (mix_i_src_c089_1_14 0 bpf_c089_1 0) vcvs gain=8.314696123025e-01
SMIXI_c089_1_14 (mix_i_src_c089_1_14 mix_i_c089_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_14 (mix_q_src_c089_1_14 0 bpf_c089_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_1_14 (mix_q_src_c089_1_14 mix_q_c089_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_1_15 (mix_i_src_c089_1_15 0 bpf_c089_1 0) vcvs gain=9.807852804032e-01
SMIXI_c089_1_15 (mix_i_src_c089_1_15 mix_i_c089_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_1_15 (mix_q_src_c089_1_15 0 bpf_c089_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_1_15 (mix_q_src_c089_1_15 mix_q_c089_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c089_1 (mix_i_c089_1 0) resistor r=1G
RMIXQ_c089_1 (mix_q_c089_1 0) resistor r=1G
RINTI_c089_1 (mix_i_c089_1 Icar_c089_1) resistor r=1k
CINTI_c089_1 (Icar_c089_1 0) capacitor c=80p
RINTQ_c089_1 (mix_q_c089_1 Qcar_c089_1) resistor r=1k
CINTQ_c089_1 (Qcar_c089_1 0) capacitor c=80p

// bl089, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c089_2 (bl089 n_cbpf_c089_2) capacitor c=4.503163717437e-14
LBPF_c089_2 (n_cbpf_c089_2 bpf_c089_2) inductor l=1.000000000000e-06
RBPF_c089_2 (bpf_c089_2 0) resistor r=2.356194490192e+02
EMIXI_c089_2_00 (mix_i_src_c089_2_00 0 bpf_c089_2 0) vcvs gain=9.807852804032e-01
SMIXI_c089_2_00 (mix_i_src_c089_2_00 mix_i_c089_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_00 (mix_q_src_c089_2_00 0 bpf_c089_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_2_00 (mix_q_src_c089_2_00 mix_q_c089_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_01 (mix_i_src_c089_2_01 0 bpf_c089_2 0) vcvs gain=8.314696123025e-01
SMIXI_c089_2_01 (mix_i_src_c089_2_01 mix_i_c089_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_01 (mix_q_src_c089_2_01 0 bpf_c089_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_2_01 (mix_q_src_c089_2_01 mix_q_c089_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_02 (mix_i_src_c089_2_02 0 bpf_c089_2 0) vcvs gain=5.555702330196e-01
SMIXI_c089_2_02 (mix_i_src_c089_2_02 mix_i_c089_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_02 (mix_q_src_c089_2_02 0 bpf_c089_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_2_02 (mix_q_src_c089_2_02 mix_q_c089_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_03 (mix_i_src_c089_2_03 0 bpf_c089_2 0) vcvs gain=1.950903220161e-01
SMIXI_c089_2_03 (mix_i_src_c089_2_03 mix_i_c089_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_03 (mix_q_src_c089_2_03 0 bpf_c089_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_2_03 (mix_q_src_c089_2_03 mix_q_c089_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_04 (mix_i_src_c089_2_04 0 bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_2_04 (mix_i_src_c089_2_04 mix_i_c089_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_04 (mix_q_src_c089_2_04 0 bpf_c089_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_2_04 (mix_q_src_c089_2_04 mix_q_c089_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_05 (mix_i_src_c089_2_05 0 bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_2_05 (mix_i_src_c089_2_05 mix_i_c089_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_05 (mix_q_src_c089_2_05 0 bpf_c089_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_2_05 (mix_q_src_c089_2_05 mix_q_c089_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_06 (mix_i_src_c089_2_06 0 bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_2_06 (mix_i_src_c089_2_06 mix_i_c089_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_06 (mix_q_src_c089_2_06 0 bpf_c089_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_2_06 (mix_q_src_c089_2_06 mix_q_c089_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_07 (mix_i_src_c089_2_07 0 bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_2_07 (mix_i_src_c089_2_07 mix_i_c089_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_07 (mix_q_src_c089_2_07 0 bpf_c089_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_2_07 (mix_q_src_c089_2_07 mix_q_c089_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_08 (mix_i_src_c089_2_08 0 bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_2_08 (mix_i_src_c089_2_08 mix_i_c089_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_08 (mix_q_src_c089_2_08 0 bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_2_08 (mix_q_src_c089_2_08 mix_q_c089_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_09 (mix_i_src_c089_2_09 0 bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_2_09 (mix_i_src_c089_2_09 mix_i_c089_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_09 (mix_q_src_c089_2_09 0 bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_2_09 (mix_q_src_c089_2_09 mix_q_c089_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_10 (mix_i_src_c089_2_10 0 bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_2_10 (mix_i_src_c089_2_10 mix_i_c089_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_10 (mix_q_src_c089_2_10 0 bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_2_10 (mix_q_src_c089_2_10 mix_q_c089_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_11 (mix_i_src_c089_2_11 0 bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_2_11 (mix_i_src_c089_2_11 mix_i_c089_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_11 (mix_q_src_c089_2_11 0 bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_2_11 (mix_q_src_c089_2_11 mix_q_c089_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_12 (mix_i_src_c089_2_12 0 bpf_c089_2 0) vcvs gain=1.950903220161e-01
SMIXI_c089_2_12 (mix_i_src_c089_2_12 mix_i_c089_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_12 (mix_q_src_c089_2_12 0 bpf_c089_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_2_12 (mix_q_src_c089_2_12 mix_q_c089_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_13 (mix_i_src_c089_2_13 0 bpf_c089_2 0) vcvs gain=5.555702330196e-01
SMIXI_c089_2_13 (mix_i_src_c089_2_13 mix_i_c089_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_13 (mix_q_src_c089_2_13 0 bpf_c089_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_2_13 (mix_q_src_c089_2_13 mix_q_c089_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_14 (mix_i_src_c089_2_14 0 bpf_c089_2 0) vcvs gain=8.314696123025e-01
SMIXI_c089_2_14 (mix_i_src_c089_2_14 mix_i_c089_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_14 (mix_q_src_c089_2_14 0 bpf_c089_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_2_14 (mix_q_src_c089_2_14 mix_q_c089_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_2_15 (mix_i_src_c089_2_15 0 bpf_c089_2 0) vcvs gain=9.807852804032e-01
SMIXI_c089_2_15 (mix_i_src_c089_2_15 mix_i_c089_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_2_15 (mix_q_src_c089_2_15 0 bpf_c089_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_2_15 (mix_q_src_c089_2_15 mix_q_c089_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c089_2 (mix_i_c089_2 0) resistor r=1G
RMIXQ_c089_2 (mix_q_c089_2 0) resistor r=1G
RINTI_c089_2 (mix_i_c089_2 Icar_c089_2) resistor r=1k
CINTI_c089_2 (Icar_c089_2 0) capacitor c=80p
RINTQ_c089_2 (mix_q_c089_2 Qcar_c089_2) resistor r=1k
CINTQ_c089_2 (Qcar_c089_2 0) capacitor c=80p

// bl089, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c089_3 (bl089 n_cbpf_c089_3) capacitor c=2.533029591058e-14
LBPF_c089_3 (n_cbpf_c089_3 bpf_c089_3) inductor l=1.000000000000e-06
RBPF_c089_3 (bpf_c089_3 0) resistor r=3.141592653590e+02
EMIXI_c089_3_00 (mix_i_src_c089_3_00 0 bpf_c089_3 0) vcvs gain=9.807852804032e-01
SMIXI_c089_3_00 (mix_i_src_c089_3_00 mix_i_c089_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_00 (mix_q_src_c089_3_00 0 bpf_c089_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_3_00 (mix_q_src_c089_3_00 mix_q_c089_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_01 (mix_i_src_c089_3_01 0 bpf_c089_3 0) vcvs gain=8.314696123025e-01
SMIXI_c089_3_01 (mix_i_src_c089_3_01 mix_i_c089_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_01 (mix_q_src_c089_3_01 0 bpf_c089_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_3_01 (mix_q_src_c089_3_01 mix_q_c089_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_02 (mix_i_src_c089_3_02 0 bpf_c089_3 0) vcvs gain=5.555702330196e-01
SMIXI_c089_3_02 (mix_i_src_c089_3_02 mix_i_c089_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_02 (mix_q_src_c089_3_02 0 bpf_c089_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_3_02 (mix_q_src_c089_3_02 mix_q_c089_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_03 (mix_i_src_c089_3_03 0 bpf_c089_3 0) vcvs gain=1.950903220161e-01
SMIXI_c089_3_03 (mix_i_src_c089_3_03 mix_i_c089_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_03 (mix_q_src_c089_3_03 0 bpf_c089_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_3_03 (mix_q_src_c089_3_03 mix_q_c089_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_04 (mix_i_src_c089_3_04 0 bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_3_04 (mix_i_src_c089_3_04 mix_i_c089_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_04 (mix_q_src_c089_3_04 0 bpf_c089_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c089_3_04 (mix_q_src_c089_3_04 mix_q_c089_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_05 (mix_i_src_c089_3_05 0 bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_3_05 (mix_i_src_c089_3_05 mix_i_c089_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_05 (mix_q_src_c089_3_05 0 bpf_c089_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c089_3_05 (mix_q_src_c089_3_05 mix_q_c089_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_06 (mix_i_src_c089_3_06 0 bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_3_06 (mix_i_src_c089_3_06 mix_i_c089_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_06 (mix_q_src_c089_3_06 0 bpf_c089_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c089_3_06 (mix_q_src_c089_3_06 mix_q_c089_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_07 (mix_i_src_c089_3_07 0 bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_3_07 (mix_i_src_c089_3_07 mix_i_c089_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_07 (mix_q_src_c089_3_07 0 bpf_c089_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c089_3_07 (mix_q_src_c089_3_07 mix_q_c089_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_08 (mix_i_src_c089_3_08 0 bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c089_3_08 (mix_i_src_c089_3_08 mix_i_c089_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_08 (mix_q_src_c089_3_08 0 bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_3_08 (mix_q_src_c089_3_08 mix_q_c089_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_09 (mix_i_src_c089_3_09 0 bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c089_3_09 (mix_i_src_c089_3_09 mix_i_c089_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_09 (mix_q_src_c089_3_09 0 bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_3_09 (mix_q_src_c089_3_09 mix_q_c089_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_10 (mix_i_src_c089_3_10 0 bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c089_3_10 (mix_i_src_c089_3_10 mix_i_c089_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_10 (mix_q_src_c089_3_10 0 bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_3_10 (mix_q_src_c089_3_10 mix_q_c089_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_11 (mix_i_src_c089_3_11 0 bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c089_3_11 (mix_i_src_c089_3_11 mix_i_c089_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_11 (mix_q_src_c089_3_11 0 bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_3_11 (mix_q_src_c089_3_11 mix_q_c089_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_12 (mix_i_src_c089_3_12 0 bpf_c089_3 0) vcvs gain=1.950903220161e-01
SMIXI_c089_3_12 (mix_i_src_c089_3_12 mix_i_c089_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_12 (mix_q_src_c089_3_12 0 bpf_c089_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c089_3_12 (mix_q_src_c089_3_12 mix_q_c089_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_13 (mix_i_src_c089_3_13 0 bpf_c089_3 0) vcvs gain=5.555702330196e-01
SMIXI_c089_3_13 (mix_i_src_c089_3_13 mix_i_c089_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_13 (mix_q_src_c089_3_13 0 bpf_c089_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c089_3_13 (mix_q_src_c089_3_13 mix_q_c089_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_14 (mix_i_src_c089_3_14 0 bpf_c089_3 0) vcvs gain=8.314696123025e-01
SMIXI_c089_3_14 (mix_i_src_c089_3_14 mix_i_c089_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_14 (mix_q_src_c089_3_14 0 bpf_c089_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c089_3_14 (mix_q_src_c089_3_14 mix_q_c089_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c089_3_15 (mix_i_src_c089_3_15 0 bpf_c089_3 0) vcvs gain=9.807852804032e-01
SMIXI_c089_3_15 (mix_i_src_c089_3_15 mix_i_c089_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c089_3_15 (mix_q_src_c089_3_15 0 bpf_c089_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c089_3_15 (mix_q_src_c089_3_15 mix_q_c089_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c089_3 (mix_i_c089_3 0) resistor r=1G
RMIXQ_c089_3 (mix_q_c089_3 0) resistor r=1G
RINTI_c089_3 (mix_i_c089_3 Icar_c089_3) resistor r=1k
CINTI_c089_3 (Icar_c089_3 0) capacitor c=80p
RINTQ_c089_3 (mix_q_c089_3 Qcar_c089_3) resistor r=1k
CINTQ_c089_3 (Qcar_c089_3 0) capacitor c=80p

// bl090, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c090_0 (bl090 n_cbpf_c090_0) capacitor c=4.052847345694e-13
LBPF_c090_0 (n_cbpf_c090_0 bpf_c090_0) inductor l=1.000000000000e-06
RBPF_c090_0 (bpf_c090_0 0) resistor r=7.853981633974e+01
EMIXI_c090_0_00 (mix_i_src_c090_0_00 0 bpf_c090_0 0) vcvs gain=9.807852804032e-01
SMIXI_c090_0_00 (mix_i_src_c090_0_00 mix_i_c090_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_00 (mix_q_src_c090_0_00 0 bpf_c090_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_0_00 (mix_q_src_c090_0_00 mix_q_c090_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_01 (mix_i_src_c090_0_01 0 bpf_c090_0 0) vcvs gain=8.314696123025e-01
SMIXI_c090_0_01 (mix_i_src_c090_0_01 mix_i_c090_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_01 (mix_q_src_c090_0_01 0 bpf_c090_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_0_01 (mix_q_src_c090_0_01 mix_q_c090_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_02 (mix_i_src_c090_0_02 0 bpf_c090_0 0) vcvs gain=5.555702330196e-01
SMIXI_c090_0_02 (mix_i_src_c090_0_02 mix_i_c090_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_02 (mix_q_src_c090_0_02 0 bpf_c090_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_0_02 (mix_q_src_c090_0_02 mix_q_c090_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_03 (mix_i_src_c090_0_03 0 bpf_c090_0 0) vcvs gain=1.950903220161e-01
SMIXI_c090_0_03 (mix_i_src_c090_0_03 mix_i_c090_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_03 (mix_q_src_c090_0_03 0 bpf_c090_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_0_03 (mix_q_src_c090_0_03 mix_q_c090_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_04 (mix_i_src_c090_0_04 0 bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_0_04 (mix_i_src_c090_0_04 mix_i_c090_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_04 (mix_q_src_c090_0_04 0 bpf_c090_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_0_04 (mix_q_src_c090_0_04 mix_q_c090_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_05 (mix_i_src_c090_0_05 0 bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_0_05 (mix_i_src_c090_0_05 mix_i_c090_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_05 (mix_q_src_c090_0_05 0 bpf_c090_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_0_05 (mix_q_src_c090_0_05 mix_q_c090_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_06 (mix_i_src_c090_0_06 0 bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_0_06 (mix_i_src_c090_0_06 mix_i_c090_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_06 (mix_q_src_c090_0_06 0 bpf_c090_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_0_06 (mix_q_src_c090_0_06 mix_q_c090_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_07 (mix_i_src_c090_0_07 0 bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_0_07 (mix_i_src_c090_0_07 mix_i_c090_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_07 (mix_q_src_c090_0_07 0 bpf_c090_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_0_07 (mix_q_src_c090_0_07 mix_q_c090_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_08 (mix_i_src_c090_0_08 0 bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_0_08 (mix_i_src_c090_0_08 mix_i_c090_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_08 (mix_q_src_c090_0_08 0 bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_0_08 (mix_q_src_c090_0_08 mix_q_c090_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_09 (mix_i_src_c090_0_09 0 bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_0_09 (mix_i_src_c090_0_09 mix_i_c090_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_09 (mix_q_src_c090_0_09 0 bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_0_09 (mix_q_src_c090_0_09 mix_q_c090_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_10 (mix_i_src_c090_0_10 0 bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_0_10 (mix_i_src_c090_0_10 mix_i_c090_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_10 (mix_q_src_c090_0_10 0 bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_0_10 (mix_q_src_c090_0_10 mix_q_c090_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_11 (mix_i_src_c090_0_11 0 bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_0_11 (mix_i_src_c090_0_11 mix_i_c090_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_11 (mix_q_src_c090_0_11 0 bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_0_11 (mix_q_src_c090_0_11 mix_q_c090_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_12 (mix_i_src_c090_0_12 0 bpf_c090_0 0) vcvs gain=1.950903220161e-01
SMIXI_c090_0_12 (mix_i_src_c090_0_12 mix_i_c090_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_12 (mix_q_src_c090_0_12 0 bpf_c090_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_0_12 (mix_q_src_c090_0_12 mix_q_c090_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_13 (mix_i_src_c090_0_13 0 bpf_c090_0 0) vcvs gain=5.555702330196e-01
SMIXI_c090_0_13 (mix_i_src_c090_0_13 mix_i_c090_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_13 (mix_q_src_c090_0_13 0 bpf_c090_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_0_13 (mix_q_src_c090_0_13 mix_q_c090_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_14 (mix_i_src_c090_0_14 0 bpf_c090_0 0) vcvs gain=8.314696123025e-01
SMIXI_c090_0_14 (mix_i_src_c090_0_14 mix_i_c090_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_14 (mix_q_src_c090_0_14 0 bpf_c090_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_0_14 (mix_q_src_c090_0_14 mix_q_c090_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_0_15 (mix_i_src_c090_0_15 0 bpf_c090_0 0) vcvs gain=9.807852804032e-01
SMIXI_c090_0_15 (mix_i_src_c090_0_15 mix_i_c090_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_0_15 (mix_q_src_c090_0_15 0 bpf_c090_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_0_15 (mix_q_src_c090_0_15 mix_q_c090_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c090_0 (mix_i_c090_0 0) resistor r=1G
RMIXQ_c090_0 (mix_q_c090_0 0) resistor r=1G
RINTI_c090_0 (mix_i_c090_0 Icar_c090_0) resistor r=1k
CINTI_c090_0 (Icar_c090_0 0) capacitor c=80p
RINTQ_c090_0 (mix_q_c090_0 Qcar_c090_0) resistor r=1k
CINTQ_c090_0 (Qcar_c090_0 0) capacitor c=80p

// bl090, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c090_1 (bl090 n_cbpf_c090_1) capacitor c=1.013211836423e-13
LBPF_c090_1 (n_cbpf_c090_1 bpf_c090_1) inductor l=1.000000000000e-06
RBPF_c090_1 (bpf_c090_1 0) resistor r=1.570796326795e+02
EMIXI_c090_1_00 (mix_i_src_c090_1_00 0 bpf_c090_1 0) vcvs gain=9.807852804032e-01
SMIXI_c090_1_00 (mix_i_src_c090_1_00 mix_i_c090_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_00 (mix_q_src_c090_1_00 0 bpf_c090_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_1_00 (mix_q_src_c090_1_00 mix_q_c090_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_01 (mix_i_src_c090_1_01 0 bpf_c090_1 0) vcvs gain=8.314696123025e-01
SMIXI_c090_1_01 (mix_i_src_c090_1_01 mix_i_c090_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_01 (mix_q_src_c090_1_01 0 bpf_c090_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_1_01 (mix_q_src_c090_1_01 mix_q_c090_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_02 (mix_i_src_c090_1_02 0 bpf_c090_1 0) vcvs gain=5.555702330196e-01
SMIXI_c090_1_02 (mix_i_src_c090_1_02 mix_i_c090_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_02 (mix_q_src_c090_1_02 0 bpf_c090_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_1_02 (mix_q_src_c090_1_02 mix_q_c090_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_03 (mix_i_src_c090_1_03 0 bpf_c090_1 0) vcvs gain=1.950903220161e-01
SMIXI_c090_1_03 (mix_i_src_c090_1_03 mix_i_c090_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_03 (mix_q_src_c090_1_03 0 bpf_c090_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_1_03 (mix_q_src_c090_1_03 mix_q_c090_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_04 (mix_i_src_c090_1_04 0 bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_1_04 (mix_i_src_c090_1_04 mix_i_c090_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_04 (mix_q_src_c090_1_04 0 bpf_c090_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_1_04 (mix_q_src_c090_1_04 mix_q_c090_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_05 (mix_i_src_c090_1_05 0 bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_1_05 (mix_i_src_c090_1_05 mix_i_c090_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_05 (mix_q_src_c090_1_05 0 bpf_c090_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_1_05 (mix_q_src_c090_1_05 mix_q_c090_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_06 (mix_i_src_c090_1_06 0 bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_1_06 (mix_i_src_c090_1_06 mix_i_c090_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_06 (mix_q_src_c090_1_06 0 bpf_c090_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_1_06 (mix_q_src_c090_1_06 mix_q_c090_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_07 (mix_i_src_c090_1_07 0 bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_1_07 (mix_i_src_c090_1_07 mix_i_c090_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_07 (mix_q_src_c090_1_07 0 bpf_c090_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_1_07 (mix_q_src_c090_1_07 mix_q_c090_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_08 (mix_i_src_c090_1_08 0 bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_1_08 (mix_i_src_c090_1_08 mix_i_c090_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_08 (mix_q_src_c090_1_08 0 bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_1_08 (mix_q_src_c090_1_08 mix_q_c090_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_09 (mix_i_src_c090_1_09 0 bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_1_09 (mix_i_src_c090_1_09 mix_i_c090_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_09 (mix_q_src_c090_1_09 0 bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_1_09 (mix_q_src_c090_1_09 mix_q_c090_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_10 (mix_i_src_c090_1_10 0 bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_1_10 (mix_i_src_c090_1_10 mix_i_c090_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_10 (mix_q_src_c090_1_10 0 bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_1_10 (mix_q_src_c090_1_10 mix_q_c090_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_11 (mix_i_src_c090_1_11 0 bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_1_11 (mix_i_src_c090_1_11 mix_i_c090_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_11 (mix_q_src_c090_1_11 0 bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_1_11 (mix_q_src_c090_1_11 mix_q_c090_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_12 (mix_i_src_c090_1_12 0 bpf_c090_1 0) vcvs gain=1.950903220161e-01
SMIXI_c090_1_12 (mix_i_src_c090_1_12 mix_i_c090_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_12 (mix_q_src_c090_1_12 0 bpf_c090_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_1_12 (mix_q_src_c090_1_12 mix_q_c090_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_13 (mix_i_src_c090_1_13 0 bpf_c090_1 0) vcvs gain=5.555702330196e-01
SMIXI_c090_1_13 (mix_i_src_c090_1_13 mix_i_c090_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_13 (mix_q_src_c090_1_13 0 bpf_c090_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_1_13 (mix_q_src_c090_1_13 mix_q_c090_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_14 (mix_i_src_c090_1_14 0 bpf_c090_1 0) vcvs gain=8.314696123025e-01
SMIXI_c090_1_14 (mix_i_src_c090_1_14 mix_i_c090_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_14 (mix_q_src_c090_1_14 0 bpf_c090_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_1_14 (mix_q_src_c090_1_14 mix_q_c090_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_1_15 (mix_i_src_c090_1_15 0 bpf_c090_1 0) vcvs gain=9.807852804032e-01
SMIXI_c090_1_15 (mix_i_src_c090_1_15 mix_i_c090_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_1_15 (mix_q_src_c090_1_15 0 bpf_c090_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_1_15 (mix_q_src_c090_1_15 mix_q_c090_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c090_1 (mix_i_c090_1 0) resistor r=1G
RMIXQ_c090_1 (mix_q_c090_1 0) resistor r=1G
RINTI_c090_1 (mix_i_c090_1 Icar_c090_1) resistor r=1k
CINTI_c090_1 (Icar_c090_1 0) capacitor c=80p
RINTQ_c090_1 (mix_q_c090_1 Qcar_c090_1) resistor r=1k
CINTQ_c090_1 (Qcar_c090_1 0) capacitor c=80p

// bl090, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c090_2 (bl090 n_cbpf_c090_2) capacitor c=4.503163717437e-14
LBPF_c090_2 (n_cbpf_c090_2 bpf_c090_2) inductor l=1.000000000000e-06
RBPF_c090_2 (bpf_c090_2 0) resistor r=2.356194490192e+02
EMIXI_c090_2_00 (mix_i_src_c090_2_00 0 bpf_c090_2 0) vcvs gain=9.807852804032e-01
SMIXI_c090_2_00 (mix_i_src_c090_2_00 mix_i_c090_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_00 (mix_q_src_c090_2_00 0 bpf_c090_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_2_00 (mix_q_src_c090_2_00 mix_q_c090_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_01 (mix_i_src_c090_2_01 0 bpf_c090_2 0) vcvs gain=8.314696123025e-01
SMIXI_c090_2_01 (mix_i_src_c090_2_01 mix_i_c090_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_01 (mix_q_src_c090_2_01 0 bpf_c090_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_2_01 (mix_q_src_c090_2_01 mix_q_c090_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_02 (mix_i_src_c090_2_02 0 bpf_c090_2 0) vcvs gain=5.555702330196e-01
SMIXI_c090_2_02 (mix_i_src_c090_2_02 mix_i_c090_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_02 (mix_q_src_c090_2_02 0 bpf_c090_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_2_02 (mix_q_src_c090_2_02 mix_q_c090_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_03 (mix_i_src_c090_2_03 0 bpf_c090_2 0) vcvs gain=1.950903220161e-01
SMIXI_c090_2_03 (mix_i_src_c090_2_03 mix_i_c090_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_03 (mix_q_src_c090_2_03 0 bpf_c090_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_2_03 (mix_q_src_c090_2_03 mix_q_c090_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_04 (mix_i_src_c090_2_04 0 bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_2_04 (mix_i_src_c090_2_04 mix_i_c090_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_04 (mix_q_src_c090_2_04 0 bpf_c090_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_2_04 (mix_q_src_c090_2_04 mix_q_c090_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_05 (mix_i_src_c090_2_05 0 bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_2_05 (mix_i_src_c090_2_05 mix_i_c090_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_05 (mix_q_src_c090_2_05 0 bpf_c090_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_2_05 (mix_q_src_c090_2_05 mix_q_c090_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_06 (mix_i_src_c090_2_06 0 bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_2_06 (mix_i_src_c090_2_06 mix_i_c090_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_06 (mix_q_src_c090_2_06 0 bpf_c090_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_2_06 (mix_q_src_c090_2_06 mix_q_c090_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_07 (mix_i_src_c090_2_07 0 bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_2_07 (mix_i_src_c090_2_07 mix_i_c090_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_07 (mix_q_src_c090_2_07 0 bpf_c090_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_2_07 (mix_q_src_c090_2_07 mix_q_c090_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_08 (mix_i_src_c090_2_08 0 bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_2_08 (mix_i_src_c090_2_08 mix_i_c090_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_08 (mix_q_src_c090_2_08 0 bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_2_08 (mix_q_src_c090_2_08 mix_q_c090_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_09 (mix_i_src_c090_2_09 0 bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_2_09 (mix_i_src_c090_2_09 mix_i_c090_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_09 (mix_q_src_c090_2_09 0 bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_2_09 (mix_q_src_c090_2_09 mix_q_c090_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_10 (mix_i_src_c090_2_10 0 bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_2_10 (mix_i_src_c090_2_10 mix_i_c090_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_10 (mix_q_src_c090_2_10 0 bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_2_10 (mix_q_src_c090_2_10 mix_q_c090_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_11 (mix_i_src_c090_2_11 0 bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_2_11 (mix_i_src_c090_2_11 mix_i_c090_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_11 (mix_q_src_c090_2_11 0 bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_2_11 (mix_q_src_c090_2_11 mix_q_c090_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_12 (mix_i_src_c090_2_12 0 bpf_c090_2 0) vcvs gain=1.950903220161e-01
SMIXI_c090_2_12 (mix_i_src_c090_2_12 mix_i_c090_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_12 (mix_q_src_c090_2_12 0 bpf_c090_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_2_12 (mix_q_src_c090_2_12 mix_q_c090_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_13 (mix_i_src_c090_2_13 0 bpf_c090_2 0) vcvs gain=5.555702330196e-01
SMIXI_c090_2_13 (mix_i_src_c090_2_13 mix_i_c090_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_13 (mix_q_src_c090_2_13 0 bpf_c090_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_2_13 (mix_q_src_c090_2_13 mix_q_c090_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_14 (mix_i_src_c090_2_14 0 bpf_c090_2 0) vcvs gain=8.314696123025e-01
SMIXI_c090_2_14 (mix_i_src_c090_2_14 mix_i_c090_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_14 (mix_q_src_c090_2_14 0 bpf_c090_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_2_14 (mix_q_src_c090_2_14 mix_q_c090_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_2_15 (mix_i_src_c090_2_15 0 bpf_c090_2 0) vcvs gain=9.807852804032e-01
SMIXI_c090_2_15 (mix_i_src_c090_2_15 mix_i_c090_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_2_15 (mix_q_src_c090_2_15 0 bpf_c090_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_2_15 (mix_q_src_c090_2_15 mix_q_c090_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c090_2 (mix_i_c090_2 0) resistor r=1G
RMIXQ_c090_2 (mix_q_c090_2 0) resistor r=1G
RINTI_c090_2 (mix_i_c090_2 Icar_c090_2) resistor r=1k
CINTI_c090_2 (Icar_c090_2 0) capacitor c=80p
RINTQ_c090_2 (mix_q_c090_2 Qcar_c090_2) resistor r=1k
CINTQ_c090_2 (Qcar_c090_2 0) capacitor c=80p

// bl090, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c090_3 (bl090 n_cbpf_c090_3) capacitor c=2.533029591058e-14
LBPF_c090_3 (n_cbpf_c090_3 bpf_c090_3) inductor l=1.000000000000e-06
RBPF_c090_3 (bpf_c090_3 0) resistor r=3.141592653590e+02
EMIXI_c090_3_00 (mix_i_src_c090_3_00 0 bpf_c090_3 0) vcvs gain=9.807852804032e-01
SMIXI_c090_3_00 (mix_i_src_c090_3_00 mix_i_c090_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_00 (mix_q_src_c090_3_00 0 bpf_c090_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_3_00 (mix_q_src_c090_3_00 mix_q_c090_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_01 (mix_i_src_c090_3_01 0 bpf_c090_3 0) vcvs gain=8.314696123025e-01
SMIXI_c090_3_01 (mix_i_src_c090_3_01 mix_i_c090_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_01 (mix_q_src_c090_3_01 0 bpf_c090_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_3_01 (mix_q_src_c090_3_01 mix_q_c090_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_02 (mix_i_src_c090_3_02 0 bpf_c090_3 0) vcvs gain=5.555702330196e-01
SMIXI_c090_3_02 (mix_i_src_c090_3_02 mix_i_c090_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_02 (mix_q_src_c090_3_02 0 bpf_c090_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_3_02 (mix_q_src_c090_3_02 mix_q_c090_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_03 (mix_i_src_c090_3_03 0 bpf_c090_3 0) vcvs gain=1.950903220161e-01
SMIXI_c090_3_03 (mix_i_src_c090_3_03 mix_i_c090_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_03 (mix_q_src_c090_3_03 0 bpf_c090_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_3_03 (mix_q_src_c090_3_03 mix_q_c090_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_04 (mix_i_src_c090_3_04 0 bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_3_04 (mix_i_src_c090_3_04 mix_i_c090_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_04 (mix_q_src_c090_3_04 0 bpf_c090_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c090_3_04 (mix_q_src_c090_3_04 mix_q_c090_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_05 (mix_i_src_c090_3_05 0 bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_3_05 (mix_i_src_c090_3_05 mix_i_c090_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_05 (mix_q_src_c090_3_05 0 bpf_c090_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c090_3_05 (mix_q_src_c090_3_05 mix_q_c090_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_06 (mix_i_src_c090_3_06 0 bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_3_06 (mix_i_src_c090_3_06 mix_i_c090_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_06 (mix_q_src_c090_3_06 0 bpf_c090_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c090_3_06 (mix_q_src_c090_3_06 mix_q_c090_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_07 (mix_i_src_c090_3_07 0 bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_3_07 (mix_i_src_c090_3_07 mix_i_c090_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_07 (mix_q_src_c090_3_07 0 bpf_c090_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c090_3_07 (mix_q_src_c090_3_07 mix_q_c090_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_08 (mix_i_src_c090_3_08 0 bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c090_3_08 (mix_i_src_c090_3_08 mix_i_c090_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_08 (mix_q_src_c090_3_08 0 bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_3_08 (mix_q_src_c090_3_08 mix_q_c090_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_09 (mix_i_src_c090_3_09 0 bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c090_3_09 (mix_i_src_c090_3_09 mix_i_c090_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_09 (mix_q_src_c090_3_09 0 bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_3_09 (mix_q_src_c090_3_09 mix_q_c090_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_10 (mix_i_src_c090_3_10 0 bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c090_3_10 (mix_i_src_c090_3_10 mix_i_c090_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_10 (mix_q_src_c090_3_10 0 bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_3_10 (mix_q_src_c090_3_10 mix_q_c090_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_11 (mix_i_src_c090_3_11 0 bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c090_3_11 (mix_i_src_c090_3_11 mix_i_c090_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_11 (mix_q_src_c090_3_11 0 bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_3_11 (mix_q_src_c090_3_11 mix_q_c090_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_12 (mix_i_src_c090_3_12 0 bpf_c090_3 0) vcvs gain=1.950903220161e-01
SMIXI_c090_3_12 (mix_i_src_c090_3_12 mix_i_c090_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_12 (mix_q_src_c090_3_12 0 bpf_c090_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c090_3_12 (mix_q_src_c090_3_12 mix_q_c090_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_13 (mix_i_src_c090_3_13 0 bpf_c090_3 0) vcvs gain=5.555702330196e-01
SMIXI_c090_3_13 (mix_i_src_c090_3_13 mix_i_c090_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_13 (mix_q_src_c090_3_13 0 bpf_c090_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c090_3_13 (mix_q_src_c090_3_13 mix_q_c090_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_14 (mix_i_src_c090_3_14 0 bpf_c090_3 0) vcvs gain=8.314696123025e-01
SMIXI_c090_3_14 (mix_i_src_c090_3_14 mix_i_c090_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_14 (mix_q_src_c090_3_14 0 bpf_c090_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c090_3_14 (mix_q_src_c090_3_14 mix_q_c090_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c090_3_15 (mix_i_src_c090_3_15 0 bpf_c090_3 0) vcvs gain=9.807852804032e-01
SMIXI_c090_3_15 (mix_i_src_c090_3_15 mix_i_c090_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c090_3_15 (mix_q_src_c090_3_15 0 bpf_c090_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c090_3_15 (mix_q_src_c090_3_15 mix_q_c090_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c090_3 (mix_i_c090_3 0) resistor r=1G
RMIXQ_c090_3 (mix_q_c090_3 0) resistor r=1G
RINTI_c090_3 (mix_i_c090_3 Icar_c090_3) resistor r=1k
CINTI_c090_3 (Icar_c090_3 0) capacitor c=80p
RINTQ_c090_3 (mix_q_c090_3 Qcar_c090_3) resistor r=1k
CINTQ_c090_3 (Qcar_c090_3 0) capacitor c=80p

// bl091, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c091_0 (bl091 n_cbpf_c091_0) capacitor c=4.052847345694e-13
LBPF_c091_0 (n_cbpf_c091_0 bpf_c091_0) inductor l=1.000000000000e-06
RBPF_c091_0 (bpf_c091_0 0) resistor r=7.853981633974e+01
EMIXI_c091_0_00 (mix_i_src_c091_0_00 0 bpf_c091_0 0) vcvs gain=9.807852804032e-01
SMIXI_c091_0_00 (mix_i_src_c091_0_00 mix_i_c091_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_00 (mix_q_src_c091_0_00 0 bpf_c091_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_0_00 (mix_q_src_c091_0_00 mix_q_c091_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_01 (mix_i_src_c091_0_01 0 bpf_c091_0 0) vcvs gain=8.314696123025e-01
SMIXI_c091_0_01 (mix_i_src_c091_0_01 mix_i_c091_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_01 (mix_q_src_c091_0_01 0 bpf_c091_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_0_01 (mix_q_src_c091_0_01 mix_q_c091_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_02 (mix_i_src_c091_0_02 0 bpf_c091_0 0) vcvs gain=5.555702330196e-01
SMIXI_c091_0_02 (mix_i_src_c091_0_02 mix_i_c091_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_02 (mix_q_src_c091_0_02 0 bpf_c091_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_0_02 (mix_q_src_c091_0_02 mix_q_c091_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_03 (mix_i_src_c091_0_03 0 bpf_c091_0 0) vcvs gain=1.950903220161e-01
SMIXI_c091_0_03 (mix_i_src_c091_0_03 mix_i_c091_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_03 (mix_q_src_c091_0_03 0 bpf_c091_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_0_03 (mix_q_src_c091_0_03 mix_q_c091_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_04 (mix_i_src_c091_0_04 0 bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_0_04 (mix_i_src_c091_0_04 mix_i_c091_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_04 (mix_q_src_c091_0_04 0 bpf_c091_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_0_04 (mix_q_src_c091_0_04 mix_q_c091_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_05 (mix_i_src_c091_0_05 0 bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_0_05 (mix_i_src_c091_0_05 mix_i_c091_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_05 (mix_q_src_c091_0_05 0 bpf_c091_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_0_05 (mix_q_src_c091_0_05 mix_q_c091_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_06 (mix_i_src_c091_0_06 0 bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_0_06 (mix_i_src_c091_0_06 mix_i_c091_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_06 (mix_q_src_c091_0_06 0 bpf_c091_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_0_06 (mix_q_src_c091_0_06 mix_q_c091_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_07 (mix_i_src_c091_0_07 0 bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_0_07 (mix_i_src_c091_0_07 mix_i_c091_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_07 (mix_q_src_c091_0_07 0 bpf_c091_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_0_07 (mix_q_src_c091_0_07 mix_q_c091_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_08 (mix_i_src_c091_0_08 0 bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_0_08 (mix_i_src_c091_0_08 mix_i_c091_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_08 (mix_q_src_c091_0_08 0 bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_0_08 (mix_q_src_c091_0_08 mix_q_c091_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_09 (mix_i_src_c091_0_09 0 bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_0_09 (mix_i_src_c091_0_09 mix_i_c091_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_09 (mix_q_src_c091_0_09 0 bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_0_09 (mix_q_src_c091_0_09 mix_q_c091_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_10 (mix_i_src_c091_0_10 0 bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_0_10 (mix_i_src_c091_0_10 mix_i_c091_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_10 (mix_q_src_c091_0_10 0 bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_0_10 (mix_q_src_c091_0_10 mix_q_c091_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_11 (mix_i_src_c091_0_11 0 bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_0_11 (mix_i_src_c091_0_11 mix_i_c091_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_11 (mix_q_src_c091_0_11 0 bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_0_11 (mix_q_src_c091_0_11 mix_q_c091_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_12 (mix_i_src_c091_0_12 0 bpf_c091_0 0) vcvs gain=1.950903220161e-01
SMIXI_c091_0_12 (mix_i_src_c091_0_12 mix_i_c091_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_12 (mix_q_src_c091_0_12 0 bpf_c091_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_0_12 (mix_q_src_c091_0_12 mix_q_c091_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_13 (mix_i_src_c091_0_13 0 bpf_c091_0 0) vcvs gain=5.555702330196e-01
SMIXI_c091_0_13 (mix_i_src_c091_0_13 mix_i_c091_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_13 (mix_q_src_c091_0_13 0 bpf_c091_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_0_13 (mix_q_src_c091_0_13 mix_q_c091_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_14 (mix_i_src_c091_0_14 0 bpf_c091_0 0) vcvs gain=8.314696123025e-01
SMIXI_c091_0_14 (mix_i_src_c091_0_14 mix_i_c091_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_14 (mix_q_src_c091_0_14 0 bpf_c091_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_0_14 (mix_q_src_c091_0_14 mix_q_c091_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_0_15 (mix_i_src_c091_0_15 0 bpf_c091_0 0) vcvs gain=9.807852804032e-01
SMIXI_c091_0_15 (mix_i_src_c091_0_15 mix_i_c091_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_0_15 (mix_q_src_c091_0_15 0 bpf_c091_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_0_15 (mix_q_src_c091_0_15 mix_q_c091_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c091_0 (mix_i_c091_0 0) resistor r=1G
RMIXQ_c091_0 (mix_q_c091_0 0) resistor r=1G
RINTI_c091_0 (mix_i_c091_0 Icar_c091_0) resistor r=1k
CINTI_c091_0 (Icar_c091_0 0) capacitor c=80p
RINTQ_c091_0 (mix_q_c091_0 Qcar_c091_0) resistor r=1k
CINTQ_c091_0 (Qcar_c091_0 0) capacitor c=80p

// bl091, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c091_1 (bl091 n_cbpf_c091_1) capacitor c=1.013211836423e-13
LBPF_c091_1 (n_cbpf_c091_1 bpf_c091_1) inductor l=1.000000000000e-06
RBPF_c091_1 (bpf_c091_1 0) resistor r=1.570796326795e+02
EMIXI_c091_1_00 (mix_i_src_c091_1_00 0 bpf_c091_1 0) vcvs gain=9.807852804032e-01
SMIXI_c091_1_00 (mix_i_src_c091_1_00 mix_i_c091_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_00 (mix_q_src_c091_1_00 0 bpf_c091_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_1_00 (mix_q_src_c091_1_00 mix_q_c091_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_01 (mix_i_src_c091_1_01 0 bpf_c091_1 0) vcvs gain=8.314696123025e-01
SMIXI_c091_1_01 (mix_i_src_c091_1_01 mix_i_c091_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_01 (mix_q_src_c091_1_01 0 bpf_c091_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_1_01 (mix_q_src_c091_1_01 mix_q_c091_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_02 (mix_i_src_c091_1_02 0 bpf_c091_1 0) vcvs gain=5.555702330196e-01
SMIXI_c091_1_02 (mix_i_src_c091_1_02 mix_i_c091_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_02 (mix_q_src_c091_1_02 0 bpf_c091_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_1_02 (mix_q_src_c091_1_02 mix_q_c091_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_03 (mix_i_src_c091_1_03 0 bpf_c091_1 0) vcvs gain=1.950903220161e-01
SMIXI_c091_1_03 (mix_i_src_c091_1_03 mix_i_c091_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_03 (mix_q_src_c091_1_03 0 bpf_c091_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_1_03 (mix_q_src_c091_1_03 mix_q_c091_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_04 (mix_i_src_c091_1_04 0 bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_1_04 (mix_i_src_c091_1_04 mix_i_c091_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_04 (mix_q_src_c091_1_04 0 bpf_c091_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_1_04 (mix_q_src_c091_1_04 mix_q_c091_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_05 (mix_i_src_c091_1_05 0 bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_1_05 (mix_i_src_c091_1_05 mix_i_c091_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_05 (mix_q_src_c091_1_05 0 bpf_c091_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_1_05 (mix_q_src_c091_1_05 mix_q_c091_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_06 (mix_i_src_c091_1_06 0 bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_1_06 (mix_i_src_c091_1_06 mix_i_c091_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_06 (mix_q_src_c091_1_06 0 bpf_c091_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_1_06 (mix_q_src_c091_1_06 mix_q_c091_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_07 (mix_i_src_c091_1_07 0 bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_1_07 (mix_i_src_c091_1_07 mix_i_c091_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_07 (mix_q_src_c091_1_07 0 bpf_c091_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_1_07 (mix_q_src_c091_1_07 mix_q_c091_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_08 (mix_i_src_c091_1_08 0 bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_1_08 (mix_i_src_c091_1_08 mix_i_c091_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_08 (mix_q_src_c091_1_08 0 bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_1_08 (mix_q_src_c091_1_08 mix_q_c091_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_09 (mix_i_src_c091_1_09 0 bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_1_09 (mix_i_src_c091_1_09 mix_i_c091_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_09 (mix_q_src_c091_1_09 0 bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_1_09 (mix_q_src_c091_1_09 mix_q_c091_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_10 (mix_i_src_c091_1_10 0 bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_1_10 (mix_i_src_c091_1_10 mix_i_c091_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_10 (mix_q_src_c091_1_10 0 bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_1_10 (mix_q_src_c091_1_10 mix_q_c091_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_11 (mix_i_src_c091_1_11 0 bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_1_11 (mix_i_src_c091_1_11 mix_i_c091_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_11 (mix_q_src_c091_1_11 0 bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_1_11 (mix_q_src_c091_1_11 mix_q_c091_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_12 (mix_i_src_c091_1_12 0 bpf_c091_1 0) vcvs gain=1.950903220161e-01
SMIXI_c091_1_12 (mix_i_src_c091_1_12 mix_i_c091_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_12 (mix_q_src_c091_1_12 0 bpf_c091_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_1_12 (mix_q_src_c091_1_12 mix_q_c091_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_13 (mix_i_src_c091_1_13 0 bpf_c091_1 0) vcvs gain=5.555702330196e-01
SMIXI_c091_1_13 (mix_i_src_c091_1_13 mix_i_c091_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_13 (mix_q_src_c091_1_13 0 bpf_c091_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_1_13 (mix_q_src_c091_1_13 mix_q_c091_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_14 (mix_i_src_c091_1_14 0 bpf_c091_1 0) vcvs gain=8.314696123025e-01
SMIXI_c091_1_14 (mix_i_src_c091_1_14 mix_i_c091_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_14 (mix_q_src_c091_1_14 0 bpf_c091_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_1_14 (mix_q_src_c091_1_14 mix_q_c091_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_1_15 (mix_i_src_c091_1_15 0 bpf_c091_1 0) vcvs gain=9.807852804032e-01
SMIXI_c091_1_15 (mix_i_src_c091_1_15 mix_i_c091_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_1_15 (mix_q_src_c091_1_15 0 bpf_c091_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_1_15 (mix_q_src_c091_1_15 mix_q_c091_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c091_1 (mix_i_c091_1 0) resistor r=1G
RMIXQ_c091_1 (mix_q_c091_1 0) resistor r=1G
RINTI_c091_1 (mix_i_c091_1 Icar_c091_1) resistor r=1k
CINTI_c091_1 (Icar_c091_1 0) capacitor c=80p
RINTQ_c091_1 (mix_q_c091_1 Qcar_c091_1) resistor r=1k
CINTQ_c091_1 (Qcar_c091_1 0) capacitor c=80p

// bl091, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c091_2 (bl091 n_cbpf_c091_2) capacitor c=4.503163717437e-14
LBPF_c091_2 (n_cbpf_c091_2 bpf_c091_2) inductor l=1.000000000000e-06
RBPF_c091_2 (bpf_c091_2 0) resistor r=2.356194490192e+02
EMIXI_c091_2_00 (mix_i_src_c091_2_00 0 bpf_c091_2 0) vcvs gain=9.807852804032e-01
SMIXI_c091_2_00 (mix_i_src_c091_2_00 mix_i_c091_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_00 (mix_q_src_c091_2_00 0 bpf_c091_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_2_00 (mix_q_src_c091_2_00 mix_q_c091_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_01 (mix_i_src_c091_2_01 0 bpf_c091_2 0) vcvs gain=8.314696123025e-01
SMIXI_c091_2_01 (mix_i_src_c091_2_01 mix_i_c091_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_01 (mix_q_src_c091_2_01 0 bpf_c091_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_2_01 (mix_q_src_c091_2_01 mix_q_c091_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_02 (mix_i_src_c091_2_02 0 bpf_c091_2 0) vcvs gain=5.555702330196e-01
SMIXI_c091_2_02 (mix_i_src_c091_2_02 mix_i_c091_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_02 (mix_q_src_c091_2_02 0 bpf_c091_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_2_02 (mix_q_src_c091_2_02 mix_q_c091_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_03 (mix_i_src_c091_2_03 0 bpf_c091_2 0) vcvs gain=1.950903220161e-01
SMIXI_c091_2_03 (mix_i_src_c091_2_03 mix_i_c091_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_03 (mix_q_src_c091_2_03 0 bpf_c091_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_2_03 (mix_q_src_c091_2_03 mix_q_c091_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_04 (mix_i_src_c091_2_04 0 bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_2_04 (mix_i_src_c091_2_04 mix_i_c091_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_04 (mix_q_src_c091_2_04 0 bpf_c091_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_2_04 (mix_q_src_c091_2_04 mix_q_c091_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_05 (mix_i_src_c091_2_05 0 bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_2_05 (mix_i_src_c091_2_05 mix_i_c091_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_05 (mix_q_src_c091_2_05 0 bpf_c091_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_2_05 (mix_q_src_c091_2_05 mix_q_c091_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_06 (mix_i_src_c091_2_06 0 bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_2_06 (mix_i_src_c091_2_06 mix_i_c091_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_06 (mix_q_src_c091_2_06 0 bpf_c091_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_2_06 (mix_q_src_c091_2_06 mix_q_c091_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_07 (mix_i_src_c091_2_07 0 bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_2_07 (mix_i_src_c091_2_07 mix_i_c091_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_07 (mix_q_src_c091_2_07 0 bpf_c091_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_2_07 (mix_q_src_c091_2_07 mix_q_c091_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_08 (mix_i_src_c091_2_08 0 bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_2_08 (mix_i_src_c091_2_08 mix_i_c091_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_08 (mix_q_src_c091_2_08 0 bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_2_08 (mix_q_src_c091_2_08 mix_q_c091_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_09 (mix_i_src_c091_2_09 0 bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_2_09 (mix_i_src_c091_2_09 mix_i_c091_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_09 (mix_q_src_c091_2_09 0 bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_2_09 (mix_q_src_c091_2_09 mix_q_c091_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_10 (mix_i_src_c091_2_10 0 bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_2_10 (mix_i_src_c091_2_10 mix_i_c091_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_10 (mix_q_src_c091_2_10 0 bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_2_10 (mix_q_src_c091_2_10 mix_q_c091_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_11 (mix_i_src_c091_2_11 0 bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_2_11 (mix_i_src_c091_2_11 mix_i_c091_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_11 (mix_q_src_c091_2_11 0 bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_2_11 (mix_q_src_c091_2_11 mix_q_c091_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_12 (mix_i_src_c091_2_12 0 bpf_c091_2 0) vcvs gain=1.950903220161e-01
SMIXI_c091_2_12 (mix_i_src_c091_2_12 mix_i_c091_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_12 (mix_q_src_c091_2_12 0 bpf_c091_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_2_12 (mix_q_src_c091_2_12 mix_q_c091_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_13 (mix_i_src_c091_2_13 0 bpf_c091_2 0) vcvs gain=5.555702330196e-01
SMIXI_c091_2_13 (mix_i_src_c091_2_13 mix_i_c091_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_13 (mix_q_src_c091_2_13 0 bpf_c091_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_2_13 (mix_q_src_c091_2_13 mix_q_c091_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_14 (mix_i_src_c091_2_14 0 bpf_c091_2 0) vcvs gain=8.314696123025e-01
SMIXI_c091_2_14 (mix_i_src_c091_2_14 mix_i_c091_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_14 (mix_q_src_c091_2_14 0 bpf_c091_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_2_14 (mix_q_src_c091_2_14 mix_q_c091_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_2_15 (mix_i_src_c091_2_15 0 bpf_c091_2 0) vcvs gain=9.807852804032e-01
SMIXI_c091_2_15 (mix_i_src_c091_2_15 mix_i_c091_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_2_15 (mix_q_src_c091_2_15 0 bpf_c091_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_2_15 (mix_q_src_c091_2_15 mix_q_c091_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c091_2 (mix_i_c091_2 0) resistor r=1G
RMIXQ_c091_2 (mix_q_c091_2 0) resistor r=1G
RINTI_c091_2 (mix_i_c091_2 Icar_c091_2) resistor r=1k
CINTI_c091_2 (Icar_c091_2 0) capacitor c=80p
RINTQ_c091_2 (mix_q_c091_2 Qcar_c091_2) resistor r=1k
CINTQ_c091_2 (Qcar_c091_2 0) capacitor c=80p

// bl091, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c091_3 (bl091 n_cbpf_c091_3) capacitor c=2.533029591058e-14
LBPF_c091_3 (n_cbpf_c091_3 bpf_c091_3) inductor l=1.000000000000e-06
RBPF_c091_3 (bpf_c091_3 0) resistor r=3.141592653590e+02
EMIXI_c091_3_00 (mix_i_src_c091_3_00 0 bpf_c091_3 0) vcvs gain=9.807852804032e-01
SMIXI_c091_3_00 (mix_i_src_c091_3_00 mix_i_c091_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_00 (mix_q_src_c091_3_00 0 bpf_c091_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_3_00 (mix_q_src_c091_3_00 mix_q_c091_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_01 (mix_i_src_c091_3_01 0 bpf_c091_3 0) vcvs gain=8.314696123025e-01
SMIXI_c091_3_01 (mix_i_src_c091_3_01 mix_i_c091_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_01 (mix_q_src_c091_3_01 0 bpf_c091_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_3_01 (mix_q_src_c091_3_01 mix_q_c091_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_02 (mix_i_src_c091_3_02 0 bpf_c091_3 0) vcvs gain=5.555702330196e-01
SMIXI_c091_3_02 (mix_i_src_c091_3_02 mix_i_c091_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_02 (mix_q_src_c091_3_02 0 bpf_c091_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_3_02 (mix_q_src_c091_3_02 mix_q_c091_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_03 (mix_i_src_c091_3_03 0 bpf_c091_3 0) vcvs gain=1.950903220161e-01
SMIXI_c091_3_03 (mix_i_src_c091_3_03 mix_i_c091_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_03 (mix_q_src_c091_3_03 0 bpf_c091_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_3_03 (mix_q_src_c091_3_03 mix_q_c091_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_04 (mix_i_src_c091_3_04 0 bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_3_04 (mix_i_src_c091_3_04 mix_i_c091_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_04 (mix_q_src_c091_3_04 0 bpf_c091_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c091_3_04 (mix_q_src_c091_3_04 mix_q_c091_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_05 (mix_i_src_c091_3_05 0 bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_3_05 (mix_i_src_c091_3_05 mix_i_c091_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_05 (mix_q_src_c091_3_05 0 bpf_c091_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c091_3_05 (mix_q_src_c091_3_05 mix_q_c091_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_06 (mix_i_src_c091_3_06 0 bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_3_06 (mix_i_src_c091_3_06 mix_i_c091_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_06 (mix_q_src_c091_3_06 0 bpf_c091_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c091_3_06 (mix_q_src_c091_3_06 mix_q_c091_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_07 (mix_i_src_c091_3_07 0 bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_3_07 (mix_i_src_c091_3_07 mix_i_c091_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_07 (mix_q_src_c091_3_07 0 bpf_c091_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c091_3_07 (mix_q_src_c091_3_07 mix_q_c091_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_08 (mix_i_src_c091_3_08 0 bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c091_3_08 (mix_i_src_c091_3_08 mix_i_c091_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_08 (mix_q_src_c091_3_08 0 bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_3_08 (mix_q_src_c091_3_08 mix_q_c091_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_09 (mix_i_src_c091_3_09 0 bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c091_3_09 (mix_i_src_c091_3_09 mix_i_c091_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_09 (mix_q_src_c091_3_09 0 bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_3_09 (mix_q_src_c091_3_09 mix_q_c091_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_10 (mix_i_src_c091_3_10 0 bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c091_3_10 (mix_i_src_c091_3_10 mix_i_c091_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_10 (mix_q_src_c091_3_10 0 bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_3_10 (mix_q_src_c091_3_10 mix_q_c091_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_11 (mix_i_src_c091_3_11 0 bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c091_3_11 (mix_i_src_c091_3_11 mix_i_c091_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_11 (mix_q_src_c091_3_11 0 bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_3_11 (mix_q_src_c091_3_11 mix_q_c091_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_12 (mix_i_src_c091_3_12 0 bpf_c091_3 0) vcvs gain=1.950903220161e-01
SMIXI_c091_3_12 (mix_i_src_c091_3_12 mix_i_c091_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_12 (mix_q_src_c091_3_12 0 bpf_c091_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c091_3_12 (mix_q_src_c091_3_12 mix_q_c091_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_13 (mix_i_src_c091_3_13 0 bpf_c091_3 0) vcvs gain=5.555702330196e-01
SMIXI_c091_3_13 (mix_i_src_c091_3_13 mix_i_c091_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_13 (mix_q_src_c091_3_13 0 bpf_c091_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c091_3_13 (mix_q_src_c091_3_13 mix_q_c091_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_14 (mix_i_src_c091_3_14 0 bpf_c091_3 0) vcvs gain=8.314696123025e-01
SMIXI_c091_3_14 (mix_i_src_c091_3_14 mix_i_c091_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_14 (mix_q_src_c091_3_14 0 bpf_c091_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c091_3_14 (mix_q_src_c091_3_14 mix_q_c091_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c091_3_15 (mix_i_src_c091_3_15 0 bpf_c091_3 0) vcvs gain=9.807852804032e-01
SMIXI_c091_3_15 (mix_i_src_c091_3_15 mix_i_c091_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c091_3_15 (mix_q_src_c091_3_15 0 bpf_c091_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c091_3_15 (mix_q_src_c091_3_15 mix_q_c091_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c091_3 (mix_i_c091_3 0) resistor r=1G
RMIXQ_c091_3 (mix_q_c091_3 0) resistor r=1G
RINTI_c091_3 (mix_i_c091_3 Icar_c091_3) resistor r=1k
CINTI_c091_3 (Icar_c091_3 0) capacitor c=80p
RINTQ_c091_3 (mix_q_c091_3 Qcar_c091_3) resistor r=1k
CINTQ_c091_3 (Qcar_c091_3 0) capacitor c=80p

// bl092, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c092_0 (bl092 n_cbpf_c092_0) capacitor c=4.052847345694e-13
LBPF_c092_0 (n_cbpf_c092_0 bpf_c092_0) inductor l=1.000000000000e-06
RBPF_c092_0 (bpf_c092_0 0) resistor r=7.853981633974e+01
EMIXI_c092_0_00 (mix_i_src_c092_0_00 0 bpf_c092_0 0) vcvs gain=9.807852804032e-01
SMIXI_c092_0_00 (mix_i_src_c092_0_00 mix_i_c092_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_00 (mix_q_src_c092_0_00 0 bpf_c092_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_0_00 (mix_q_src_c092_0_00 mix_q_c092_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_01 (mix_i_src_c092_0_01 0 bpf_c092_0 0) vcvs gain=8.314696123025e-01
SMIXI_c092_0_01 (mix_i_src_c092_0_01 mix_i_c092_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_01 (mix_q_src_c092_0_01 0 bpf_c092_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_0_01 (mix_q_src_c092_0_01 mix_q_c092_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_02 (mix_i_src_c092_0_02 0 bpf_c092_0 0) vcvs gain=5.555702330196e-01
SMIXI_c092_0_02 (mix_i_src_c092_0_02 mix_i_c092_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_02 (mix_q_src_c092_0_02 0 bpf_c092_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_0_02 (mix_q_src_c092_0_02 mix_q_c092_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_03 (mix_i_src_c092_0_03 0 bpf_c092_0 0) vcvs gain=1.950903220161e-01
SMIXI_c092_0_03 (mix_i_src_c092_0_03 mix_i_c092_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_03 (mix_q_src_c092_0_03 0 bpf_c092_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_0_03 (mix_q_src_c092_0_03 mix_q_c092_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_04 (mix_i_src_c092_0_04 0 bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_0_04 (mix_i_src_c092_0_04 mix_i_c092_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_04 (mix_q_src_c092_0_04 0 bpf_c092_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_0_04 (mix_q_src_c092_0_04 mix_q_c092_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_05 (mix_i_src_c092_0_05 0 bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_0_05 (mix_i_src_c092_0_05 mix_i_c092_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_05 (mix_q_src_c092_0_05 0 bpf_c092_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_0_05 (mix_q_src_c092_0_05 mix_q_c092_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_06 (mix_i_src_c092_0_06 0 bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_0_06 (mix_i_src_c092_0_06 mix_i_c092_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_06 (mix_q_src_c092_0_06 0 bpf_c092_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_0_06 (mix_q_src_c092_0_06 mix_q_c092_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_07 (mix_i_src_c092_0_07 0 bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_0_07 (mix_i_src_c092_0_07 mix_i_c092_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_07 (mix_q_src_c092_0_07 0 bpf_c092_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_0_07 (mix_q_src_c092_0_07 mix_q_c092_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_08 (mix_i_src_c092_0_08 0 bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_0_08 (mix_i_src_c092_0_08 mix_i_c092_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_08 (mix_q_src_c092_0_08 0 bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_0_08 (mix_q_src_c092_0_08 mix_q_c092_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_09 (mix_i_src_c092_0_09 0 bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_0_09 (mix_i_src_c092_0_09 mix_i_c092_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_09 (mix_q_src_c092_0_09 0 bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_0_09 (mix_q_src_c092_0_09 mix_q_c092_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_10 (mix_i_src_c092_0_10 0 bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_0_10 (mix_i_src_c092_0_10 mix_i_c092_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_10 (mix_q_src_c092_0_10 0 bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_0_10 (mix_q_src_c092_0_10 mix_q_c092_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_11 (mix_i_src_c092_0_11 0 bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_0_11 (mix_i_src_c092_0_11 mix_i_c092_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_11 (mix_q_src_c092_0_11 0 bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_0_11 (mix_q_src_c092_0_11 mix_q_c092_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_12 (mix_i_src_c092_0_12 0 bpf_c092_0 0) vcvs gain=1.950903220161e-01
SMIXI_c092_0_12 (mix_i_src_c092_0_12 mix_i_c092_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_12 (mix_q_src_c092_0_12 0 bpf_c092_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_0_12 (mix_q_src_c092_0_12 mix_q_c092_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_13 (mix_i_src_c092_0_13 0 bpf_c092_0 0) vcvs gain=5.555702330196e-01
SMIXI_c092_0_13 (mix_i_src_c092_0_13 mix_i_c092_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_13 (mix_q_src_c092_0_13 0 bpf_c092_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_0_13 (mix_q_src_c092_0_13 mix_q_c092_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_14 (mix_i_src_c092_0_14 0 bpf_c092_0 0) vcvs gain=8.314696123025e-01
SMIXI_c092_0_14 (mix_i_src_c092_0_14 mix_i_c092_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_14 (mix_q_src_c092_0_14 0 bpf_c092_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_0_14 (mix_q_src_c092_0_14 mix_q_c092_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_0_15 (mix_i_src_c092_0_15 0 bpf_c092_0 0) vcvs gain=9.807852804032e-01
SMIXI_c092_0_15 (mix_i_src_c092_0_15 mix_i_c092_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_0_15 (mix_q_src_c092_0_15 0 bpf_c092_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_0_15 (mix_q_src_c092_0_15 mix_q_c092_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c092_0 (mix_i_c092_0 0) resistor r=1G
RMIXQ_c092_0 (mix_q_c092_0 0) resistor r=1G
RINTI_c092_0 (mix_i_c092_0 Icar_c092_0) resistor r=1k
CINTI_c092_0 (Icar_c092_0 0) capacitor c=80p
RINTQ_c092_0 (mix_q_c092_0 Qcar_c092_0) resistor r=1k
CINTQ_c092_0 (Qcar_c092_0 0) capacitor c=80p

// bl092, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c092_1 (bl092 n_cbpf_c092_1) capacitor c=1.013211836423e-13
LBPF_c092_1 (n_cbpf_c092_1 bpf_c092_1) inductor l=1.000000000000e-06
RBPF_c092_1 (bpf_c092_1 0) resistor r=1.570796326795e+02
EMIXI_c092_1_00 (mix_i_src_c092_1_00 0 bpf_c092_1 0) vcvs gain=9.807852804032e-01
SMIXI_c092_1_00 (mix_i_src_c092_1_00 mix_i_c092_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_00 (mix_q_src_c092_1_00 0 bpf_c092_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_1_00 (mix_q_src_c092_1_00 mix_q_c092_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_01 (mix_i_src_c092_1_01 0 bpf_c092_1 0) vcvs gain=8.314696123025e-01
SMIXI_c092_1_01 (mix_i_src_c092_1_01 mix_i_c092_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_01 (mix_q_src_c092_1_01 0 bpf_c092_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_1_01 (mix_q_src_c092_1_01 mix_q_c092_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_02 (mix_i_src_c092_1_02 0 bpf_c092_1 0) vcvs gain=5.555702330196e-01
SMIXI_c092_1_02 (mix_i_src_c092_1_02 mix_i_c092_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_02 (mix_q_src_c092_1_02 0 bpf_c092_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_1_02 (mix_q_src_c092_1_02 mix_q_c092_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_03 (mix_i_src_c092_1_03 0 bpf_c092_1 0) vcvs gain=1.950903220161e-01
SMIXI_c092_1_03 (mix_i_src_c092_1_03 mix_i_c092_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_03 (mix_q_src_c092_1_03 0 bpf_c092_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_1_03 (mix_q_src_c092_1_03 mix_q_c092_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_04 (mix_i_src_c092_1_04 0 bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_1_04 (mix_i_src_c092_1_04 mix_i_c092_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_04 (mix_q_src_c092_1_04 0 bpf_c092_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_1_04 (mix_q_src_c092_1_04 mix_q_c092_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_05 (mix_i_src_c092_1_05 0 bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_1_05 (mix_i_src_c092_1_05 mix_i_c092_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_05 (mix_q_src_c092_1_05 0 bpf_c092_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_1_05 (mix_q_src_c092_1_05 mix_q_c092_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_06 (mix_i_src_c092_1_06 0 bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_1_06 (mix_i_src_c092_1_06 mix_i_c092_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_06 (mix_q_src_c092_1_06 0 bpf_c092_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_1_06 (mix_q_src_c092_1_06 mix_q_c092_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_07 (mix_i_src_c092_1_07 0 bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_1_07 (mix_i_src_c092_1_07 mix_i_c092_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_07 (mix_q_src_c092_1_07 0 bpf_c092_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_1_07 (mix_q_src_c092_1_07 mix_q_c092_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_08 (mix_i_src_c092_1_08 0 bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_1_08 (mix_i_src_c092_1_08 mix_i_c092_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_08 (mix_q_src_c092_1_08 0 bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_1_08 (mix_q_src_c092_1_08 mix_q_c092_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_09 (mix_i_src_c092_1_09 0 bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_1_09 (mix_i_src_c092_1_09 mix_i_c092_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_09 (mix_q_src_c092_1_09 0 bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_1_09 (mix_q_src_c092_1_09 mix_q_c092_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_10 (mix_i_src_c092_1_10 0 bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_1_10 (mix_i_src_c092_1_10 mix_i_c092_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_10 (mix_q_src_c092_1_10 0 bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_1_10 (mix_q_src_c092_1_10 mix_q_c092_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_11 (mix_i_src_c092_1_11 0 bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_1_11 (mix_i_src_c092_1_11 mix_i_c092_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_11 (mix_q_src_c092_1_11 0 bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_1_11 (mix_q_src_c092_1_11 mix_q_c092_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_12 (mix_i_src_c092_1_12 0 bpf_c092_1 0) vcvs gain=1.950903220161e-01
SMIXI_c092_1_12 (mix_i_src_c092_1_12 mix_i_c092_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_12 (mix_q_src_c092_1_12 0 bpf_c092_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_1_12 (mix_q_src_c092_1_12 mix_q_c092_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_13 (mix_i_src_c092_1_13 0 bpf_c092_1 0) vcvs gain=5.555702330196e-01
SMIXI_c092_1_13 (mix_i_src_c092_1_13 mix_i_c092_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_13 (mix_q_src_c092_1_13 0 bpf_c092_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_1_13 (mix_q_src_c092_1_13 mix_q_c092_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_14 (mix_i_src_c092_1_14 0 bpf_c092_1 0) vcvs gain=8.314696123025e-01
SMIXI_c092_1_14 (mix_i_src_c092_1_14 mix_i_c092_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_14 (mix_q_src_c092_1_14 0 bpf_c092_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_1_14 (mix_q_src_c092_1_14 mix_q_c092_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_1_15 (mix_i_src_c092_1_15 0 bpf_c092_1 0) vcvs gain=9.807852804032e-01
SMIXI_c092_1_15 (mix_i_src_c092_1_15 mix_i_c092_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_1_15 (mix_q_src_c092_1_15 0 bpf_c092_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_1_15 (mix_q_src_c092_1_15 mix_q_c092_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c092_1 (mix_i_c092_1 0) resistor r=1G
RMIXQ_c092_1 (mix_q_c092_1 0) resistor r=1G
RINTI_c092_1 (mix_i_c092_1 Icar_c092_1) resistor r=1k
CINTI_c092_1 (Icar_c092_1 0) capacitor c=80p
RINTQ_c092_1 (mix_q_c092_1 Qcar_c092_1) resistor r=1k
CINTQ_c092_1 (Qcar_c092_1 0) capacitor c=80p

// bl092, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c092_2 (bl092 n_cbpf_c092_2) capacitor c=4.503163717437e-14
LBPF_c092_2 (n_cbpf_c092_2 bpf_c092_2) inductor l=1.000000000000e-06
RBPF_c092_2 (bpf_c092_2 0) resistor r=2.356194490192e+02
EMIXI_c092_2_00 (mix_i_src_c092_2_00 0 bpf_c092_2 0) vcvs gain=9.807852804032e-01
SMIXI_c092_2_00 (mix_i_src_c092_2_00 mix_i_c092_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_00 (mix_q_src_c092_2_00 0 bpf_c092_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_2_00 (mix_q_src_c092_2_00 mix_q_c092_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_01 (mix_i_src_c092_2_01 0 bpf_c092_2 0) vcvs gain=8.314696123025e-01
SMIXI_c092_2_01 (mix_i_src_c092_2_01 mix_i_c092_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_01 (mix_q_src_c092_2_01 0 bpf_c092_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_2_01 (mix_q_src_c092_2_01 mix_q_c092_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_02 (mix_i_src_c092_2_02 0 bpf_c092_2 0) vcvs gain=5.555702330196e-01
SMIXI_c092_2_02 (mix_i_src_c092_2_02 mix_i_c092_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_02 (mix_q_src_c092_2_02 0 bpf_c092_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_2_02 (mix_q_src_c092_2_02 mix_q_c092_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_03 (mix_i_src_c092_2_03 0 bpf_c092_2 0) vcvs gain=1.950903220161e-01
SMIXI_c092_2_03 (mix_i_src_c092_2_03 mix_i_c092_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_03 (mix_q_src_c092_2_03 0 bpf_c092_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_2_03 (mix_q_src_c092_2_03 mix_q_c092_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_04 (mix_i_src_c092_2_04 0 bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_2_04 (mix_i_src_c092_2_04 mix_i_c092_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_04 (mix_q_src_c092_2_04 0 bpf_c092_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_2_04 (mix_q_src_c092_2_04 mix_q_c092_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_05 (mix_i_src_c092_2_05 0 bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_2_05 (mix_i_src_c092_2_05 mix_i_c092_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_05 (mix_q_src_c092_2_05 0 bpf_c092_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_2_05 (mix_q_src_c092_2_05 mix_q_c092_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_06 (mix_i_src_c092_2_06 0 bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_2_06 (mix_i_src_c092_2_06 mix_i_c092_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_06 (mix_q_src_c092_2_06 0 bpf_c092_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_2_06 (mix_q_src_c092_2_06 mix_q_c092_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_07 (mix_i_src_c092_2_07 0 bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_2_07 (mix_i_src_c092_2_07 mix_i_c092_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_07 (mix_q_src_c092_2_07 0 bpf_c092_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_2_07 (mix_q_src_c092_2_07 mix_q_c092_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_08 (mix_i_src_c092_2_08 0 bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_2_08 (mix_i_src_c092_2_08 mix_i_c092_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_08 (mix_q_src_c092_2_08 0 bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_2_08 (mix_q_src_c092_2_08 mix_q_c092_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_09 (mix_i_src_c092_2_09 0 bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_2_09 (mix_i_src_c092_2_09 mix_i_c092_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_09 (mix_q_src_c092_2_09 0 bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_2_09 (mix_q_src_c092_2_09 mix_q_c092_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_10 (mix_i_src_c092_2_10 0 bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_2_10 (mix_i_src_c092_2_10 mix_i_c092_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_10 (mix_q_src_c092_2_10 0 bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_2_10 (mix_q_src_c092_2_10 mix_q_c092_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_11 (mix_i_src_c092_2_11 0 bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_2_11 (mix_i_src_c092_2_11 mix_i_c092_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_11 (mix_q_src_c092_2_11 0 bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_2_11 (mix_q_src_c092_2_11 mix_q_c092_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_12 (mix_i_src_c092_2_12 0 bpf_c092_2 0) vcvs gain=1.950903220161e-01
SMIXI_c092_2_12 (mix_i_src_c092_2_12 mix_i_c092_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_12 (mix_q_src_c092_2_12 0 bpf_c092_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_2_12 (mix_q_src_c092_2_12 mix_q_c092_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_13 (mix_i_src_c092_2_13 0 bpf_c092_2 0) vcvs gain=5.555702330196e-01
SMIXI_c092_2_13 (mix_i_src_c092_2_13 mix_i_c092_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_13 (mix_q_src_c092_2_13 0 bpf_c092_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_2_13 (mix_q_src_c092_2_13 mix_q_c092_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_14 (mix_i_src_c092_2_14 0 bpf_c092_2 0) vcvs gain=8.314696123025e-01
SMIXI_c092_2_14 (mix_i_src_c092_2_14 mix_i_c092_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_14 (mix_q_src_c092_2_14 0 bpf_c092_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_2_14 (mix_q_src_c092_2_14 mix_q_c092_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_2_15 (mix_i_src_c092_2_15 0 bpf_c092_2 0) vcvs gain=9.807852804032e-01
SMIXI_c092_2_15 (mix_i_src_c092_2_15 mix_i_c092_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_2_15 (mix_q_src_c092_2_15 0 bpf_c092_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_2_15 (mix_q_src_c092_2_15 mix_q_c092_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c092_2 (mix_i_c092_2 0) resistor r=1G
RMIXQ_c092_2 (mix_q_c092_2 0) resistor r=1G
RINTI_c092_2 (mix_i_c092_2 Icar_c092_2) resistor r=1k
CINTI_c092_2 (Icar_c092_2 0) capacitor c=80p
RINTQ_c092_2 (mix_q_c092_2 Qcar_c092_2) resistor r=1k
CINTQ_c092_2 (Qcar_c092_2 0) capacitor c=80p

// bl092, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c092_3 (bl092 n_cbpf_c092_3) capacitor c=2.533029591058e-14
LBPF_c092_3 (n_cbpf_c092_3 bpf_c092_3) inductor l=1.000000000000e-06
RBPF_c092_3 (bpf_c092_3 0) resistor r=3.141592653590e+02
EMIXI_c092_3_00 (mix_i_src_c092_3_00 0 bpf_c092_3 0) vcvs gain=9.807852804032e-01
SMIXI_c092_3_00 (mix_i_src_c092_3_00 mix_i_c092_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_00 (mix_q_src_c092_3_00 0 bpf_c092_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_3_00 (mix_q_src_c092_3_00 mix_q_c092_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_01 (mix_i_src_c092_3_01 0 bpf_c092_3 0) vcvs gain=8.314696123025e-01
SMIXI_c092_3_01 (mix_i_src_c092_3_01 mix_i_c092_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_01 (mix_q_src_c092_3_01 0 bpf_c092_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_3_01 (mix_q_src_c092_3_01 mix_q_c092_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_02 (mix_i_src_c092_3_02 0 bpf_c092_3 0) vcvs gain=5.555702330196e-01
SMIXI_c092_3_02 (mix_i_src_c092_3_02 mix_i_c092_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_02 (mix_q_src_c092_3_02 0 bpf_c092_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_3_02 (mix_q_src_c092_3_02 mix_q_c092_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_03 (mix_i_src_c092_3_03 0 bpf_c092_3 0) vcvs gain=1.950903220161e-01
SMIXI_c092_3_03 (mix_i_src_c092_3_03 mix_i_c092_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_03 (mix_q_src_c092_3_03 0 bpf_c092_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_3_03 (mix_q_src_c092_3_03 mix_q_c092_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_04 (mix_i_src_c092_3_04 0 bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_3_04 (mix_i_src_c092_3_04 mix_i_c092_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_04 (mix_q_src_c092_3_04 0 bpf_c092_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c092_3_04 (mix_q_src_c092_3_04 mix_q_c092_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_05 (mix_i_src_c092_3_05 0 bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_3_05 (mix_i_src_c092_3_05 mix_i_c092_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_05 (mix_q_src_c092_3_05 0 bpf_c092_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c092_3_05 (mix_q_src_c092_3_05 mix_q_c092_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_06 (mix_i_src_c092_3_06 0 bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_3_06 (mix_i_src_c092_3_06 mix_i_c092_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_06 (mix_q_src_c092_3_06 0 bpf_c092_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c092_3_06 (mix_q_src_c092_3_06 mix_q_c092_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_07 (mix_i_src_c092_3_07 0 bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_3_07 (mix_i_src_c092_3_07 mix_i_c092_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_07 (mix_q_src_c092_3_07 0 bpf_c092_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c092_3_07 (mix_q_src_c092_3_07 mix_q_c092_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_08 (mix_i_src_c092_3_08 0 bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c092_3_08 (mix_i_src_c092_3_08 mix_i_c092_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_08 (mix_q_src_c092_3_08 0 bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_3_08 (mix_q_src_c092_3_08 mix_q_c092_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_09 (mix_i_src_c092_3_09 0 bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c092_3_09 (mix_i_src_c092_3_09 mix_i_c092_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_09 (mix_q_src_c092_3_09 0 bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_3_09 (mix_q_src_c092_3_09 mix_q_c092_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_10 (mix_i_src_c092_3_10 0 bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c092_3_10 (mix_i_src_c092_3_10 mix_i_c092_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_10 (mix_q_src_c092_3_10 0 bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_3_10 (mix_q_src_c092_3_10 mix_q_c092_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_11 (mix_i_src_c092_3_11 0 bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c092_3_11 (mix_i_src_c092_3_11 mix_i_c092_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_11 (mix_q_src_c092_3_11 0 bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_3_11 (mix_q_src_c092_3_11 mix_q_c092_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_12 (mix_i_src_c092_3_12 0 bpf_c092_3 0) vcvs gain=1.950903220161e-01
SMIXI_c092_3_12 (mix_i_src_c092_3_12 mix_i_c092_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_12 (mix_q_src_c092_3_12 0 bpf_c092_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c092_3_12 (mix_q_src_c092_3_12 mix_q_c092_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_13 (mix_i_src_c092_3_13 0 bpf_c092_3 0) vcvs gain=5.555702330196e-01
SMIXI_c092_3_13 (mix_i_src_c092_3_13 mix_i_c092_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_13 (mix_q_src_c092_3_13 0 bpf_c092_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c092_3_13 (mix_q_src_c092_3_13 mix_q_c092_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_14 (mix_i_src_c092_3_14 0 bpf_c092_3 0) vcvs gain=8.314696123025e-01
SMIXI_c092_3_14 (mix_i_src_c092_3_14 mix_i_c092_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_14 (mix_q_src_c092_3_14 0 bpf_c092_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c092_3_14 (mix_q_src_c092_3_14 mix_q_c092_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c092_3_15 (mix_i_src_c092_3_15 0 bpf_c092_3 0) vcvs gain=9.807852804032e-01
SMIXI_c092_3_15 (mix_i_src_c092_3_15 mix_i_c092_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c092_3_15 (mix_q_src_c092_3_15 0 bpf_c092_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c092_3_15 (mix_q_src_c092_3_15 mix_q_c092_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c092_3 (mix_i_c092_3 0) resistor r=1G
RMIXQ_c092_3 (mix_q_c092_3 0) resistor r=1G
RINTI_c092_3 (mix_i_c092_3 Icar_c092_3) resistor r=1k
CINTI_c092_3 (Icar_c092_3 0) capacitor c=80p
RINTQ_c092_3 (mix_q_c092_3 Qcar_c092_3) resistor r=1k
CINTQ_c092_3 (Qcar_c092_3 0) capacitor c=80p

// bl093, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c093_0 (bl093 n_cbpf_c093_0) capacitor c=4.052847345694e-13
LBPF_c093_0 (n_cbpf_c093_0 bpf_c093_0) inductor l=1.000000000000e-06
RBPF_c093_0 (bpf_c093_0 0) resistor r=7.853981633974e+01
EMIXI_c093_0_00 (mix_i_src_c093_0_00 0 bpf_c093_0 0) vcvs gain=9.807852804032e-01
SMIXI_c093_0_00 (mix_i_src_c093_0_00 mix_i_c093_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_00 (mix_q_src_c093_0_00 0 bpf_c093_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_0_00 (mix_q_src_c093_0_00 mix_q_c093_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_01 (mix_i_src_c093_0_01 0 bpf_c093_0 0) vcvs gain=8.314696123025e-01
SMIXI_c093_0_01 (mix_i_src_c093_0_01 mix_i_c093_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_01 (mix_q_src_c093_0_01 0 bpf_c093_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_0_01 (mix_q_src_c093_0_01 mix_q_c093_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_02 (mix_i_src_c093_0_02 0 bpf_c093_0 0) vcvs gain=5.555702330196e-01
SMIXI_c093_0_02 (mix_i_src_c093_0_02 mix_i_c093_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_02 (mix_q_src_c093_0_02 0 bpf_c093_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_0_02 (mix_q_src_c093_0_02 mix_q_c093_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_03 (mix_i_src_c093_0_03 0 bpf_c093_0 0) vcvs gain=1.950903220161e-01
SMIXI_c093_0_03 (mix_i_src_c093_0_03 mix_i_c093_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_03 (mix_q_src_c093_0_03 0 bpf_c093_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_0_03 (mix_q_src_c093_0_03 mix_q_c093_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_04 (mix_i_src_c093_0_04 0 bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_0_04 (mix_i_src_c093_0_04 mix_i_c093_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_04 (mix_q_src_c093_0_04 0 bpf_c093_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_0_04 (mix_q_src_c093_0_04 mix_q_c093_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_05 (mix_i_src_c093_0_05 0 bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_0_05 (mix_i_src_c093_0_05 mix_i_c093_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_05 (mix_q_src_c093_0_05 0 bpf_c093_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_0_05 (mix_q_src_c093_0_05 mix_q_c093_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_06 (mix_i_src_c093_0_06 0 bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_0_06 (mix_i_src_c093_0_06 mix_i_c093_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_06 (mix_q_src_c093_0_06 0 bpf_c093_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_0_06 (mix_q_src_c093_0_06 mix_q_c093_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_07 (mix_i_src_c093_0_07 0 bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_0_07 (mix_i_src_c093_0_07 mix_i_c093_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_07 (mix_q_src_c093_0_07 0 bpf_c093_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_0_07 (mix_q_src_c093_0_07 mix_q_c093_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_08 (mix_i_src_c093_0_08 0 bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_0_08 (mix_i_src_c093_0_08 mix_i_c093_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_08 (mix_q_src_c093_0_08 0 bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_0_08 (mix_q_src_c093_0_08 mix_q_c093_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_09 (mix_i_src_c093_0_09 0 bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_0_09 (mix_i_src_c093_0_09 mix_i_c093_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_09 (mix_q_src_c093_0_09 0 bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_0_09 (mix_q_src_c093_0_09 mix_q_c093_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_10 (mix_i_src_c093_0_10 0 bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_0_10 (mix_i_src_c093_0_10 mix_i_c093_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_10 (mix_q_src_c093_0_10 0 bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_0_10 (mix_q_src_c093_0_10 mix_q_c093_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_11 (mix_i_src_c093_0_11 0 bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_0_11 (mix_i_src_c093_0_11 mix_i_c093_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_11 (mix_q_src_c093_0_11 0 bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_0_11 (mix_q_src_c093_0_11 mix_q_c093_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_12 (mix_i_src_c093_0_12 0 bpf_c093_0 0) vcvs gain=1.950903220161e-01
SMIXI_c093_0_12 (mix_i_src_c093_0_12 mix_i_c093_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_12 (mix_q_src_c093_0_12 0 bpf_c093_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_0_12 (mix_q_src_c093_0_12 mix_q_c093_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_13 (mix_i_src_c093_0_13 0 bpf_c093_0 0) vcvs gain=5.555702330196e-01
SMIXI_c093_0_13 (mix_i_src_c093_0_13 mix_i_c093_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_13 (mix_q_src_c093_0_13 0 bpf_c093_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_0_13 (mix_q_src_c093_0_13 mix_q_c093_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_14 (mix_i_src_c093_0_14 0 bpf_c093_0 0) vcvs gain=8.314696123025e-01
SMIXI_c093_0_14 (mix_i_src_c093_0_14 mix_i_c093_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_14 (mix_q_src_c093_0_14 0 bpf_c093_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_0_14 (mix_q_src_c093_0_14 mix_q_c093_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_0_15 (mix_i_src_c093_0_15 0 bpf_c093_0 0) vcvs gain=9.807852804032e-01
SMIXI_c093_0_15 (mix_i_src_c093_0_15 mix_i_c093_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_0_15 (mix_q_src_c093_0_15 0 bpf_c093_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_0_15 (mix_q_src_c093_0_15 mix_q_c093_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c093_0 (mix_i_c093_0 0) resistor r=1G
RMIXQ_c093_0 (mix_q_c093_0 0) resistor r=1G
RINTI_c093_0 (mix_i_c093_0 Icar_c093_0) resistor r=1k
CINTI_c093_0 (Icar_c093_0 0) capacitor c=80p
RINTQ_c093_0 (mix_q_c093_0 Qcar_c093_0) resistor r=1k
CINTQ_c093_0 (Qcar_c093_0 0) capacitor c=80p

// bl093, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c093_1 (bl093 n_cbpf_c093_1) capacitor c=1.013211836423e-13
LBPF_c093_1 (n_cbpf_c093_1 bpf_c093_1) inductor l=1.000000000000e-06
RBPF_c093_1 (bpf_c093_1 0) resistor r=1.570796326795e+02
EMIXI_c093_1_00 (mix_i_src_c093_1_00 0 bpf_c093_1 0) vcvs gain=9.807852804032e-01
SMIXI_c093_1_00 (mix_i_src_c093_1_00 mix_i_c093_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_00 (mix_q_src_c093_1_00 0 bpf_c093_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_1_00 (mix_q_src_c093_1_00 mix_q_c093_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_01 (mix_i_src_c093_1_01 0 bpf_c093_1 0) vcvs gain=8.314696123025e-01
SMIXI_c093_1_01 (mix_i_src_c093_1_01 mix_i_c093_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_01 (mix_q_src_c093_1_01 0 bpf_c093_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_1_01 (mix_q_src_c093_1_01 mix_q_c093_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_02 (mix_i_src_c093_1_02 0 bpf_c093_1 0) vcvs gain=5.555702330196e-01
SMIXI_c093_1_02 (mix_i_src_c093_1_02 mix_i_c093_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_02 (mix_q_src_c093_1_02 0 bpf_c093_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_1_02 (mix_q_src_c093_1_02 mix_q_c093_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_03 (mix_i_src_c093_1_03 0 bpf_c093_1 0) vcvs gain=1.950903220161e-01
SMIXI_c093_1_03 (mix_i_src_c093_1_03 mix_i_c093_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_03 (mix_q_src_c093_1_03 0 bpf_c093_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_1_03 (mix_q_src_c093_1_03 mix_q_c093_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_04 (mix_i_src_c093_1_04 0 bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_1_04 (mix_i_src_c093_1_04 mix_i_c093_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_04 (mix_q_src_c093_1_04 0 bpf_c093_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_1_04 (mix_q_src_c093_1_04 mix_q_c093_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_05 (mix_i_src_c093_1_05 0 bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_1_05 (mix_i_src_c093_1_05 mix_i_c093_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_05 (mix_q_src_c093_1_05 0 bpf_c093_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_1_05 (mix_q_src_c093_1_05 mix_q_c093_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_06 (mix_i_src_c093_1_06 0 bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_1_06 (mix_i_src_c093_1_06 mix_i_c093_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_06 (mix_q_src_c093_1_06 0 bpf_c093_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_1_06 (mix_q_src_c093_1_06 mix_q_c093_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_07 (mix_i_src_c093_1_07 0 bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_1_07 (mix_i_src_c093_1_07 mix_i_c093_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_07 (mix_q_src_c093_1_07 0 bpf_c093_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_1_07 (mix_q_src_c093_1_07 mix_q_c093_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_08 (mix_i_src_c093_1_08 0 bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_1_08 (mix_i_src_c093_1_08 mix_i_c093_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_08 (mix_q_src_c093_1_08 0 bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_1_08 (mix_q_src_c093_1_08 mix_q_c093_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_09 (mix_i_src_c093_1_09 0 bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_1_09 (mix_i_src_c093_1_09 mix_i_c093_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_09 (mix_q_src_c093_1_09 0 bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_1_09 (mix_q_src_c093_1_09 mix_q_c093_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_10 (mix_i_src_c093_1_10 0 bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_1_10 (mix_i_src_c093_1_10 mix_i_c093_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_10 (mix_q_src_c093_1_10 0 bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_1_10 (mix_q_src_c093_1_10 mix_q_c093_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_11 (mix_i_src_c093_1_11 0 bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_1_11 (mix_i_src_c093_1_11 mix_i_c093_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_11 (mix_q_src_c093_1_11 0 bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_1_11 (mix_q_src_c093_1_11 mix_q_c093_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_12 (mix_i_src_c093_1_12 0 bpf_c093_1 0) vcvs gain=1.950903220161e-01
SMIXI_c093_1_12 (mix_i_src_c093_1_12 mix_i_c093_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_12 (mix_q_src_c093_1_12 0 bpf_c093_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_1_12 (mix_q_src_c093_1_12 mix_q_c093_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_13 (mix_i_src_c093_1_13 0 bpf_c093_1 0) vcvs gain=5.555702330196e-01
SMIXI_c093_1_13 (mix_i_src_c093_1_13 mix_i_c093_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_13 (mix_q_src_c093_1_13 0 bpf_c093_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_1_13 (mix_q_src_c093_1_13 mix_q_c093_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_14 (mix_i_src_c093_1_14 0 bpf_c093_1 0) vcvs gain=8.314696123025e-01
SMIXI_c093_1_14 (mix_i_src_c093_1_14 mix_i_c093_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_14 (mix_q_src_c093_1_14 0 bpf_c093_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_1_14 (mix_q_src_c093_1_14 mix_q_c093_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_1_15 (mix_i_src_c093_1_15 0 bpf_c093_1 0) vcvs gain=9.807852804032e-01
SMIXI_c093_1_15 (mix_i_src_c093_1_15 mix_i_c093_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_1_15 (mix_q_src_c093_1_15 0 bpf_c093_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_1_15 (mix_q_src_c093_1_15 mix_q_c093_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c093_1 (mix_i_c093_1 0) resistor r=1G
RMIXQ_c093_1 (mix_q_c093_1 0) resistor r=1G
RINTI_c093_1 (mix_i_c093_1 Icar_c093_1) resistor r=1k
CINTI_c093_1 (Icar_c093_1 0) capacitor c=80p
RINTQ_c093_1 (mix_q_c093_1 Qcar_c093_1) resistor r=1k
CINTQ_c093_1 (Qcar_c093_1 0) capacitor c=80p

// bl093, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c093_2 (bl093 n_cbpf_c093_2) capacitor c=4.503163717437e-14
LBPF_c093_2 (n_cbpf_c093_2 bpf_c093_2) inductor l=1.000000000000e-06
RBPF_c093_2 (bpf_c093_2 0) resistor r=2.356194490192e+02
EMIXI_c093_2_00 (mix_i_src_c093_2_00 0 bpf_c093_2 0) vcvs gain=9.807852804032e-01
SMIXI_c093_2_00 (mix_i_src_c093_2_00 mix_i_c093_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_00 (mix_q_src_c093_2_00 0 bpf_c093_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_2_00 (mix_q_src_c093_2_00 mix_q_c093_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_01 (mix_i_src_c093_2_01 0 bpf_c093_2 0) vcvs gain=8.314696123025e-01
SMIXI_c093_2_01 (mix_i_src_c093_2_01 mix_i_c093_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_01 (mix_q_src_c093_2_01 0 bpf_c093_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_2_01 (mix_q_src_c093_2_01 mix_q_c093_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_02 (mix_i_src_c093_2_02 0 bpf_c093_2 0) vcvs gain=5.555702330196e-01
SMIXI_c093_2_02 (mix_i_src_c093_2_02 mix_i_c093_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_02 (mix_q_src_c093_2_02 0 bpf_c093_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_2_02 (mix_q_src_c093_2_02 mix_q_c093_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_03 (mix_i_src_c093_2_03 0 bpf_c093_2 0) vcvs gain=1.950903220161e-01
SMIXI_c093_2_03 (mix_i_src_c093_2_03 mix_i_c093_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_03 (mix_q_src_c093_2_03 0 bpf_c093_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_2_03 (mix_q_src_c093_2_03 mix_q_c093_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_04 (mix_i_src_c093_2_04 0 bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_2_04 (mix_i_src_c093_2_04 mix_i_c093_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_04 (mix_q_src_c093_2_04 0 bpf_c093_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_2_04 (mix_q_src_c093_2_04 mix_q_c093_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_05 (mix_i_src_c093_2_05 0 bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_2_05 (mix_i_src_c093_2_05 mix_i_c093_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_05 (mix_q_src_c093_2_05 0 bpf_c093_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_2_05 (mix_q_src_c093_2_05 mix_q_c093_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_06 (mix_i_src_c093_2_06 0 bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_2_06 (mix_i_src_c093_2_06 mix_i_c093_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_06 (mix_q_src_c093_2_06 0 bpf_c093_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_2_06 (mix_q_src_c093_2_06 mix_q_c093_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_07 (mix_i_src_c093_2_07 0 bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_2_07 (mix_i_src_c093_2_07 mix_i_c093_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_07 (mix_q_src_c093_2_07 0 bpf_c093_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_2_07 (mix_q_src_c093_2_07 mix_q_c093_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_08 (mix_i_src_c093_2_08 0 bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_2_08 (mix_i_src_c093_2_08 mix_i_c093_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_08 (mix_q_src_c093_2_08 0 bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_2_08 (mix_q_src_c093_2_08 mix_q_c093_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_09 (mix_i_src_c093_2_09 0 bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_2_09 (mix_i_src_c093_2_09 mix_i_c093_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_09 (mix_q_src_c093_2_09 0 bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_2_09 (mix_q_src_c093_2_09 mix_q_c093_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_10 (mix_i_src_c093_2_10 0 bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_2_10 (mix_i_src_c093_2_10 mix_i_c093_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_10 (mix_q_src_c093_2_10 0 bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_2_10 (mix_q_src_c093_2_10 mix_q_c093_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_11 (mix_i_src_c093_2_11 0 bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_2_11 (mix_i_src_c093_2_11 mix_i_c093_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_11 (mix_q_src_c093_2_11 0 bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_2_11 (mix_q_src_c093_2_11 mix_q_c093_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_12 (mix_i_src_c093_2_12 0 bpf_c093_2 0) vcvs gain=1.950903220161e-01
SMIXI_c093_2_12 (mix_i_src_c093_2_12 mix_i_c093_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_12 (mix_q_src_c093_2_12 0 bpf_c093_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_2_12 (mix_q_src_c093_2_12 mix_q_c093_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_13 (mix_i_src_c093_2_13 0 bpf_c093_2 0) vcvs gain=5.555702330196e-01
SMIXI_c093_2_13 (mix_i_src_c093_2_13 mix_i_c093_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_13 (mix_q_src_c093_2_13 0 bpf_c093_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_2_13 (mix_q_src_c093_2_13 mix_q_c093_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_14 (mix_i_src_c093_2_14 0 bpf_c093_2 0) vcvs gain=8.314696123025e-01
SMIXI_c093_2_14 (mix_i_src_c093_2_14 mix_i_c093_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_14 (mix_q_src_c093_2_14 0 bpf_c093_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_2_14 (mix_q_src_c093_2_14 mix_q_c093_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_2_15 (mix_i_src_c093_2_15 0 bpf_c093_2 0) vcvs gain=9.807852804032e-01
SMIXI_c093_2_15 (mix_i_src_c093_2_15 mix_i_c093_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_2_15 (mix_q_src_c093_2_15 0 bpf_c093_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_2_15 (mix_q_src_c093_2_15 mix_q_c093_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c093_2 (mix_i_c093_2 0) resistor r=1G
RMIXQ_c093_2 (mix_q_c093_2 0) resistor r=1G
RINTI_c093_2 (mix_i_c093_2 Icar_c093_2) resistor r=1k
CINTI_c093_2 (Icar_c093_2 0) capacitor c=80p
RINTQ_c093_2 (mix_q_c093_2 Qcar_c093_2) resistor r=1k
CINTQ_c093_2 (Qcar_c093_2 0) capacitor c=80p

// bl093, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c093_3 (bl093 n_cbpf_c093_3) capacitor c=2.533029591058e-14
LBPF_c093_3 (n_cbpf_c093_3 bpf_c093_3) inductor l=1.000000000000e-06
RBPF_c093_3 (bpf_c093_3 0) resistor r=3.141592653590e+02
EMIXI_c093_3_00 (mix_i_src_c093_3_00 0 bpf_c093_3 0) vcvs gain=9.807852804032e-01
SMIXI_c093_3_00 (mix_i_src_c093_3_00 mix_i_c093_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_00 (mix_q_src_c093_3_00 0 bpf_c093_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_3_00 (mix_q_src_c093_3_00 mix_q_c093_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_01 (mix_i_src_c093_3_01 0 bpf_c093_3 0) vcvs gain=8.314696123025e-01
SMIXI_c093_3_01 (mix_i_src_c093_3_01 mix_i_c093_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_01 (mix_q_src_c093_3_01 0 bpf_c093_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_3_01 (mix_q_src_c093_3_01 mix_q_c093_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_02 (mix_i_src_c093_3_02 0 bpf_c093_3 0) vcvs gain=5.555702330196e-01
SMIXI_c093_3_02 (mix_i_src_c093_3_02 mix_i_c093_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_02 (mix_q_src_c093_3_02 0 bpf_c093_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_3_02 (mix_q_src_c093_3_02 mix_q_c093_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_03 (mix_i_src_c093_3_03 0 bpf_c093_3 0) vcvs gain=1.950903220161e-01
SMIXI_c093_3_03 (mix_i_src_c093_3_03 mix_i_c093_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_03 (mix_q_src_c093_3_03 0 bpf_c093_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_3_03 (mix_q_src_c093_3_03 mix_q_c093_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_04 (mix_i_src_c093_3_04 0 bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_3_04 (mix_i_src_c093_3_04 mix_i_c093_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_04 (mix_q_src_c093_3_04 0 bpf_c093_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c093_3_04 (mix_q_src_c093_3_04 mix_q_c093_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_05 (mix_i_src_c093_3_05 0 bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_3_05 (mix_i_src_c093_3_05 mix_i_c093_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_05 (mix_q_src_c093_3_05 0 bpf_c093_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c093_3_05 (mix_q_src_c093_3_05 mix_q_c093_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_06 (mix_i_src_c093_3_06 0 bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_3_06 (mix_i_src_c093_3_06 mix_i_c093_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_06 (mix_q_src_c093_3_06 0 bpf_c093_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c093_3_06 (mix_q_src_c093_3_06 mix_q_c093_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_07 (mix_i_src_c093_3_07 0 bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_3_07 (mix_i_src_c093_3_07 mix_i_c093_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_07 (mix_q_src_c093_3_07 0 bpf_c093_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c093_3_07 (mix_q_src_c093_3_07 mix_q_c093_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_08 (mix_i_src_c093_3_08 0 bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c093_3_08 (mix_i_src_c093_3_08 mix_i_c093_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_08 (mix_q_src_c093_3_08 0 bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_3_08 (mix_q_src_c093_3_08 mix_q_c093_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_09 (mix_i_src_c093_3_09 0 bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c093_3_09 (mix_i_src_c093_3_09 mix_i_c093_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_09 (mix_q_src_c093_3_09 0 bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_3_09 (mix_q_src_c093_3_09 mix_q_c093_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_10 (mix_i_src_c093_3_10 0 bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c093_3_10 (mix_i_src_c093_3_10 mix_i_c093_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_10 (mix_q_src_c093_3_10 0 bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_3_10 (mix_q_src_c093_3_10 mix_q_c093_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_11 (mix_i_src_c093_3_11 0 bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c093_3_11 (mix_i_src_c093_3_11 mix_i_c093_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_11 (mix_q_src_c093_3_11 0 bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_3_11 (mix_q_src_c093_3_11 mix_q_c093_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_12 (mix_i_src_c093_3_12 0 bpf_c093_3 0) vcvs gain=1.950903220161e-01
SMIXI_c093_3_12 (mix_i_src_c093_3_12 mix_i_c093_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_12 (mix_q_src_c093_3_12 0 bpf_c093_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c093_3_12 (mix_q_src_c093_3_12 mix_q_c093_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_13 (mix_i_src_c093_3_13 0 bpf_c093_3 0) vcvs gain=5.555702330196e-01
SMIXI_c093_3_13 (mix_i_src_c093_3_13 mix_i_c093_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_13 (mix_q_src_c093_3_13 0 bpf_c093_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c093_3_13 (mix_q_src_c093_3_13 mix_q_c093_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_14 (mix_i_src_c093_3_14 0 bpf_c093_3 0) vcvs gain=8.314696123025e-01
SMIXI_c093_3_14 (mix_i_src_c093_3_14 mix_i_c093_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_14 (mix_q_src_c093_3_14 0 bpf_c093_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c093_3_14 (mix_q_src_c093_3_14 mix_q_c093_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c093_3_15 (mix_i_src_c093_3_15 0 bpf_c093_3 0) vcvs gain=9.807852804032e-01
SMIXI_c093_3_15 (mix_i_src_c093_3_15 mix_i_c093_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c093_3_15 (mix_q_src_c093_3_15 0 bpf_c093_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c093_3_15 (mix_q_src_c093_3_15 mix_q_c093_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c093_3 (mix_i_c093_3 0) resistor r=1G
RMIXQ_c093_3 (mix_q_c093_3 0) resistor r=1G
RINTI_c093_3 (mix_i_c093_3 Icar_c093_3) resistor r=1k
CINTI_c093_3 (Icar_c093_3 0) capacitor c=80p
RINTQ_c093_3 (mix_q_c093_3 Qcar_c093_3) resistor r=1k
CINTQ_c093_3 (Qcar_c093_3 0) capacitor c=80p

// bl094, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c094_0 (bl094 n_cbpf_c094_0) capacitor c=4.052847345694e-13
LBPF_c094_0 (n_cbpf_c094_0 bpf_c094_0) inductor l=1.000000000000e-06
RBPF_c094_0 (bpf_c094_0 0) resistor r=7.853981633974e+01
EMIXI_c094_0_00 (mix_i_src_c094_0_00 0 bpf_c094_0 0) vcvs gain=9.807852804032e-01
SMIXI_c094_0_00 (mix_i_src_c094_0_00 mix_i_c094_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_00 (mix_q_src_c094_0_00 0 bpf_c094_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_0_00 (mix_q_src_c094_0_00 mix_q_c094_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_01 (mix_i_src_c094_0_01 0 bpf_c094_0 0) vcvs gain=8.314696123025e-01
SMIXI_c094_0_01 (mix_i_src_c094_0_01 mix_i_c094_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_01 (mix_q_src_c094_0_01 0 bpf_c094_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_0_01 (mix_q_src_c094_0_01 mix_q_c094_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_02 (mix_i_src_c094_0_02 0 bpf_c094_0 0) vcvs gain=5.555702330196e-01
SMIXI_c094_0_02 (mix_i_src_c094_0_02 mix_i_c094_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_02 (mix_q_src_c094_0_02 0 bpf_c094_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_0_02 (mix_q_src_c094_0_02 mix_q_c094_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_03 (mix_i_src_c094_0_03 0 bpf_c094_0 0) vcvs gain=1.950903220161e-01
SMIXI_c094_0_03 (mix_i_src_c094_0_03 mix_i_c094_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_03 (mix_q_src_c094_0_03 0 bpf_c094_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_0_03 (mix_q_src_c094_0_03 mix_q_c094_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_04 (mix_i_src_c094_0_04 0 bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_0_04 (mix_i_src_c094_0_04 mix_i_c094_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_04 (mix_q_src_c094_0_04 0 bpf_c094_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_0_04 (mix_q_src_c094_0_04 mix_q_c094_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_05 (mix_i_src_c094_0_05 0 bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_0_05 (mix_i_src_c094_0_05 mix_i_c094_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_05 (mix_q_src_c094_0_05 0 bpf_c094_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_0_05 (mix_q_src_c094_0_05 mix_q_c094_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_06 (mix_i_src_c094_0_06 0 bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_0_06 (mix_i_src_c094_0_06 mix_i_c094_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_06 (mix_q_src_c094_0_06 0 bpf_c094_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_0_06 (mix_q_src_c094_0_06 mix_q_c094_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_07 (mix_i_src_c094_0_07 0 bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_0_07 (mix_i_src_c094_0_07 mix_i_c094_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_07 (mix_q_src_c094_0_07 0 bpf_c094_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_0_07 (mix_q_src_c094_0_07 mix_q_c094_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_08 (mix_i_src_c094_0_08 0 bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_0_08 (mix_i_src_c094_0_08 mix_i_c094_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_08 (mix_q_src_c094_0_08 0 bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_0_08 (mix_q_src_c094_0_08 mix_q_c094_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_09 (mix_i_src_c094_0_09 0 bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_0_09 (mix_i_src_c094_0_09 mix_i_c094_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_09 (mix_q_src_c094_0_09 0 bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_0_09 (mix_q_src_c094_0_09 mix_q_c094_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_10 (mix_i_src_c094_0_10 0 bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_0_10 (mix_i_src_c094_0_10 mix_i_c094_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_10 (mix_q_src_c094_0_10 0 bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_0_10 (mix_q_src_c094_0_10 mix_q_c094_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_11 (mix_i_src_c094_0_11 0 bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_0_11 (mix_i_src_c094_0_11 mix_i_c094_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_11 (mix_q_src_c094_0_11 0 bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_0_11 (mix_q_src_c094_0_11 mix_q_c094_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_12 (mix_i_src_c094_0_12 0 bpf_c094_0 0) vcvs gain=1.950903220161e-01
SMIXI_c094_0_12 (mix_i_src_c094_0_12 mix_i_c094_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_12 (mix_q_src_c094_0_12 0 bpf_c094_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_0_12 (mix_q_src_c094_0_12 mix_q_c094_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_13 (mix_i_src_c094_0_13 0 bpf_c094_0 0) vcvs gain=5.555702330196e-01
SMIXI_c094_0_13 (mix_i_src_c094_0_13 mix_i_c094_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_13 (mix_q_src_c094_0_13 0 bpf_c094_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_0_13 (mix_q_src_c094_0_13 mix_q_c094_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_14 (mix_i_src_c094_0_14 0 bpf_c094_0 0) vcvs gain=8.314696123025e-01
SMIXI_c094_0_14 (mix_i_src_c094_0_14 mix_i_c094_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_14 (mix_q_src_c094_0_14 0 bpf_c094_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_0_14 (mix_q_src_c094_0_14 mix_q_c094_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_0_15 (mix_i_src_c094_0_15 0 bpf_c094_0 0) vcvs gain=9.807852804032e-01
SMIXI_c094_0_15 (mix_i_src_c094_0_15 mix_i_c094_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_0_15 (mix_q_src_c094_0_15 0 bpf_c094_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_0_15 (mix_q_src_c094_0_15 mix_q_c094_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c094_0 (mix_i_c094_0 0) resistor r=1G
RMIXQ_c094_0 (mix_q_c094_0 0) resistor r=1G
RINTI_c094_0 (mix_i_c094_0 Icar_c094_0) resistor r=1k
CINTI_c094_0 (Icar_c094_0 0) capacitor c=80p
RINTQ_c094_0 (mix_q_c094_0 Qcar_c094_0) resistor r=1k
CINTQ_c094_0 (Qcar_c094_0 0) capacitor c=80p

// bl094, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c094_1 (bl094 n_cbpf_c094_1) capacitor c=1.013211836423e-13
LBPF_c094_1 (n_cbpf_c094_1 bpf_c094_1) inductor l=1.000000000000e-06
RBPF_c094_1 (bpf_c094_1 0) resistor r=1.570796326795e+02
EMIXI_c094_1_00 (mix_i_src_c094_1_00 0 bpf_c094_1 0) vcvs gain=9.807852804032e-01
SMIXI_c094_1_00 (mix_i_src_c094_1_00 mix_i_c094_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_00 (mix_q_src_c094_1_00 0 bpf_c094_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_1_00 (mix_q_src_c094_1_00 mix_q_c094_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_01 (mix_i_src_c094_1_01 0 bpf_c094_1 0) vcvs gain=8.314696123025e-01
SMIXI_c094_1_01 (mix_i_src_c094_1_01 mix_i_c094_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_01 (mix_q_src_c094_1_01 0 bpf_c094_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_1_01 (mix_q_src_c094_1_01 mix_q_c094_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_02 (mix_i_src_c094_1_02 0 bpf_c094_1 0) vcvs gain=5.555702330196e-01
SMIXI_c094_1_02 (mix_i_src_c094_1_02 mix_i_c094_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_02 (mix_q_src_c094_1_02 0 bpf_c094_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_1_02 (mix_q_src_c094_1_02 mix_q_c094_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_03 (mix_i_src_c094_1_03 0 bpf_c094_1 0) vcvs gain=1.950903220161e-01
SMIXI_c094_1_03 (mix_i_src_c094_1_03 mix_i_c094_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_03 (mix_q_src_c094_1_03 0 bpf_c094_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_1_03 (mix_q_src_c094_1_03 mix_q_c094_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_04 (mix_i_src_c094_1_04 0 bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_1_04 (mix_i_src_c094_1_04 mix_i_c094_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_04 (mix_q_src_c094_1_04 0 bpf_c094_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_1_04 (mix_q_src_c094_1_04 mix_q_c094_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_05 (mix_i_src_c094_1_05 0 bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_1_05 (mix_i_src_c094_1_05 mix_i_c094_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_05 (mix_q_src_c094_1_05 0 bpf_c094_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_1_05 (mix_q_src_c094_1_05 mix_q_c094_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_06 (mix_i_src_c094_1_06 0 bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_1_06 (mix_i_src_c094_1_06 mix_i_c094_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_06 (mix_q_src_c094_1_06 0 bpf_c094_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_1_06 (mix_q_src_c094_1_06 mix_q_c094_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_07 (mix_i_src_c094_1_07 0 bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_1_07 (mix_i_src_c094_1_07 mix_i_c094_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_07 (mix_q_src_c094_1_07 0 bpf_c094_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_1_07 (mix_q_src_c094_1_07 mix_q_c094_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_08 (mix_i_src_c094_1_08 0 bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_1_08 (mix_i_src_c094_1_08 mix_i_c094_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_08 (mix_q_src_c094_1_08 0 bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_1_08 (mix_q_src_c094_1_08 mix_q_c094_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_09 (mix_i_src_c094_1_09 0 bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_1_09 (mix_i_src_c094_1_09 mix_i_c094_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_09 (mix_q_src_c094_1_09 0 bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_1_09 (mix_q_src_c094_1_09 mix_q_c094_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_10 (mix_i_src_c094_1_10 0 bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_1_10 (mix_i_src_c094_1_10 mix_i_c094_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_10 (mix_q_src_c094_1_10 0 bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_1_10 (mix_q_src_c094_1_10 mix_q_c094_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_11 (mix_i_src_c094_1_11 0 bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_1_11 (mix_i_src_c094_1_11 mix_i_c094_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_11 (mix_q_src_c094_1_11 0 bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_1_11 (mix_q_src_c094_1_11 mix_q_c094_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_12 (mix_i_src_c094_1_12 0 bpf_c094_1 0) vcvs gain=1.950903220161e-01
SMIXI_c094_1_12 (mix_i_src_c094_1_12 mix_i_c094_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_12 (mix_q_src_c094_1_12 0 bpf_c094_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_1_12 (mix_q_src_c094_1_12 mix_q_c094_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_13 (mix_i_src_c094_1_13 0 bpf_c094_1 0) vcvs gain=5.555702330196e-01
SMIXI_c094_1_13 (mix_i_src_c094_1_13 mix_i_c094_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_13 (mix_q_src_c094_1_13 0 bpf_c094_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_1_13 (mix_q_src_c094_1_13 mix_q_c094_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_14 (mix_i_src_c094_1_14 0 bpf_c094_1 0) vcvs gain=8.314696123025e-01
SMIXI_c094_1_14 (mix_i_src_c094_1_14 mix_i_c094_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_14 (mix_q_src_c094_1_14 0 bpf_c094_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_1_14 (mix_q_src_c094_1_14 mix_q_c094_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_1_15 (mix_i_src_c094_1_15 0 bpf_c094_1 0) vcvs gain=9.807852804032e-01
SMIXI_c094_1_15 (mix_i_src_c094_1_15 mix_i_c094_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_1_15 (mix_q_src_c094_1_15 0 bpf_c094_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_1_15 (mix_q_src_c094_1_15 mix_q_c094_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c094_1 (mix_i_c094_1 0) resistor r=1G
RMIXQ_c094_1 (mix_q_c094_1 0) resistor r=1G
RINTI_c094_1 (mix_i_c094_1 Icar_c094_1) resistor r=1k
CINTI_c094_1 (Icar_c094_1 0) capacitor c=80p
RINTQ_c094_1 (mix_q_c094_1 Qcar_c094_1) resistor r=1k
CINTQ_c094_1 (Qcar_c094_1 0) capacitor c=80p

// bl094, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c094_2 (bl094 n_cbpf_c094_2) capacitor c=4.503163717437e-14
LBPF_c094_2 (n_cbpf_c094_2 bpf_c094_2) inductor l=1.000000000000e-06
RBPF_c094_2 (bpf_c094_2 0) resistor r=2.356194490192e+02
EMIXI_c094_2_00 (mix_i_src_c094_2_00 0 bpf_c094_2 0) vcvs gain=9.807852804032e-01
SMIXI_c094_2_00 (mix_i_src_c094_2_00 mix_i_c094_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_00 (mix_q_src_c094_2_00 0 bpf_c094_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_2_00 (mix_q_src_c094_2_00 mix_q_c094_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_01 (mix_i_src_c094_2_01 0 bpf_c094_2 0) vcvs gain=8.314696123025e-01
SMIXI_c094_2_01 (mix_i_src_c094_2_01 mix_i_c094_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_01 (mix_q_src_c094_2_01 0 bpf_c094_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_2_01 (mix_q_src_c094_2_01 mix_q_c094_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_02 (mix_i_src_c094_2_02 0 bpf_c094_2 0) vcvs gain=5.555702330196e-01
SMIXI_c094_2_02 (mix_i_src_c094_2_02 mix_i_c094_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_02 (mix_q_src_c094_2_02 0 bpf_c094_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_2_02 (mix_q_src_c094_2_02 mix_q_c094_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_03 (mix_i_src_c094_2_03 0 bpf_c094_2 0) vcvs gain=1.950903220161e-01
SMIXI_c094_2_03 (mix_i_src_c094_2_03 mix_i_c094_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_03 (mix_q_src_c094_2_03 0 bpf_c094_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_2_03 (mix_q_src_c094_2_03 mix_q_c094_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_04 (mix_i_src_c094_2_04 0 bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_2_04 (mix_i_src_c094_2_04 mix_i_c094_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_04 (mix_q_src_c094_2_04 0 bpf_c094_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_2_04 (mix_q_src_c094_2_04 mix_q_c094_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_05 (mix_i_src_c094_2_05 0 bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_2_05 (mix_i_src_c094_2_05 mix_i_c094_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_05 (mix_q_src_c094_2_05 0 bpf_c094_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_2_05 (mix_q_src_c094_2_05 mix_q_c094_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_06 (mix_i_src_c094_2_06 0 bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_2_06 (mix_i_src_c094_2_06 mix_i_c094_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_06 (mix_q_src_c094_2_06 0 bpf_c094_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_2_06 (mix_q_src_c094_2_06 mix_q_c094_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_07 (mix_i_src_c094_2_07 0 bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_2_07 (mix_i_src_c094_2_07 mix_i_c094_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_07 (mix_q_src_c094_2_07 0 bpf_c094_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_2_07 (mix_q_src_c094_2_07 mix_q_c094_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_08 (mix_i_src_c094_2_08 0 bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_2_08 (mix_i_src_c094_2_08 mix_i_c094_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_08 (mix_q_src_c094_2_08 0 bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_2_08 (mix_q_src_c094_2_08 mix_q_c094_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_09 (mix_i_src_c094_2_09 0 bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_2_09 (mix_i_src_c094_2_09 mix_i_c094_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_09 (mix_q_src_c094_2_09 0 bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_2_09 (mix_q_src_c094_2_09 mix_q_c094_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_10 (mix_i_src_c094_2_10 0 bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_2_10 (mix_i_src_c094_2_10 mix_i_c094_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_10 (mix_q_src_c094_2_10 0 bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_2_10 (mix_q_src_c094_2_10 mix_q_c094_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_11 (mix_i_src_c094_2_11 0 bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_2_11 (mix_i_src_c094_2_11 mix_i_c094_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_11 (mix_q_src_c094_2_11 0 bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_2_11 (mix_q_src_c094_2_11 mix_q_c094_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_12 (mix_i_src_c094_2_12 0 bpf_c094_2 0) vcvs gain=1.950903220161e-01
SMIXI_c094_2_12 (mix_i_src_c094_2_12 mix_i_c094_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_12 (mix_q_src_c094_2_12 0 bpf_c094_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_2_12 (mix_q_src_c094_2_12 mix_q_c094_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_13 (mix_i_src_c094_2_13 0 bpf_c094_2 0) vcvs gain=5.555702330196e-01
SMIXI_c094_2_13 (mix_i_src_c094_2_13 mix_i_c094_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_13 (mix_q_src_c094_2_13 0 bpf_c094_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_2_13 (mix_q_src_c094_2_13 mix_q_c094_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_14 (mix_i_src_c094_2_14 0 bpf_c094_2 0) vcvs gain=8.314696123025e-01
SMIXI_c094_2_14 (mix_i_src_c094_2_14 mix_i_c094_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_14 (mix_q_src_c094_2_14 0 bpf_c094_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_2_14 (mix_q_src_c094_2_14 mix_q_c094_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_2_15 (mix_i_src_c094_2_15 0 bpf_c094_2 0) vcvs gain=9.807852804032e-01
SMIXI_c094_2_15 (mix_i_src_c094_2_15 mix_i_c094_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_2_15 (mix_q_src_c094_2_15 0 bpf_c094_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_2_15 (mix_q_src_c094_2_15 mix_q_c094_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c094_2 (mix_i_c094_2 0) resistor r=1G
RMIXQ_c094_2 (mix_q_c094_2 0) resistor r=1G
RINTI_c094_2 (mix_i_c094_2 Icar_c094_2) resistor r=1k
CINTI_c094_2 (Icar_c094_2 0) capacitor c=80p
RINTQ_c094_2 (mix_q_c094_2 Qcar_c094_2) resistor r=1k
CINTQ_c094_2 (Qcar_c094_2 0) capacitor c=80p

// bl094, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c094_3 (bl094 n_cbpf_c094_3) capacitor c=2.533029591058e-14
LBPF_c094_3 (n_cbpf_c094_3 bpf_c094_3) inductor l=1.000000000000e-06
RBPF_c094_3 (bpf_c094_3 0) resistor r=3.141592653590e+02
EMIXI_c094_3_00 (mix_i_src_c094_3_00 0 bpf_c094_3 0) vcvs gain=9.807852804032e-01
SMIXI_c094_3_00 (mix_i_src_c094_3_00 mix_i_c094_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_00 (mix_q_src_c094_3_00 0 bpf_c094_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_3_00 (mix_q_src_c094_3_00 mix_q_c094_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_01 (mix_i_src_c094_3_01 0 bpf_c094_3 0) vcvs gain=8.314696123025e-01
SMIXI_c094_3_01 (mix_i_src_c094_3_01 mix_i_c094_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_01 (mix_q_src_c094_3_01 0 bpf_c094_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_3_01 (mix_q_src_c094_3_01 mix_q_c094_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_02 (mix_i_src_c094_3_02 0 bpf_c094_3 0) vcvs gain=5.555702330196e-01
SMIXI_c094_3_02 (mix_i_src_c094_3_02 mix_i_c094_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_02 (mix_q_src_c094_3_02 0 bpf_c094_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_3_02 (mix_q_src_c094_3_02 mix_q_c094_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_03 (mix_i_src_c094_3_03 0 bpf_c094_3 0) vcvs gain=1.950903220161e-01
SMIXI_c094_3_03 (mix_i_src_c094_3_03 mix_i_c094_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_03 (mix_q_src_c094_3_03 0 bpf_c094_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_3_03 (mix_q_src_c094_3_03 mix_q_c094_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_04 (mix_i_src_c094_3_04 0 bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_3_04 (mix_i_src_c094_3_04 mix_i_c094_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_04 (mix_q_src_c094_3_04 0 bpf_c094_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c094_3_04 (mix_q_src_c094_3_04 mix_q_c094_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_05 (mix_i_src_c094_3_05 0 bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_3_05 (mix_i_src_c094_3_05 mix_i_c094_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_05 (mix_q_src_c094_3_05 0 bpf_c094_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c094_3_05 (mix_q_src_c094_3_05 mix_q_c094_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_06 (mix_i_src_c094_3_06 0 bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_3_06 (mix_i_src_c094_3_06 mix_i_c094_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_06 (mix_q_src_c094_3_06 0 bpf_c094_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c094_3_06 (mix_q_src_c094_3_06 mix_q_c094_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_07 (mix_i_src_c094_3_07 0 bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_3_07 (mix_i_src_c094_3_07 mix_i_c094_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_07 (mix_q_src_c094_3_07 0 bpf_c094_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c094_3_07 (mix_q_src_c094_3_07 mix_q_c094_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_08 (mix_i_src_c094_3_08 0 bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c094_3_08 (mix_i_src_c094_3_08 mix_i_c094_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_08 (mix_q_src_c094_3_08 0 bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_3_08 (mix_q_src_c094_3_08 mix_q_c094_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_09 (mix_i_src_c094_3_09 0 bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c094_3_09 (mix_i_src_c094_3_09 mix_i_c094_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_09 (mix_q_src_c094_3_09 0 bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_3_09 (mix_q_src_c094_3_09 mix_q_c094_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_10 (mix_i_src_c094_3_10 0 bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c094_3_10 (mix_i_src_c094_3_10 mix_i_c094_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_10 (mix_q_src_c094_3_10 0 bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_3_10 (mix_q_src_c094_3_10 mix_q_c094_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_11 (mix_i_src_c094_3_11 0 bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c094_3_11 (mix_i_src_c094_3_11 mix_i_c094_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_11 (mix_q_src_c094_3_11 0 bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_3_11 (mix_q_src_c094_3_11 mix_q_c094_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_12 (mix_i_src_c094_3_12 0 bpf_c094_3 0) vcvs gain=1.950903220161e-01
SMIXI_c094_3_12 (mix_i_src_c094_3_12 mix_i_c094_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_12 (mix_q_src_c094_3_12 0 bpf_c094_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c094_3_12 (mix_q_src_c094_3_12 mix_q_c094_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_13 (mix_i_src_c094_3_13 0 bpf_c094_3 0) vcvs gain=5.555702330196e-01
SMIXI_c094_3_13 (mix_i_src_c094_3_13 mix_i_c094_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_13 (mix_q_src_c094_3_13 0 bpf_c094_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c094_3_13 (mix_q_src_c094_3_13 mix_q_c094_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_14 (mix_i_src_c094_3_14 0 bpf_c094_3 0) vcvs gain=8.314696123025e-01
SMIXI_c094_3_14 (mix_i_src_c094_3_14 mix_i_c094_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_14 (mix_q_src_c094_3_14 0 bpf_c094_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c094_3_14 (mix_q_src_c094_3_14 mix_q_c094_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c094_3_15 (mix_i_src_c094_3_15 0 bpf_c094_3 0) vcvs gain=9.807852804032e-01
SMIXI_c094_3_15 (mix_i_src_c094_3_15 mix_i_c094_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c094_3_15 (mix_q_src_c094_3_15 0 bpf_c094_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c094_3_15 (mix_q_src_c094_3_15 mix_q_c094_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c094_3 (mix_i_c094_3 0) resistor r=1G
RMIXQ_c094_3 (mix_q_c094_3 0) resistor r=1G
RINTI_c094_3 (mix_i_c094_3 Icar_c094_3) resistor r=1k
CINTI_c094_3 (Icar_c094_3 0) capacitor c=80p
RINTQ_c094_3 (mix_q_c094_3 Qcar_c094_3) resistor r=1k
CINTQ_c094_3 (Qcar_c094_3 0) capacitor c=80p

// bl095, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c095_0 (bl095 n_cbpf_c095_0) capacitor c=4.052847345694e-13
LBPF_c095_0 (n_cbpf_c095_0 bpf_c095_0) inductor l=1.000000000000e-06
RBPF_c095_0 (bpf_c095_0 0) resistor r=7.853981633974e+01
EMIXI_c095_0_00 (mix_i_src_c095_0_00 0 bpf_c095_0 0) vcvs gain=9.807852804032e-01
SMIXI_c095_0_00 (mix_i_src_c095_0_00 mix_i_c095_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_00 (mix_q_src_c095_0_00 0 bpf_c095_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_0_00 (mix_q_src_c095_0_00 mix_q_c095_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_01 (mix_i_src_c095_0_01 0 bpf_c095_0 0) vcvs gain=8.314696123025e-01
SMIXI_c095_0_01 (mix_i_src_c095_0_01 mix_i_c095_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_01 (mix_q_src_c095_0_01 0 bpf_c095_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_0_01 (mix_q_src_c095_0_01 mix_q_c095_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_02 (mix_i_src_c095_0_02 0 bpf_c095_0 0) vcvs gain=5.555702330196e-01
SMIXI_c095_0_02 (mix_i_src_c095_0_02 mix_i_c095_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_02 (mix_q_src_c095_0_02 0 bpf_c095_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_0_02 (mix_q_src_c095_0_02 mix_q_c095_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_03 (mix_i_src_c095_0_03 0 bpf_c095_0 0) vcvs gain=1.950903220161e-01
SMIXI_c095_0_03 (mix_i_src_c095_0_03 mix_i_c095_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_03 (mix_q_src_c095_0_03 0 bpf_c095_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_0_03 (mix_q_src_c095_0_03 mix_q_c095_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_04 (mix_i_src_c095_0_04 0 bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_0_04 (mix_i_src_c095_0_04 mix_i_c095_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_04 (mix_q_src_c095_0_04 0 bpf_c095_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_0_04 (mix_q_src_c095_0_04 mix_q_c095_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_05 (mix_i_src_c095_0_05 0 bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_0_05 (mix_i_src_c095_0_05 mix_i_c095_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_05 (mix_q_src_c095_0_05 0 bpf_c095_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_0_05 (mix_q_src_c095_0_05 mix_q_c095_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_06 (mix_i_src_c095_0_06 0 bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_0_06 (mix_i_src_c095_0_06 mix_i_c095_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_06 (mix_q_src_c095_0_06 0 bpf_c095_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_0_06 (mix_q_src_c095_0_06 mix_q_c095_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_07 (mix_i_src_c095_0_07 0 bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_0_07 (mix_i_src_c095_0_07 mix_i_c095_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_07 (mix_q_src_c095_0_07 0 bpf_c095_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_0_07 (mix_q_src_c095_0_07 mix_q_c095_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_08 (mix_i_src_c095_0_08 0 bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_0_08 (mix_i_src_c095_0_08 mix_i_c095_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_08 (mix_q_src_c095_0_08 0 bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_0_08 (mix_q_src_c095_0_08 mix_q_c095_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_09 (mix_i_src_c095_0_09 0 bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_0_09 (mix_i_src_c095_0_09 mix_i_c095_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_09 (mix_q_src_c095_0_09 0 bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_0_09 (mix_q_src_c095_0_09 mix_q_c095_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_10 (mix_i_src_c095_0_10 0 bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_0_10 (mix_i_src_c095_0_10 mix_i_c095_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_10 (mix_q_src_c095_0_10 0 bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_0_10 (mix_q_src_c095_0_10 mix_q_c095_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_11 (mix_i_src_c095_0_11 0 bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_0_11 (mix_i_src_c095_0_11 mix_i_c095_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_11 (mix_q_src_c095_0_11 0 bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_0_11 (mix_q_src_c095_0_11 mix_q_c095_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_12 (mix_i_src_c095_0_12 0 bpf_c095_0 0) vcvs gain=1.950903220161e-01
SMIXI_c095_0_12 (mix_i_src_c095_0_12 mix_i_c095_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_12 (mix_q_src_c095_0_12 0 bpf_c095_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_0_12 (mix_q_src_c095_0_12 mix_q_c095_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_13 (mix_i_src_c095_0_13 0 bpf_c095_0 0) vcvs gain=5.555702330196e-01
SMIXI_c095_0_13 (mix_i_src_c095_0_13 mix_i_c095_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_13 (mix_q_src_c095_0_13 0 bpf_c095_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_0_13 (mix_q_src_c095_0_13 mix_q_c095_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_14 (mix_i_src_c095_0_14 0 bpf_c095_0 0) vcvs gain=8.314696123025e-01
SMIXI_c095_0_14 (mix_i_src_c095_0_14 mix_i_c095_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_14 (mix_q_src_c095_0_14 0 bpf_c095_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_0_14 (mix_q_src_c095_0_14 mix_q_c095_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_0_15 (mix_i_src_c095_0_15 0 bpf_c095_0 0) vcvs gain=9.807852804032e-01
SMIXI_c095_0_15 (mix_i_src_c095_0_15 mix_i_c095_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_0_15 (mix_q_src_c095_0_15 0 bpf_c095_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_0_15 (mix_q_src_c095_0_15 mix_q_c095_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c095_0 (mix_i_c095_0 0) resistor r=1G
RMIXQ_c095_0 (mix_q_c095_0 0) resistor r=1G
RINTI_c095_0 (mix_i_c095_0 Icar_c095_0) resistor r=1k
CINTI_c095_0 (Icar_c095_0 0) capacitor c=80p
RINTQ_c095_0 (mix_q_c095_0 Qcar_c095_0) resistor r=1k
CINTQ_c095_0 (Qcar_c095_0 0) capacitor c=80p

// bl095, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c095_1 (bl095 n_cbpf_c095_1) capacitor c=1.013211836423e-13
LBPF_c095_1 (n_cbpf_c095_1 bpf_c095_1) inductor l=1.000000000000e-06
RBPF_c095_1 (bpf_c095_1 0) resistor r=1.570796326795e+02
EMIXI_c095_1_00 (mix_i_src_c095_1_00 0 bpf_c095_1 0) vcvs gain=9.807852804032e-01
SMIXI_c095_1_00 (mix_i_src_c095_1_00 mix_i_c095_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_00 (mix_q_src_c095_1_00 0 bpf_c095_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_1_00 (mix_q_src_c095_1_00 mix_q_c095_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_01 (mix_i_src_c095_1_01 0 bpf_c095_1 0) vcvs gain=8.314696123025e-01
SMIXI_c095_1_01 (mix_i_src_c095_1_01 mix_i_c095_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_01 (mix_q_src_c095_1_01 0 bpf_c095_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_1_01 (mix_q_src_c095_1_01 mix_q_c095_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_02 (mix_i_src_c095_1_02 0 bpf_c095_1 0) vcvs gain=5.555702330196e-01
SMIXI_c095_1_02 (mix_i_src_c095_1_02 mix_i_c095_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_02 (mix_q_src_c095_1_02 0 bpf_c095_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_1_02 (mix_q_src_c095_1_02 mix_q_c095_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_03 (mix_i_src_c095_1_03 0 bpf_c095_1 0) vcvs gain=1.950903220161e-01
SMIXI_c095_1_03 (mix_i_src_c095_1_03 mix_i_c095_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_03 (mix_q_src_c095_1_03 0 bpf_c095_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_1_03 (mix_q_src_c095_1_03 mix_q_c095_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_04 (mix_i_src_c095_1_04 0 bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_1_04 (mix_i_src_c095_1_04 mix_i_c095_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_04 (mix_q_src_c095_1_04 0 bpf_c095_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_1_04 (mix_q_src_c095_1_04 mix_q_c095_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_05 (mix_i_src_c095_1_05 0 bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_1_05 (mix_i_src_c095_1_05 mix_i_c095_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_05 (mix_q_src_c095_1_05 0 bpf_c095_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_1_05 (mix_q_src_c095_1_05 mix_q_c095_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_06 (mix_i_src_c095_1_06 0 bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_1_06 (mix_i_src_c095_1_06 mix_i_c095_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_06 (mix_q_src_c095_1_06 0 bpf_c095_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_1_06 (mix_q_src_c095_1_06 mix_q_c095_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_07 (mix_i_src_c095_1_07 0 bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_1_07 (mix_i_src_c095_1_07 mix_i_c095_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_07 (mix_q_src_c095_1_07 0 bpf_c095_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_1_07 (mix_q_src_c095_1_07 mix_q_c095_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_08 (mix_i_src_c095_1_08 0 bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_1_08 (mix_i_src_c095_1_08 mix_i_c095_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_08 (mix_q_src_c095_1_08 0 bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_1_08 (mix_q_src_c095_1_08 mix_q_c095_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_09 (mix_i_src_c095_1_09 0 bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_1_09 (mix_i_src_c095_1_09 mix_i_c095_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_09 (mix_q_src_c095_1_09 0 bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_1_09 (mix_q_src_c095_1_09 mix_q_c095_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_10 (mix_i_src_c095_1_10 0 bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_1_10 (mix_i_src_c095_1_10 mix_i_c095_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_10 (mix_q_src_c095_1_10 0 bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_1_10 (mix_q_src_c095_1_10 mix_q_c095_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_11 (mix_i_src_c095_1_11 0 bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_1_11 (mix_i_src_c095_1_11 mix_i_c095_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_11 (mix_q_src_c095_1_11 0 bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_1_11 (mix_q_src_c095_1_11 mix_q_c095_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_12 (mix_i_src_c095_1_12 0 bpf_c095_1 0) vcvs gain=1.950903220161e-01
SMIXI_c095_1_12 (mix_i_src_c095_1_12 mix_i_c095_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_12 (mix_q_src_c095_1_12 0 bpf_c095_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_1_12 (mix_q_src_c095_1_12 mix_q_c095_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_13 (mix_i_src_c095_1_13 0 bpf_c095_1 0) vcvs gain=5.555702330196e-01
SMIXI_c095_1_13 (mix_i_src_c095_1_13 mix_i_c095_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_13 (mix_q_src_c095_1_13 0 bpf_c095_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_1_13 (mix_q_src_c095_1_13 mix_q_c095_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_14 (mix_i_src_c095_1_14 0 bpf_c095_1 0) vcvs gain=8.314696123025e-01
SMIXI_c095_1_14 (mix_i_src_c095_1_14 mix_i_c095_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_14 (mix_q_src_c095_1_14 0 bpf_c095_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_1_14 (mix_q_src_c095_1_14 mix_q_c095_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_1_15 (mix_i_src_c095_1_15 0 bpf_c095_1 0) vcvs gain=9.807852804032e-01
SMIXI_c095_1_15 (mix_i_src_c095_1_15 mix_i_c095_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_1_15 (mix_q_src_c095_1_15 0 bpf_c095_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_1_15 (mix_q_src_c095_1_15 mix_q_c095_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c095_1 (mix_i_c095_1 0) resistor r=1G
RMIXQ_c095_1 (mix_q_c095_1 0) resistor r=1G
RINTI_c095_1 (mix_i_c095_1 Icar_c095_1) resistor r=1k
CINTI_c095_1 (Icar_c095_1 0) capacitor c=80p
RINTQ_c095_1 (mix_q_c095_1 Qcar_c095_1) resistor r=1k
CINTQ_c095_1 (Qcar_c095_1 0) capacitor c=80p

// bl095, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c095_2 (bl095 n_cbpf_c095_2) capacitor c=4.503163717437e-14
LBPF_c095_2 (n_cbpf_c095_2 bpf_c095_2) inductor l=1.000000000000e-06
RBPF_c095_2 (bpf_c095_2 0) resistor r=2.356194490192e+02
EMIXI_c095_2_00 (mix_i_src_c095_2_00 0 bpf_c095_2 0) vcvs gain=9.807852804032e-01
SMIXI_c095_2_00 (mix_i_src_c095_2_00 mix_i_c095_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_00 (mix_q_src_c095_2_00 0 bpf_c095_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_2_00 (mix_q_src_c095_2_00 mix_q_c095_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_01 (mix_i_src_c095_2_01 0 bpf_c095_2 0) vcvs gain=8.314696123025e-01
SMIXI_c095_2_01 (mix_i_src_c095_2_01 mix_i_c095_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_01 (mix_q_src_c095_2_01 0 bpf_c095_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_2_01 (mix_q_src_c095_2_01 mix_q_c095_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_02 (mix_i_src_c095_2_02 0 bpf_c095_2 0) vcvs gain=5.555702330196e-01
SMIXI_c095_2_02 (mix_i_src_c095_2_02 mix_i_c095_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_02 (mix_q_src_c095_2_02 0 bpf_c095_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_2_02 (mix_q_src_c095_2_02 mix_q_c095_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_03 (mix_i_src_c095_2_03 0 bpf_c095_2 0) vcvs gain=1.950903220161e-01
SMIXI_c095_2_03 (mix_i_src_c095_2_03 mix_i_c095_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_03 (mix_q_src_c095_2_03 0 bpf_c095_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_2_03 (mix_q_src_c095_2_03 mix_q_c095_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_04 (mix_i_src_c095_2_04 0 bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_2_04 (mix_i_src_c095_2_04 mix_i_c095_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_04 (mix_q_src_c095_2_04 0 bpf_c095_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_2_04 (mix_q_src_c095_2_04 mix_q_c095_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_05 (mix_i_src_c095_2_05 0 bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_2_05 (mix_i_src_c095_2_05 mix_i_c095_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_05 (mix_q_src_c095_2_05 0 bpf_c095_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_2_05 (mix_q_src_c095_2_05 mix_q_c095_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_06 (mix_i_src_c095_2_06 0 bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_2_06 (mix_i_src_c095_2_06 mix_i_c095_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_06 (mix_q_src_c095_2_06 0 bpf_c095_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_2_06 (mix_q_src_c095_2_06 mix_q_c095_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_07 (mix_i_src_c095_2_07 0 bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_2_07 (mix_i_src_c095_2_07 mix_i_c095_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_07 (mix_q_src_c095_2_07 0 bpf_c095_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_2_07 (mix_q_src_c095_2_07 mix_q_c095_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_08 (mix_i_src_c095_2_08 0 bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_2_08 (mix_i_src_c095_2_08 mix_i_c095_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_08 (mix_q_src_c095_2_08 0 bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_2_08 (mix_q_src_c095_2_08 mix_q_c095_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_09 (mix_i_src_c095_2_09 0 bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_2_09 (mix_i_src_c095_2_09 mix_i_c095_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_09 (mix_q_src_c095_2_09 0 bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_2_09 (mix_q_src_c095_2_09 mix_q_c095_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_10 (mix_i_src_c095_2_10 0 bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_2_10 (mix_i_src_c095_2_10 mix_i_c095_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_10 (mix_q_src_c095_2_10 0 bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_2_10 (mix_q_src_c095_2_10 mix_q_c095_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_11 (mix_i_src_c095_2_11 0 bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_2_11 (mix_i_src_c095_2_11 mix_i_c095_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_11 (mix_q_src_c095_2_11 0 bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_2_11 (mix_q_src_c095_2_11 mix_q_c095_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_12 (mix_i_src_c095_2_12 0 bpf_c095_2 0) vcvs gain=1.950903220161e-01
SMIXI_c095_2_12 (mix_i_src_c095_2_12 mix_i_c095_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_12 (mix_q_src_c095_2_12 0 bpf_c095_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_2_12 (mix_q_src_c095_2_12 mix_q_c095_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_13 (mix_i_src_c095_2_13 0 bpf_c095_2 0) vcvs gain=5.555702330196e-01
SMIXI_c095_2_13 (mix_i_src_c095_2_13 mix_i_c095_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_13 (mix_q_src_c095_2_13 0 bpf_c095_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_2_13 (mix_q_src_c095_2_13 mix_q_c095_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_14 (mix_i_src_c095_2_14 0 bpf_c095_2 0) vcvs gain=8.314696123025e-01
SMIXI_c095_2_14 (mix_i_src_c095_2_14 mix_i_c095_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_14 (mix_q_src_c095_2_14 0 bpf_c095_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_2_14 (mix_q_src_c095_2_14 mix_q_c095_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_2_15 (mix_i_src_c095_2_15 0 bpf_c095_2 0) vcvs gain=9.807852804032e-01
SMIXI_c095_2_15 (mix_i_src_c095_2_15 mix_i_c095_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_2_15 (mix_q_src_c095_2_15 0 bpf_c095_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_2_15 (mix_q_src_c095_2_15 mix_q_c095_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c095_2 (mix_i_c095_2 0) resistor r=1G
RMIXQ_c095_2 (mix_q_c095_2 0) resistor r=1G
RINTI_c095_2 (mix_i_c095_2 Icar_c095_2) resistor r=1k
CINTI_c095_2 (Icar_c095_2 0) capacitor c=80p
RINTQ_c095_2 (mix_q_c095_2 Qcar_c095_2) resistor r=1k
CINTQ_c095_2 (Qcar_c095_2 0) capacitor c=80p

// bl095, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c095_3 (bl095 n_cbpf_c095_3) capacitor c=2.533029591058e-14
LBPF_c095_3 (n_cbpf_c095_3 bpf_c095_3) inductor l=1.000000000000e-06
RBPF_c095_3 (bpf_c095_3 0) resistor r=3.141592653590e+02
EMIXI_c095_3_00 (mix_i_src_c095_3_00 0 bpf_c095_3 0) vcvs gain=9.807852804032e-01
SMIXI_c095_3_00 (mix_i_src_c095_3_00 mix_i_c095_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_00 (mix_q_src_c095_3_00 0 bpf_c095_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_3_00 (mix_q_src_c095_3_00 mix_q_c095_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_01 (mix_i_src_c095_3_01 0 bpf_c095_3 0) vcvs gain=8.314696123025e-01
SMIXI_c095_3_01 (mix_i_src_c095_3_01 mix_i_c095_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_01 (mix_q_src_c095_3_01 0 bpf_c095_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_3_01 (mix_q_src_c095_3_01 mix_q_c095_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_02 (mix_i_src_c095_3_02 0 bpf_c095_3 0) vcvs gain=5.555702330196e-01
SMIXI_c095_3_02 (mix_i_src_c095_3_02 mix_i_c095_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_02 (mix_q_src_c095_3_02 0 bpf_c095_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_3_02 (mix_q_src_c095_3_02 mix_q_c095_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_03 (mix_i_src_c095_3_03 0 bpf_c095_3 0) vcvs gain=1.950903220161e-01
SMIXI_c095_3_03 (mix_i_src_c095_3_03 mix_i_c095_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_03 (mix_q_src_c095_3_03 0 bpf_c095_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_3_03 (mix_q_src_c095_3_03 mix_q_c095_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_04 (mix_i_src_c095_3_04 0 bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_3_04 (mix_i_src_c095_3_04 mix_i_c095_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_04 (mix_q_src_c095_3_04 0 bpf_c095_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c095_3_04 (mix_q_src_c095_3_04 mix_q_c095_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_05 (mix_i_src_c095_3_05 0 bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_3_05 (mix_i_src_c095_3_05 mix_i_c095_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_05 (mix_q_src_c095_3_05 0 bpf_c095_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c095_3_05 (mix_q_src_c095_3_05 mix_q_c095_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_06 (mix_i_src_c095_3_06 0 bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_3_06 (mix_i_src_c095_3_06 mix_i_c095_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_06 (mix_q_src_c095_3_06 0 bpf_c095_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c095_3_06 (mix_q_src_c095_3_06 mix_q_c095_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_07 (mix_i_src_c095_3_07 0 bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_3_07 (mix_i_src_c095_3_07 mix_i_c095_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_07 (mix_q_src_c095_3_07 0 bpf_c095_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c095_3_07 (mix_q_src_c095_3_07 mix_q_c095_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_08 (mix_i_src_c095_3_08 0 bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c095_3_08 (mix_i_src_c095_3_08 mix_i_c095_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_08 (mix_q_src_c095_3_08 0 bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_3_08 (mix_q_src_c095_3_08 mix_q_c095_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_09 (mix_i_src_c095_3_09 0 bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c095_3_09 (mix_i_src_c095_3_09 mix_i_c095_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_09 (mix_q_src_c095_3_09 0 bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_3_09 (mix_q_src_c095_3_09 mix_q_c095_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_10 (mix_i_src_c095_3_10 0 bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c095_3_10 (mix_i_src_c095_3_10 mix_i_c095_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_10 (mix_q_src_c095_3_10 0 bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_3_10 (mix_q_src_c095_3_10 mix_q_c095_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_11 (mix_i_src_c095_3_11 0 bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c095_3_11 (mix_i_src_c095_3_11 mix_i_c095_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_11 (mix_q_src_c095_3_11 0 bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_3_11 (mix_q_src_c095_3_11 mix_q_c095_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_12 (mix_i_src_c095_3_12 0 bpf_c095_3 0) vcvs gain=1.950903220161e-01
SMIXI_c095_3_12 (mix_i_src_c095_3_12 mix_i_c095_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_12 (mix_q_src_c095_3_12 0 bpf_c095_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c095_3_12 (mix_q_src_c095_3_12 mix_q_c095_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_13 (mix_i_src_c095_3_13 0 bpf_c095_3 0) vcvs gain=5.555702330196e-01
SMIXI_c095_3_13 (mix_i_src_c095_3_13 mix_i_c095_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_13 (mix_q_src_c095_3_13 0 bpf_c095_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c095_3_13 (mix_q_src_c095_3_13 mix_q_c095_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_14 (mix_i_src_c095_3_14 0 bpf_c095_3 0) vcvs gain=8.314696123025e-01
SMIXI_c095_3_14 (mix_i_src_c095_3_14 mix_i_c095_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_14 (mix_q_src_c095_3_14 0 bpf_c095_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c095_3_14 (mix_q_src_c095_3_14 mix_q_c095_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c095_3_15 (mix_i_src_c095_3_15 0 bpf_c095_3 0) vcvs gain=9.807852804032e-01
SMIXI_c095_3_15 (mix_i_src_c095_3_15 mix_i_c095_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c095_3_15 (mix_q_src_c095_3_15 0 bpf_c095_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c095_3_15 (mix_q_src_c095_3_15 mix_q_c095_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c095_3 (mix_i_c095_3 0) resistor r=1G
RMIXQ_c095_3 (mix_q_c095_3 0) resistor r=1G
RINTI_c095_3 (mix_i_c095_3 Icar_c095_3) resistor r=1k
CINTI_c095_3 (Icar_c095_3 0) capacitor c=80p
RINTQ_c095_3 (mix_q_c095_3 Qcar_c095_3) resistor r=1k
CINTQ_c095_3 (Qcar_c095_3 0) capacitor c=80p

// bl096, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c096_0 (bl096 n_cbpf_c096_0) capacitor c=4.052847345694e-13
LBPF_c096_0 (n_cbpf_c096_0 bpf_c096_0) inductor l=1.000000000000e-06
RBPF_c096_0 (bpf_c096_0 0) resistor r=7.853981633974e+01
EMIXI_c096_0_00 (mix_i_src_c096_0_00 0 bpf_c096_0 0) vcvs gain=9.807852804032e-01
SMIXI_c096_0_00 (mix_i_src_c096_0_00 mix_i_c096_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_00 (mix_q_src_c096_0_00 0 bpf_c096_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_0_00 (mix_q_src_c096_0_00 mix_q_c096_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_01 (mix_i_src_c096_0_01 0 bpf_c096_0 0) vcvs gain=8.314696123025e-01
SMIXI_c096_0_01 (mix_i_src_c096_0_01 mix_i_c096_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_01 (mix_q_src_c096_0_01 0 bpf_c096_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_0_01 (mix_q_src_c096_0_01 mix_q_c096_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_02 (mix_i_src_c096_0_02 0 bpf_c096_0 0) vcvs gain=5.555702330196e-01
SMIXI_c096_0_02 (mix_i_src_c096_0_02 mix_i_c096_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_02 (mix_q_src_c096_0_02 0 bpf_c096_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_0_02 (mix_q_src_c096_0_02 mix_q_c096_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_03 (mix_i_src_c096_0_03 0 bpf_c096_0 0) vcvs gain=1.950903220161e-01
SMIXI_c096_0_03 (mix_i_src_c096_0_03 mix_i_c096_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_03 (mix_q_src_c096_0_03 0 bpf_c096_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_0_03 (mix_q_src_c096_0_03 mix_q_c096_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_04 (mix_i_src_c096_0_04 0 bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_0_04 (mix_i_src_c096_0_04 mix_i_c096_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_04 (mix_q_src_c096_0_04 0 bpf_c096_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_0_04 (mix_q_src_c096_0_04 mix_q_c096_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_05 (mix_i_src_c096_0_05 0 bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_0_05 (mix_i_src_c096_0_05 mix_i_c096_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_05 (mix_q_src_c096_0_05 0 bpf_c096_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_0_05 (mix_q_src_c096_0_05 mix_q_c096_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_06 (mix_i_src_c096_0_06 0 bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_0_06 (mix_i_src_c096_0_06 mix_i_c096_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_06 (mix_q_src_c096_0_06 0 bpf_c096_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_0_06 (mix_q_src_c096_0_06 mix_q_c096_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_07 (mix_i_src_c096_0_07 0 bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_0_07 (mix_i_src_c096_0_07 mix_i_c096_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_07 (mix_q_src_c096_0_07 0 bpf_c096_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_0_07 (mix_q_src_c096_0_07 mix_q_c096_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_08 (mix_i_src_c096_0_08 0 bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_0_08 (mix_i_src_c096_0_08 mix_i_c096_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_08 (mix_q_src_c096_0_08 0 bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_0_08 (mix_q_src_c096_0_08 mix_q_c096_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_09 (mix_i_src_c096_0_09 0 bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_0_09 (mix_i_src_c096_0_09 mix_i_c096_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_09 (mix_q_src_c096_0_09 0 bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_0_09 (mix_q_src_c096_0_09 mix_q_c096_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_10 (mix_i_src_c096_0_10 0 bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_0_10 (mix_i_src_c096_0_10 mix_i_c096_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_10 (mix_q_src_c096_0_10 0 bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_0_10 (mix_q_src_c096_0_10 mix_q_c096_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_11 (mix_i_src_c096_0_11 0 bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_0_11 (mix_i_src_c096_0_11 mix_i_c096_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_11 (mix_q_src_c096_0_11 0 bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_0_11 (mix_q_src_c096_0_11 mix_q_c096_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_12 (mix_i_src_c096_0_12 0 bpf_c096_0 0) vcvs gain=1.950903220161e-01
SMIXI_c096_0_12 (mix_i_src_c096_0_12 mix_i_c096_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_12 (mix_q_src_c096_0_12 0 bpf_c096_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_0_12 (mix_q_src_c096_0_12 mix_q_c096_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_13 (mix_i_src_c096_0_13 0 bpf_c096_0 0) vcvs gain=5.555702330196e-01
SMIXI_c096_0_13 (mix_i_src_c096_0_13 mix_i_c096_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_13 (mix_q_src_c096_0_13 0 bpf_c096_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_0_13 (mix_q_src_c096_0_13 mix_q_c096_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_14 (mix_i_src_c096_0_14 0 bpf_c096_0 0) vcvs gain=8.314696123025e-01
SMIXI_c096_0_14 (mix_i_src_c096_0_14 mix_i_c096_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_14 (mix_q_src_c096_0_14 0 bpf_c096_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_0_14 (mix_q_src_c096_0_14 mix_q_c096_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_0_15 (mix_i_src_c096_0_15 0 bpf_c096_0 0) vcvs gain=9.807852804032e-01
SMIXI_c096_0_15 (mix_i_src_c096_0_15 mix_i_c096_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_0_15 (mix_q_src_c096_0_15 0 bpf_c096_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_0_15 (mix_q_src_c096_0_15 mix_q_c096_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c096_0 (mix_i_c096_0 0) resistor r=1G
RMIXQ_c096_0 (mix_q_c096_0 0) resistor r=1G
RINTI_c096_0 (mix_i_c096_0 Icar_c096_0) resistor r=1k
CINTI_c096_0 (Icar_c096_0 0) capacitor c=80p
RINTQ_c096_0 (mix_q_c096_0 Qcar_c096_0) resistor r=1k
CINTQ_c096_0 (Qcar_c096_0 0) capacitor c=80p

// bl096, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c096_1 (bl096 n_cbpf_c096_1) capacitor c=1.013211836423e-13
LBPF_c096_1 (n_cbpf_c096_1 bpf_c096_1) inductor l=1.000000000000e-06
RBPF_c096_1 (bpf_c096_1 0) resistor r=1.570796326795e+02
EMIXI_c096_1_00 (mix_i_src_c096_1_00 0 bpf_c096_1 0) vcvs gain=9.807852804032e-01
SMIXI_c096_1_00 (mix_i_src_c096_1_00 mix_i_c096_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_00 (mix_q_src_c096_1_00 0 bpf_c096_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_1_00 (mix_q_src_c096_1_00 mix_q_c096_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_01 (mix_i_src_c096_1_01 0 bpf_c096_1 0) vcvs gain=8.314696123025e-01
SMIXI_c096_1_01 (mix_i_src_c096_1_01 mix_i_c096_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_01 (mix_q_src_c096_1_01 0 bpf_c096_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_1_01 (mix_q_src_c096_1_01 mix_q_c096_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_02 (mix_i_src_c096_1_02 0 bpf_c096_1 0) vcvs gain=5.555702330196e-01
SMIXI_c096_1_02 (mix_i_src_c096_1_02 mix_i_c096_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_02 (mix_q_src_c096_1_02 0 bpf_c096_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_1_02 (mix_q_src_c096_1_02 mix_q_c096_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_03 (mix_i_src_c096_1_03 0 bpf_c096_1 0) vcvs gain=1.950903220161e-01
SMIXI_c096_1_03 (mix_i_src_c096_1_03 mix_i_c096_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_03 (mix_q_src_c096_1_03 0 bpf_c096_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_1_03 (mix_q_src_c096_1_03 mix_q_c096_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_04 (mix_i_src_c096_1_04 0 bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_1_04 (mix_i_src_c096_1_04 mix_i_c096_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_04 (mix_q_src_c096_1_04 0 bpf_c096_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_1_04 (mix_q_src_c096_1_04 mix_q_c096_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_05 (mix_i_src_c096_1_05 0 bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_1_05 (mix_i_src_c096_1_05 mix_i_c096_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_05 (mix_q_src_c096_1_05 0 bpf_c096_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_1_05 (mix_q_src_c096_1_05 mix_q_c096_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_06 (mix_i_src_c096_1_06 0 bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_1_06 (mix_i_src_c096_1_06 mix_i_c096_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_06 (mix_q_src_c096_1_06 0 bpf_c096_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_1_06 (mix_q_src_c096_1_06 mix_q_c096_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_07 (mix_i_src_c096_1_07 0 bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_1_07 (mix_i_src_c096_1_07 mix_i_c096_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_07 (mix_q_src_c096_1_07 0 bpf_c096_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_1_07 (mix_q_src_c096_1_07 mix_q_c096_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_08 (mix_i_src_c096_1_08 0 bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_1_08 (mix_i_src_c096_1_08 mix_i_c096_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_08 (mix_q_src_c096_1_08 0 bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_1_08 (mix_q_src_c096_1_08 mix_q_c096_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_09 (mix_i_src_c096_1_09 0 bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_1_09 (mix_i_src_c096_1_09 mix_i_c096_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_09 (mix_q_src_c096_1_09 0 bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_1_09 (mix_q_src_c096_1_09 mix_q_c096_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_10 (mix_i_src_c096_1_10 0 bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_1_10 (mix_i_src_c096_1_10 mix_i_c096_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_10 (mix_q_src_c096_1_10 0 bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_1_10 (mix_q_src_c096_1_10 mix_q_c096_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_11 (mix_i_src_c096_1_11 0 bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_1_11 (mix_i_src_c096_1_11 mix_i_c096_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_11 (mix_q_src_c096_1_11 0 bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_1_11 (mix_q_src_c096_1_11 mix_q_c096_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_12 (mix_i_src_c096_1_12 0 bpf_c096_1 0) vcvs gain=1.950903220161e-01
SMIXI_c096_1_12 (mix_i_src_c096_1_12 mix_i_c096_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_12 (mix_q_src_c096_1_12 0 bpf_c096_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_1_12 (mix_q_src_c096_1_12 mix_q_c096_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_13 (mix_i_src_c096_1_13 0 bpf_c096_1 0) vcvs gain=5.555702330196e-01
SMIXI_c096_1_13 (mix_i_src_c096_1_13 mix_i_c096_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_13 (mix_q_src_c096_1_13 0 bpf_c096_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_1_13 (mix_q_src_c096_1_13 mix_q_c096_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_14 (mix_i_src_c096_1_14 0 bpf_c096_1 0) vcvs gain=8.314696123025e-01
SMIXI_c096_1_14 (mix_i_src_c096_1_14 mix_i_c096_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_14 (mix_q_src_c096_1_14 0 bpf_c096_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_1_14 (mix_q_src_c096_1_14 mix_q_c096_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_1_15 (mix_i_src_c096_1_15 0 bpf_c096_1 0) vcvs gain=9.807852804032e-01
SMIXI_c096_1_15 (mix_i_src_c096_1_15 mix_i_c096_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_1_15 (mix_q_src_c096_1_15 0 bpf_c096_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_1_15 (mix_q_src_c096_1_15 mix_q_c096_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c096_1 (mix_i_c096_1 0) resistor r=1G
RMIXQ_c096_1 (mix_q_c096_1 0) resistor r=1G
RINTI_c096_1 (mix_i_c096_1 Icar_c096_1) resistor r=1k
CINTI_c096_1 (Icar_c096_1 0) capacitor c=80p
RINTQ_c096_1 (mix_q_c096_1 Qcar_c096_1) resistor r=1k
CINTQ_c096_1 (Qcar_c096_1 0) capacitor c=80p

// bl096, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c096_2 (bl096 n_cbpf_c096_2) capacitor c=4.503163717437e-14
LBPF_c096_2 (n_cbpf_c096_2 bpf_c096_2) inductor l=1.000000000000e-06
RBPF_c096_2 (bpf_c096_2 0) resistor r=2.356194490192e+02
EMIXI_c096_2_00 (mix_i_src_c096_2_00 0 bpf_c096_2 0) vcvs gain=9.807852804032e-01
SMIXI_c096_2_00 (mix_i_src_c096_2_00 mix_i_c096_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_00 (mix_q_src_c096_2_00 0 bpf_c096_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_2_00 (mix_q_src_c096_2_00 mix_q_c096_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_01 (mix_i_src_c096_2_01 0 bpf_c096_2 0) vcvs gain=8.314696123025e-01
SMIXI_c096_2_01 (mix_i_src_c096_2_01 mix_i_c096_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_01 (mix_q_src_c096_2_01 0 bpf_c096_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_2_01 (mix_q_src_c096_2_01 mix_q_c096_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_02 (mix_i_src_c096_2_02 0 bpf_c096_2 0) vcvs gain=5.555702330196e-01
SMIXI_c096_2_02 (mix_i_src_c096_2_02 mix_i_c096_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_02 (mix_q_src_c096_2_02 0 bpf_c096_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_2_02 (mix_q_src_c096_2_02 mix_q_c096_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_03 (mix_i_src_c096_2_03 0 bpf_c096_2 0) vcvs gain=1.950903220161e-01
SMIXI_c096_2_03 (mix_i_src_c096_2_03 mix_i_c096_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_03 (mix_q_src_c096_2_03 0 bpf_c096_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_2_03 (mix_q_src_c096_2_03 mix_q_c096_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_04 (mix_i_src_c096_2_04 0 bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_2_04 (mix_i_src_c096_2_04 mix_i_c096_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_04 (mix_q_src_c096_2_04 0 bpf_c096_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_2_04 (mix_q_src_c096_2_04 mix_q_c096_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_05 (mix_i_src_c096_2_05 0 bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_2_05 (mix_i_src_c096_2_05 mix_i_c096_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_05 (mix_q_src_c096_2_05 0 bpf_c096_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_2_05 (mix_q_src_c096_2_05 mix_q_c096_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_06 (mix_i_src_c096_2_06 0 bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_2_06 (mix_i_src_c096_2_06 mix_i_c096_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_06 (mix_q_src_c096_2_06 0 bpf_c096_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_2_06 (mix_q_src_c096_2_06 mix_q_c096_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_07 (mix_i_src_c096_2_07 0 bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_2_07 (mix_i_src_c096_2_07 mix_i_c096_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_07 (mix_q_src_c096_2_07 0 bpf_c096_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_2_07 (mix_q_src_c096_2_07 mix_q_c096_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_08 (mix_i_src_c096_2_08 0 bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_2_08 (mix_i_src_c096_2_08 mix_i_c096_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_08 (mix_q_src_c096_2_08 0 bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_2_08 (mix_q_src_c096_2_08 mix_q_c096_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_09 (mix_i_src_c096_2_09 0 bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_2_09 (mix_i_src_c096_2_09 mix_i_c096_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_09 (mix_q_src_c096_2_09 0 bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_2_09 (mix_q_src_c096_2_09 mix_q_c096_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_10 (mix_i_src_c096_2_10 0 bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_2_10 (mix_i_src_c096_2_10 mix_i_c096_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_10 (mix_q_src_c096_2_10 0 bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_2_10 (mix_q_src_c096_2_10 mix_q_c096_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_11 (mix_i_src_c096_2_11 0 bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_2_11 (mix_i_src_c096_2_11 mix_i_c096_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_11 (mix_q_src_c096_2_11 0 bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_2_11 (mix_q_src_c096_2_11 mix_q_c096_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_12 (mix_i_src_c096_2_12 0 bpf_c096_2 0) vcvs gain=1.950903220161e-01
SMIXI_c096_2_12 (mix_i_src_c096_2_12 mix_i_c096_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_12 (mix_q_src_c096_2_12 0 bpf_c096_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_2_12 (mix_q_src_c096_2_12 mix_q_c096_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_13 (mix_i_src_c096_2_13 0 bpf_c096_2 0) vcvs gain=5.555702330196e-01
SMIXI_c096_2_13 (mix_i_src_c096_2_13 mix_i_c096_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_13 (mix_q_src_c096_2_13 0 bpf_c096_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_2_13 (mix_q_src_c096_2_13 mix_q_c096_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_14 (mix_i_src_c096_2_14 0 bpf_c096_2 0) vcvs gain=8.314696123025e-01
SMIXI_c096_2_14 (mix_i_src_c096_2_14 mix_i_c096_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_14 (mix_q_src_c096_2_14 0 bpf_c096_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_2_14 (mix_q_src_c096_2_14 mix_q_c096_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_2_15 (mix_i_src_c096_2_15 0 bpf_c096_2 0) vcvs gain=9.807852804032e-01
SMIXI_c096_2_15 (mix_i_src_c096_2_15 mix_i_c096_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_2_15 (mix_q_src_c096_2_15 0 bpf_c096_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_2_15 (mix_q_src_c096_2_15 mix_q_c096_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c096_2 (mix_i_c096_2 0) resistor r=1G
RMIXQ_c096_2 (mix_q_c096_2 0) resistor r=1G
RINTI_c096_2 (mix_i_c096_2 Icar_c096_2) resistor r=1k
CINTI_c096_2 (Icar_c096_2 0) capacitor c=80p
RINTQ_c096_2 (mix_q_c096_2 Qcar_c096_2) resistor r=1k
CINTQ_c096_2 (Qcar_c096_2 0) capacitor c=80p

// bl096, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c096_3 (bl096 n_cbpf_c096_3) capacitor c=2.533029591058e-14
LBPF_c096_3 (n_cbpf_c096_3 bpf_c096_3) inductor l=1.000000000000e-06
RBPF_c096_3 (bpf_c096_3 0) resistor r=3.141592653590e+02
EMIXI_c096_3_00 (mix_i_src_c096_3_00 0 bpf_c096_3 0) vcvs gain=9.807852804032e-01
SMIXI_c096_3_00 (mix_i_src_c096_3_00 mix_i_c096_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_00 (mix_q_src_c096_3_00 0 bpf_c096_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_3_00 (mix_q_src_c096_3_00 mix_q_c096_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_01 (mix_i_src_c096_3_01 0 bpf_c096_3 0) vcvs gain=8.314696123025e-01
SMIXI_c096_3_01 (mix_i_src_c096_3_01 mix_i_c096_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_01 (mix_q_src_c096_3_01 0 bpf_c096_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_3_01 (mix_q_src_c096_3_01 mix_q_c096_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_02 (mix_i_src_c096_3_02 0 bpf_c096_3 0) vcvs gain=5.555702330196e-01
SMIXI_c096_3_02 (mix_i_src_c096_3_02 mix_i_c096_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_02 (mix_q_src_c096_3_02 0 bpf_c096_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_3_02 (mix_q_src_c096_3_02 mix_q_c096_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_03 (mix_i_src_c096_3_03 0 bpf_c096_3 0) vcvs gain=1.950903220161e-01
SMIXI_c096_3_03 (mix_i_src_c096_3_03 mix_i_c096_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_03 (mix_q_src_c096_3_03 0 bpf_c096_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_3_03 (mix_q_src_c096_3_03 mix_q_c096_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_04 (mix_i_src_c096_3_04 0 bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_3_04 (mix_i_src_c096_3_04 mix_i_c096_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_04 (mix_q_src_c096_3_04 0 bpf_c096_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c096_3_04 (mix_q_src_c096_3_04 mix_q_c096_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_05 (mix_i_src_c096_3_05 0 bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_3_05 (mix_i_src_c096_3_05 mix_i_c096_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_05 (mix_q_src_c096_3_05 0 bpf_c096_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c096_3_05 (mix_q_src_c096_3_05 mix_q_c096_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_06 (mix_i_src_c096_3_06 0 bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_3_06 (mix_i_src_c096_3_06 mix_i_c096_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_06 (mix_q_src_c096_3_06 0 bpf_c096_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c096_3_06 (mix_q_src_c096_3_06 mix_q_c096_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_07 (mix_i_src_c096_3_07 0 bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_3_07 (mix_i_src_c096_3_07 mix_i_c096_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_07 (mix_q_src_c096_3_07 0 bpf_c096_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c096_3_07 (mix_q_src_c096_3_07 mix_q_c096_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_08 (mix_i_src_c096_3_08 0 bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c096_3_08 (mix_i_src_c096_3_08 mix_i_c096_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_08 (mix_q_src_c096_3_08 0 bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_3_08 (mix_q_src_c096_3_08 mix_q_c096_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_09 (mix_i_src_c096_3_09 0 bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c096_3_09 (mix_i_src_c096_3_09 mix_i_c096_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_09 (mix_q_src_c096_3_09 0 bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_3_09 (mix_q_src_c096_3_09 mix_q_c096_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_10 (mix_i_src_c096_3_10 0 bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c096_3_10 (mix_i_src_c096_3_10 mix_i_c096_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_10 (mix_q_src_c096_3_10 0 bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_3_10 (mix_q_src_c096_3_10 mix_q_c096_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_11 (mix_i_src_c096_3_11 0 bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c096_3_11 (mix_i_src_c096_3_11 mix_i_c096_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_11 (mix_q_src_c096_3_11 0 bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_3_11 (mix_q_src_c096_3_11 mix_q_c096_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_12 (mix_i_src_c096_3_12 0 bpf_c096_3 0) vcvs gain=1.950903220161e-01
SMIXI_c096_3_12 (mix_i_src_c096_3_12 mix_i_c096_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_12 (mix_q_src_c096_3_12 0 bpf_c096_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c096_3_12 (mix_q_src_c096_3_12 mix_q_c096_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_13 (mix_i_src_c096_3_13 0 bpf_c096_3 0) vcvs gain=5.555702330196e-01
SMIXI_c096_3_13 (mix_i_src_c096_3_13 mix_i_c096_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_13 (mix_q_src_c096_3_13 0 bpf_c096_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c096_3_13 (mix_q_src_c096_3_13 mix_q_c096_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_14 (mix_i_src_c096_3_14 0 bpf_c096_3 0) vcvs gain=8.314696123025e-01
SMIXI_c096_3_14 (mix_i_src_c096_3_14 mix_i_c096_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_14 (mix_q_src_c096_3_14 0 bpf_c096_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c096_3_14 (mix_q_src_c096_3_14 mix_q_c096_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c096_3_15 (mix_i_src_c096_3_15 0 bpf_c096_3 0) vcvs gain=9.807852804032e-01
SMIXI_c096_3_15 (mix_i_src_c096_3_15 mix_i_c096_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c096_3_15 (mix_q_src_c096_3_15 0 bpf_c096_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c096_3_15 (mix_q_src_c096_3_15 mix_q_c096_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c096_3 (mix_i_c096_3 0) resistor r=1G
RMIXQ_c096_3 (mix_q_c096_3 0) resistor r=1G
RINTI_c096_3 (mix_i_c096_3 Icar_c096_3) resistor r=1k
CINTI_c096_3 (Icar_c096_3 0) capacitor c=80p
RINTQ_c096_3 (mix_q_c096_3 Qcar_c096_3) resistor r=1k
CINTQ_c096_3 (Qcar_c096_3 0) capacitor c=80p

// bl097, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c097_0 (bl097 n_cbpf_c097_0) capacitor c=4.052847345694e-13
LBPF_c097_0 (n_cbpf_c097_0 bpf_c097_0) inductor l=1.000000000000e-06
RBPF_c097_0 (bpf_c097_0 0) resistor r=7.853981633974e+01
EMIXI_c097_0_00 (mix_i_src_c097_0_00 0 bpf_c097_0 0) vcvs gain=9.807852804032e-01
SMIXI_c097_0_00 (mix_i_src_c097_0_00 mix_i_c097_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_00 (mix_q_src_c097_0_00 0 bpf_c097_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_0_00 (mix_q_src_c097_0_00 mix_q_c097_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_01 (mix_i_src_c097_0_01 0 bpf_c097_0 0) vcvs gain=8.314696123025e-01
SMIXI_c097_0_01 (mix_i_src_c097_0_01 mix_i_c097_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_01 (mix_q_src_c097_0_01 0 bpf_c097_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_0_01 (mix_q_src_c097_0_01 mix_q_c097_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_02 (mix_i_src_c097_0_02 0 bpf_c097_0 0) vcvs gain=5.555702330196e-01
SMIXI_c097_0_02 (mix_i_src_c097_0_02 mix_i_c097_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_02 (mix_q_src_c097_0_02 0 bpf_c097_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_0_02 (mix_q_src_c097_0_02 mix_q_c097_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_03 (mix_i_src_c097_0_03 0 bpf_c097_0 0) vcvs gain=1.950903220161e-01
SMIXI_c097_0_03 (mix_i_src_c097_0_03 mix_i_c097_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_03 (mix_q_src_c097_0_03 0 bpf_c097_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_0_03 (mix_q_src_c097_0_03 mix_q_c097_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_04 (mix_i_src_c097_0_04 0 bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_0_04 (mix_i_src_c097_0_04 mix_i_c097_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_04 (mix_q_src_c097_0_04 0 bpf_c097_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_0_04 (mix_q_src_c097_0_04 mix_q_c097_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_05 (mix_i_src_c097_0_05 0 bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_0_05 (mix_i_src_c097_0_05 mix_i_c097_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_05 (mix_q_src_c097_0_05 0 bpf_c097_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_0_05 (mix_q_src_c097_0_05 mix_q_c097_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_06 (mix_i_src_c097_0_06 0 bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_0_06 (mix_i_src_c097_0_06 mix_i_c097_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_06 (mix_q_src_c097_0_06 0 bpf_c097_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_0_06 (mix_q_src_c097_0_06 mix_q_c097_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_07 (mix_i_src_c097_0_07 0 bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_0_07 (mix_i_src_c097_0_07 mix_i_c097_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_07 (mix_q_src_c097_0_07 0 bpf_c097_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_0_07 (mix_q_src_c097_0_07 mix_q_c097_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_08 (mix_i_src_c097_0_08 0 bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_0_08 (mix_i_src_c097_0_08 mix_i_c097_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_08 (mix_q_src_c097_0_08 0 bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_0_08 (mix_q_src_c097_0_08 mix_q_c097_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_09 (mix_i_src_c097_0_09 0 bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_0_09 (mix_i_src_c097_0_09 mix_i_c097_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_09 (mix_q_src_c097_0_09 0 bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_0_09 (mix_q_src_c097_0_09 mix_q_c097_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_10 (mix_i_src_c097_0_10 0 bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_0_10 (mix_i_src_c097_0_10 mix_i_c097_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_10 (mix_q_src_c097_0_10 0 bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_0_10 (mix_q_src_c097_0_10 mix_q_c097_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_11 (mix_i_src_c097_0_11 0 bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_0_11 (mix_i_src_c097_0_11 mix_i_c097_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_11 (mix_q_src_c097_0_11 0 bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_0_11 (mix_q_src_c097_0_11 mix_q_c097_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_12 (mix_i_src_c097_0_12 0 bpf_c097_0 0) vcvs gain=1.950903220161e-01
SMIXI_c097_0_12 (mix_i_src_c097_0_12 mix_i_c097_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_12 (mix_q_src_c097_0_12 0 bpf_c097_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_0_12 (mix_q_src_c097_0_12 mix_q_c097_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_13 (mix_i_src_c097_0_13 0 bpf_c097_0 0) vcvs gain=5.555702330196e-01
SMIXI_c097_0_13 (mix_i_src_c097_0_13 mix_i_c097_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_13 (mix_q_src_c097_0_13 0 bpf_c097_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_0_13 (mix_q_src_c097_0_13 mix_q_c097_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_14 (mix_i_src_c097_0_14 0 bpf_c097_0 0) vcvs gain=8.314696123025e-01
SMIXI_c097_0_14 (mix_i_src_c097_0_14 mix_i_c097_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_14 (mix_q_src_c097_0_14 0 bpf_c097_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_0_14 (mix_q_src_c097_0_14 mix_q_c097_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_0_15 (mix_i_src_c097_0_15 0 bpf_c097_0 0) vcvs gain=9.807852804032e-01
SMIXI_c097_0_15 (mix_i_src_c097_0_15 mix_i_c097_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_0_15 (mix_q_src_c097_0_15 0 bpf_c097_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_0_15 (mix_q_src_c097_0_15 mix_q_c097_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c097_0 (mix_i_c097_0 0) resistor r=1G
RMIXQ_c097_0 (mix_q_c097_0 0) resistor r=1G
RINTI_c097_0 (mix_i_c097_0 Icar_c097_0) resistor r=1k
CINTI_c097_0 (Icar_c097_0 0) capacitor c=80p
RINTQ_c097_0 (mix_q_c097_0 Qcar_c097_0) resistor r=1k
CINTQ_c097_0 (Qcar_c097_0 0) capacitor c=80p

// bl097, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c097_1 (bl097 n_cbpf_c097_1) capacitor c=1.013211836423e-13
LBPF_c097_1 (n_cbpf_c097_1 bpf_c097_1) inductor l=1.000000000000e-06
RBPF_c097_1 (bpf_c097_1 0) resistor r=1.570796326795e+02
EMIXI_c097_1_00 (mix_i_src_c097_1_00 0 bpf_c097_1 0) vcvs gain=9.807852804032e-01
SMIXI_c097_1_00 (mix_i_src_c097_1_00 mix_i_c097_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_00 (mix_q_src_c097_1_00 0 bpf_c097_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_1_00 (mix_q_src_c097_1_00 mix_q_c097_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_01 (mix_i_src_c097_1_01 0 bpf_c097_1 0) vcvs gain=8.314696123025e-01
SMIXI_c097_1_01 (mix_i_src_c097_1_01 mix_i_c097_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_01 (mix_q_src_c097_1_01 0 bpf_c097_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_1_01 (mix_q_src_c097_1_01 mix_q_c097_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_02 (mix_i_src_c097_1_02 0 bpf_c097_1 0) vcvs gain=5.555702330196e-01
SMIXI_c097_1_02 (mix_i_src_c097_1_02 mix_i_c097_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_02 (mix_q_src_c097_1_02 0 bpf_c097_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_1_02 (mix_q_src_c097_1_02 mix_q_c097_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_03 (mix_i_src_c097_1_03 0 bpf_c097_1 0) vcvs gain=1.950903220161e-01
SMIXI_c097_1_03 (mix_i_src_c097_1_03 mix_i_c097_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_03 (mix_q_src_c097_1_03 0 bpf_c097_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_1_03 (mix_q_src_c097_1_03 mix_q_c097_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_04 (mix_i_src_c097_1_04 0 bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_1_04 (mix_i_src_c097_1_04 mix_i_c097_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_04 (mix_q_src_c097_1_04 0 bpf_c097_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_1_04 (mix_q_src_c097_1_04 mix_q_c097_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_05 (mix_i_src_c097_1_05 0 bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_1_05 (mix_i_src_c097_1_05 mix_i_c097_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_05 (mix_q_src_c097_1_05 0 bpf_c097_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_1_05 (mix_q_src_c097_1_05 mix_q_c097_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_06 (mix_i_src_c097_1_06 0 bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_1_06 (mix_i_src_c097_1_06 mix_i_c097_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_06 (mix_q_src_c097_1_06 0 bpf_c097_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_1_06 (mix_q_src_c097_1_06 mix_q_c097_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_07 (mix_i_src_c097_1_07 0 bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_1_07 (mix_i_src_c097_1_07 mix_i_c097_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_07 (mix_q_src_c097_1_07 0 bpf_c097_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_1_07 (mix_q_src_c097_1_07 mix_q_c097_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_08 (mix_i_src_c097_1_08 0 bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_1_08 (mix_i_src_c097_1_08 mix_i_c097_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_08 (mix_q_src_c097_1_08 0 bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_1_08 (mix_q_src_c097_1_08 mix_q_c097_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_09 (mix_i_src_c097_1_09 0 bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_1_09 (mix_i_src_c097_1_09 mix_i_c097_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_09 (mix_q_src_c097_1_09 0 bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_1_09 (mix_q_src_c097_1_09 mix_q_c097_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_10 (mix_i_src_c097_1_10 0 bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_1_10 (mix_i_src_c097_1_10 mix_i_c097_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_10 (mix_q_src_c097_1_10 0 bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_1_10 (mix_q_src_c097_1_10 mix_q_c097_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_11 (mix_i_src_c097_1_11 0 bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_1_11 (mix_i_src_c097_1_11 mix_i_c097_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_11 (mix_q_src_c097_1_11 0 bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_1_11 (mix_q_src_c097_1_11 mix_q_c097_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_12 (mix_i_src_c097_1_12 0 bpf_c097_1 0) vcvs gain=1.950903220161e-01
SMIXI_c097_1_12 (mix_i_src_c097_1_12 mix_i_c097_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_12 (mix_q_src_c097_1_12 0 bpf_c097_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_1_12 (mix_q_src_c097_1_12 mix_q_c097_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_13 (mix_i_src_c097_1_13 0 bpf_c097_1 0) vcvs gain=5.555702330196e-01
SMIXI_c097_1_13 (mix_i_src_c097_1_13 mix_i_c097_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_13 (mix_q_src_c097_1_13 0 bpf_c097_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_1_13 (mix_q_src_c097_1_13 mix_q_c097_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_14 (mix_i_src_c097_1_14 0 bpf_c097_1 0) vcvs gain=8.314696123025e-01
SMIXI_c097_1_14 (mix_i_src_c097_1_14 mix_i_c097_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_14 (mix_q_src_c097_1_14 0 bpf_c097_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_1_14 (mix_q_src_c097_1_14 mix_q_c097_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_1_15 (mix_i_src_c097_1_15 0 bpf_c097_1 0) vcvs gain=9.807852804032e-01
SMIXI_c097_1_15 (mix_i_src_c097_1_15 mix_i_c097_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_1_15 (mix_q_src_c097_1_15 0 bpf_c097_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_1_15 (mix_q_src_c097_1_15 mix_q_c097_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c097_1 (mix_i_c097_1 0) resistor r=1G
RMIXQ_c097_1 (mix_q_c097_1 0) resistor r=1G
RINTI_c097_1 (mix_i_c097_1 Icar_c097_1) resistor r=1k
CINTI_c097_1 (Icar_c097_1 0) capacitor c=80p
RINTQ_c097_1 (mix_q_c097_1 Qcar_c097_1) resistor r=1k
CINTQ_c097_1 (Qcar_c097_1 0) capacitor c=80p

// bl097, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c097_2 (bl097 n_cbpf_c097_2) capacitor c=4.503163717437e-14
LBPF_c097_2 (n_cbpf_c097_2 bpf_c097_2) inductor l=1.000000000000e-06
RBPF_c097_2 (bpf_c097_2 0) resistor r=2.356194490192e+02
EMIXI_c097_2_00 (mix_i_src_c097_2_00 0 bpf_c097_2 0) vcvs gain=9.807852804032e-01
SMIXI_c097_2_00 (mix_i_src_c097_2_00 mix_i_c097_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_00 (mix_q_src_c097_2_00 0 bpf_c097_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_2_00 (mix_q_src_c097_2_00 mix_q_c097_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_01 (mix_i_src_c097_2_01 0 bpf_c097_2 0) vcvs gain=8.314696123025e-01
SMIXI_c097_2_01 (mix_i_src_c097_2_01 mix_i_c097_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_01 (mix_q_src_c097_2_01 0 bpf_c097_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_2_01 (mix_q_src_c097_2_01 mix_q_c097_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_02 (mix_i_src_c097_2_02 0 bpf_c097_2 0) vcvs gain=5.555702330196e-01
SMIXI_c097_2_02 (mix_i_src_c097_2_02 mix_i_c097_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_02 (mix_q_src_c097_2_02 0 bpf_c097_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_2_02 (mix_q_src_c097_2_02 mix_q_c097_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_03 (mix_i_src_c097_2_03 0 bpf_c097_2 0) vcvs gain=1.950903220161e-01
SMIXI_c097_2_03 (mix_i_src_c097_2_03 mix_i_c097_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_03 (mix_q_src_c097_2_03 0 bpf_c097_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_2_03 (mix_q_src_c097_2_03 mix_q_c097_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_04 (mix_i_src_c097_2_04 0 bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_2_04 (mix_i_src_c097_2_04 mix_i_c097_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_04 (mix_q_src_c097_2_04 0 bpf_c097_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_2_04 (mix_q_src_c097_2_04 mix_q_c097_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_05 (mix_i_src_c097_2_05 0 bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_2_05 (mix_i_src_c097_2_05 mix_i_c097_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_05 (mix_q_src_c097_2_05 0 bpf_c097_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_2_05 (mix_q_src_c097_2_05 mix_q_c097_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_06 (mix_i_src_c097_2_06 0 bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_2_06 (mix_i_src_c097_2_06 mix_i_c097_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_06 (mix_q_src_c097_2_06 0 bpf_c097_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_2_06 (mix_q_src_c097_2_06 mix_q_c097_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_07 (mix_i_src_c097_2_07 0 bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_2_07 (mix_i_src_c097_2_07 mix_i_c097_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_07 (mix_q_src_c097_2_07 0 bpf_c097_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_2_07 (mix_q_src_c097_2_07 mix_q_c097_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_08 (mix_i_src_c097_2_08 0 bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_2_08 (mix_i_src_c097_2_08 mix_i_c097_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_08 (mix_q_src_c097_2_08 0 bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_2_08 (mix_q_src_c097_2_08 mix_q_c097_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_09 (mix_i_src_c097_2_09 0 bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_2_09 (mix_i_src_c097_2_09 mix_i_c097_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_09 (mix_q_src_c097_2_09 0 bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_2_09 (mix_q_src_c097_2_09 mix_q_c097_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_10 (mix_i_src_c097_2_10 0 bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_2_10 (mix_i_src_c097_2_10 mix_i_c097_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_10 (mix_q_src_c097_2_10 0 bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_2_10 (mix_q_src_c097_2_10 mix_q_c097_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_11 (mix_i_src_c097_2_11 0 bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_2_11 (mix_i_src_c097_2_11 mix_i_c097_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_11 (mix_q_src_c097_2_11 0 bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_2_11 (mix_q_src_c097_2_11 mix_q_c097_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_12 (mix_i_src_c097_2_12 0 bpf_c097_2 0) vcvs gain=1.950903220161e-01
SMIXI_c097_2_12 (mix_i_src_c097_2_12 mix_i_c097_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_12 (mix_q_src_c097_2_12 0 bpf_c097_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_2_12 (mix_q_src_c097_2_12 mix_q_c097_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_13 (mix_i_src_c097_2_13 0 bpf_c097_2 0) vcvs gain=5.555702330196e-01
SMIXI_c097_2_13 (mix_i_src_c097_2_13 mix_i_c097_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_13 (mix_q_src_c097_2_13 0 bpf_c097_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_2_13 (mix_q_src_c097_2_13 mix_q_c097_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_14 (mix_i_src_c097_2_14 0 bpf_c097_2 0) vcvs gain=8.314696123025e-01
SMIXI_c097_2_14 (mix_i_src_c097_2_14 mix_i_c097_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_14 (mix_q_src_c097_2_14 0 bpf_c097_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_2_14 (mix_q_src_c097_2_14 mix_q_c097_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_2_15 (mix_i_src_c097_2_15 0 bpf_c097_2 0) vcvs gain=9.807852804032e-01
SMIXI_c097_2_15 (mix_i_src_c097_2_15 mix_i_c097_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_2_15 (mix_q_src_c097_2_15 0 bpf_c097_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_2_15 (mix_q_src_c097_2_15 mix_q_c097_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c097_2 (mix_i_c097_2 0) resistor r=1G
RMIXQ_c097_2 (mix_q_c097_2 0) resistor r=1G
RINTI_c097_2 (mix_i_c097_2 Icar_c097_2) resistor r=1k
CINTI_c097_2 (Icar_c097_2 0) capacitor c=80p
RINTQ_c097_2 (mix_q_c097_2 Qcar_c097_2) resistor r=1k
CINTQ_c097_2 (Qcar_c097_2 0) capacitor c=80p

// bl097, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c097_3 (bl097 n_cbpf_c097_3) capacitor c=2.533029591058e-14
LBPF_c097_3 (n_cbpf_c097_3 bpf_c097_3) inductor l=1.000000000000e-06
RBPF_c097_3 (bpf_c097_3 0) resistor r=3.141592653590e+02
EMIXI_c097_3_00 (mix_i_src_c097_3_00 0 bpf_c097_3 0) vcvs gain=9.807852804032e-01
SMIXI_c097_3_00 (mix_i_src_c097_3_00 mix_i_c097_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_00 (mix_q_src_c097_3_00 0 bpf_c097_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_3_00 (mix_q_src_c097_3_00 mix_q_c097_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_01 (mix_i_src_c097_3_01 0 bpf_c097_3 0) vcvs gain=8.314696123025e-01
SMIXI_c097_3_01 (mix_i_src_c097_3_01 mix_i_c097_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_01 (mix_q_src_c097_3_01 0 bpf_c097_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_3_01 (mix_q_src_c097_3_01 mix_q_c097_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_02 (mix_i_src_c097_3_02 0 bpf_c097_3 0) vcvs gain=5.555702330196e-01
SMIXI_c097_3_02 (mix_i_src_c097_3_02 mix_i_c097_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_02 (mix_q_src_c097_3_02 0 bpf_c097_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_3_02 (mix_q_src_c097_3_02 mix_q_c097_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_03 (mix_i_src_c097_3_03 0 bpf_c097_3 0) vcvs gain=1.950903220161e-01
SMIXI_c097_3_03 (mix_i_src_c097_3_03 mix_i_c097_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_03 (mix_q_src_c097_3_03 0 bpf_c097_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_3_03 (mix_q_src_c097_3_03 mix_q_c097_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_04 (mix_i_src_c097_3_04 0 bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_3_04 (mix_i_src_c097_3_04 mix_i_c097_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_04 (mix_q_src_c097_3_04 0 bpf_c097_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c097_3_04 (mix_q_src_c097_3_04 mix_q_c097_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_05 (mix_i_src_c097_3_05 0 bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_3_05 (mix_i_src_c097_3_05 mix_i_c097_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_05 (mix_q_src_c097_3_05 0 bpf_c097_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c097_3_05 (mix_q_src_c097_3_05 mix_q_c097_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_06 (mix_i_src_c097_3_06 0 bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_3_06 (mix_i_src_c097_3_06 mix_i_c097_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_06 (mix_q_src_c097_3_06 0 bpf_c097_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c097_3_06 (mix_q_src_c097_3_06 mix_q_c097_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_07 (mix_i_src_c097_3_07 0 bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_3_07 (mix_i_src_c097_3_07 mix_i_c097_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_07 (mix_q_src_c097_3_07 0 bpf_c097_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c097_3_07 (mix_q_src_c097_3_07 mix_q_c097_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_08 (mix_i_src_c097_3_08 0 bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c097_3_08 (mix_i_src_c097_3_08 mix_i_c097_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_08 (mix_q_src_c097_3_08 0 bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_3_08 (mix_q_src_c097_3_08 mix_q_c097_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_09 (mix_i_src_c097_3_09 0 bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c097_3_09 (mix_i_src_c097_3_09 mix_i_c097_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_09 (mix_q_src_c097_3_09 0 bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_3_09 (mix_q_src_c097_3_09 mix_q_c097_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_10 (mix_i_src_c097_3_10 0 bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c097_3_10 (mix_i_src_c097_3_10 mix_i_c097_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_10 (mix_q_src_c097_3_10 0 bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_3_10 (mix_q_src_c097_3_10 mix_q_c097_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_11 (mix_i_src_c097_3_11 0 bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c097_3_11 (mix_i_src_c097_3_11 mix_i_c097_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_11 (mix_q_src_c097_3_11 0 bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_3_11 (mix_q_src_c097_3_11 mix_q_c097_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_12 (mix_i_src_c097_3_12 0 bpf_c097_3 0) vcvs gain=1.950903220161e-01
SMIXI_c097_3_12 (mix_i_src_c097_3_12 mix_i_c097_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_12 (mix_q_src_c097_3_12 0 bpf_c097_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c097_3_12 (mix_q_src_c097_3_12 mix_q_c097_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_13 (mix_i_src_c097_3_13 0 bpf_c097_3 0) vcvs gain=5.555702330196e-01
SMIXI_c097_3_13 (mix_i_src_c097_3_13 mix_i_c097_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_13 (mix_q_src_c097_3_13 0 bpf_c097_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c097_3_13 (mix_q_src_c097_3_13 mix_q_c097_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_14 (mix_i_src_c097_3_14 0 bpf_c097_3 0) vcvs gain=8.314696123025e-01
SMIXI_c097_3_14 (mix_i_src_c097_3_14 mix_i_c097_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_14 (mix_q_src_c097_3_14 0 bpf_c097_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c097_3_14 (mix_q_src_c097_3_14 mix_q_c097_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c097_3_15 (mix_i_src_c097_3_15 0 bpf_c097_3 0) vcvs gain=9.807852804032e-01
SMIXI_c097_3_15 (mix_i_src_c097_3_15 mix_i_c097_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c097_3_15 (mix_q_src_c097_3_15 0 bpf_c097_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c097_3_15 (mix_q_src_c097_3_15 mix_q_c097_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c097_3 (mix_i_c097_3 0) resistor r=1G
RMIXQ_c097_3 (mix_q_c097_3 0) resistor r=1G
RINTI_c097_3 (mix_i_c097_3 Icar_c097_3) resistor r=1k
CINTI_c097_3 (Icar_c097_3 0) capacitor c=80p
RINTQ_c097_3 (mix_q_c097_3 Qcar_c097_3) resistor r=1k
CINTQ_c097_3 (Qcar_c097_3 0) capacitor c=80p

// bl098, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c098_0 (bl098 n_cbpf_c098_0) capacitor c=4.052847345694e-13
LBPF_c098_0 (n_cbpf_c098_0 bpf_c098_0) inductor l=1.000000000000e-06
RBPF_c098_0 (bpf_c098_0 0) resistor r=7.853981633974e+01
EMIXI_c098_0_00 (mix_i_src_c098_0_00 0 bpf_c098_0 0) vcvs gain=9.807852804032e-01
SMIXI_c098_0_00 (mix_i_src_c098_0_00 mix_i_c098_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_00 (mix_q_src_c098_0_00 0 bpf_c098_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_0_00 (mix_q_src_c098_0_00 mix_q_c098_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_01 (mix_i_src_c098_0_01 0 bpf_c098_0 0) vcvs gain=8.314696123025e-01
SMIXI_c098_0_01 (mix_i_src_c098_0_01 mix_i_c098_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_01 (mix_q_src_c098_0_01 0 bpf_c098_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_0_01 (mix_q_src_c098_0_01 mix_q_c098_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_02 (mix_i_src_c098_0_02 0 bpf_c098_0 0) vcvs gain=5.555702330196e-01
SMIXI_c098_0_02 (mix_i_src_c098_0_02 mix_i_c098_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_02 (mix_q_src_c098_0_02 0 bpf_c098_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_0_02 (mix_q_src_c098_0_02 mix_q_c098_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_03 (mix_i_src_c098_0_03 0 bpf_c098_0 0) vcvs gain=1.950903220161e-01
SMIXI_c098_0_03 (mix_i_src_c098_0_03 mix_i_c098_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_03 (mix_q_src_c098_0_03 0 bpf_c098_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_0_03 (mix_q_src_c098_0_03 mix_q_c098_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_04 (mix_i_src_c098_0_04 0 bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_0_04 (mix_i_src_c098_0_04 mix_i_c098_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_04 (mix_q_src_c098_0_04 0 bpf_c098_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_0_04 (mix_q_src_c098_0_04 mix_q_c098_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_05 (mix_i_src_c098_0_05 0 bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_0_05 (mix_i_src_c098_0_05 mix_i_c098_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_05 (mix_q_src_c098_0_05 0 bpf_c098_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_0_05 (mix_q_src_c098_0_05 mix_q_c098_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_06 (mix_i_src_c098_0_06 0 bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_0_06 (mix_i_src_c098_0_06 mix_i_c098_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_06 (mix_q_src_c098_0_06 0 bpf_c098_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_0_06 (mix_q_src_c098_0_06 mix_q_c098_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_07 (mix_i_src_c098_0_07 0 bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_0_07 (mix_i_src_c098_0_07 mix_i_c098_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_07 (mix_q_src_c098_0_07 0 bpf_c098_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_0_07 (mix_q_src_c098_0_07 mix_q_c098_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_08 (mix_i_src_c098_0_08 0 bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_0_08 (mix_i_src_c098_0_08 mix_i_c098_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_08 (mix_q_src_c098_0_08 0 bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_0_08 (mix_q_src_c098_0_08 mix_q_c098_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_09 (mix_i_src_c098_0_09 0 bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_0_09 (mix_i_src_c098_0_09 mix_i_c098_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_09 (mix_q_src_c098_0_09 0 bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_0_09 (mix_q_src_c098_0_09 mix_q_c098_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_10 (mix_i_src_c098_0_10 0 bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_0_10 (mix_i_src_c098_0_10 mix_i_c098_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_10 (mix_q_src_c098_0_10 0 bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_0_10 (mix_q_src_c098_0_10 mix_q_c098_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_11 (mix_i_src_c098_0_11 0 bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_0_11 (mix_i_src_c098_0_11 mix_i_c098_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_11 (mix_q_src_c098_0_11 0 bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_0_11 (mix_q_src_c098_0_11 mix_q_c098_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_12 (mix_i_src_c098_0_12 0 bpf_c098_0 0) vcvs gain=1.950903220161e-01
SMIXI_c098_0_12 (mix_i_src_c098_0_12 mix_i_c098_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_12 (mix_q_src_c098_0_12 0 bpf_c098_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_0_12 (mix_q_src_c098_0_12 mix_q_c098_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_13 (mix_i_src_c098_0_13 0 bpf_c098_0 0) vcvs gain=5.555702330196e-01
SMIXI_c098_0_13 (mix_i_src_c098_0_13 mix_i_c098_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_13 (mix_q_src_c098_0_13 0 bpf_c098_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_0_13 (mix_q_src_c098_0_13 mix_q_c098_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_14 (mix_i_src_c098_0_14 0 bpf_c098_0 0) vcvs gain=8.314696123025e-01
SMIXI_c098_0_14 (mix_i_src_c098_0_14 mix_i_c098_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_14 (mix_q_src_c098_0_14 0 bpf_c098_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_0_14 (mix_q_src_c098_0_14 mix_q_c098_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_0_15 (mix_i_src_c098_0_15 0 bpf_c098_0 0) vcvs gain=9.807852804032e-01
SMIXI_c098_0_15 (mix_i_src_c098_0_15 mix_i_c098_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_0_15 (mix_q_src_c098_0_15 0 bpf_c098_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_0_15 (mix_q_src_c098_0_15 mix_q_c098_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c098_0 (mix_i_c098_0 0) resistor r=1G
RMIXQ_c098_0 (mix_q_c098_0 0) resistor r=1G
RINTI_c098_0 (mix_i_c098_0 Icar_c098_0) resistor r=1k
CINTI_c098_0 (Icar_c098_0 0) capacitor c=80p
RINTQ_c098_0 (mix_q_c098_0 Qcar_c098_0) resistor r=1k
CINTQ_c098_0 (Qcar_c098_0 0) capacitor c=80p

// bl098, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c098_1 (bl098 n_cbpf_c098_1) capacitor c=1.013211836423e-13
LBPF_c098_1 (n_cbpf_c098_1 bpf_c098_1) inductor l=1.000000000000e-06
RBPF_c098_1 (bpf_c098_1 0) resistor r=1.570796326795e+02
EMIXI_c098_1_00 (mix_i_src_c098_1_00 0 bpf_c098_1 0) vcvs gain=9.807852804032e-01
SMIXI_c098_1_00 (mix_i_src_c098_1_00 mix_i_c098_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_00 (mix_q_src_c098_1_00 0 bpf_c098_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_1_00 (mix_q_src_c098_1_00 mix_q_c098_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_01 (mix_i_src_c098_1_01 0 bpf_c098_1 0) vcvs gain=8.314696123025e-01
SMIXI_c098_1_01 (mix_i_src_c098_1_01 mix_i_c098_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_01 (mix_q_src_c098_1_01 0 bpf_c098_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_1_01 (mix_q_src_c098_1_01 mix_q_c098_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_02 (mix_i_src_c098_1_02 0 bpf_c098_1 0) vcvs gain=5.555702330196e-01
SMIXI_c098_1_02 (mix_i_src_c098_1_02 mix_i_c098_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_02 (mix_q_src_c098_1_02 0 bpf_c098_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_1_02 (mix_q_src_c098_1_02 mix_q_c098_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_03 (mix_i_src_c098_1_03 0 bpf_c098_1 0) vcvs gain=1.950903220161e-01
SMIXI_c098_1_03 (mix_i_src_c098_1_03 mix_i_c098_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_03 (mix_q_src_c098_1_03 0 bpf_c098_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_1_03 (mix_q_src_c098_1_03 mix_q_c098_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_04 (mix_i_src_c098_1_04 0 bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_1_04 (mix_i_src_c098_1_04 mix_i_c098_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_04 (mix_q_src_c098_1_04 0 bpf_c098_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_1_04 (mix_q_src_c098_1_04 mix_q_c098_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_05 (mix_i_src_c098_1_05 0 bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_1_05 (mix_i_src_c098_1_05 mix_i_c098_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_05 (mix_q_src_c098_1_05 0 bpf_c098_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_1_05 (mix_q_src_c098_1_05 mix_q_c098_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_06 (mix_i_src_c098_1_06 0 bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_1_06 (mix_i_src_c098_1_06 mix_i_c098_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_06 (mix_q_src_c098_1_06 0 bpf_c098_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_1_06 (mix_q_src_c098_1_06 mix_q_c098_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_07 (mix_i_src_c098_1_07 0 bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_1_07 (mix_i_src_c098_1_07 mix_i_c098_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_07 (mix_q_src_c098_1_07 0 bpf_c098_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_1_07 (mix_q_src_c098_1_07 mix_q_c098_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_08 (mix_i_src_c098_1_08 0 bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_1_08 (mix_i_src_c098_1_08 mix_i_c098_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_08 (mix_q_src_c098_1_08 0 bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_1_08 (mix_q_src_c098_1_08 mix_q_c098_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_09 (mix_i_src_c098_1_09 0 bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_1_09 (mix_i_src_c098_1_09 mix_i_c098_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_09 (mix_q_src_c098_1_09 0 bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_1_09 (mix_q_src_c098_1_09 mix_q_c098_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_10 (mix_i_src_c098_1_10 0 bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_1_10 (mix_i_src_c098_1_10 mix_i_c098_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_10 (mix_q_src_c098_1_10 0 bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_1_10 (mix_q_src_c098_1_10 mix_q_c098_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_11 (mix_i_src_c098_1_11 0 bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_1_11 (mix_i_src_c098_1_11 mix_i_c098_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_11 (mix_q_src_c098_1_11 0 bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_1_11 (mix_q_src_c098_1_11 mix_q_c098_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_12 (mix_i_src_c098_1_12 0 bpf_c098_1 0) vcvs gain=1.950903220161e-01
SMIXI_c098_1_12 (mix_i_src_c098_1_12 mix_i_c098_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_12 (mix_q_src_c098_1_12 0 bpf_c098_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_1_12 (mix_q_src_c098_1_12 mix_q_c098_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_13 (mix_i_src_c098_1_13 0 bpf_c098_1 0) vcvs gain=5.555702330196e-01
SMIXI_c098_1_13 (mix_i_src_c098_1_13 mix_i_c098_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_13 (mix_q_src_c098_1_13 0 bpf_c098_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_1_13 (mix_q_src_c098_1_13 mix_q_c098_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_14 (mix_i_src_c098_1_14 0 bpf_c098_1 0) vcvs gain=8.314696123025e-01
SMIXI_c098_1_14 (mix_i_src_c098_1_14 mix_i_c098_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_14 (mix_q_src_c098_1_14 0 bpf_c098_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_1_14 (mix_q_src_c098_1_14 mix_q_c098_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_1_15 (mix_i_src_c098_1_15 0 bpf_c098_1 0) vcvs gain=9.807852804032e-01
SMIXI_c098_1_15 (mix_i_src_c098_1_15 mix_i_c098_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_1_15 (mix_q_src_c098_1_15 0 bpf_c098_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_1_15 (mix_q_src_c098_1_15 mix_q_c098_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c098_1 (mix_i_c098_1 0) resistor r=1G
RMIXQ_c098_1 (mix_q_c098_1 0) resistor r=1G
RINTI_c098_1 (mix_i_c098_1 Icar_c098_1) resistor r=1k
CINTI_c098_1 (Icar_c098_1 0) capacitor c=80p
RINTQ_c098_1 (mix_q_c098_1 Qcar_c098_1) resistor r=1k
CINTQ_c098_1 (Qcar_c098_1 0) capacitor c=80p

// bl098, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c098_2 (bl098 n_cbpf_c098_2) capacitor c=4.503163717437e-14
LBPF_c098_2 (n_cbpf_c098_2 bpf_c098_2) inductor l=1.000000000000e-06
RBPF_c098_2 (bpf_c098_2 0) resistor r=2.356194490192e+02
EMIXI_c098_2_00 (mix_i_src_c098_2_00 0 bpf_c098_2 0) vcvs gain=9.807852804032e-01
SMIXI_c098_2_00 (mix_i_src_c098_2_00 mix_i_c098_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_00 (mix_q_src_c098_2_00 0 bpf_c098_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_2_00 (mix_q_src_c098_2_00 mix_q_c098_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_01 (mix_i_src_c098_2_01 0 bpf_c098_2 0) vcvs gain=8.314696123025e-01
SMIXI_c098_2_01 (mix_i_src_c098_2_01 mix_i_c098_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_01 (mix_q_src_c098_2_01 0 bpf_c098_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_2_01 (mix_q_src_c098_2_01 mix_q_c098_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_02 (mix_i_src_c098_2_02 0 bpf_c098_2 0) vcvs gain=5.555702330196e-01
SMIXI_c098_2_02 (mix_i_src_c098_2_02 mix_i_c098_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_02 (mix_q_src_c098_2_02 0 bpf_c098_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_2_02 (mix_q_src_c098_2_02 mix_q_c098_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_03 (mix_i_src_c098_2_03 0 bpf_c098_2 0) vcvs gain=1.950903220161e-01
SMIXI_c098_2_03 (mix_i_src_c098_2_03 mix_i_c098_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_03 (mix_q_src_c098_2_03 0 bpf_c098_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_2_03 (mix_q_src_c098_2_03 mix_q_c098_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_04 (mix_i_src_c098_2_04 0 bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_2_04 (mix_i_src_c098_2_04 mix_i_c098_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_04 (mix_q_src_c098_2_04 0 bpf_c098_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_2_04 (mix_q_src_c098_2_04 mix_q_c098_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_05 (mix_i_src_c098_2_05 0 bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_2_05 (mix_i_src_c098_2_05 mix_i_c098_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_05 (mix_q_src_c098_2_05 0 bpf_c098_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_2_05 (mix_q_src_c098_2_05 mix_q_c098_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_06 (mix_i_src_c098_2_06 0 bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_2_06 (mix_i_src_c098_2_06 mix_i_c098_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_06 (mix_q_src_c098_2_06 0 bpf_c098_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_2_06 (mix_q_src_c098_2_06 mix_q_c098_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_07 (mix_i_src_c098_2_07 0 bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_2_07 (mix_i_src_c098_2_07 mix_i_c098_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_07 (mix_q_src_c098_2_07 0 bpf_c098_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_2_07 (mix_q_src_c098_2_07 mix_q_c098_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_08 (mix_i_src_c098_2_08 0 bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_2_08 (mix_i_src_c098_2_08 mix_i_c098_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_08 (mix_q_src_c098_2_08 0 bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_2_08 (mix_q_src_c098_2_08 mix_q_c098_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_09 (mix_i_src_c098_2_09 0 bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_2_09 (mix_i_src_c098_2_09 mix_i_c098_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_09 (mix_q_src_c098_2_09 0 bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_2_09 (mix_q_src_c098_2_09 mix_q_c098_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_10 (mix_i_src_c098_2_10 0 bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_2_10 (mix_i_src_c098_2_10 mix_i_c098_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_10 (mix_q_src_c098_2_10 0 bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_2_10 (mix_q_src_c098_2_10 mix_q_c098_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_11 (mix_i_src_c098_2_11 0 bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_2_11 (mix_i_src_c098_2_11 mix_i_c098_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_11 (mix_q_src_c098_2_11 0 bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_2_11 (mix_q_src_c098_2_11 mix_q_c098_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_12 (mix_i_src_c098_2_12 0 bpf_c098_2 0) vcvs gain=1.950903220161e-01
SMIXI_c098_2_12 (mix_i_src_c098_2_12 mix_i_c098_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_12 (mix_q_src_c098_2_12 0 bpf_c098_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_2_12 (mix_q_src_c098_2_12 mix_q_c098_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_13 (mix_i_src_c098_2_13 0 bpf_c098_2 0) vcvs gain=5.555702330196e-01
SMIXI_c098_2_13 (mix_i_src_c098_2_13 mix_i_c098_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_13 (mix_q_src_c098_2_13 0 bpf_c098_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_2_13 (mix_q_src_c098_2_13 mix_q_c098_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_14 (mix_i_src_c098_2_14 0 bpf_c098_2 0) vcvs gain=8.314696123025e-01
SMIXI_c098_2_14 (mix_i_src_c098_2_14 mix_i_c098_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_14 (mix_q_src_c098_2_14 0 bpf_c098_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_2_14 (mix_q_src_c098_2_14 mix_q_c098_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_2_15 (mix_i_src_c098_2_15 0 bpf_c098_2 0) vcvs gain=9.807852804032e-01
SMIXI_c098_2_15 (mix_i_src_c098_2_15 mix_i_c098_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_2_15 (mix_q_src_c098_2_15 0 bpf_c098_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_2_15 (mix_q_src_c098_2_15 mix_q_c098_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c098_2 (mix_i_c098_2 0) resistor r=1G
RMIXQ_c098_2 (mix_q_c098_2 0) resistor r=1G
RINTI_c098_2 (mix_i_c098_2 Icar_c098_2) resistor r=1k
CINTI_c098_2 (Icar_c098_2 0) capacitor c=80p
RINTQ_c098_2 (mix_q_c098_2 Qcar_c098_2) resistor r=1k
CINTQ_c098_2 (Qcar_c098_2 0) capacitor c=80p

// bl098, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c098_3 (bl098 n_cbpf_c098_3) capacitor c=2.533029591058e-14
LBPF_c098_3 (n_cbpf_c098_3 bpf_c098_3) inductor l=1.000000000000e-06
RBPF_c098_3 (bpf_c098_3 0) resistor r=3.141592653590e+02
EMIXI_c098_3_00 (mix_i_src_c098_3_00 0 bpf_c098_3 0) vcvs gain=9.807852804032e-01
SMIXI_c098_3_00 (mix_i_src_c098_3_00 mix_i_c098_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_00 (mix_q_src_c098_3_00 0 bpf_c098_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_3_00 (mix_q_src_c098_3_00 mix_q_c098_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_01 (mix_i_src_c098_3_01 0 bpf_c098_3 0) vcvs gain=8.314696123025e-01
SMIXI_c098_3_01 (mix_i_src_c098_3_01 mix_i_c098_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_01 (mix_q_src_c098_3_01 0 bpf_c098_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_3_01 (mix_q_src_c098_3_01 mix_q_c098_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_02 (mix_i_src_c098_3_02 0 bpf_c098_3 0) vcvs gain=5.555702330196e-01
SMIXI_c098_3_02 (mix_i_src_c098_3_02 mix_i_c098_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_02 (mix_q_src_c098_3_02 0 bpf_c098_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_3_02 (mix_q_src_c098_3_02 mix_q_c098_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_03 (mix_i_src_c098_3_03 0 bpf_c098_3 0) vcvs gain=1.950903220161e-01
SMIXI_c098_3_03 (mix_i_src_c098_3_03 mix_i_c098_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_03 (mix_q_src_c098_3_03 0 bpf_c098_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_3_03 (mix_q_src_c098_3_03 mix_q_c098_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_04 (mix_i_src_c098_3_04 0 bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_3_04 (mix_i_src_c098_3_04 mix_i_c098_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_04 (mix_q_src_c098_3_04 0 bpf_c098_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c098_3_04 (mix_q_src_c098_3_04 mix_q_c098_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_05 (mix_i_src_c098_3_05 0 bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_3_05 (mix_i_src_c098_3_05 mix_i_c098_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_05 (mix_q_src_c098_3_05 0 bpf_c098_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c098_3_05 (mix_q_src_c098_3_05 mix_q_c098_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_06 (mix_i_src_c098_3_06 0 bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_3_06 (mix_i_src_c098_3_06 mix_i_c098_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_06 (mix_q_src_c098_3_06 0 bpf_c098_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c098_3_06 (mix_q_src_c098_3_06 mix_q_c098_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_07 (mix_i_src_c098_3_07 0 bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_3_07 (mix_i_src_c098_3_07 mix_i_c098_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_07 (mix_q_src_c098_3_07 0 bpf_c098_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c098_3_07 (mix_q_src_c098_3_07 mix_q_c098_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_08 (mix_i_src_c098_3_08 0 bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c098_3_08 (mix_i_src_c098_3_08 mix_i_c098_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_08 (mix_q_src_c098_3_08 0 bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_3_08 (mix_q_src_c098_3_08 mix_q_c098_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_09 (mix_i_src_c098_3_09 0 bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c098_3_09 (mix_i_src_c098_3_09 mix_i_c098_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_09 (mix_q_src_c098_3_09 0 bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_3_09 (mix_q_src_c098_3_09 mix_q_c098_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_10 (mix_i_src_c098_3_10 0 bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c098_3_10 (mix_i_src_c098_3_10 mix_i_c098_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_10 (mix_q_src_c098_3_10 0 bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_3_10 (mix_q_src_c098_3_10 mix_q_c098_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_11 (mix_i_src_c098_3_11 0 bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c098_3_11 (mix_i_src_c098_3_11 mix_i_c098_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_11 (mix_q_src_c098_3_11 0 bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_3_11 (mix_q_src_c098_3_11 mix_q_c098_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_12 (mix_i_src_c098_3_12 0 bpf_c098_3 0) vcvs gain=1.950903220161e-01
SMIXI_c098_3_12 (mix_i_src_c098_3_12 mix_i_c098_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_12 (mix_q_src_c098_3_12 0 bpf_c098_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c098_3_12 (mix_q_src_c098_3_12 mix_q_c098_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_13 (mix_i_src_c098_3_13 0 bpf_c098_3 0) vcvs gain=5.555702330196e-01
SMIXI_c098_3_13 (mix_i_src_c098_3_13 mix_i_c098_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_13 (mix_q_src_c098_3_13 0 bpf_c098_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c098_3_13 (mix_q_src_c098_3_13 mix_q_c098_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_14 (mix_i_src_c098_3_14 0 bpf_c098_3 0) vcvs gain=8.314696123025e-01
SMIXI_c098_3_14 (mix_i_src_c098_3_14 mix_i_c098_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_14 (mix_q_src_c098_3_14 0 bpf_c098_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c098_3_14 (mix_q_src_c098_3_14 mix_q_c098_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c098_3_15 (mix_i_src_c098_3_15 0 bpf_c098_3 0) vcvs gain=9.807852804032e-01
SMIXI_c098_3_15 (mix_i_src_c098_3_15 mix_i_c098_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c098_3_15 (mix_q_src_c098_3_15 0 bpf_c098_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c098_3_15 (mix_q_src_c098_3_15 mix_q_c098_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c098_3 (mix_i_c098_3 0) resistor r=1G
RMIXQ_c098_3 (mix_q_c098_3 0) resistor r=1G
RINTI_c098_3 (mix_i_c098_3 Icar_c098_3) resistor r=1k
CINTI_c098_3 (Icar_c098_3 0) capacitor c=80p
RINTQ_c098_3 (mix_q_c098_3 Qcar_c098_3) resistor r=1k
CINTQ_c098_3 (Qcar_c098_3 0) capacitor c=80p

// bl099, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c099_0 (bl099 n_cbpf_c099_0) capacitor c=4.052847345694e-13
LBPF_c099_0 (n_cbpf_c099_0 bpf_c099_0) inductor l=1.000000000000e-06
RBPF_c099_0 (bpf_c099_0 0) resistor r=7.853981633974e+01
EMIXI_c099_0_00 (mix_i_src_c099_0_00 0 bpf_c099_0 0) vcvs gain=9.807852804032e-01
SMIXI_c099_0_00 (mix_i_src_c099_0_00 mix_i_c099_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_00 (mix_q_src_c099_0_00 0 bpf_c099_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_0_00 (mix_q_src_c099_0_00 mix_q_c099_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_01 (mix_i_src_c099_0_01 0 bpf_c099_0 0) vcvs gain=8.314696123025e-01
SMIXI_c099_0_01 (mix_i_src_c099_0_01 mix_i_c099_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_01 (mix_q_src_c099_0_01 0 bpf_c099_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_0_01 (mix_q_src_c099_0_01 mix_q_c099_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_02 (mix_i_src_c099_0_02 0 bpf_c099_0 0) vcvs gain=5.555702330196e-01
SMIXI_c099_0_02 (mix_i_src_c099_0_02 mix_i_c099_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_02 (mix_q_src_c099_0_02 0 bpf_c099_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_0_02 (mix_q_src_c099_0_02 mix_q_c099_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_03 (mix_i_src_c099_0_03 0 bpf_c099_0 0) vcvs gain=1.950903220161e-01
SMIXI_c099_0_03 (mix_i_src_c099_0_03 mix_i_c099_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_03 (mix_q_src_c099_0_03 0 bpf_c099_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_0_03 (mix_q_src_c099_0_03 mix_q_c099_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_04 (mix_i_src_c099_0_04 0 bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_0_04 (mix_i_src_c099_0_04 mix_i_c099_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_04 (mix_q_src_c099_0_04 0 bpf_c099_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_0_04 (mix_q_src_c099_0_04 mix_q_c099_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_05 (mix_i_src_c099_0_05 0 bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_0_05 (mix_i_src_c099_0_05 mix_i_c099_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_05 (mix_q_src_c099_0_05 0 bpf_c099_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_0_05 (mix_q_src_c099_0_05 mix_q_c099_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_06 (mix_i_src_c099_0_06 0 bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_0_06 (mix_i_src_c099_0_06 mix_i_c099_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_06 (mix_q_src_c099_0_06 0 bpf_c099_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_0_06 (mix_q_src_c099_0_06 mix_q_c099_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_07 (mix_i_src_c099_0_07 0 bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_0_07 (mix_i_src_c099_0_07 mix_i_c099_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_07 (mix_q_src_c099_0_07 0 bpf_c099_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_0_07 (mix_q_src_c099_0_07 mix_q_c099_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_08 (mix_i_src_c099_0_08 0 bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_0_08 (mix_i_src_c099_0_08 mix_i_c099_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_08 (mix_q_src_c099_0_08 0 bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_0_08 (mix_q_src_c099_0_08 mix_q_c099_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_09 (mix_i_src_c099_0_09 0 bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_0_09 (mix_i_src_c099_0_09 mix_i_c099_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_09 (mix_q_src_c099_0_09 0 bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_0_09 (mix_q_src_c099_0_09 mix_q_c099_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_10 (mix_i_src_c099_0_10 0 bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_0_10 (mix_i_src_c099_0_10 mix_i_c099_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_10 (mix_q_src_c099_0_10 0 bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c099_0_10 (mix_q_src_c099_0_10 mix_q_c099_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_11 (mix_i_src_c099_0_11 0 bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_0_11 (mix_i_src_c099_0_11 mix_i_c099_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_11 (mix_q_src_c099_0_11 0 bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_0_11 (mix_q_src_c099_0_11 mix_q_c099_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_12 (mix_i_src_c099_0_12 0 bpf_c099_0 0) vcvs gain=1.950903220161e-01
SMIXI_c099_0_12 (mix_i_src_c099_0_12 mix_i_c099_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_12 (mix_q_src_c099_0_12 0 bpf_c099_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_0_12 (mix_q_src_c099_0_12 mix_q_c099_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_13 (mix_i_src_c099_0_13 0 bpf_c099_0 0) vcvs gain=5.555702330196e-01
SMIXI_c099_0_13 (mix_i_src_c099_0_13 mix_i_c099_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_13 (mix_q_src_c099_0_13 0 bpf_c099_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c099_0_13 (mix_q_src_c099_0_13 mix_q_c099_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_14 (mix_i_src_c099_0_14 0 bpf_c099_0 0) vcvs gain=8.314696123025e-01
SMIXI_c099_0_14 (mix_i_src_c099_0_14 mix_i_c099_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_14 (mix_q_src_c099_0_14 0 bpf_c099_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_0_14 (mix_q_src_c099_0_14 mix_q_c099_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_0_15 (mix_i_src_c099_0_15 0 bpf_c099_0 0) vcvs gain=9.807852804032e-01
SMIXI_c099_0_15 (mix_i_src_c099_0_15 mix_i_c099_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_0_15 (mix_q_src_c099_0_15 0 bpf_c099_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_0_15 (mix_q_src_c099_0_15 mix_q_c099_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c099_0 (mix_i_c099_0 0) resistor r=1G
RMIXQ_c099_0 (mix_q_c099_0 0) resistor r=1G
RINTI_c099_0 (mix_i_c099_0 Icar_c099_0) resistor r=1k
CINTI_c099_0 (Icar_c099_0 0) capacitor c=80p
RINTQ_c099_0 (mix_q_c099_0 Qcar_c099_0) resistor r=1k
CINTQ_c099_0 (Qcar_c099_0 0) capacitor c=80p

// bl099, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c099_1 (bl099 n_cbpf_c099_1) capacitor c=1.013211836423e-13
LBPF_c099_1 (n_cbpf_c099_1 bpf_c099_1) inductor l=1.000000000000e-06
RBPF_c099_1 (bpf_c099_1 0) resistor r=1.570796326795e+02
EMIXI_c099_1_00 (mix_i_src_c099_1_00 0 bpf_c099_1 0) vcvs gain=9.807852804032e-01
SMIXI_c099_1_00 (mix_i_src_c099_1_00 mix_i_c099_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_00 (mix_q_src_c099_1_00 0 bpf_c099_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_1_00 (mix_q_src_c099_1_00 mix_q_c099_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_01 (mix_i_src_c099_1_01 0 bpf_c099_1 0) vcvs gain=8.314696123025e-01
SMIXI_c099_1_01 (mix_i_src_c099_1_01 mix_i_c099_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_01 (mix_q_src_c099_1_01 0 bpf_c099_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_1_01 (mix_q_src_c099_1_01 mix_q_c099_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_02 (mix_i_src_c099_1_02 0 bpf_c099_1 0) vcvs gain=5.555702330196e-01
SMIXI_c099_1_02 (mix_i_src_c099_1_02 mix_i_c099_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_02 (mix_q_src_c099_1_02 0 bpf_c099_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_1_02 (mix_q_src_c099_1_02 mix_q_c099_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_03 (mix_i_src_c099_1_03 0 bpf_c099_1 0) vcvs gain=1.950903220161e-01
SMIXI_c099_1_03 (mix_i_src_c099_1_03 mix_i_c099_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_03 (mix_q_src_c099_1_03 0 bpf_c099_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_1_03 (mix_q_src_c099_1_03 mix_q_c099_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_04 (mix_i_src_c099_1_04 0 bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_1_04 (mix_i_src_c099_1_04 mix_i_c099_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_04 (mix_q_src_c099_1_04 0 bpf_c099_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c099_1_04 (mix_q_src_c099_1_04 mix_q_c099_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_05 (mix_i_src_c099_1_05 0 bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_1_05 (mix_i_src_c099_1_05 mix_i_c099_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_05 (mix_q_src_c099_1_05 0 bpf_c099_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c099_1_05 (mix_q_src_c099_1_05 mix_q_c099_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_06 (mix_i_src_c099_1_06 0 bpf_c099_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_1_06 (mix_i_src_c099_1_06 mix_i_c099_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_06 (mix_q_src_c099_1_06 0 bpf_c099_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c099_1_06 (mix_q_src_c099_1_06 mix_q_c099_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_07 (mix_i_src_c099_1_07 0 bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_1_07 (mix_i_src_c099_1_07 mix_i_c099_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_07 (mix_q_src_c099_1_07 0 bpf_c099_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c099_1_07 (mix_q_src_c099_1_07 mix_q_c099_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_08 (mix_i_src_c099_1_08 0 bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c099_1_08 (mix_i_src_c099_1_08 mix_i_c099_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_08 (mix_q_src_c099_1_08 0 bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c099_1_08 (mix_q_src_c099_1_08 mix_q_c099_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_09 (mix_i_src_c099_1_09 0 bpf_c099_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c099_1_09 (mix_i_src_c099_1_09 mix_i_c099_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_09 (mix_q_src_c099_1_09 0 bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c099_1_09 (mix_q_src_c099_1_09 mix_q_c099_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_10 (mix_i_src_c099_1_10 0 bpf_c099_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c099_1_10 (mix_i_src_c099_1_10 mix_i_c099_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_10 (mix_q_src_c099_1_10 0 bpf_c099_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c099_1_10 (mix_q_src_c099_1_10 mix_q_c099_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_11 (mix_i_src_c099_1_11 0 bpf_c099_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c099_1_11 (mix_i_src_c099_1_11 mix_i_c099_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_11 (mix_q_src_c099_1_11 0 bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_1_11 (mix_q_src_c099_1_11 mix_q_c099_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_12 (mix_i_src_c099_1_12 0 bpf_c099_1 0) vcvs gain=1.950903220161e-01
SMIXI_c099_1_12 (mix_i_src_c099_1_12 mix_i_c099_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_12 (mix_q_src_c099_1_12 0 bpf_c099_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c099_1_12 (mix_q_src_c099_1_12 mix_q_c099_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c099_1_13 (mix_i_src_c099_1_13 0 bpf_c099_1 0) vcvs gain=5.555702330196e-01
SMIXI_c099_1_13 (mix_i_src_c099_1_13 mix_i_c099_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c099_1_13 (mix_q_src_c099_1_13 0 bpf_c099_1 0) vcvs gain=-8.314696123025e-01
