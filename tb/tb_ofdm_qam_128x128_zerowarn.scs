SMIXI_c056_2_11 (mix_i_src_c056_2_11 mix_i_c056_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_11 (mix_q_src_c056_2_11 0 bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_2_11 (mix_q_src_c056_2_11 mix_q_c056_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_12 (mix_i_src_c056_2_12 0 bpf_c056_2 0) vcvs gain=1.950903220161e-01
SMIXI_c056_2_12 (mix_i_src_c056_2_12 mix_i_c056_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_12 (mix_q_src_c056_2_12 0 bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_2_12 (mix_q_src_c056_2_12 mix_q_c056_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_13 (mix_i_src_c056_2_13 0 bpf_c056_2 0) vcvs gain=5.555702330196e-01
SMIXI_c056_2_13 (mix_i_src_c056_2_13 mix_i_c056_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_13 (mix_q_src_c056_2_13 0 bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_2_13 (mix_q_src_c056_2_13 mix_q_c056_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_14 (mix_i_src_c056_2_14 0 bpf_c056_2 0) vcvs gain=8.314696123025e-01
SMIXI_c056_2_14 (mix_i_src_c056_2_14 mix_i_c056_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_14 (mix_q_src_c056_2_14 0 bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_2_14 (mix_q_src_c056_2_14 mix_q_c056_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_15 (mix_i_src_c056_2_15 0 bpf_c056_2 0) vcvs gain=9.807852804032e-01
SMIXI_c056_2_15 (mix_i_src_c056_2_15 mix_i_c056_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_15 (mix_q_src_c056_2_15 0 bpf_c056_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_2_15 (mix_q_src_c056_2_15 mix_q_c056_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c056_2 (mix_i_c056_2 0) resistor r=1G
RMIXQ_c056_2 (mix_q_c056_2 0) resistor r=1G
RINTI_c056_2 (mix_i_c056_2 Icar_c056_2) resistor r=1k
CINTI_c056_2 (Icar_c056_2 0) capacitor c=80p
RINTQ_c056_2 (mix_q_c056_2 Qcar_c056_2) resistor r=1k
CINTQ_c056_2 (Qcar_c056_2 0) capacitor c=80p

// bl056, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c056_3 (bl056 n_cbpf_c056_3) capacitor c=2.533029591058e-14
LBPF_c056_3 (n_cbpf_c056_3 bpf_c056_3) inductor l=1.000000000000e-06
RBPF_c056_3 (bpf_c056_3 0) resistor r=3.141592653590e+02
EMIXI_c056_3_00 (mix_i_src_c056_3_00 0 bpf_c056_3 0) vcvs gain=9.807852804032e-01
SMIXI_c056_3_00 (mix_i_src_c056_3_00 mix_i_c056_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_00 (mix_q_src_c056_3_00 0 bpf_c056_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_3_00 (mix_q_src_c056_3_00 mix_q_c056_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_01 (mix_i_src_c056_3_01 0 bpf_c056_3 0) vcvs gain=8.314696123025e-01
SMIXI_c056_3_01 (mix_i_src_c056_3_01 mix_i_c056_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_01 (mix_q_src_c056_3_01 0 bpf_c056_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_3_01 (mix_q_src_c056_3_01 mix_q_c056_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_02 (mix_i_src_c056_3_02 0 bpf_c056_3 0) vcvs gain=5.555702330196e-01
SMIXI_c056_3_02 (mix_i_src_c056_3_02 mix_i_c056_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_02 (mix_q_src_c056_3_02 0 bpf_c056_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_3_02 (mix_q_src_c056_3_02 mix_q_c056_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_03 (mix_i_src_c056_3_03 0 bpf_c056_3 0) vcvs gain=1.950903220161e-01
SMIXI_c056_3_03 (mix_i_src_c056_3_03 mix_i_c056_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_03 (mix_q_src_c056_3_03 0 bpf_c056_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_3_03 (mix_q_src_c056_3_03 mix_q_c056_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_04 (mix_i_src_c056_3_04 0 bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c056_3_04 (mix_i_src_c056_3_04 mix_i_c056_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_04 (mix_q_src_c056_3_04 0 bpf_c056_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_3_04 (mix_q_src_c056_3_04 mix_q_c056_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_05 (mix_i_src_c056_3_05 0 bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_3_05 (mix_i_src_c056_3_05 mix_i_c056_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_05 (mix_q_src_c056_3_05 0 bpf_c056_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_3_05 (mix_q_src_c056_3_05 mix_q_c056_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_06 (mix_i_src_c056_3_06 0 bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_3_06 (mix_i_src_c056_3_06 mix_i_c056_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_06 (mix_q_src_c056_3_06 0 bpf_c056_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_3_06 (mix_q_src_c056_3_06 mix_q_c056_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_07 (mix_i_src_c056_3_07 0 bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_3_07 (mix_i_src_c056_3_07 mix_i_c056_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_07 (mix_q_src_c056_3_07 0 bpf_c056_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_3_07 (mix_q_src_c056_3_07 mix_q_c056_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_08 (mix_i_src_c056_3_08 0 bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_3_08 (mix_i_src_c056_3_08 mix_i_c056_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_08 (mix_q_src_c056_3_08 0 bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_3_08 (mix_q_src_c056_3_08 mix_q_c056_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_09 (mix_i_src_c056_3_09 0 bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_3_09 (mix_i_src_c056_3_09 mix_i_c056_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_09 (mix_q_src_c056_3_09 0 bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_3_09 (mix_q_src_c056_3_09 mix_q_c056_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_10 (mix_i_src_c056_3_10 0 bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_3_10 (mix_i_src_c056_3_10 mix_i_c056_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_10 (mix_q_src_c056_3_10 0 bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_3_10 (mix_q_src_c056_3_10 mix_q_c056_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_11 (mix_i_src_c056_3_11 0 bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c056_3_11 (mix_i_src_c056_3_11 mix_i_c056_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_11 (mix_q_src_c056_3_11 0 bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_3_11 (mix_q_src_c056_3_11 mix_q_c056_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_12 (mix_i_src_c056_3_12 0 bpf_c056_3 0) vcvs gain=1.950903220161e-01
SMIXI_c056_3_12 (mix_i_src_c056_3_12 mix_i_c056_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_12 (mix_q_src_c056_3_12 0 bpf_c056_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_3_12 (mix_q_src_c056_3_12 mix_q_c056_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_13 (mix_i_src_c056_3_13 0 bpf_c056_3 0) vcvs gain=5.555702330196e-01
SMIXI_c056_3_13 (mix_i_src_c056_3_13 mix_i_c056_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_13 (mix_q_src_c056_3_13 0 bpf_c056_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_3_13 (mix_q_src_c056_3_13 mix_q_c056_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_14 (mix_i_src_c056_3_14 0 bpf_c056_3 0) vcvs gain=8.314696123025e-01
SMIXI_c056_3_14 (mix_i_src_c056_3_14 mix_i_c056_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_14 (mix_q_src_c056_3_14 0 bpf_c056_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_3_14 (mix_q_src_c056_3_14 mix_q_c056_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_3_15 (mix_i_src_c056_3_15 0 bpf_c056_3 0) vcvs gain=9.807852804032e-01
SMIXI_c056_3_15 (mix_i_src_c056_3_15 mix_i_c056_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_3_15 (mix_q_src_c056_3_15 0 bpf_c056_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_3_15 (mix_q_src_c056_3_15 mix_q_c056_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c056_3 (mix_i_c056_3 0) resistor r=1G
RMIXQ_c056_3 (mix_q_c056_3 0) resistor r=1G
RINTI_c056_3 (mix_i_c056_3 Icar_c056_3) resistor r=1k
CINTI_c056_3 (Icar_c056_3 0) capacitor c=80p
RINTQ_c056_3 (mix_q_c056_3 Qcar_c056_3) resistor r=1k
CINTQ_c056_3 (Qcar_c056_3 0) capacitor c=80p

// bl057, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c057_0 (bl057 n_cbpf_c057_0) capacitor c=4.052847345694e-13
LBPF_c057_0 (n_cbpf_c057_0 bpf_c057_0) inductor l=1.000000000000e-06
RBPF_c057_0 (bpf_c057_0 0) resistor r=7.853981633974e+01
EMIXI_c057_0_00 (mix_i_src_c057_0_00 0 bpf_c057_0 0) vcvs gain=9.807852804032e-01
SMIXI_c057_0_00 (mix_i_src_c057_0_00 mix_i_c057_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_00 (mix_q_src_c057_0_00 0 bpf_c057_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_0_00 (mix_q_src_c057_0_00 mix_q_c057_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_01 (mix_i_src_c057_0_01 0 bpf_c057_0 0) vcvs gain=8.314696123025e-01
SMIXI_c057_0_01 (mix_i_src_c057_0_01 mix_i_c057_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_01 (mix_q_src_c057_0_01 0 bpf_c057_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_0_01 (mix_q_src_c057_0_01 mix_q_c057_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_02 (mix_i_src_c057_0_02 0 bpf_c057_0 0) vcvs gain=5.555702330196e-01
SMIXI_c057_0_02 (mix_i_src_c057_0_02 mix_i_c057_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_02 (mix_q_src_c057_0_02 0 bpf_c057_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_0_02 (mix_q_src_c057_0_02 mix_q_c057_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_03 (mix_i_src_c057_0_03 0 bpf_c057_0 0) vcvs gain=1.950903220161e-01
SMIXI_c057_0_03 (mix_i_src_c057_0_03 mix_i_c057_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_03 (mix_q_src_c057_0_03 0 bpf_c057_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_0_03 (mix_q_src_c057_0_03 mix_q_c057_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_04 (mix_i_src_c057_0_04 0 bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_0_04 (mix_i_src_c057_0_04 mix_i_c057_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_04 (mix_q_src_c057_0_04 0 bpf_c057_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_0_04 (mix_q_src_c057_0_04 mix_q_c057_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_05 (mix_i_src_c057_0_05 0 bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_0_05 (mix_i_src_c057_0_05 mix_i_c057_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_05 (mix_q_src_c057_0_05 0 bpf_c057_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_0_05 (mix_q_src_c057_0_05 mix_q_c057_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_06 (mix_i_src_c057_0_06 0 bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_0_06 (mix_i_src_c057_0_06 mix_i_c057_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_06 (mix_q_src_c057_0_06 0 bpf_c057_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_0_06 (mix_q_src_c057_0_06 mix_q_c057_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_07 (mix_i_src_c057_0_07 0 bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_0_07 (mix_i_src_c057_0_07 mix_i_c057_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_07 (mix_q_src_c057_0_07 0 bpf_c057_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_0_07 (mix_q_src_c057_0_07 mix_q_c057_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_08 (mix_i_src_c057_0_08 0 bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_0_08 (mix_i_src_c057_0_08 mix_i_c057_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_08 (mix_q_src_c057_0_08 0 bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_0_08 (mix_q_src_c057_0_08 mix_q_c057_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_09 (mix_i_src_c057_0_09 0 bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_0_09 (mix_i_src_c057_0_09 mix_i_c057_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_09 (mix_q_src_c057_0_09 0 bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_0_09 (mix_q_src_c057_0_09 mix_q_c057_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_10 (mix_i_src_c057_0_10 0 bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_0_10 (mix_i_src_c057_0_10 mix_i_c057_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_10 (mix_q_src_c057_0_10 0 bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_0_10 (mix_q_src_c057_0_10 mix_q_c057_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_11 (mix_i_src_c057_0_11 0 bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_0_11 (mix_i_src_c057_0_11 mix_i_c057_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_11 (mix_q_src_c057_0_11 0 bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_0_11 (mix_q_src_c057_0_11 mix_q_c057_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_12 (mix_i_src_c057_0_12 0 bpf_c057_0 0) vcvs gain=1.950903220161e-01
SMIXI_c057_0_12 (mix_i_src_c057_0_12 mix_i_c057_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_12 (mix_q_src_c057_0_12 0 bpf_c057_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_0_12 (mix_q_src_c057_0_12 mix_q_c057_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_13 (mix_i_src_c057_0_13 0 bpf_c057_0 0) vcvs gain=5.555702330196e-01
SMIXI_c057_0_13 (mix_i_src_c057_0_13 mix_i_c057_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_13 (mix_q_src_c057_0_13 0 bpf_c057_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_0_13 (mix_q_src_c057_0_13 mix_q_c057_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_14 (mix_i_src_c057_0_14 0 bpf_c057_0 0) vcvs gain=8.314696123025e-01
SMIXI_c057_0_14 (mix_i_src_c057_0_14 mix_i_c057_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_14 (mix_q_src_c057_0_14 0 bpf_c057_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_0_14 (mix_q_src_c057_0_14 mix_q_c057_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_0_15 (mix_i_src_c057_0_15 0 bpf_c057_0 0) vcvs gain=9.807852804032e-01
SMIXI_c057_0_15 (mix_i_src_c057_0_15 mix_i_c057_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_0_15 (mix_q_src_c057_0_15 0 bpf_c057_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_0_15 (mix_q_src_c057_0_15 mix_q_c057_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c057_0 (mix_i_c057_0 0) resistor r=1G
RMIXQ_c057_0 (mix_q_c057_0 0) resistor r=1G
RINTI_c057_0 (mix_i_c057_0 Icar_c057_0) resistor r=1k
CINTI_c057_0 (Icar_c057_0 0) capacitor c=80p
RINTQ_c057_0 (mix_q_c057_0 Qcar_c057_0) resistor r=1k
CINTQ_c057_0 (Qcar_c057_0 0) capacitor c=80p

// bl057, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c057_1 (bl057 n_cbpf_c057_1) capacitor c=1.013211836423e-13
LBPF_c057_1 (n_cbpf_c057_1 bpf_c057_1) inductor l=1.000000000000e-06
RBPF_c057_1 (bpf_c057_1 0) resistor r=1.570796326795e+02
EMIXI_c057_1_00 (mix_i_src_c057_1_00 0 bpf_c057_1 0) vcvs gain=9.807852804032e-01
SMIXI_c057_1_00 (mix_i_src_c057_1_00 mix_i_c057_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_00 (mix_q_src_c057_1_00 0 bpf_c057_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_1_00 (mix_q_src_c057_1_00 mix_q_c057_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_01 (mix_i_src_c057_1_01 0 bpf_c057_1 0) vcvs gain=8.314696123025e-01
SMIXI_c057_1_01 (mix_i_src_c057_1_01 mix_i_c057_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_01 (mix_q_src_c057_1_01 0 bpf_c057_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_1_01 (mix_q_src_c057_1_01 mix_q_c057_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_02 (mix_i_src_c057_1_02 0 bpf_c057_1 0) vcvs gain=5.555702330196e-01
SMIXI_c057_1_02 (mix_i_src_c057_1_02 mix_i_c057_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_02 (mix_q_src_c057_1_02 0 bpf_c057_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_1_02 (mix_q_src_c057_1_02 mix_q_c057_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_03 (mix_i_src_c057_1_03 0 bpf_c057_1 0) vcvs gain=1.950903220161e-01
SMIXI_c057_1_03 (mix_i_src_c057_1_03 mix_i_c057_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_03 (mix_q_src_c057_1_03 0 bpf_c057_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_1_03 (mix_q_src_c057_1_03 mix_q_c057_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_04 (mix_i_src_c057_1_04 0 bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_1_04 (mix_i_src_c057_1_04 mix_i_c057_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_04 (mix_q_src_c057_1_04 0 bpf_c057_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_1_04 (mix_q_src_c057_1_04 mix_q_c057_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_05 (mix_i_src_c057_1_05 0 bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_1_05 (mix_i_src_c057_1_05 mix_i_c057_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_05 (mix_q_src_c057_1_05 0 bpf_c057_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_1_05 (mix_q_src_c057_1_05 mix_q_c057_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_06 (mix_i_src_c057_1_06 0 bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_1_06 (mix_i_src_c057_1_06 mix_i_c057_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_06 (mix_q_src_c057_1_06 0 bpf_c057_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_1_06 (mix_q_src_c057_1_06 mix_q_c057_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_07 (mix_i_src_c057_1_07 0 bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_1_07 (mix_i_src_c057_1_07 mix_i_c057_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_07 (mix_q_src_c057_1_07 0 bpf_c057_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_1_07 (mix_q_src_c057_1_07 mix_q_c057_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_08 (mix_i_src_c057_1_08 0 bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_1_08 (mix_i_src_c057_1_08 mix_i_c057_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_08 (mix_q_src_c057_1_08 0 bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_1_08 (mix_q_src_c057_1_08 mix_q_c057_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_09 (mix_i_src_c057_1_09 0 bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_1_09 (mix_i_src_c057_1_09 mix_i_c057_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_09 (mix_q_src_c057_1_09 0 bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_1_09 (mix_q_src_c057_1_09 mix_q_c057_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_10 (mix_i_src_c057_1_10 0 bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_1_10 (mix_i_src_c057_1_10 mix_i_c057_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_10 (mix_q_src_c057_1_10 0 bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_1_10 (mix_q_src_c057_1_10 mix_q_c057_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_11 (mix_i_src_c057_1_11 0 bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_1_11 (mix_i_src_c057_1_11 mix_i_c057_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_11 (mix_q_src_c057_1_11 0 bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_1_11 (mix_q_src_c057_1_11 mix_q_c057_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_12 (mix_i_src_c057_1_12 0 bpf_c057_1 0) vcvs gain=1.950903220161e-01
SMIXI_c057_1_12 (mix_i_src_c057_1_12 mix_i_c057_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_12 (mix_q_src_c057_1_12 0 bpf_c057_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_1_12 (mix_q_src_c057_1_12 mix_q_c057_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_13 (mix_i_src_c057_1_13 0 bpf_c057_1 0) vcvs gain=5.555702330196e-01
SMIXI_c057_1_13 (mix_i_src_c057_1_13 mix_i_c057_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_13 (mix_q_src_c057_1_13 0 bpf_c057_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_1_13 (mix_q_src_c057_1_13 mix_q_c057_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_14 (mix_i_src_c057_1_14 0 bpf_c057_1 0) vcvs gain=8.314696123025e-01
SMIXI_c057_1_14 (mix_i_src_c057_1_14 mix_i_c057_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_14 (mix_q_src_c057_1_14 0 bpf_c057_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_1_14 (mix_q_src_c057_1_14 mix_q_c057_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_1_15 (mix_i_src_c057_1_15 0 bpf_c057_1 0) vcvs gain=9.807852804032e-01
SMIXI_c057_1_15 (mix_i_src_c057_1_15 mix_i_c057_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_1_15 (mix_q_src_c057_1_15 0 bpf_c057_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_1_15 (mix_q_src_c057_1_15 mix_q_c057_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c057_1 (mix_i_c057_1 0) resistor r=1G
RMIXQ_c057_1 (mix_q_c057_1 0) resistor r=1G
RINTI_c057_1 (mix_i_c057_1 Icar_c057_1) resistor r=1k
CINTI_c057_1 (Icar_c057_1 0) capacitor c=80p
RINTQ_c057_1 (mix_q_c057_1 Qcar_c057_1) resistor r=1k
CINTQ_c057_1 (Qcar_c057_1 0) capacitor c=80p

// bl057, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c057_2 (bl057 n_cbpf_c057_2) capacitor c=4.503163717437e-14
LBPF_c057_2 (n_cbpf_c057_2 bpf_c057_2) inductor l=1.000000000000e-06
RBPF_c057_2 (bpf_c057_2 0) resistor r=2.356194490192e+02
EMIXI_c057_2_00 (mix_i_src_c057_2_00 0 bpf_c057_2 0) vcvs gain=9.807852804032e-01
SMIXI_c057_2_00 (mix_i_src_c057_2_00 mix_i_c057_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_00 (mix_q_src_c057_2_00 0 bpf_c057_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_2_00 (mix_q_src_c057_2_00 mix_q_c057_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_01 (mix_i_src_c057_2_01 0 bpf_c057_2 0) vcvs gain=8.314696123025e-01
SMIXI_c057_2_01 (mix_i_src_c057_2_01 mix_i_c057_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_01 (mix_q_src_c057_2_01 0 bpf_c057_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_2_01 (mix_q_src_c057_2_01 mix_q_c057_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_02 (mix_i_src_c057_2_02 0 bpf_c057_2 0) vcvs gain=5.555702330196e-01
SMIXI_c057_2_02 (mix_i_src_c057_2_02 mix_i_c057_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_02 (mix_q_src_c057_2_02 0 bpf_c057_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_2_02 (mix_q_src_c057_2_02 mix_q_c057_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_03 (mix_i_src_c057_2_03 0 bpf_c057_2 0) vcvs gain=1.950903220161e-01
SMIXI_c057_2_03 (mix_i_src_c057_2_03 mix_i_c057_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_03 (mix_q_src_c057_2_03 0 bpf_c057_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_2_03 (mix_q_src_c057_2_03 mix_q_c057_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_04 (mix_i_src_c057_2_04 0 bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_2_04 (mix_i_src_c057_2_04 mix_i_c057_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_04 (mix_q_src_c057_2_04 0 bpf_c057_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_2_04 (mix_q_src_c057_2_04 mix_q_c057_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_05 (mix_i_src_c057_2_05 0 bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_2_05 (mix_i_src_c057_2_05 mix_i_c057_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_05 (mix_q_src_c057_2_05 0 bpf_c057_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_2_05 (mix_q_src_c057_2_05 mix_q_c057_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_06 (mix_i_src_c057_2_06 0 bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_2_06 (mix_i_src_c057_2_06 mix_i_c057_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_06 (mix_q_src_c057_2_06 0 bpf_c057_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_2_06 (mix_q_src_c057_2_06 mix_q_c057_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_07 (mix_i_src_c057_2_07 0 bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_2_07 (mix_i_src_c057_2_07 mix_i_c057_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_07 (mix_q_src_c057_2_07 0 bpf_c057_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_2_07 (mix_q_src_c057_2_07 mix_q_c057_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_08 (mix_i_src_c057_2_08 0 bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_2_08 (mix_i_src_c057_2_08 mix_i_c057_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_08 (mix_q_src_c057_2_08 0 bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_2_08 (mix_q_src_c057_2_08 mix_q_c057_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_09 (mix_i_src_c057_2_09 0 bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_2_09 (mix_i_src_c057_2_09 mix_i_c057_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_09 (mix_q_src_c057_2_09 0 bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_2_09 (mix_q_src_c057_2_09 mix_q_c057_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_10 (mix_i_src_c057_2_10 0 bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_2_10 (mix_i_src_c057_2_10 mix_i_c057_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_10 (mix_q_src_c057_2_10 0 bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_2_10 (mix_q_src_c057_2_10 mix_q_c057_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_11 (mix_i_src_c057_2_11 0 bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_2_11 (mix_i_src_c057_2_11 mix_i_c057_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_11 (mix_q_src_c057_2_11 0 bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_2_11 (mix_q_src_c057_2_11 mix_q_c057_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_12 (mix_i_src_c057_2_12 0 bpf_c057_2 0) vcvs gain=1.950903220161e-01
SMIXI_c057_2_12 (mix_i_src_c057_2_12 mix_i_c057_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_12 (mix_q_src_c057_2_12 0 bpf_c057_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_2_12 (mix_q_src_c057_2_12 mix_q_c057_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_13 (mix_i_src_c057_2_13 0 bpf_c057_2 0) vcvs gain=5.555702330196e-01
SMIXI_c057_2_13 (mix_i_src_c057_2_13 mix_i_c057_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_13 (mix_q_src_c057_2_13 0 bpf_c057_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_2_13 (mix_q_src_c057_2_13 mix_q_c057_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_14 (mix_i_src_c057_2_14 0 bpf_c057_2 0) vcvs gain=8.314696123025e-01
SMIXI_c057_2_14 (mix_i_src_c057_2_14 mix_i_c057_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_14 (mix_q_src_c057_2_14 0 bpf_c057_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_2_14 (mix_q_src_c057_2_14 mix_q_c057_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_2_15 (mix_i_src_c057_2_15 0 bpf_c057_2 0) vcvs gain=9.807852804032e-01
SMIXI_c057_2_15 (mix_i_src_c057_2_15 mix_i_c057_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_2_15 (mix_q_src_c057_2_15 0 bpf_c057_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_2_15 (mix_q_src_c057_2_15 mix_q_c057_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c057_2 (mix_i_c057_2 0) resistor r=1G
RMIXQ_c057_2 (mix_q_c057_2 0) resistor r=1G
RINTI_c057_2 (mix_i_c057_2 Icar_c057_2) resistor r=1k
CINTI_c057_2 (Icar_c057_2 0) capacitor c=80p
RINTQ_c057_2 (mix_q_c057_2 Qcar_c057_2) resistor r=1k
CINTQ_c057_2 (Qcar_c057_2 0) capacitor c=80p

// bl057, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c057_3 (bl057 n_cbpf_c057_3) capacitor c=2.533029591058e-14
LBPF_c057_3 (n_cbpf_c057_3 bpf_c057_3) inductor l=1.000000000000e-06
RBPF_c057_3 (bpf_c057_3 0) resistor r=3.141592653590e+02
EMIXI_c057_3_00 (mix_i_src_c057_3_00 0 bpf_c057_3 0) vcvs gain=9.807852804032e-01
SMIXI_c057_3_00 (mix_i_src_c057_3_00 mix_i_c057_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_00 (mix_q_src_c057_3_00 0 bpf_c057_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_3_00 (mix_q_src_c057_3_00 mix_q_c057_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_01 (mix_i_src_c057_3_01 0 bpf_c057_3 0) vcvs gain=8.314696123025e-01
SMIXI_c057_3_01 (mix_i_src_c057_3_01 mix_i_c057_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_01 (mix_q_src_c057_3_01 0 bpf_c057_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_3_01 (mix_q_src_c057_3_01 mix_q_c057_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_02 (mix_i_src_c057_3_02 0 bpf_c057_3 0) vcvs gain=5.555702330196e-01
SMIXI_c057_3_02 (mix_i_src_c057_3_02 mix_i_c057_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_02 (mix_q_src_c057_3_02 0 bpf_c057_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_3_02 (mix_q_src_c057_3_02 mix_q_c057_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_03 (mix_i_src_c057_3_03 0 bpf_c057_3 0) vcvs gain=1.950903220161e-01
SMIXI_c057_3_03 (mix_i_src_c057_3_03 mix_i_c057_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_03 (mix_q_src_c057_3_03 0 bpf_c057_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_3_03 (mix_q_src_c057_3_03 mix_q_c057_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_04 (mix_i_src_c057_3_04 0 bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_3_04 (mix_i_src_c057_3_04 mix_i_c057_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_04 (mix_q_src_c057_3_04 0 bpf_c057_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c057_3_04 (mix_q_src_c057_3_04 mix_q_c057_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_05 (mix_i_src_c057_3_05 0 bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_3_05 (mix_i_src_c057_3_05 mix_i_c057_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_05 (mix_q_src_c057_3_05 0 bpf_c057_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c057_3_05 (mix_q_src_c057_3_05 mix_q_c057_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_06 (mix_i_src_c057_3_06 0 bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_3_06 (mix_i_src_c057_3_06 mix_i_c057_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_06 (mix_q_src_c057_3_06 0 bpf_c057_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c057_3_06 (mix_q_src_c057_3_06 mix_q_c057_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_07 (mix_i_src_c057_3_07 0 bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_3_07 (mix_i_src_c057_3_07 mix_i_c057_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_07 (mix_q_src_c057_3_07 0 bpf_c057_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c057_3_07 (mix_q_src_c057_3_07 mix_q_c057_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_08 (mix_i_src_c057_3_08 0 bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c057_3_08 (mix_i_src_c057_3_08 mix_i_c057_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_08 (mix_q_src_c057_3_08 0 bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_3_08 (mix_q_src_c057_3_08 mix_q_c057_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_09 (mix_i_src_c057_3_09 0 bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c057_3_09 (mix_i_src_c057_3_09 mix_i_c057_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_09 (mix_q_src_c057_3_09 0 bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_3_09 (mix_q_src_c057_3_09 mix_q_c057_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_10 (mix_i_src_c057_3_10 0 bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c057_3_10 (mix_i_src_c057_3_10 mix_i_c057_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_10 (mix_q_src_c057_3_10 0 bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_3_10 (mix_q_src_c057_3_10 mix_q_c057_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_11 (mix_i_src_c057_3_11 0 bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c057_3_11 (mix_i_src_c057_3_11 mix_i_c057_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_11 (mix_q_src_c057_3_11 0 bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_3_11 (mix_q_src_c057_3_11 mix_q_c057_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_12 (mix_i_src_c057_3_12 0 bpf_c057_3 0) vcvs gain=1.950903220161e-01
SMIXI_c057_3_12 (mix_i_src_c057_3_12 mix_i_c057_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_12 (mix_q_src_c057_3_12 0 bpf_c057_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c057_3_12 (mix_q_src_c057_3_12 mix_q_c057_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_13 (mix_i_src_c057_3_13 0 bpf_c057_3 0) vcvs gain=5.555702330196e-01
SMIXI_c057_3_13 (mix_i_src_c057_3_13 mix_i_c057_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_13 (mix_q_src_c057_3_13 0 bpf_c057_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c057_3_13 (mix_q_src_c057_3_13 mix_q_c057_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_14 (mix_i_src_c057_3_14 0 bpf_c057_3 0) vcvs gain=8.314696123025e-01
SMIXI_c057_3_14 (mix_i_src_c057_3_14 mix_i_c057_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_14 (mix_q_src_c057_3_14 0 bpf_c057_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c057_3_14 (mix_q_src_c057_3_14 mix_q_c057_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c057_3_15 (mix_i_src_c057_3_15 0 bpf_c057_3 0) vcvs gain=9.807852804032e-01
SMIXI_c057_3_15 (mix_i_src_c057_3_15 mix_i_c057_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c057_3_15 (mix_q_src_c057_3_15 0 bpf_c057_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c057_3_15 (mix_q_src_c057_3_15 mix_q_c057_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c057_3 (mix_i_c057_3 0) resistor r=1G
RMIXQ_c057_3 (mix_q_c057_3 0) resistor r=1G
RINTI_c057_3 (mix_i_c057_3 Icar_c057_3) resistor r=1k
CINTI_c057_3 (Icar_c057_3 0) capacitor c=80p
RINTQ_c057_3 (mix_q_c057_3 Qcar_c057_3) resistor r=1k
CINTQ_c057_3 (Qcar_c057_3 0) capacitor c=80p

// bl058, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c058_0 (bl058 n_cbpf_c058_0) capacitor c=4.052847345694e-13
LBPF_c058_0 (n_cbpf_c058_0 bpf_c058_0) inductor l=1.000000000000e-06
RBPF_c058_0 (bpf_c058_0 0) resistor r=7.853981633974e+01
EMIXI_c058_0_00 (mix_i_src_c058_0_00 0 bpf_c058_0 0) vcvs gain=9.807852804032e-01
SMIXI_c058_0_00 (mix_i_src_c058_0_00 mix_i_c058_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_00 (mix_q_src_c058_0_00 0 bpf_c058_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_0_00 (mix_q_src_c058_0_00 mix_q_c058_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_01 (mix_i_src_c058_0_01 0 bpf_c058_0 0) vcvs gain=8.314696123025e-01
SMIXI_c058_0_01 (mix_i_src_c058_0_01 mix_i_c058_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_01 (mix_q_src_c058_0_01 0 bpf_c058_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_0_01 (mix_q_src_c058_0_01 mix_q_c058_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_02 (mix_i_src_c058_0_02 0 bpf_c058_0 0) vcvs gain=5.555702330196e-01
SMIXI_c058_0_02 (mix_i_src_c058_0_02 mix_i_c058_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_02 (mix_q_src_c058_0_02 0 bpf_c058_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_0_02 (mix_q_src_c058_0_02 mix_q_c058_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_03 (mix_i_src_c058_0_03 0 bpf_c058_0 0) vcvs gain=1.950903220161e-01
SMIXI_c058_0_03 (mix_i_src_c058_0_03 mix_i_c058_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_03 (mix_q_src_c058_0_03 0 bpf_c058_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_0_03 (mix_q_src_c058_0_03 mix_q_c058_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_04 (mix_i_src_c058_0_04 0 bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_0_04 (mix_i_src_c058_0_04 mix_i_c058_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_04 (mix_q_src_c058_0_04 0 bpf_c058_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_0_04 (mix_q_src_c058_0_04 mix_q_c058_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_05 (mix_i_src_c058_0_05 0 bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_0_05 (mix_i_src_c058_0_05 mix_i_c058_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_05 (mix_q_src_c058_0_05 0 bpf_c058_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_0_05 (mix_q_src_c058_0_05 mix_q_c058_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_06 (mix_i_src_c058_0_06 0 bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_0_06 (mix_i_src_c058_0_06 mix_i_c058_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_06 (mix_q_src_c058_0_06 0 bpf_c058_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_0_06 (mix_q_src_c058_0_06 mix_q_c058_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_07 (mix_i_src_c058_0_07 0 bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_0_07 (mix_i_src_c058_0_07 mix_i_c058_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_07 (mix_q_src_c058_0_07 0 bpf_c058_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_0_07 (mix_q_src_c058_0_07 mix_q_c058_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_08 (mix_i_src_c058_0_08 0 bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_0_08 (mix_i_src_c058_0_08 mix_i_c058_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_08 (mix_q_src_c058_0_08 0 bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_0_08 (mix_q_src_c058_0_08 mix_q_c058_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_09 (mix_i_src_c058_0_09 0 bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_0_09 (mix_i_src_c058_0_09 mix_i_c058_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_09 (mix_q_src_c058_0_09 0 bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_0_09 (mix_q_src_c058_0_09 mix_q_c058_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_10 (mix_i_src_c058_0_10 0 bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_0_10 (mix_i_src_c058_0_10 mix_i_c058_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_10 (mix_q_src_c058_0_10 0 bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_0_10 (mix_q_src_c058_0_10 mix_q_c058_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_11 (mix_i_src_c058_0_11 0 bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_0_11 (mix_i_src_c058_0_11 mix_i_c058_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_11 (mix_q_src_c058_0_11 0 bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_0_11 (mix_q_src_c058_0_11 mix_q_c058_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_12 (mix_i_src_c058_0_12 0 bpf_c058_0 0) vcvs gain=1.950903220161e-01
SMIXI_c058_0_12 (mix_i_src_c058_0_12 mix_i_c058_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_12 (mix_q_src_c058_0_12 0 bpf_c058_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_0_12 (mix_q_src_c058_0_12 mix_q_c058_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_13 (mix_i_src_c058_0_13 0 bpf_c058_0 0) vcvs gain=5.555702330196e-01
SMIXI_c058_0_13 (mix_i_src_c058_0_13 mix_i_c058_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_13 (mix_q_src_c058_0_13 0 bpf_c058_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_0_13 (mix_q_src_c058_0_13 mix_q_c058_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_14 (mix_i_src_c058_0_14 0 bpf_c058_0 0) vcvs gain=8.314696123025e-01
SMIXI_c058_0_14 (mix_i_src_c058_0_14 mix_i_c058_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_14 (mix_q_src_c058_0_14 0 bpf_c058_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_0_14 (mix_q_src_c058_0_14 mix_q_c058_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_0_15 (mix_i_src_c058_0_15 0 bpf_c058_0 0) vcvs gain=9.807852804032e-01
SMIXI_c058_0_15 (mix_i_src_c058_0_15 mix_i_c058_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_0_15 (mix_q_src_c058_0_15 0 bpf_c058_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_0_15 (mix_q_src_c058_0_15 mix_q_c058_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c058_0 (mix_i_c058_0 0) resistor r=1G
RMIXQ_c058_0 (mix_q_c058_0 0) resistor r=1G
RINTI_c058_0 (mix_i_c058_0 Icar_c058_0) resistor r=1k
CINTI_c058_0 (Icar_c058_0 0) capacitor c=80p
RINTQ_c058_0 (mix_q_c058_0 Qcar_c058_0) resistor r=1k
CINTQ_c058_0 (Qcar_c058_0 0) capacitor c=80p

// bl058, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c058_1 (bl058 n_cbpf_c058_1) capacitor c=1.013211836423e-13
LBPF_c058_1 (n_cbpf_c058_1 bpf_c058_1) inductor l=1.000000000000e-06
RBPF_c058_1 (bpf_c058_1 0) resistor r=1.570796326795e+02
EMIXI_c058_1_00 (mix_i_src_c058_1_00 0 bpf_c058_1 0) vcvs gain=9.807852804032e-01
SMIXI_c058_1_00 (mix_i_src_c058_1_00 mix_i_c058_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_00 (mix_q_src_c058_1_00 0 bpf_c058_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_1_00 (mix_q_src_c058_1_00 mix_q_c058_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_01 (mix_i_src_c058_1_01 0 bpf_c058_1 0) vcvs gain=8.314696123025e-01
SMIXI_c058_1_01 (mix_i_src_c058_1_01 mix_i_c058_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_01 (mix_q_src_c058_1_01 0 bpf_c058_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_1_01 (mix_q_src_c058_1_01 mix_q_c058_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_02 (mix_i_src_c058_1_02 0 bpf_c058_1 0) vcvs gain=5.555702330196e-01
SMIXI_c058_1_02 (mix_i_src_c058_1_02 mix_i_c058_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_02 (mix_q_src_c058_1_02 0 bpf_c058_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_1_02 (mix_q_src_c058_1_02 mix_q_c058_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_03 (mix_i_src_c058_1_03 0 bpf_c058_1 0) vcvs gain=1.950903220161e-01
SMIXI_c058_1_03 (mix_i_src_c058_1_03 mix_i_c058_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_03 (mix_q_src_c058_1_03 0 bpf_c058_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_1_03 (mix_q_src_c058_1_03 mix_q_c058_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_04 (mix_i_src_c058_1_04 0 bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_1_04 (mix_i_src_c058_1_04 mix_i_c058_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_04 (mix_q_src_c058_1_04 0 bpf_c058_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_1_04 (mix_q_src_c058_1_04 mix_q_c058_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_05 (mix_i_src_c058_1_05 0 bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_1_05 (mix_i_src_c058_1_05 mix_i_c058_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_05 (mix_q_src_c058_1_05 0 bpf_c058_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_1_05 (mix_q_src_c058_1_05 mix_q_c058_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_06 (mix_i_src_c058_1_06 0 bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_1_06 (mix_i_src_c058_1_06 mix_i_c058_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_06 (mix_q_src_c058_1_06 0 bpf_c058_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_1_06 (mix_q_src_c058_1_06 mix_q_c058_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_07 (mix_i_src_c058_1_07 0 bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_1_07 (mix_i_src_c058_1_07 mix_i_c058_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_07 (mix_q_src_c058_1_07 0 bpf_c058_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_1_07 (mix_q_src_c058_1_07 mix_q_c058_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_08 (mix_i_src_c058_1_08 0 bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_1_08 (mix_i_src_c058_1_08 mix_i_c058_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_08 (mix_q_src_c058_1_08 0 bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_1_08 (mix_q_src_c058_1_08 mix_q_c058_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_09 (mix_i_src_c058_1_09 0 bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_1_09 (mix_i_src_c058_1_09 mix_i_c058_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_09 (mix_q_src_c058_1_09 0 bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_1_09 (mix_q_src_c058_1_09 mix_q_c058_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_10 (mix_i_src_c058_1_10 0 bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_1_10 (mix_i_src_c058_1_10 mix_i_c058_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_10 (mix_q_src_c058_1_10 0 bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_1_10 (mix_q_src_c058_1_10 mix_q_c058_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_11 (mix_i_src_c058_1_11 0 bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_1_11 (mix_i_src_c058_1_11 mix_i_c058_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_11 (mix_q_src_c058_1_11 0 bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_1_11 (mix_q_src_c058_1_11 mix_q_c058_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_12 (mix_i_src_c058_1_12 0 bpf_c058_1 0) vcvs gain=1.950903220161e-01
SMIXI_c058_1_12 (mix_i_src_c058_1_12 mix_i_c058_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_12 (mix_q_src_c058_1_12 0 bpf_c058_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_1_12 (mix_q_src_c058_1_12 mix_q_c058_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_13 (mix_i_src_c058_1_13 0 bpf_c058_1 0) vcvs gain=5.555702330196e-01
SMIXI_c058_1_13 (mix_i_src_c058_1_13 mix_i_c058_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_13 (mix_q_src_c058_1_13 0 bpf_c058_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_1_13 (mix_q_src_c058_1_13 mix_q_c058_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_14 (mix_i_src_c058_1_14 0 bpf_c058_1 0) vcvs gain=8.314696123025e-01
SMIXI_c058_1_14 (mix_i_src_c058_1_14 mix_i_c058_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_14 (mix_q_src_c058_1_14 0 bpf_c058_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_1_14 (mix_q_src_c058_1_14 mix_q_c058_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_1_15 (mix_i_src_c058_1_15 0 bpf_c058_1 0) vcvs gain=9.807852804032e-01
SMIXI_c058_1_15 (mix_i_src_c058_1_15 mix_i_c058_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_1_15 (mix_q_src_c058_1_15 0 bpf_c058_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_1_15 (mix_q_src_c058_1_15 mix_q_c058_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c058_1 (mix_i_c058_1 0) resistor r=1G
RMIXQ_c058_1 (mix_q_c058_1 0) resistor r=1G
RINTI_c058_1 (mix_i_c058_1 Icar_c058_1) resistor r=1k
CINTI_c058_1 (Icar_c058_1 0) capacitor c=80p
RINTQ_c058_1 (mix_q_c058_1 Qcar_c058_1) resistor r=1k
CINTQ_c058_1 (Qcar_c058_1 0) capacitor c=80p

// bl058, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c058_2 (bl058 n_cbpf_c058_2) capacitor c=4.503163717437e-14
LBPF_c058_2 (n_cbpf_c058_2 bpf_c058_2) inductor l=1.000000000000e-06
RBPF_c058_2 (bpf_c058_2 0) resistor r=2.356194490192e+02
EMIXI_c058_2_00 (mix_i_src_c058_2_00 0 bpf_c058_2 0) vcvs gain=9.807852804032e-01
SMIXI_c058_2_00 (mix_i_src_c058_2_00 mix_i_c058_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_00 (mix_q_src_c058_2_00 0 bpf_c058_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_2_00 (mix_q_src_c058_2_00 mix_q_c058_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_01 (mix_i_src_c058_2_01 0 bpf_c058_2 0) vcvs gain=8.314696123025e-01
SMIXI_c058_2_01 (mix_i_src_c058_2_01 mix_i_c058_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_01 (mix_q_src_c058_2_01 0 bpf_c058_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_2_01 (mix_q_src_c058_2_01 mix_q_c058_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_02 (mix_i_src_c058_2_02 0 bpf_c058_2 0) vcvs gain=5.555702330196e-01
SMIXI_c058_2_02 (mix_i_src_c058_2_02 mix_i_c058_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_02 (mix_q_src_c058_2_02 0 bpf_c058_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_2_02 (mix_q_src_c058_2_02 mix_q_c058_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_03 (mix_i_src_c058_2_03 0 bpf_c058_2 0) vcvs gain=1.950903220161e-01
SMIXI_c058_2_03 (mix_i_src_c058_2_03 mix_i_c058_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_03 (mix_q_src_c058_2_03 0 bpf_c058_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_2_03 (mix_q_src_c058_2_03 mix_q_c058_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_04 (mix_i_src_c058_2_04 0 bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_2_04 (mix_i_src_c058_2_04 mix_i_c058_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_04 (mix_q_src_c058_2_04 0 bpf_c058_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_2_04 (mix_q_src_c058_2_04 mix_q_c058_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_05 (mix_i_src_c058_2_05 0 bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_2_05 (mix_i_src_c058_2_05 mix_i_c058_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_05 (mix_q_src_c058_2_05 0 bpf_c058_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_2_05 (mix_q_src_c058_2_05 mix_q_c058_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_06 (mix_i_src_c058_2_06 0 bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_2_06 (mix_i_src_c058_2_06 mix_i_c058_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_06 (mix_q_src_c058_2_06 0 bpf_c058_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_2_06 (mix_q_src_c058_2_06 mix_q_c058_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_07 (mix_i_src_c058_2_07 0 bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_2_07 (mix_i_src_c058_2_07 mix_i_c058_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_07 (mix_q_src_c058_2_07 0 bpf_c058_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_2_07 (mix_q_src_c058_2_07 mix_q_c058_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_08 (mix_i_src_c058_2_08 0 bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_2_08 (mix_i_src_c058_2_08 mix_i_c058_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_08 (mix_q_src_c058_2_08 0 bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_2_08 (mix_q_src_c058_2_08 mix_q_c058_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_09 (mix_i_src_c058_2_09 0 bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_2_09 (mix_i_src_c058_2_09 mix_i_c058_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_09 (mix_q_src_c058_2_09 0 bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_2_09 (mix_q_src_c058_2_09 mix_q_c058_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_10 (mix_i_src_c058_2_10 0 bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_2_10 (mix_i_src_c058_2_10 mix_i_c058_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_10 (mix_q_src_c058_2_10 0 bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_2_10 (mix_q_src_c058_2_10 mix_q_c058_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_11 (mix_i_src_c058_2_11 0 bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_2_11 (mix_i_src_c058_2_11 mix_i_c058_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_11 (mix_q_src_c058_2_11 0 bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_2_11 (mix_q_src_c058_2_11 mix_q_c058_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_12 (mix_i_src_c058_2_12 0 bpf_c058_2 0) vcvs gain=1.950903220161e-01
SMIXI_c058_2_12 (mix_i_src_c058_2_12 mix_i_c058_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_12 (mix_q_src_c058_2_12 0 bpf_c058_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_2_12 (mix_q_src_c058_2_12 mix_q_c058_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_13 (mix_i_src_c058_2_13 0 bpf_c058_2 0) vcvs gain=5.555702330196e-01
SMIXI_c058_2_13 (mix_i_src_c058_2_13 mix_i_c058_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_13 (mix_q_src_c058_2_13 0 bpf_c058_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_2_13 (mix_q_src_c058_2_13 mix_q_c058_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_14 (mix_i_src_c058_2_14 0 bpf_c058_2 0) vcvs gain=8.314696123025e-01
SMIXI_c058_2_14 (mix_i_src_c058_2_14 mix_i_c058_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_14 (mix_q_src_c058_2_14 0 bpf_c058_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_2_14 (mix_q_src_c058_2_14 mix_q_c058_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_2_15 (mix_i_src_c058_2_15 0 bpf_c058_2 0) vcvs gain=9.807852804032e-01
SMIXI_c058_2_15 (mix_i_src_c058_2_15 mix_i_c058_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_2_15 (mix_q_src_c058_2_15 0 bpf_c058_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_2_15 (mix_q_src_c058_2_15 mix_q_c058_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c058_2 (mix_i_c058_2 0) resistor r=1G
RMIXQ_c058_2 (mix_q_c058_2 0) resistor r=1G
RINTI_c058_2 (mix_i_c058_2 Icar_c058_2) resistor r=1k
CINTI_c058_2 (Icar_c058_2 0) capacitor c=80p
RINTQ_c058_2 (mix_q_c058_2 Qcar_c058_2) resistor r=1k
CINTQ_c058_2 (Qcar_c058_2 0) capacitor c=80p

// bl058, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c058_3 (bl058 n_cbpf_c058_3) capacitor c=2.533029591058e-14
LBPF_c058_3 (n_cbpf_c058_3 bpf_c058_3) inductor l=1.000000000000e-06
RBPF_c058_3 (bpf_c058_3 0) resistor r=3.141592653590e+02
EMIXI_c058_3_00 (mix_i_src_c058_3_00 0 bpf_c058_3 0) vcvs gain=9.807852804032e-01
SMIXI_c058_3_00 (mix_i_src_c058_3_00 mix_i_c058_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_00 (mix_q_src_c058_3_00 0 bpf_c058_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_3_00 (mix_q_src_c058_3_00 mix_q_c058_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_01 (mix_i_src_c058_3_01 0 bpf_c058_3 0) vcvs gain=8.314696123025e-01
SMIXI_c058_3_01 (mix_i_src_c058_3_01 mix_i_c058_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_01 (mix_q_src_c058_3_01 0 bpf_c058_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_3_01 (mix_q_src_c058_3_01 mix_q_c058_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_02 (mix_i_src_c058_3_02 0 bpf_c058_3 0) vcvs gain=5.555702330196e-01
SMIXI_c058_3_02 (mix_i_src_c058_3_02 mix_i_c058_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_02 (mix_q_src_c058_3_02 0 bpf_c058_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_3_02 (mix_q_src_c058_3_02 mix_q_c058_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_03 (mix_i_src_c058_3_03 0 bpf_c058_3 0) vcvs gain=1.950903220161e-01
SMIXI_c058_3_03 (mix_i_src_c058_3_03 mix_i_c058_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_03 (mix_q_src_c058_3_03 0 bpf_c058_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_3_03 (mix_q_src_c058_3_03 mix_q_c058_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_04 (mix_i_src_c058_3_04 0 bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_3_04 (mix_i_src_c058_3_04 mix_i_c058_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_04 (mix_q_src_c058_3_04 0 bpf_c058_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c058_3_04 (mix_q_src_c058_3_04 mix_q_c058_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_05 (mix_i_src_c058_3_05 0 bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_3_05 (mix_i_src_c058_3_05 mix_i_c058_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_05 (mix_q_src_c058_3_05 0 bpf_c058_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c058_3_05 (mix_q_src_c058_3_05 mix_q_c058_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_06 (mix_i_src_c058_3_06 0 bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_3_06 (mix_i_src_c058_3_06 mix_i_c058_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_06 (mix_q_src_c058_3_06 0 bpf_c058_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c058_3_06 (mix_q_src_c058_3_06 mix_q_c058_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_07 (mix_i_src_c058_3_07 0 bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_3_07 (mix_i_src_c058_3_07 mix_i_c058_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_07 (mix_q_src_c058_3_07 0 bpf_c058_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c058_3_07 (mix_q_src_c058_3_07 mix_q_c058_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_08 (mix_i_src_c058_3_08 0 bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c058_3_08 (mix_i_src_c058_3_08 mix_i_c058_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_08 (mix_q_src_c058_3_08 0 bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_3_08 (mix_q_src_c058_3_08 mix_q_c058_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_09 (mix_i_src_c058_3_09 0 bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c058_3_09 (mix_i_src_c058_3_09 mix_i_c058_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_09 (mix_q_src_c058_3_09 0 bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_3_09 (mix_q_src_c058_3_09 mix_q_c058_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_10 (mix_i_src_c058_3_10 0 bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c058_3_10 (mix_i_src_c058_3_10 mix_i_c058_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_10 (mix_q_src_c058_3_10 0 bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_3_10 (mix_q_src_c058_3_10 mix_q_c058_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_11 (mix_i_src_c058_3_11 0 bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c058_3_11 (mix_i_src_c058_3_11 mix_i_c058_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_11 (mix_q_src_c058_3_11 0 bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_3_11 (mix_q_src_c058_3_11 mix_q_c058_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_12 (mix_i_src_c058_3_12 0 bpf_c058_3 0) vcvs gain=1.950903220161e-01
SMIXI_c058_3_12 (mix_i_src_c058_3_12 mix_i_c058_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_12 (mix_q_src_c058_3_12 0 bpf_c058_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c058_3_12 (mix_q_src_c058_3_12 mix_q_c058_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_13 (mix_i_src_c058_3_13 0 bpf_c058_3 0) vcvs gain=5.555702330196e-01
SMIXI_c058_3_13 (mix_i_src_c058_3_13 mix_i_c058_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_13 (mix_q_src_c058_3_13 0 bpf_c058_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c058_3_13 (mix_q_src_c058_3_13 mix_q_c058_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_14 (mix_i_src_c058_3_14 0 bpf_c058_3 0) vcvs gain=8.314696123025e-01
SMIXI_c058_3_14 (mix_i_src_c058_3_14 mix_i_c058_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_14 (mix_q_src_c058_3_14 0 bpf_c058_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c058_3_14 (mix_q_src_c058_3_14 mix_q_c058_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c058_3_15 (mix_i_src_c058_3_15 0 bpf_c058_3 0) vcvs gain=9.807852804032e-01
SMIXI_c058_3_15 (mix_i_src_c058_3_15 mix_i_c058_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c058_3_15 (mix_q_src_c058_3_15 0 bpf_c058_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c058_3_15 (mix_q_src_c058_3_15 mix_q_c058_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c058_3 (mix_i_c058_3 0) resistor r=1G
RMIXQ_c058_3 (mix_q_c058_3 0) resistor r=1G
RINTI_c058_3 (mix_i_c058_3 Icar_c058_3) resistor r=1k
CINTI_c058_3 (Icar_c058_3 0) capacitor c=80p
RINTQ_c058_3 (mix_q_c058_3 Qcar_c058_3) resistor r=1k
CINTQ_c058_3 (Qcar_c058_3 0) capacitor c=80p

// bl059, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c059_0 (bl059 n_cbpf_c059_0) capacitor c=4.052847345694e-13
LBPF_c059_0 (n_cbpf_c059_0 bpf_c059_0) inductor l=1.000000000000e-06
RBPF_c059_0 (bpf_c059_0 0) resistor r=7.853981633974e+01
EMIXI_c059_0_00 (mix_i_src_c059_0_00 0 bpf_c059_0 0) vcvs gain=9.807852804032e-01
SMIXI_c059_0_00 (mix_i_src_c059_0_00 mix_i_c059_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_00 (mix_q_src_c059_0_00 0 bpf_c059_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_0_00 (mix_q_src_c059_0_00 mix_q_c059_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_01 (mix_i_src_c059_0_01 0 bpf_c059_0 0) vcvs gain=8.314696123025e-01
SMIXI_c059_0_01 (mix_i_src_c059_0_01 mix_i_c059_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_01 (mix_q_src_c059_0_01 0 bpf_c059_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_0_01 (mix_q_src_c059_0_01 mix_q_c059_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_02 (mix_i_src_c059_0_02 0 bpf_c059_0 0) vcvs gain=5.555702330196e-01
SMIXI_c059_0_02 (mix_i_src_c059_0_02 mix_i_c059_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_02 (mix_q_src_c059_0_02 0 bpf_c059_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_0_02 (mix_q_src_c059_0_02 mix_q_c059_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_03 (mix_i_src_c059_0_03 0 bpf_c059_0 0) vcvs gain=1.950903220161e-01
SMIXI_c059_0_03 (mix_i_src_c059_0_03 mix_i_c059_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_03 (mix_q_src_c059_0_03 0 bpf_c059_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_0_03 (mix_q_src_c059_0_03 mix_q_c059_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_04 (mix_i_src_c059_0_04 0 bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_0_04 (mix_i_src_c059_0_04 mix_i_c059_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_04 (mix_q_src_c059_0_04 0 bpf_c059_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_0_04 (mix_q_src_c059_0_04 mix_q_c059_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_05 (mix_i_src_c059_0_05 0 bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_0_05 (mix_i_src_c059_0_05 mix_i_c059_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_05 (mix_q_src_c059_0_05 0 bpf_c059_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_0_05 (mix_q_src_c059_0_05 mix_q_c059_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_06 (mix_i_src_c059_0_06 0 bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_0_06 (mix_i_src_c059_0_06 mix_i_c059_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_06 (mix_q_src_c059_0_06 0 bpf_c059_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_0_06 (mix_q_src_c059_0_06 mix_q_c059_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_07 (mix_i_src_c059_0_07 0 bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_0_07 (mix_i_src_c059_0_07 mix_i_c059_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_07 (mix_q_src_c059_0_07 0 bpf_c059_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_0_07 (mix_q_src_c059_0_07 mix_q_c059_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_08 (mix_i_src_c059_0_08 0 bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_0_08 (mix_i_src_c059_0_08 mix_i_c059_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_08 (mix_q_src_c059_0_08 0 bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_0_08 (mix_q_src_c059_0_08 mix_q_c059_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_09 (mix_i_src_c059_0_09 0 bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_0_09 (mix_i_src_c059_0_09 mix_i_c059_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_09 (mix_q_src_c059_0_09 0 bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_0_09 (mix_q_src_c059_0_09 mix_q_c059_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_10 (mix_i_src_c059_0_10 0 bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_0_10 (mix_i_src_c059_0_10 mix_i_c059_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_10 (mix_q_src_c059_0_10 0 bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_0_10 (mix_q_src_c059_0_10 mix_q_c059_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_11 (mix_i_src_c059_0_11 0 bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_0_11 (mix_i_src_c059_0_11 mix_i_c059_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_11 (mix_q_src_c059_0_11 0 bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_0_11 (mix_q_src_c059_0_11 mix_q_c059_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_12 (mix_i_src_c059_0_12 0 bpf_c059_0 0) vcvs gain=1.950903220161e-01
SMIXI_c059_0_12 (mix_i_src_c059_0_12 mix_i_c059_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_12 (mix_q_src_c059_0_12 0 bpf_c059_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_0_12 (mix_q_src_c059_0_12 mix_q_c059_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_13 (mix_i_src_c059_0_13 0 bpf_c059_0 0) vcvs gain=5.555702330196e-01
SMIXI_c059_0_13 (mix_i_src_c059_0_13 mix_i_c059_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_13 (mix_q_src_c059_0_13 0 bpf_c059_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_0_13 (mix_q_src_c059_0_13 mix_q_c059_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_14 (mix_i_src_c059_0_14 0 bpf_c059_0 0) vcvs gain=8.314696123025e-01
SMIXI_c059_0_14 (mix_i_src_c059_0_14 mix_i_c059_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_14 (mix_q_src_c059_0_14 0 bpf_c059_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_0_14 (mix_q_src_c059_0_14 mix_q_c059_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_0_15 (mix_i_src_c059_0_15 0 bpf_c059_0 0) vcvs gain=9.807852804032e-01
SMIXI_c059_0_15 (mix_i_src_c059_0_15 mix_i_c059_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_0_15 (mix_q_src_c059_0_15 0 bpf_c059_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_0_15 (mix_q_src_c059_0_15 mix_q_c059_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c059_0 (mix_i_c059_0 0) resistor r=1G
RMIXQ_c059_0 (mix_q_c059_0 0) resistor r=1G
RINTI_c059_0 (mix_i_c059_0 Icar_c059_0) resistor r=1k
CINTI_c059_0 (Icar_c059_0 0) capacitor c=80p
RINTQ_c059_0 (mix_q_c059_0 Qcar_c059_0) resistor r=1k
CINTQ_c059_0 (Qcar_c059_0 0) capacitor c=80p

// bl059, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c059_1 (bl059 n_cbpf_c059_1) capacitor c=1.013211836423e-13
LBPF_c059_1 (n_cbpf_c059_1 bpf_c059_1) inductor l=1.000000000000e-06
RBPF_c059_1 (bpf_c059_1 0) resistor r=1.570796326795e+02
EMIXI_c059_1_00 (mix_i_src_c059_1_00 0 bpf_c059_1 0) vcvs gain=9.807852804032e-01
SMIXI_c059_1_00 (mix_i_src_c059_1_00 mix_i_c059_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_00 (mix_q_src_c059_1_00 0 bpf_c059_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_1_00 (mix_q_src_c059_1_00 mix_q_c059_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_01 (mix_i_src_c059_1_01 0 bpf_c059_1 0) vcvs gain=8.314696123025e-01
SMIXI_c059_1_01 (mix_i_src_c059_1_01 mix_i_c059_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_01 (mix_q_src_c059_1_01 0 bpf_c059_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_1_01 (mix_q_src_c059_1_01 mix_q_c059_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_02 (mix_i_src_c059_1_02 0 bpf_c059_1 0) vcvs gain=5.555702330196e-01
SMIXI_c059_1_02 (mix_i_src_c059_1_02 mix_i_c059_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_02 (mix_q_src_c059_1_02 0 bpf_c059_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_1_02 (mix_q_src_c059_1_02 mix_q_c059_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_03 (mix_i_src_c059_1_03 0 bpf_c059_1 0) vcvs gain=1.950903220161e-01
SMIXI_c059_1_03 (mix_i_src_c059_1_03 mix_i_c059_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_03 (mix_q_src_c059_1_03 0 bpf_c059_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_1_03 (mix_q_src_c059_1_03 mix_q_c059_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_04 (mix_i_src_c059_1_04 0 bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_1_04 (mix_i_src_c059_1_04 mix_i_c059_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_04 (mix_q_src_c059_1_04 0 bpf_c059_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_1_04 (mix_q_src_c059_1_04 mix_q_c059_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_05 (mix_i_src_c059_1_05 0 bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_1_05 (mix_i_src_c059_1_05 mix_i_c059_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_05 (mix_q_src_c059_1_05 0 bpf_c059_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_1_05 (mix_q_src_c059_1_05 mix_q_c059_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_06 (mix_i_src_c059_1_06 0 bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_1_06 (mix_i_src_c059_1_06 mix_i_c059_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_06 (mix_q_src_c059_1_06 0 bpf_c059_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_1_06 (mix_q_src_c059_1_06 mix_q_c059_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_07 (mix_i_src_c059_1_07 0 bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_1_07 (mix_i_src_c059_1_07 mix_i_c059_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_07 (mix_q_src_c059_1_07 0 bpf_c059_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_1_07 (mix_q_src_c059_1_07 mix_q_c059_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_08 (mix_i_src_c059_1_08 0 bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_1_08 (mix_i_src_c059_1_08 mix_i_c059_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_08 (mix_q_src_c059_1_08 0 bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_1_08 (mix_q_src_c059_1_08 mix_q_c059_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_09 (mix_i_src_c059_1_09 0 bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_1_09 (mix_i_src_c059_1_09 mix_i_c059_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_09 (mix_q_src_c059_1_09 0 bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_1_09 (mix_q_src_c059_1_09 mix_q_c059_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_10 (mix_i_src_c059_1_10 0 bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_1_10 (mix_i_src_c059_1_10 mix_i_c059_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_10 (mix_q_src_c059_1_10 0 bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_1_10 (mix_q_src_c059_1_10 mix_q_c059_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_11 (mix_i_src_c059_1_11 0 bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_1_11 (mix_i_src_c059_1_11 mix_i_c059_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_11 (mix_q_src_c059_1_11 0 bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_1_11 (mix_q_src_c059_1_11 mix_q_c059_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_12 (mix_i_src_c059_1_12 0 bpf_c059_1 0) vcvs gain=1.950903220161e-01
SMIXI_c059_1_12 (mix_i_src_c059_1_12 mix_i_c059_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_12 (mix_q_src_c059_1_12 0 bpf_c059_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_1_12 (mix_q_src_c059_1_12 mix_q_c059_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_13 (mix_i_src_c059_1_13 0 bpf_c059_1 0) vcvs gain=5.555702330196e-01
SMIXI_c059_1_13 (mix_i_src_c059_1_13 mix_i_c059_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_13 (mix_q_src_c059_1_13 0 bpf_c059_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_1_13 (mix_q_src_c059_1_13 mix_q_c059_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_14 (mix_i_src_c059_1_14 0 bpf_c059_1 0) vcvs gain=8.314696123025e-01
SMIXI_c059_1_14 (mix_i_src_c059_1_14 mix_i_c059_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_14 (mix_q_src_c059_1_14 0 bpf_c059_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_1_14 (mix_q_src_c059_1_14 mix_q_c059_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_1_15 (mix_i_src_c059_1_15 0 bpf_c059_1 0) vcvs gain=9.807852804032e-01
SMIXI_c059_1_15 (mix_i_src_c059_1_15 mix_i_c059_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_1_15 (mix_q_src_c059_1_15 0 bpf_c059_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_1_15 (mix_q_src_c059_1_15 mix_q_c059_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c059_1 (mix_i_c059_1 0) resistor r=1G
RMIXQ_c059_1 (mix_q_c059_1 0) resistor r=1G
RINTI_c059_1 (mix_i_c059_1 Icar_c059_1) resistor r=1k
CINTI_c059_1 (Icar_c059_1 0) capacitor c=80p
RINTQ_c059_1 (mix_q_c059_1 Qcar_c059_1) resistor r=1k
CINTQ_c059_1 (Qcar_c059_1 0) capacitor c=80p

// bl059, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c059_2 (bl059 n_cbpf_c059_2) capacitor c=4.503163717437e-14
LBPF_c059_2 (n_cbpf_c059_2 bpf_c059_2) inductor l=1.000000000000e-06
RBPF_c059_2 (bpf_c059_2 0) resistor r=2.356194490192e+02
EMIXI_c059_2_00 (mix_i_src_c059_2_00 0 bpf_c059_2 0) vcvs gain=9.807852804032e-01
SMIXI_c059_2_00 (mix_i_src_c059_2_00 mix_i_c059_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_00 (mix_q_src_c059_2_00 0 bpf_c059_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_2_00 (mix_q_src_c059_2_00 mix_q_c059_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_01 (mix_i_src_c059_2_01 0 bpf_c059_2 0) vcvs gain=8.314696123025e-01
SMIXI_c059_2_01 (mix_i_src_c059_2_01 mix_i_c059_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_01 (mix_q_src_c059_2_01 0 bpf_c059_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_2_01 (mix_q_src_c059_2_01 mix_q_c059_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_02 (mix_i_src_c059_2_02 0 bpf_c059_2 0) vcvs gain=5.555702330196e-01
SMIXI_c059_2_02 (mix_i_src_c059_2_02 mix_i_c059_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_02 (mix_q_src_c059_2_02 0 bpf_c059_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_2_02 (mix_q_src_c059_2_02 mix_q_c059_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_03 (mix_i_src_c059_2_03 0 bpf_c059_2 0) vcvs gain=1.950903220161e-01
SMIXI_c059_2_03 (mix_i_src_c059_2_03 mix_i_c059_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_03 (mix_q_src_c059_2_03 0 bpf_c059_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_2_03 (mix_q_src_c059_2_03 mix_q_c059_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_04 (mix_i_src_c059_2_04 0 bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_2_04 (mix_i_src_c059_2_04 mix_i_c059_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_04 (mix_q_src_c059_2_04 0 bpf_c059_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_2_04 (mix_q_src_c059_2_04 mix_q_c059_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_05 (mix_i_src_c059_2_05 0 bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_2_05 (mix_i_src_c059_2_05 mix_i_c059_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_05 (mix_q_src_c059_2_05 0 bpf_c059_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_2_05 (mix_q_src_c059_2_05 mix_q_c059_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_06 (mix_i_src_c059_2_06 0 bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_2_06 (mix_i_src_c059_2_06 mix_i_c059_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_06 (mix_q_src_c059_2_06 0 bpf_c059_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_2_06 (mix_q_src_c059_2_06 mix_q_c059_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_07 (mix_i_src_c059_2_07 0 bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_2_07 (mix_i_src_c059_2_07 mix_i_c059_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_07 (mix_q_src_c059_2_07 0 bpf_c059_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_2_07 (mix_q_src_c059_2_07 mix_q_c059_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_08 (mix_i_src_c059_2_08 0 bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_2_08 (mix_i_src_c059_2_08 mix_i_c059_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_08 (mix_q_src_c059_2_08 0 bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_2_08 (mix_q_src_c059_2_08 mix_q_c059_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_09 (mix_i_src_c059_2_09 0 bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_2_09 (mix_i_src_c059_2_09 mix_i_c059_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_09 (mix_q_src_c059_2_09 0 bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_2_09 (mix_q_src_c059_2_09 mix_q_c059_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_10 (mix_i_src_c059_2_10 0 bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_2_10 (mix_i_src_c059_2_10 mix_i_c059_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_10 (mix_q_src_c059_2_10 0 bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_2_10 (mix_q_src_c059_2_10 mix_q_c059_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_11 (mix_i_src_c059_2_11 0 bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_2_11 (mix_i_src_c059_2_11 mix_i_c059_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_11 (mix_q_src_c059_2_11 0 bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_2_11 (mix_q_src_c059_2_11 mix_q_c059_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_12 (mix_i_src_c059_2_12 0 bpf_c059_2 0) vcvs gain=1.950903220161e-01
SMIXI_c059_2_12 (mix_i_src_c059_2_12 mix_i_c059_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_12 (mix_q_src_c059_2_12 0 bpf_c059_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_2_12 (mix_q_src_c059_2_12 mix_q_c059_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_13 (mix_i_src_c059_2_13 0 bpf_c059_2 0) vcvs gain=5.555702330196e-01
SMIXI_c059_2_13 (mix_i_src_c059_2_13 mix_i_c059_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_13 (mix_q_src_c059_2_13 0 bpf_c059_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_2_13 (mix_q_src_c059_2_13 mix_q_c059_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_14 (mix_i_src_c059_2_14 0 bpf_c059_2 0) vcvs gain=8.314696123025e-01
SMIXI_c059_2_14 (mix_i_src_c059_2_14 mix_i_c059_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_14 (mix_q_src_c059_2_14 0 bpf_c059_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_2_14 (mix_q_src_c059_2_14 mix_q_c059_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_2_15 (mix_i_src_c059_2_15 0 bpf_c059_2 0) vcvs gain=9.807852804032e-01
SMIXI_c059_2_15 (mix_i_src_c059_2_15 mix_i_c059_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_2_15 (mix_q_src_c059_2_15 0 bpf_c059_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_2_15 (mix_q_src_c059_2_15 mix_q_c059_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c059_2 (mix_i_c059_2 0) resistor r=1G
RMIXQ_c059_2 (mix_q_c059_2 0) resistor r=1G
RINTI_c059_2 (mix_i_c059_2 Icar_c059_2) resistor r=1k
CINTI_c059_2 (Icar_c059_2 0) capacitor c=80p
RINTQ_c059_2 (mix_q_c059_2 Qcar_c059_2) resistor r=1k
CINTQ_c059_2 (Qcar_c059_2 0) capacitor c=80p

// bl059, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c059_3 (bl059 n_cbpf_c059_3) capacitor c=2.533029591058e-14
LBPF_c059_3 (n_cbpf_c059_3 bpf_c059_3) inductor l=1.000000000000e-06
RBPF_c059_3 (bpf_c059_3 0) resistor r=3.141592653590e+02
EMIXI_c059_3_00 (mix_i_src_c059_3_00 0 bpf_c059_3 0) vcvs gain=9.807852804032e-01
SMIXI_c059_3_00 (mix_i_src_c059_3_00 mix_i_c059_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_00 (mix_q_src_c059_3_00 0 bpf_c059_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_3_00 (mix_q_src_c059_3_00 mix_q_c059_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_01 (mix_i_src_c059_3_01 0 bpf_c059_3 0) vcvs gain=8.314696123025e-01
SMIXI_c059_3_01 (mix_i_src_c059_3_01 mix_i_c059_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_01 (mix_q_src_c059_3_01 0 bpf_c059_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_3_01 (mix_q_src_c059_3_01 mix_q_c059_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_02 (mix_i_src_c059_3_02 0 bpf_c059_3 0) vcvs gain=5.555702330196e-01
SMIXI_c059_3_02 (mix_i_src_c059_3_02 mix_i_c059_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_02 (mix_q_src_c059_3_02 0 bpf_c059_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_3_02 (mix_q_src_c059_3_02 mix_q_c059_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_03 (mix_i_src_c059_3_03 0 bpf_c059_3 0) vcvs gain=1.950903220161e-01
SMIXI_c059_3_03 (mix_i_src_c059_3_03 mix_i_c059_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_03 (mix_q_src_c059_3_03 0 bpf_c059_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_3_03 (mix_q_src_c059_3_03 mix_q_c059_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_04 (mix_i_src_c059_3_04 0 bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_3_04 (mix_i_src_c059_3_04 mix_i_c059_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_04 (mix_q_src_c059_3_04 0 bpf_c059_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c059_3_04 (mix_q_src_c059_3_04 mix_q_c059_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_05 (mix_i_src_c059_3_05 0 bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_3_05 (mix_i_src_c059_3_05 mix_i_c059_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_05 (mix_q_src_c059_3_05 0 bpf_c059_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c059_3_05 (mix_q_src_c059_3_05 mix_q_c059_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_06 (mix_i_src_c059_3_06 0 bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_3_06 (mix_i_src_c059_3_06 mix_i_c059_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_06 (mix_q_src_c059_3_06 0 bpf_c059_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c059_3_06 (mix_q_src_c059_3_06 mix_q_c059_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_07 (mix_i_src_c059_3_07 0 bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_3_07 (mix_i_src_c059_3_07 mix_i_c059_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_07 (mix_q_src_c059_3_07 0 bpf_c059_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c059_3_07 (mix_q_src_c059_3_07 mix_q_c059_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_08 (mix_i_src_c059_3_08 0 bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c059_3_08 (mix_i_src_c059_3_08 mix_i_c059_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_08 (mix_q_src_c059_3_08 0 bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_3_08 (mix_q_src_c059_3_08 mix_q_c059_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_09 (mix_i_src_c059_3_09 0 bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c059_3_09 (mix_i_src_c059_3_09 mix_i_c059_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_09 (mix_q_src_c059_3_09 0 bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_3_09 (mix_q_src_c059_3_09 mix_q_c059_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_10 (mix_i_src_c059_3_10 0 bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c059_3_10 (mix_i_src_c059_3_10 mix_i_c059_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_10 (mix_q_src_c059_3_10 0 bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_3_10 (mix_q_src_c059_3_10 mix_q_c059_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_11 (mix_i_src_c059_3_11 0 bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c059_3_11 (mix_i_src_c059_3_11 mix_i_c059_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_11 (mix_q_src_c059_3_11 0 bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_3_11 (mix_q_src_c059_3_11 mix_q_c059_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_12 (mix_i_src_c059_3_12 0 bpf_c059_3 0) vcvs gain=1.950903220161e-01
SMIXI_c059_3_12 (mix_i_src_c059_3_12 mix_i_c059_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_12 (mix_q_src_c059_3_12 0 bpf_c059_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c059_3_12 (mix_q_src_c059_3_12 mix_q_c059_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_13 (mix_i_src_c059_3_13 0 bpf_c059_3 0) vcvs gain=5.555702330196e-01
SMIXI_c059_3_13 (mix_i_src_c059_3_13 mix_i_c059_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_13 (mix_q_src_c059_3_13 0 bpf_c059_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c059_3_13 (mix_q_src_c059_3_13 mix_q_c059_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_14 (mix_i_src_c059_3_14 0 bpf_c059_3 0) vcvs gain=8.314696123025e-01
SMIXI_c059_3_14 (mix_i_src_c059_3_14 mix_i_c059_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_14 (mix_q_src_c059_3_14 0 bpf_c059_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c059_3_14 (mix_q_src_c059_3_14 mix_q_c059_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c059_3_15 (mix_i_src_c059_3_15 0 bpf_c059_3 0) vcvs gain=9.807852804032e-01
SMIXI_c059_3_15 (mix_i_src_c059_3_15 mix_i_c059_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c059_3_15 (mix_q_src_c059_3_15 0 bpf_c059_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c059_3_15 (mix_q_src_c059_3_15 mix_q_c059_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c059_3 (mix_i_c059_3 0) resistor r=1G
RMIXQ_c059_3 (mix_q_c059_3 0) resistor r=1G
RINTI_c059_3 (mix_i_c059_3 Icar_c059_3) resistor r=1k
CINTI_c059_3 (Icar_c059_3 0) capacitor c=80p
RINTQ_c059_3 (mix_q_c059_3 Qcar_c059_3) resistor r=1k
CINTQ_c059_3 (Qcar_c059_3 0) capacitor c=80p

// bl060, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c060_0 (bl060 n_cbpf_c060_0) capacitor c=4.052847345694e-13
LBPF_c060_0 (n_cbpf_c060_0 bpf_c060_0) inductor l=1.000000000000e-06
RBPF_c060_0 (bpf_c060_0 0) resistor r=7.853981633974e+01
EMIXI_c060_0_00 (mix_i_src_c060_0_00 0 bpf_c060_0 0) vcvs gain=9.807852804032e-01
SMIXI_c060_0_00 (mix_i_src_c060_0_00 mix_i_c060_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_00 (mix_q_src_c060_0_00 0 bpf_c060_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_0_00 (mix_q_src_c060_0_00 mix_q_c060_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_01 (mix_i_src_c060_0_01 0 bpf_c060_0 0) vcvs gain=8.314696123025e-01
SMIXI_c060_0_01 (mix_i_src_c060_0_01 mix_i_c060_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_01 (mix_q_src_c060_0_01 0 bpf_c060_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_0_01 (mix_q_src_c060_0_01 mix_q_c060_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_02 (mix_i_src_c060_0_02 0 bpf_c060_0 0) vcvs gain=5.555702330196e-01
SMIXI_c060_0_02 (mix_i_src_c060_0_02 mix_i_c060_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_02 (mix_q_src_c060_0_02 0 bpf_c060_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_0_02 (mix_q_src_c060_0_02 mix_q_c060_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_03 (mix_i_src_c060_0_03 0 bpf_c060_0 0) vcvs gain=1.950903220161e-01
SMIXI_c060_0_03 (mix_i_src_c060_0_03 mix_i_c060_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_03 (mix_q_src_c060_0_03 0 bpf_c060_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_0_03 (mix_q_src_c060_0_03 mix_q_c060_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_04 (mix_i_src_c060_0_04 0 bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_0_04 (mix_i_src_c060_0_04 mix_i_c060_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_04 (mix_q_src_c060_0_04 0 bpf_c060_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_0_04 (mix_q_src_c060_0_04 mix_q_c060_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_05 (mix_i_src_c060_0_05 0 bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_0_05 (mix_i_src_c060_0_05 mix_i_c060_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_05 (mix_q_src_c060_0_05 0 bpf_c060_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_0_05 (mix_q_src_c060_0_05 mix_q_c060_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_06 (mix_i_src_c060_0_06 0 bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_0_06 (mix_i_src_c060_0_06 mix_i_c060_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_06 (mix_q_src_c060_0_06 0 bpf_c060_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_0_06 (mix_q_src_c060_0_06 mix_q_c060_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_07 (mix_i_src_c060_0_07 0 bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_0_07 (mix_i_src_c060_0_07 mix_i_c060_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_07 (mix_q_src_c060_0_07 0 bpf_c060_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_0_07 (mix_q_src_c060_0_07 mix_q_c060_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_08 (mix_i_src_c060_0_08 0 bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_0_08 (mix_i_src_c060_0_08 mix_i_c060_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_08 (mix_q_src_c060_0_08 0 bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_0_08 (mix_q_src_c060_0_08 mix_q_c060_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_09 (mix_i_src_c060_0_09 0 bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_0_09 (mix_i_src_c060_0_09 mix_i_c060_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_09 (mix_q_src_c060_0_09 0 bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_0_09 (mix_q_src_c060_0_09 mix_q_c060_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_10 (mix_i_src_c060_0_10 0 bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_0_10 (mix_i_src_c060_0_10 mix_i_c060_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_10 (mix_q_src_c060_0_10 0 bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_0_10 (mix_q_src_c060_0_10 mix_q_c060_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_11 (mix_i_src_c060_0_11 0 bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_0_11 (mix_i_src_c060_0_11 mix_i_c060_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_11 (mix_q_src_c060_0_11 0 bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_0_11 (mix_q_src_c060_0_11 mix_q_c060_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_12 (mix_i_src_c060_0_12 0 bpf_c060_0 0) vcvs gain=1.950903220161e-01
SMIXI_c060_0_12 (mix_i_src_c060_0_12 mix_i_c060_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_12 (mix_q_src_c060_0_12 0 bpf_c060_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_0_12 (mix_q_src_c060_0_12 mix_q_c060_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_13 (mix_i_src_c060_0_13 0 bpf_c060_0 0) vcvs gain=5.555702330196e-01
SMIXI_c060_0_13 (mix_i_src_c060_0_13 mix_i_c060_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_13 (mix_q_src_c060_0_13 0 bpf_c060_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_0_13 (mix_q_src_c060_0_13 mix_q_c060_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_14 (mix_i_src_c060_0_14 0 bpf_c060_0 0) vcvs gain=8.314696123025e-01
SMIXI_c060_0_14 (mix_i_src_c060_0_14 mix_i_c060_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_14 (mix_q_src_c060_0_14 0 bpf_c060_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_0_14 (mix_q_src_c060_0_14 mix_q_c060_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_0_15 (mix_i_src_c060_0_15 0 bpf_c060_0 0) vcvs gain=9.807852804032e-01
SMIXI_c060_0_15 (mix_i_src_c060_0_15 mix_i_c060_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_0_15 (mix_q_src_c060_0_15 0 bpf_c060_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_0_15 (mix_q_src_c060_0_15 mix_q_c060_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c060_0 (mix_i_c060_0 0) resistor r=1G
RMIXQ_c060_0 (mix_q_c060_0 0) resistor r=1G
RINTI_c060_0 (mix_i_c060_0 Icar_c060_0) resistor r=1k
CINTI_c060_0 (Icar_c060_0 0) capacitor c=80p
RINTQ_c060_0 (mix_q_c060_0 Qcar_c060_0) resistor r=1k
CINTQ_c060_0 (Qcar_c060_0 0) capacitor c=80p

// bl060, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c060_1 (bl060 n_cbpf_c060_1) capacitor c=1.013211836423e-13
LBPF_c060_1 (n_cbpf_c060_1 bpf_c060_1) inductor l=1.000000000000e-06
RBPF_c060_1 (bpf_c060_1 0) resistor r=1.570796326795e+02
EMIXI_c060_1_00 (mix_i_src_c060_1_00 0 bpf_c060_1 0) vcvs gain=9.807852804032e-01
SMIXI_c060_1_00 (mix_i_src_c060_1_00 mix_i_c060_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_00 (mix_q_src_c060_1_00 0 bpf_c060_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_1_00 (mix_q_src_c060_1_00 mix_q_c060_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_01 (mix_i_src_c060_1_01 0 bpf_c060_1 0) vcvs gain=8.314696123025e-01
SMIXI_c060_1_01 (mix_i_src_c060_1_01 mix_i_c060_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_01 (mix_q_src_c060_1_01 0 bpf_c060_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_1_01 (mix_q_src_c060_1_01 mix_q_c060_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_02 (mix_i_src_c060_1_02 0 bpf_c060_1 0) vcvs gain=5.555702330196e-01
SMIXI_c060_1_02 (mix_i_src_c060_1_02 mix_i_c060_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_02 (mix_q_src_c060_1_02 0 bpf_c060_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_1_02 (mix_q_src_c060_1_02 mix_q_c060_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_03 (mix_i_src_c060_1_03 0 bpf_c060_1 0) vcvs gain=1.950903220161e-01
SMIXI_c060_1_03 (mix_i_src_c060_1_03 mix_i_c060_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_03 (mix_q_src_c060_1_03 0 bpf_c060_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_1_03 (mix_q_src_c060_1_03 mix_q_c060_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_04 (mix_i_src_c060_1_04 0 bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_1_04 (mix_i_src_c060_1_04 mix_i_c060_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_04 (mix_q_src_c060_1_04 0 bpf_c060_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_1_04 (mix_q_src_c060_1_04 mix_q_c060_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_05 (mix_i_src_c060_1_05 0 bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_1_05 (mix_i_src_c060_1_05 mix_i_c060_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_05 (mix_q_src_c060_1_05 0 bpf_c060_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_1_05 (mix_q_src_c060_1_05 mix_q_c060_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_06 (mix_i_src_c060_1_06 0 bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_1_06 (mix_i_src_c060_1_06 mix_i_c060_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_06 (mix_q_src_c060_1_06 0 bpf_c060_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_1_06 (mix_q_src_c060_1_06 mix_q_c060_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_07 (mix_i_src_c060_1_07 0 bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_1_07 (mix_i_src_c060_1_07 mix_i_c060_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_07 (mix_q_src_c060_1_07 0 bpf_c060_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_1_07 (mix_q_src_c060_1_07 mix_q_c060_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_08 (mix_i_src_c060_1_08 0 bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_1_08 (mix_i_src_c060_1_08 mix_i_c060_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_08 (mix_q_src_c060_1_08 0 bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_1_08 (mix_q_src_c060_1_08 mix_q_c060_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_09 (mix_i_src_c060_1_09 0 bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_1_09 (mix_i_src_c060_1_09 mix_i_c060_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_09 (mix_q_src_c060_1_09 0 bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_1_09 (mix_q_src_c060_1_09 mix_q_c060_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_10 (mix_i_src_c060_1_10 0 bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_1_10 (mix_i_src_c060_1_10 mix_i_c060_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_10 (mix_q_src_c060_1_10 0 bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_1_10 (mix_q_src_c060_1_10 mix_q_c060_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_11 (mix_i_src_c060_1_11 0 bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_1_11 (mix_i_src_c060_1_11 mix_i_c060_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_11 (mix_q_src_c060_1_11 0 bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_1_11 (mix_q_src_c060_1_11 mix_q_c060_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_12 (mix_i_src_c060_1_12 0 bpf_c060_1 0) vcvs gain=1.950903220161e-01
SMIXI_c060_1_12 (mix_i_src_c060_1_12 mix_i_c060_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_12 (mix_q_src_c060_1_12 0 bpf_c060_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_1_12 (mix_q_src_c060_1_12 mix_q_c060_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_13 (mix_i_src_c060_1_13 0 bpf_c060_1 0) vcvs gain=5.555702330196e-01
SMIXI_c060_1_13 (mix_i_src_c060_1_13 mix_i_c060_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_13 (mix_q_src_c060_1_13 0 bpf_c060_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_1_13 (mix_q_src_c060_1_13 mix_q_c060_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_14 (mix_i_src_c060_1_14 0 bpf_c060_1 0) vcvs gain=8.314696123025e-01
SMIXI_c060_1_14 (mix_i_src_c060_1_14 mix_i_c060_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_14 (mix_q_src_c060_1_14 0 bpf_c060_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_1_14 (mix_q_src_c060_1_14 mix_q_c060_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_1_15 (mix_i_src_c060_1_15 0 bpf_c060_1 0) vcvs gain=9.807852804032e-01
SMIXI_c060_1_15 (mix_i_src_c060_1_15 mix_i_c060_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_1_15 (mix_q_src_c060_1_15 0 bpf_c060_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_1_15 (mix_q_src_c060_1_15 mix_q_c060_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c060_1 (mix_i_c060_1 0) resistor r=1G
RMIXQ_c060_1 (mix_q_c060_1 0) resistor r=1G
RINTI_c060_1 (mix_i_c060_1 Icar_c060_1) resistor r=1k
CINTI_c060_1 (Icar_c060_1 0) capacitor c=80p
RINTQ_c060_1 (mix_q_c060_1 Qcar_c060_1) resistor r=1k
CINTQ_c060_1 (Qcar_c060_1 0) capacitor c=80p

// bl060, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c060_2 (bl060 n_cbpf_c060_2) capacitor c=4.503163717437e-14
LBPF_c060_2 (n_cbpf_c060_2 bpf_c060_2) inductor l=1.000000000000e-06
RBPF_c060_2 (bpf_c060_2 0) resistor r=2.356194490192e+02
EMIXI_c060_2_00 (mix_i_src_c060_2_00 0 bpf_c060_2 0) vcvs gain=9.807852804032e-01
SMIXI_c060_2_00 (mix_i_src_c060_2_00 mix_i_c060_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_00 (mix_q_src_c060_2_00 0 bpf_c060_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_2_00 (mix_q_src_c060_2_00 mix_q_c060_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_01 (mix_i_src_c060_2_01 0 bpf_c060_2 0) vcvs gain=8.314696123025e-01
SMIXI_c060_2_01 (mix_i_src_c060_2_01 mix_i_c060_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_01 (mix_q_src_c060_2_01 0 bpf_c060_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_2_01 (mix_q_src_c060_2_01 mix_q_c060_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_02 (mix_i_src_c060_2_02 0 bpf_c060_2 0) vcvs gain=5.555702330196e-01
SMIXI_c060_2_02 (mix_i_src_c060_2_02 mix_i_c060_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_02 (mix_q_src_c060_2_02 0 bpf_c060_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_2_02 (mix_q_src_c060_2_02 mix_q_c060_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_03 (mix_i_src_c060_2_03 0 bpf_c060_2 0) vcvs gain=1.950903220161e-01
SMIXI_c060_2_03 (mix_i_src_c060_2_03 mix_i_c060_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_03 (mix_q_src_c060_2_03 0 bpf_c060_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_2_03 (mix_q_src_c060_2_03 mix_q_c060_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_04 (mix_i_src_c060_2_04 0 bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_2_04 (mix_i_src_c060_2_04 mix_i_c060_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_04 (mix_q_src_c060_2_04 0 bpf_c060_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_2_04 (mix_q_src_c060_2_04 mix_q_c060_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_05 (mix_i_src_c060_2_05 0 bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_2_05 (mix_i_src_c060_2_05 mix_i_c060_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_05 (mix_q_src_c060_2_05 0 bpf_c060_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_2_05 (mix_q_src_c060_2_05 mix_q_c060_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_06 (mix_i_src_c060_2_06 0 bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_2_06 (mix_i_src_c060_2_06 mix_i_c060_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_06 (mix_q_src_c060_2_06 0 bpf_c060_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_2_06 (mix_q_src_c060_2_06 mix_q_c060_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_07 (mix_i_src_c060_2_07 0 bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_2_07 (mix_i_src_c060_2_07 mix_i_c060_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_07 (mix_q_src_c060_2_07 0 bpf_c060_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_2_07 (mix_q_src_c060_2_07 mix_q_c060_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_08 (mix_i_src_c060_2_08 0 bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_2_08 (mix_i_src_c060_2_08 mix_i_c060_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_08 (mix_q_src_c060_2_08 0 bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_2_08 (mix_q_src_c060_2_08 mix_q_c060_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_09 (mix_i_src_c060_2_09 0 bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_2_09 (mix_i_src_c060_2_09 mix_i_c060_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_09 (mix_q_src_c060_2_09 0 bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_2_09 (mix_q_src_c060_2_09 mix_q_c060_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_10 (mix_i_src_c060_2_10 0 bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_2_10 (mix_i_src_c060_2_10 mix_i_c060_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_10 (mix_q_src_c060_2_10 0 bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_2_10 (mix_q_src_c060_2_10 mix_q_c060_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_11 (mix_i_src_c060_2_11 0 bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_2_11 (mix_i_src_c060_2_11 mix_i_c060_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_11 (mix_q_src_c060_2_11 0 bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_2_11 (mix_q_src_c060_2_11 mix_q_c060_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_12 (mix_i_src_c060_2_12 0 bpf_c060_2 0) vcvs gain=1.950903220161e-01
SMIXI_c060_2_12 (mix_i_src_c060_2_12 mix_i_c060_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_12 (mix_q_src_c060_2_12 0 bpf_c060_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_2_12 (mix_q_src_c060_2_12 mix_q_c060_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_13 (mix_i_src_c060_2_13 0 bpf_c060_2 0) vcvs gain=5.555702330196e-01
SMIXI_c060_2_13 (mix_i_src_c060_2_13 mix_i_c060_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_13 (mix_q_src_c060_2_13 0 bpf_c060_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_2_13 (mix_q_src_c060_2_13 mix_q_c060_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_14 (mix_i_src_c060_2_14 0 bpf_c060_2 0) vcvs gain=8.314696123025e-01
SMIXI_c060_2_14 (mix_i_src_c060_2_14 mix_i_c060_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_14 (mix_q_src_c060_2_14 0 bpf_c060_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_2_14 (mix_q_src_c060_2_14 mix_q_c060_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_2_15 (mix_i_src_c060_2_15 0 bpf_c060_2 0) vcvs gain=9.807852804032e-01
SMIXI_c060_2_15 (mix_i_src_c060_2_15 mix_i_c060_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_2_15 (mix_q_src_c060_2_15 0 bpf_c060_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_2_15 (mix_q_src_c060_2_15 mix_q_c060_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c060_2 (mix_i_c060_2 0) resistor r=1G
RMIXQ_c060_2 (mix_q_c060_2 0) resistor r=1G
RINTI_c060_2 (mix_i_c060_2 Icar_c060_2) resistor r=1k
CINTI_c060_2 (Icar_c060_2 0) capacitor c=80p
RINTQ_c060_2 (mix_q_c060_2 Qcar_c060_2) resistor r=1k
CINTQ_c060_2 (Qcar_c060_2 0) capacitor c=80p

// bl060, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c060_3 (bl060 n_cbpf_c060_3) capacitor c=2.533029591058e-14
LBPF_c060_3 (n_cbpf_c060_3 bpf_c060_3) inductor l=1.000000000000e-06
RBPF_c060_3 (bpf_c060_3 0) resistor r=3.141592653590e+02
EMIXI_c060_3_00 (mix_i_src_c060_3_00 0 bpf_c060_3 0) vcvs gain=9.807852804032e-01
SMIXI_c060_3_00 (mix_i_src_c060_3_00 mix_i_c060_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_00 (mix_q_src_c060_3_00 0 bpf_c060_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_3_00 (mix_q_src_c060_3_00 mix_q_c060_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_01 (mix_i_src_c060_3_01 0 bpf_c060_3 0) vcvs gain=8.314696123025e-01
SMIXI_c060_3_01 (mix_i_src_c060_3_01 mix_i_c060_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_01 (mix_q_src_c060_3_01 0 bpf_c060_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_3_01 (mix_q_src_c060_3_01 mix_q_c060_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_02 (mix_i_src_c060_3_02 0 bpf_c060_3 0) vcvs gain=5.555702330196e-01
SMIXI_c060_3_02 (mix_i_src_c060_3_02 mix_i_c060_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_02 (mix_q_src_c060_3_02 0 bpf_c060_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_3_02 (mix_q_src_c060_3_02 mix_q_c060_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_03 (mix_i_src_c060_3_03 0 bpf_c060_3 0) vcvs gain=1.950903220161e-01
SMIXI_c060_3_03 (mix_i_src_c060_3_03 mix_i_c060_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_03 (mix_q_src_c060_3_03 0 bpf_c060_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_3_03 (mix_q_src_c060_3_03 mix_q_c060_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_04 (mix_i_src_c060_3_04 0 bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_3_04 (mix_i_src_c060_3_04 mix_i_c060_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_04 (mix_q_src_c060_3_04 0 bpf_c060_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c060_3_04 (mix_q_src_c060_3_04 mix_q_c060_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_05 (mix_i_src_c060_3_05 0 bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_3_05 (mix_i_src_c060_3_05 mix_i_c060_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_05 (mix_q_src_c060_3_05 0 bpf_c060_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c060_3_05 (mix_q_src_c060_3_05 mix_q_c060_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_06 (mix_i_src_c060_3_06 0 bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_3_06 (mix_i_src_c060_3_06 mix_i_c060_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_06 (mix_q_src_c060_3_06 0 bpf_c060_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c060_3_06 (mix_q_src_c060_3_06 mix_q_c060_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_07 (mix_i_src_c060_3_07 0 bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_3_07 (mix_i_src_c060_3_07 mix_i_c060_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_07 (mix_q_src_c060_3_07 0 bpf_c060_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c060_3_07 (mix_q_src_c060_3_07 mix_q_c060_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_08 (mix_i_src_c060_3_08 0 bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c060_3_08 (mix_i_src_c060_3_08 mix_i_c060_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_08 (mix_q_src_c060_3_08 0 bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_3_08 (mix_q_src_c060_3_08 mix_q_c060_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_09 (mix_i_src_c060_3_09 0 bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c060_3_09 (mix_i_src_c060_3_09 mix_i_c060_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_09 (mix_q_src_c060_3_09 0 bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_3_09 (mix_q_src_c060_3_09 mix_q_c060_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_10 (mix_i_src_c060_3_10 0 bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c060_3_10 (mix_i_src_c060_3_10 mix_i_c060_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_10 (mix_q_src_c060_3_10 0 bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_3_10 (mix_q_src_c060_3_10 mix_q_c060_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_11 (mix_i_src_c060_3_11 0 bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c060_3_11 (mix_i_src_c060_3_11 mix_i_c060_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_11 (mix_q_src_c060_3_11 0 bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_3_11 (mix_q_src_c060_3_11 mix_q_c060_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_12 (mix_i_src_c060_3_12 0 bpf_c060_3 0) vcvs gain=1.950903220161e-01
SMIXI_c060_3_12 (mix_i_src_c060_3_12 mix_i_c060_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_12 (mix_q_src_c060_3_12 0 bpf_c060_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c060_3_12 (mix_q_src_c060_3_12 mix_q_c060_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_13 (mix_i_src_c060_3_13 0 bpf_c060_3 0) vcvs gain=5.555702330196e-01
SMIXI_c060_3_13 (mix_i_src_c060_3_13 mix_i_c060_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_13 (mix_q_src_c060_3_13 0 bpf_c060_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c060_3_13 (mix_q_src_c060_3_13 mix_q_c060_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_14 (mix_i_src_c060_3_14 0 bpf_c060_3 0) vcvs gain=8.314696123025e-01
SMIXI_c060_3_14 (mix_i_src_c060_3_14 mix_i_c060_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_14 (mix_q_src_c060_3_14 0 bpf_c060_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c060_3_14 (mix_q_src_c060_3_14 mix_q_c060_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c060_3_15 (mix_i_src_c060_3_15 0 bpf_c060_3 0) vcvs gain=9.807852804032e-01
SMIXI_c060_3_15 (mix_i_src_c060_3_15 mix_i_c060_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c060_3_15 (mix_q_src_c060_3_15 0 bpf_c060_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c060_3_15 (mix_q_src_c060_3_15 mix_q_c060_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c060_3 (mix_i_c060_3 0) resistor r=1G
RMIXQ_c060_3 (mix_q_c060_3 0) resistor r=1G
RINTI_c060_3 (mix_i_c060_3 Icar_c060_3) resistor r=1k
CINTI_c060_3 (Icar_c060_3 0) capacitor c=80p
RINTQ_c060_3 (mix_q_c060_3 Qcar_c060_3) resistor r=1k
CINTQ_c060_3 (Qcar_c060_3 0) capacitor c=80p

// bl061, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c061_0 (bl061 n_cbpf_c061_0) capacitor c=4.052847345694e-13
LBPF_c061_0 (n_cbpf_c061_0 bpf_c061_0) inductor l=1.000000000000e-06
RBPF_c061_0 (bpf_c061_0 0) resistor r=7.853981633974e+01
EMIXI_c061_0_00 (mix_i_src_c061_0_00 0 bpf_c061_0 0) vcvs gain=9.807852804032e-01
SMIXI_c061_0_00 (mix_i_src_c061_0_00 mix_i_c061_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_00 (mix_q_src_c061_0_00 0 bpf_c061_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_0_00 (mix_q_src_c061_0_00 mix_q_c061_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_01 (mix_i_src_c061_0_01 0 bpf_c061_0 0) vcvs gain=8.314696123025e-01
SMIXI_c061_0_01 (mix_i_src_c061_0_01 mix_i_c061_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_01 (mix_q_src_c061_0_01 0 bpf_c061_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_0_01 (mix_q_src_c061_0_01 mix_q_c061_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_02 (mix_i_src_c061_0_02 0 bpf_c061_0 0) vcvs gain=5.555702330196e-01
SMIXI_c061_0_02 (mix_i_src_c061_0_02 mix_i_c061_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_02 (mix_q_src_c061_0_02 0 bpf_c061_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_0_02 (mix_q_src_c061_0_02 mix_q_c061_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_03 (mix_i_src_c061_0_03 0 bpf_c061_0 0) vcvs gain=1.950903220161e-01
SMIXI_c061_0_03 (mix_i_src_c061_0_03 mix_i_c061_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_03 (mix_q_src_c061_0_03 0 bpf_c061_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_0_03 (mix_q_src_c061_0_03 mix_q_c061_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_04 (mix_i_src_c061_0_04 0 bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_0_04 (mix_i_src_c061_0_04 mix_i_c061_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_04 (mix_q_src_c061_0_04 0 bpf_c061_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_0_04 (mix_q_src_c061_0_04 mix_q_c061_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_05 (mix_i_src_c061_0_05 0 bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_0_05 (mix_i_src_c061_0_05 mix_i_c061_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_05 (mix_q_src_c061_0_05 0 bpf_c061_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_0_05 (mix_q_src_c061_0_05 mix_q_c061_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_06 (mix_i_src_c061_0_06 0 bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_0_06 (mix_i_src_c061_0_06 mix_i_c061_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_06 (mix_q_src_c061_0_06 0 bpf_c061_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_0_06 (mix_q_src_c061_0_06 mix_q_c061_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_07 (mix_i_src_c061_0_07 0 bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_0_07 (mix_i_src_c061_0_07 mix_i_c061_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_07 (mix_q_src_c061_0_07 0 bpf_c061_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_0_07 (mix_q_src_c061_0_07 mix_q_c061_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_08 (mix_i_src_c061_0_08 0 bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_0_08 (mix_i_src_c061_0_08 mix_i_c061_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_08 (mix_q_src_c061_0_08 0 bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_0_08 (mix_q_src_c061_0_08 mix_q_c061_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_09 (mix_i_src_c061_0_09 0 bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_0_09 (mix_i_src_c061_0_09 mix_i_c061_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_09 (mix_q_src_c061_0_09 0 bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_0_09 (mix_q_src_c061_0_09 mix_q_c061_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_10 (mix_i_src_c061_0_10 0 bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_0_10 (mix_i_src_c061_0_10 mix_i_c061_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_10 (mix_q_src_c061_0_10 0 bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_0_10 (mix_q_src_c061_0_10 mix_q_c061_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_11 (mix_i_src_c061_0_11 0 bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_0_11 (mix_i_src_c061_0_11 mix_i_c061_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_11 (mix_q_src_c061_0_11 0 bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_0_11 (mix_q_src_c061_0_11 mix_q_c061_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_12 (mix_i_src_c061_0_12 0 bpf_c061_0 0) vcvs gain=1.950903220161e-01
SMIXI_c061_0_12 (mix_i_src_c061_0_12 mix_i_c061_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_12 (mix_q_src_c061_0_12 0 bpf_c061_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_0_12 (mix_q_src_c061_0_12 mix_q_c061_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_13 (mix_i_src_c061_0_13 0 bpf_c061_0 0) vcvs gain=5.555702330196e-01
SMIXI_c061_0_13 (mix_i_src_c061_0_13 mix_i_c061_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_13 (mix_q_src_c061_0_13 0 bpf_c061_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_0_13 (mix_q_src_c061_0_13 mix_q_c061_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_14 (mix_i_src_c061_0_14 0 bpf_c061_0 0) vcvs gain=8.314696123025e-01
SMIXI_c061_0_14 (mix_i_src_c061_0_14 mix_i_c061_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_14 (mix_q_src_c061_0_14 0 bpf_c061_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_0_14 (mix_q_src_c061_0_14 mix_q_c061_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_0_15 (mix_i_src_c061_0_15 0 bpf_c061_0 0) vcvs gain=9.807852804032e-01
SMIXI_c061_0_15 (mix_i_src_c061_0_15 mix_i_c061_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_0_15 (mix_q_src_c061_0_15 0 bpf_c061_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_0_15 (mix_q_src_c061_0_15 mix_q_c061_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c061_0 (mix_i_c061_0 0) resistor r=1G
RMIXQ_c061_0 (mix_q_c061_0 0) resistor r=1G
RINTI_c061_0 (mix_i_c061_0 Icar_c061_0) resistor r=1k
CINTI_c061_0 (Icar_c061_0 0) capacitor c=80p
RINTQ_c061_0 (mix_q_c061_0 Qcar_c061_0) resistor r=1k
CINTQ_c061_0 (Qcar_c061_0 0) capacitor c=80p

// bl061, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c061_1 (bl061 n_cbpf_c061_1) capacitor c=1.013211836423e-13
LBPF_c061_1 (n_cbpf_c061_1 bpf_c061_1) inductor l=1.000000000000e-06
RBPF_c061_1 (bpf_c061_1 0) resistor r=1.570796326795e+02
EMIXI_c061_1_00 (mix_i_src_c061_1_00 0 bpf_c061_1 0) vcvs gain=9.807852804032e-01
SMIXI_c061_1_00 (mix_i_src_c061_1_00 mix_i_c061_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_00 (mix_q_src_c061_1_00 0 bpf_c061_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_1_00 (mix_q_src_c061_1_00 mix_q_c061_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_01 (mix_i_src_c061_1_01 0 bpf_c061_1 0) vcvs gain=8.314696123025e-01
SMIXI_c061_1_01 (mix_i_src_c061_1_01 mix_i_c061_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_01 (mix_q_src_c061_1_01 0 bpf_c061_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_1_01 (mix_q_src_c061_1_01 mix_q_c061_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_02 (mix_i_src_c061_1_02 0 bpf_c061_1 0) vcvs gain=5.555702330196e-01
SMIXI_c061_1_02 (mix_i_src_c061_1_02 mix_i_c061_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_02 (mix_q_src_c061_1_02 0 bpf_c061_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_1_02 (mix_q_src_c061_1_02 mix_q_c061_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_03 (mix_i_src_c061_1_03 0 bpf_c061_1 0) vcvs gain=1.950903220161e-01
SMIXI_c061_1_03 (mix_i_src_c061_1_03 mix_i_c061_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_03 (mix_q_src_c061_1_03 0 bpf_c061_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_1_03 (mix_q_src_c061_1_03 mix_q_c061_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_04 (mix_i_src_c061_1_04 0 bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_1_04 (mix_i_src_c061_1_04 mix_i_c061_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_04 (mix_q_src_c061_1_04 0 bpf_c061_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_1_04 (mix_q_src_c061_1_04 mix_q_c061_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_05 (mix_i_src_c061_1_05 0 bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_1_05 (mix_i_src_c061_1_05 mix_i_c061_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_05 (mix_q_src_c061_1_05 0 bpf_c061_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_1_05 (mix_q_src_c061_1_05 mix_q_c061_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_06 (mix_i_src_c061_1_06 0 bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_1_06 (mix_i_src_c061_1_06 mix_i_c061_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_06 (mix_q_src_c061_1_06 0 bpf_c061_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_1_06 (mix_q_src_c061_1_06 mix_q_c061_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_07 (mix_i_src_c061_1_07 0 bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_1_07 (mix_i_src_c061_1_07 mix_i_c061_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_07 (mix_q_src_c061_1_07 0 bpf_c061_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_1_07 (mix_q_src_c061_1_07 mix_q_c061_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_08 (mix_i_src_c061_1_08 0 bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_1_08 (mix_i_src_c061_1_08 mix_i_c061_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_08 (mix_q_src_c061_1_08 0 bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_1_08 (mix_q_src_c061_1_08 mix_q_c061_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_09 (mix_i_src_c061_1_09 0 bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_1_09 (mix_i_src_c061_1_09 mix_i_c061_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_09 (mix_q_src_c061_1_09 0 bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_1_09 (mix_q_src_c061_1_09 mix_q_c061_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_10 (mix_i_src_c061_1_10 0 bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_1_10 (mix_i_src_c061_1_10 mix_i_c061_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_10 (mix_q_src_c061_1_10 0 bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_1_10 (mix_q_src_c061_1_10 mix_q_c061_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_11 (mix_i_src_c061_1_11 0 bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_1_11 (mix_i_src_c061_1_11 mix_i_c061_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_11 (mix_q_src_c061_1_11 0 bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_1_11 (mix_q_src_c061_1_11 mix_q_c061_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_12 (mix_i_src_c061_1_12 0 bpf_c061_1 0) vcvs gain=1.950903220161e-01
SMIXI_c061_1_12 (mix_i_src_c061_1_12 mix_i_c061_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_12 (mix_q_src_c061_1_12 0 bpf_c061_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_1_12 (mix_q_src_c061_1_12 mix_q_c061_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_13 (mix_i_src_c061_1_13 0 bpf_c061_1 0) vcvs gain=5.555702330196e-01
SMIXI_c061_1_13 (mix_i_src_c061_1_13 mix_i_c061_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_13 (mix_q_src_c061_1_13 0 bpf_c061_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_1_13 (mix_q_src_c061_1_13 mix_q_c061_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_14 (mix_i_src_c061_1_14 0 bpf_c061_1 0) vcvs gain=8.314696123025e-01
SMIXI_c061_1_14 (mix_i_src_c061_1_14 mix_i_c061_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_14 (mix_q_src_c061_1_14 0 bpf_c061_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_1_14 (mix_q_src_c061_1_14 mix_q_c061_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_1_15 (mix_i_src_c061_1_15 0 bpf_c061_1 0) vcvs gain=9.807852804032e-01
SMIXI_c061_1_15 (mix_i_src_c061_1_15 mix_i_c061_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_1_15 (mix_q_src_c061_1_15 0 bpf_c061_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_1_15 (mix_q_src_c061_1_15 mix_q_c061_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c061_1 (mix_i_c061_1 0) resistor r=1G
RMIXQ_c061_1 (mix_q_c061_1 0) resistor r=1G
RINTI_c061_1 (mix_i_c061_1 Icar_c061_1) resistor r=1k
CINTI_c061_1 (Icar_c061_1 0) capacitor c=80p
RINTQ_c061_1 (mix_q_c061_1 Qcar_c061_1) resistor r=1k
CINTQ_c061_1 (Qcar_c061_1 0) capacitor c=80p

// bl061, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c061_2 (bl061 n_cbpf_c061_2) capacitor c=4.503163717437e-14
LBPF_c061_2 (n_cbpf_c061_2 bpf_c061_2) inductor l=1.000000000000e-06
RBPF_c061_2 (bpf_c061_2 0) resistor r=2.356194490192e+02
EMIXI_c061_2_00 (mix_i_src_c061_2_00 0 bpf_c061_2 0) vcvs gain=9.807852804032e-01
SMIXI_c061_2_00 (mix_i_src_c061_2_00 mix_i_c061_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_00 (mix_q_src_c061_2_00 0 bpf_c061_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_2_00 (mix_q_src_c061_2_00 mix_q_c061_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_01 (mix_i_src_c061_2_01 0 bpf_c061_2 0) vcvs gain=8.314696123025e-01
SMIXI_c061_2_01 (mix_i_src_c061_2_01 mix_i_c061_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_01 (mix_q_src_c061_2_01 0 bpf_c061_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_2_01 (mix_q_src_c061_2_01 mix_q_c061_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_02 (mix_i_src_c061_2_02 0 bpf_c061_2 0) vcvs gain=5.555702330196e-01
SMIXI_c061_2_02 (mix_i_src_c061_2_02 mix_i_c061_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_02 (mix_q_src_c061_2_02 0 bpf_c061_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_2_02 (mix_q_src_c061_2_02 mix_q_c061_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_03 (mix_i_src_c061_2_03 0 bpf_c061_2 0) vcvs gain=1.950903220161e-01
SMIXI_c061_2_03 (mix_i_src_c061_2_03 mix_i_c061_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_03 (mix_q_src_c061_2_03 0 bpf_c061_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_2_03 (mix_q_src_c061_2_03 mix_q_c061_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_04 (mix_i_src_c061_2_04 0 bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_2_04 (mix_i_src_c061_2_04 mix_i_c061_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_04 (mix_q_src_c061_2_04 0 bpf_c061_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_2_04 (mix_q_src_c061_2_04 mix_q_c061_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_05 (mix_i_src_c061_2_05 0 bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_2_05 (mix_i_src_c061_2_05 mix_i_c061_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_05 (mix_q_src_c061_2_05 0 bpf_c061_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_2_05 (mix_q_src_c061_2_05 mix_q_c061_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_06 (mix_i_src_c061_2_06 0 bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_2_06 (mix_i_src_c061_2_06 mix_i_c061_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_06 (mix_q_src_c061_2_06 0 bpf_c061_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_2_06 (mix_q_src_c061_2_06 mix_q_c061_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_07 (mix_i_src_c061_2_07 0 bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_2_07 (mix_i_src_c061_2_07 mix_i_c061_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_07 (mix_q_src_c061_2_07 0 bpf_c061_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_2_07 (mix_q_src_c061_2_07 mix_q_c061_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_08 (mix_i_src_c061_2_08 0 bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_2_08 (mix_i_src_c061_2_08 mix_i_c061_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_08 (mix_q_src_c061_2_08 0 bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_2_08 (mix_q_src_c061_2_08 mix_q_c061_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_09 (mix_i_src_c061_2_09 0 bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_2_09 (mix_i_src_c061_2_09 mix_i_c061_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_09 (mix_q_src_c061_2_09 0 bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_2_09 (mix_q_src_c061_2_09 mix_q_c061_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_10 (mix_i_src_c061_2_10 0 bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_2_10 (mix_i_src_c061_2_10 mix_i_c061_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_10 (mix_q_src_c061_2_10 0 bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_2_10 (mix_q_src_c061_2_10 mix_q_c061_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_11 (mix_i_src_c061_2_11 0 bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_2_11 (mix_i_src_c061_2_11 mix_i_c061_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_11 (mix_q_src_c061_2_11 0 bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_2_11 (mix_q_src_c061_2_11 mix_q_c061_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_12 (mix_i_src_c061_2_12 0 bpf_c061_2 0) vcvs gain=1.950903220161e-01
SMIXI_c061_2_12 (mix_i_src_c061_2_12 mix_i_c061_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_12 (mix_q_src_c061_2_12 0 bpf_c061_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_2_12 (mix_q_src_c061_2_12 mix_q_c061_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_13 (mix_i_src_c061_2_13 0 bpf_c061_2 0) vcvs gain=5.555702330196e-01
SMIXI_c061_2_13 (mix_i_src_c061_2_13 mix_i_c061_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_13 (mix_q_src_c061_2_13 0 bpf_c061_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_2_13 (mix_q_src_c061_2_13 mix_q_c061_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_14 (mix_i_src_c061_2_14 0 bpf_c061_2 0) vcvs gain=8.314696123025e-01
SMIXI_c061_2_14 (mix_i_src_c061_2_14 mix_i_c061_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_14 (mix_q_src_c061_2_14 0 bpf_c061_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_2_14 (mix_q_src_c061_2_14 mix_q_c061_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_2_15 (mix_i_src_c061_2_15 0 bpf_c061_2 0) vcvs gain=9.807852804032e-01
SMIXI_c061_2_15 (mix_i_src_c061_2_15 mix_i_c061_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_2_15 (mix_q_src_c061_2_15 0 bpf_c061_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_2_15 (mix_q_src_c061_2_15 mix_q_c061_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c061_2 (mix_i_c061_2 0) resistor r=1G
RMIXQ_c061_2 (mix_q_c061_2 0) resistor r=1G
RINTI_c061_2 (mix_i_c061_2 Icar_c061_2) resistor r=1k
CINTI_c061_2 (Icar_c061_2 0) capacitor c=80p
RINTQ_c061_2 (mix_q_c061_2 Qcar_c061_2) resistor r=1k
CINTQ_c061_2 (Qcar_c061_2 0) capacitor c=80p

// bl061, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c061_3 (bl061 n_cbpf_c061_3) capacitor c=2.533029591058e-14
LBPF_c061_3 (n_cbpf_c061_3 bpf_c061_3) inductor l=1.000000000000e-06
RBPF_c061_3 (bpf_c061_3 0) resistor r=3.141592653590e+02
EMIXI_c061_3_00 (mix_i_src_c061_3_00 0 bpf_c061_3 0) vcvs gain=9.807852804032e-01
SMIXI_c061_3_00 (mix_i_src_c061_3_00 mix_i_c061_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_00 (mix_q_src_c061_3_00 0 bpf_c061_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_3_00 (mix_q_src_c061_3_00 mix_q_c061_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_01 (mix_i_src_c061_3_01 0 bpf_c061_3 0) vcvs gain=8.314696123025e-01
SMIXI_c061_3_01 (mix_i_src_c061_3_01 mix_i_c061_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_01 (mix_q_src_c061_3_01 0 bpf_c061_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_3_01 (mix_q_src_c061_3_01 mix_q_c061_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_02 (mix_i_src_c061_3_02 0 bpf_c061_3 0) vcvs gain=5.555702330196e-01
SMIXI_c061_3_02 (mix_i_src_c061_3_02 mix_i_c061_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_02 (mix_q_src_c061_3_02 0 bpf_c061_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_3_02 (mix_q_src_c061_3_02 mix_q_c061_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_03 (mix_i_src_c061_3_03 0 bpf_c061_3 0) vcvs gain=1.950903220161e-01
SMIXI_c061_3_03 (mix_i_src_c061_3_03 mix_i_c061_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_03 (mix_q_src_c061_3_03 0 bpf_c061_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_3_03 (mix_q_src_c061_3_03 mix_q_c061_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_04 (mix_i_src_c061_3_04 0 bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_3_04 (mix_i_src_c061_3_04 mix_i_c061_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_04 (mix_q_src_c061_3_04 0 bpf_c061_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c061_3_04 (mix_q_src_c061_3_04 mix_q_c061_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_05 (mix_i_src_c061_3_05 0 bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_3_05 (mix_i_src_c061_3_05 mix_i_c061_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_05 (mix_q_src_c061_3_05 0 bpf_c061_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c061_3_05 (mix_q_src_c061_3_05 mix_q_c061_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_06 (mix_i_src_c061_3_06 0 bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_3_06 (mix_i_src_c061_3_06 mix_i_c061_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_06 (mix_q_src_c061_3_06 0 bpf_c061_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c061_3_06 (mix_q_src_c061_3_06 mix_q_c061_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_07 (mix_i_src_c061_3_07 0 bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_3_07 (mix_i_src_c061_3_07 mix_i_c061_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_07 (mix_q_src_c061_3_07 0 bpf_c061_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c061_3_07 (mix_q_src_c061_3_07 mix_q_c061_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_08 (mix_i_src_c061_3_08 0 bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c061_3_08 (mix_i_src_c061_3_08 mix_i_c061_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_08 (mix_q_src_c061_3_08 0 bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_3_08 (mix_q_src_c061_3_08 mix_q_c061_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_09 (mix_i_src_c061_3_09 0 bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c061_3_09 (mix_i_src_c061_3_09 mix_i_c061_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_09 (mix_q_src_c061_3_09 0 bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_3_09 (mix_q_src_c061_3_09 mix_q_c061_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_10 (mix_i_src_c061_3_10 0 bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c061_3_10 (mix_i_src_c061_3_10 mix_i_c061_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_10 (mix_q_src_c061_3_10 0 bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_3_10 (mix_q_src_c061_3_10 mix_q_c061_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_11 (mix_i_src_c061_3_11 0 bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c061_3_11 (mix_i_src_c061_3_11 mix_i_c061_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_11 (mix_q_src_c061_3_11 0 bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_3_11 (mix_q_src_c061_3_11 mix_q_c061_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_12 (mix_i_src_c061_3_12 0 bpf_c061_3 0) vcvs gain=1.950903220161e-01
SMIXI_c061_3_12 (mix_i_src_c061_3_12 mix_i_c061_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_12 (mix_q_src_c061_3_12 0 bpf_c061_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c061_3_12 (mix_q_src_c061_3_12 mix_q_c061_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_13 (mix_i_src_c061_3_13 0 bpf_c061_3 0) vcvs gain=5.555702330196e-01
SMIXI_c061_3_13 (mix_i_src_c061_3_13 mix_i_c061_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_13 (mix_q_src_c061_3_13 0 bpf_c061_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c061_3_13 (mix_q_src_c061_3_13 mix_q_c061_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_14 (mix_i_src_c061_3_14 0 bpf_c061_3 0) vcvs gain=8.314696123025e-01
SMIXI_c061_3_14 (mix_i_src_c061_3_14 mix_i_c061_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_14 (mix_q_src_c061_3_14 0 bpf_c061_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c061_3_14 (mix_q_src_c061_3_14 mix_q_c061_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c061_3_15 (mix_i_src_c061_3_15 0 bpf_c061_3 0) vcvs gain=9.807852804032e-01
SMIXI_c061_3_15 (mix_i_src_c061_3_15 mix_i_c061_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c061_3_15 (mix_q_src_c061_3_15 0 bpf_c061_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c061_3_15 (mix_q_src_c061_3_15 mix_q_c061_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c061_3 (mix_i_c061_3 0) resistor r=1G
RMIXQ_c061_3 (mix_q_c061_3 0) resistor r=1G
RINTI_c061_3 (mix_i_c061_3 Icar_c061_3) resistor r=1k
CINTI_c061_3 (Icar_c061_3 0) capacitor c=80p
RINTQ_c061_3 (mix_q_c061_3 Qcar_c061_3) resistor r=1k
CINTQ_c061_3 (Qcar_c061_3 0) capacitor c=80p

// bl062, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c062_0 (bl062 n_cbpf_c062_0) capacitor c=4.052847345694e-13
LBPF_c062_0 (n_cbpf_c062_0 bpf_c062_0) inductor l=1.000000000000e-06
RBPF_c062_0 (bpf_c062_0 0) resistor r=7.853981633974e+01
EMIXI_c062_0_00 (mix_i_src_c062_0_00 0 bpf_c062_0 0) vcvs gain=9.807852804032e-01
SMIXI_c062_0_00 (mix_i_src_c062_0_00 mix_i_c062_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_00 (mix_q_src_c062_0_00 0 bpf_c062_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_0_00 (mix_q_src_c062_0_00 mix_q_c062_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_01 (mix_i_src_c062_0_01 0 bpf_c062_0 0) vcvs gain=8.314696123025e-01
SMIXI_c062_0_01 (mix_i_src_c062_0_01 mix_i_c062_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_01 (mix_q_src_c062_0_01 0 bpf_c062_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_0_01 (mix_q_src_c062_0_01 mix_q_c062_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_02 (mix_i_src_c062_0_02 0 bpf_c062_0 0) vcvs gain=5.555702330196e-01
SMIXI_c062_0_02 (mix_i_src_c062_0_02 mix_i_c062_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_02 (mix_q_src_c062_0_02 0 bpf_c062_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_0_02 (mix_q_src_c062_0_02 mix_q_c062_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_03 (mix_i_src_c062_0_03 0 bpf_c062_0 0) vcvs gain=1.950903220161e-01
SMIXI_c062_0_03 (mix_i_src_c062_0_03 mix_i_c062_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_03 (mix_q_src_c062_0_03 0 bpf_c062_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_0_03 (mix_q_src_c062_0_03 mix_q_c062_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_04 (mix_i_src_c062_0_04 0 bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_0_04 (mix_i_src_c062_0_04 mix_i_c062_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_04 (mix_q_src_c062_0_04 0 bpf_c062_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_0_04 (mix_q_src_c062_0_04 mix_q_c062_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_05 (mix_i_src_c062_0_05 0 bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_0_05 (mix_i_src_c062_0_05 mix_i_c062_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_05 (mix_q_src_c062_0_05 0 bpf_c062_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_0_05 (mix_q_src_c062_0_05 mix_q_c062_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_06 (mix_i_src_c062_0_06 0 bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_0_06 (mix_i_src_c062_0_06 mix_i_c062_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_06 (mix_q_src_c062_0_06 0 bpf_c062_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_0_06 (mix_q_src_c062_0_06 mix_q_c062_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_07 (mix_i_src_c062_0_07 0 bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_0_07 (mix_i_src_c062_0_07 mix_i_c062_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_07 (mix_q_src_c062_0_07 0 bpf_c062_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_0_07 (mix_q_src_c062_0_07 mix_q_c062_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_08 (mix_i_src_c062_0_08 0 bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_0_08 (mix_i_src_c062_0_08 mix_i_c062_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_08 (mix_q_src_c062_0_08 0 bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_0_08 (mix_q_src_c062_0_08 mix_q_c062_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_09 (mix_i_src_c062_0_09 0 bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_0_09 (mix_i_src_c062_0_09 mix_i_c062_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_09 (mix_q_src_c062_0_09 0 bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_0_09 (mix_q_src_c062_0_09 mix_q_c062_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_10 (mix_i_src_c062_0_10 0 bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_0_10 (mix_i_src_c062_0_10 mix_i_c062_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_10 (mix_q_src_c062_0_10 0 bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_0_10 (mix_q_src_c062_0_10 mix_q_c062_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_11 (mix_i_src_c062_0_11 0 bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_0_11 (mix_i_src_c062_0_11 mix_i_c062_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_11 (mix_q_src_c062_0_11 0 bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_0_11 (mix_q_src_c062_0_11 mix_q_c062_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_12 (mix_i_src_c062_0_12 0 bpf_c062_0 0) vcvs gain=1.950903220161e-01
SMIXI_c062_0_12 (mix_i_src_c062_0_12 mix_i_c062_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_12 (mix_q_src_c062_0_12 0 bpf_c062_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_0_12 (mix_q_src_c062_0_12 mix_q_c062_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_13 (mix_i_src_c062_0_13 0 bpf_c062_0 0) vcvs gain=5.555702330196e-01
SMIXI_c062_0_13 (mix_i_src_c062_0_13 mix_i_c062_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_13 (mix_q_src_c062_0_13 0 bpf_c062_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_0_13 (mix_q_src_c062_0_13 mix_q_c062_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_14 (mix_i_src_c062_0_14 0 bpf_c062_0 0) vcvs gain=8.314696123025e-01
SMIXI_c062_0_14 (mix_i_src_c062_0_14 mix_i_c062_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_14 (mix_q_src_c062_0_14 0 bpf_c062_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_0_14 (mix_q_src_c062_0_14 mix_q_c062_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_0_15 (mix_i_src_c062_0_15 0 bpf_c062_0 0) vcvs gain=9.807852804032e-01
SMIXI_c062_0_15 (mix_i_src_c062_0_15 mix_i_c062_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_0_15 (mix_q_src_c062_0_15 0 bpf_c062_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_0_15 (mix_q_src_c062_0_15 mix_q_c062_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c062_0 (mix_i_c062_0 0) resistor r=1G
RMIXQ_c062_0 (mix_q_c062_0 0) resistor r=1G
RINTI_c062_0 (mix_i_c062_0 Icar_c062_0) resistor r=1k
CINTI_c062_0 (Icar_c062_0 0) capacitor c=80p
RINTQ_c062_0 (mix_q_c062_0 Qcar_c062_0) resistor r=1k
CINTQ_c062_0 (Qcar_c062_0 0) capacitor c=80p

// bl062, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c062_1 (bl062 n_cbpf_c062_1) capacitor c=1.013211836423e-13
LBPF_c062_1 (n_cbpf_c062_1 bpf_c062_1) inductor l=1.000000000000e-06
RBPF_c062_1 (bpf_c062_1 0) resistor r=1.570796326795e+02
EMIXI_c062_1_00 (mix_i_src_c062_1_00 0 bpf_c062_1 0) vcvs gain=9.807852804032e-01
SMIXI_c062_1_00 (mix_i_src_c062_1_00 mix_i_c062_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_00 (mix_q_src_c062_1_00 0 bpf_c062_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_1_00 (mix_q_src_c062_1_00 mix_q_c062_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_01 (mix_i_src_c062_1_01 0 bpf_c062_1 0) vcvs gain=8.314696123025e-01
SMIXI_c062_1_01 (mix_i_src_c062_1_01 mix_i_c062_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_01 (mix_q_src_c062_1_01 0 bpf_c062_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_1_01 (mix_q_src_c062_1_01 mix_q_c062_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_02 (mix_i_src_c062_1_02 0 bpf_c062_1 0) vcvs gain=5.555702330196e-01
SMIXI_c062_1_02 (mix_i_src_c062_1_02 mix_i_c062_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_02 (mix_q_src_c062_1_02 0 bpf_c062_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_1_02 (mix_q_src_c062_1_02 mix_q_c062_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_03 (mix_i_src_c062_1_03 0 bpf_c062_1 0) vcvs gain=1.950903220161e-01
SMIXI_c062_1_03 (mix_i_src_c062_1_03 mix_i_c062_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_03 (mix_q_src_c062_1_03 0 bpf_c062_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_1_03 (mix_q_src_c062_1_03 mix_q_c062_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_04 (mix_i_src_c062_1_04 0 bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_1_04 (mix_i_src_c062_1_04 mix_i_c062_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_04 (mix_q_src_c062_1_04 0 bpf_c062_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_1_04 (mix_q_src_c062_1_04 mix_q_c062_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_05 (mix_i_src_c062_1_05 0 bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_1_05 (mix_i_src_c062_1_05 mix_i_c062_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_05 (mix_q_src_c062_1_05 0 bpf_c062_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_1_05 (mix_q_src_c062_1_05 mix_q_c062_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_06 (mix_i_src_c062_1_06 0 bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_1_06 (mix_i_src_c062_1_06 mix_i_c062_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_06 (mix_q_src_c062_1_06 0 bpf_c062_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_1_06 (mix_q_src_c062_1_06 mix_q_c062_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_07 (mix_i_src_c062_1_07 0 bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_1_07 (mix_i_src_c062_1_07 mix_i_c062_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_07 (mix_q_src_c062_1_07 0 bpf_c062_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_1_07 (mix_q_src_c062_1_07 mix_q_c062_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_08 (mix_i_src_c062_1_08 0 bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_1_08 (mix_i_src_c062_1_08 mix_i_c062_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_08 (mix_q_src_c062_1_08 0 bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_1_08 (mix_q_src_c062_1_08 mix_q_c062_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_09 (mix_i_src_c062_1_09 0 bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_1_09 (mix_i_src_c062_1_09 mix_i_c062_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_09 (mix_q_src_c062_1_09 0 bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_1_09 (mix_q_src_c062_1_09 mix_q_c062_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_10 (mix_i_src_c062_1_10 0 bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_1_10 (mix_i_src_c062_1_10 mix_i_c062_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_10 (mix_q_src_c062_1_10 0 bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_1_10 (mix_q_src_c062_1_10 mix_q_c062_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_11 (mix_i_src_c062_1_11 0 bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_1_11 (mix_i_src_c062_1_11 mix_i_c062_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_11 (mix_q_src_c062_1_11 0 bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_1_11 (mix_q_src_c062_1_11 mix_q_c062_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_12 (mix_i_src_c062_1_12 0 bpf_c062_1 0) vcvs gain=1.950903220161e-01
SMIXI_c062_1_12 (mix_i_src_c062_1_12 mix_i_c062_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_12 (mix_q_src_c062_1_12 0 bpf_c062_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_1_12 (mix_q_src_c062_1_12 mix_q_c062_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_13 (mix_i_src_c062_1_13 0 bpf_c062_1 0) vcvs gain=5.555702330196e-01
SMIXI_c062_1_13 (mix_i_src_c062_1_13 mix_i_c062_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_13 (mix_q_src_c062_1_13 0 bpf_c062_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_1_13 (mix_q_src_c062_1_13 mix_q_c062_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_14 (mix_i_src_c062_1_14 0 bpf_c062_1 0) vcvs gain=8.314696123025e-01
SMIXI_c062_1_14 (mix_i_src_c062_1_14 mix_i_c062_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_14 (mix_q_src_c062_1_14 0 bpf_c062_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_1_14 (mix_q_src_c062_1_14 mix_q_c062_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_1_15 (mix_i_src_c062_1_15 0 bpf_c062_1 0) vcvs gain=9.807852804032e-01
SMIXI_c062_1_15 (mix_i_src_c062_1_15 mix_i_c062_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_1_15 (mix_q_src_c062_1_15 0 bpf_c062_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_1_15 (mix_q_src_c062_1_15 mix_q_c062_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c062_1 (mix_i_c062_1 0) resistor r=1G
RMIXQ_c062_1 (mix_q_c062_1 0) resistor r=1G
RINTI_c062_1 (mix_i_c062_1 Icar_c062_1) resistor r=1k
CINTI_c062_1 (Icar_c062_1 0) capacitor c=80p
RINTQ_c062_1 (mix_q_c062_1 Qcar_c062_1) resistor r=1k
CINTQ_c062_1 (Qcar_c062_1 0) capacitor c=80p

// bl062, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c062_2 (bl062 n_cbpf_c062_2) capacitor c=4.503163717437e-14
LBPF_c062_2 (n_cbpf_c062_2 bpf_c062_2) inductor l=1.000000000000e-06
RBPF_c062_2 (bpf_c062_2 0) resistor r=2.356194490192e+02
EMIXI_c062_2_00 (mix_i_src_c062_2_00 0 bpf_c062_2 0) vcvs gain=9.807852804032e-01
SMIXI_c062_2_00 (mix_i_src_c062_2_00 mix_i_c062_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_00 (mix_q_src_c062_2_00 0 bpf_c062_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_2_00 (mix_q_src_c062_2_00 mix_q_c062_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_01 (mix_i_src_c062_2_01 0 bpf_c062_2 0) vcvs gain=8.314696123025e-01
SMIXI_c062_2_01 (mix_i_src_c062_2_01 mix_i_c062_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_01 (mix_q_src_c062_2_01 0 bpf_c062_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_2_01 (mix_q_src_c062_2_01 mix_q_c062_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_02 (mix_i_src_c062_2_02 0 bpf_c062_2 0) vcvs gain=5.555702330196e-01
SMIXI_c062_2_02 (mix_i_src_c062_2_02 mix_i_c062_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_02 (mix_q_src_c062_2_02 0 bpf_c062_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_2_02 (mix_q_src_c062_2_02 mix_q_c062_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_03 (mix_i_src_c062_2_03 0 bpf_c062_2 0) vcvs gain=1.950903220161e-01
SMIXI_c062_2_03 (mix_i_src_c062_2_03 mix_i_c062_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_03 (mix_q_src_c062_2_03 0 bpf_c062_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_2_03 (mix_q_src_c062_2_03 mix_q_c062_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_04 (mix_i_src_c062_2_04 0 bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_2_04 (mix_i_src_c062_2_04 mix_i_c062_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_04 (mix_q_src_c062_2_04 0 bpf_c062_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_2_04 (mix_q_src_c062_2_04 mix_q_c062_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_05 (mix_i_src_c062_2_05 0 bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_2_05 (mix_i_src_c062_2_05 mix_i_c062_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_05 (mix_q_src_c062_2_05 0 bpf_c062_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_2_05 (mix_q_src_c062_2_05 mix_q_c062_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_06 (mix_i_src_c062_2_06 0 bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_2_06 (mix_i_src_c062_2_06 mix_i_c062_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_06 (mix_q_src_c062_2_06 0 bpf_c062_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_2_06 (mix_q_src_c062_2_06 mix_q_c062_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_07 (mix_i_src_c062_2_07 0 bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_2_07 (mix_i_src_c062_2_07 mix_i_c062_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_07 (mix_q_src_c062_2_07 0 bpf_c062_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_2_07 (mix_q_src_c062_2_07 mix_q_c062_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_08 (mix_i_src_c062_2_08 0 bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_2_08 (mix_i_src_c062_2_08 mix_i_c062_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_08 (mix_q_src_c062_2_08 0 bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_2_08 (mix_q_src_c062_2_08 mix_q_c062_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_09 (mix_i_src_c062_2_09 0 bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_2_09 (mix_i_src_c062_2_09 mix_i_c062_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_09 (mix_q_src_c062_2_09 0 bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_2_09 (mix_q_src_c062_2_09 mix_q_c062_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_10 (mix_i_src_c062_2_10 0 bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_2_10 (mix_i_src_c062_2_10 mix_i_c062_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_10 (mix_q_src_c062_2_10 0 bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_2_10 (mix_q_src_c062_2_10 mix_q_c062_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_11 (mix_i_src_c062_2_11 0 bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_2_11 (mix_i_src_c062_2_11 mix_i_c062_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_11 (mix_q_src_c062_2_11 0 bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_2_11 (mix_q_src_c062_2_11 mix_q_c062_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_12 (mix_i_src_c062_2_12 0 bpf_c062_2 0) vcvs gain=1.950903220161e-01
SMIXI_c062_2_12 (mix_i_src_c062_2_12 mix_i_c062_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_12 (mix_q_src_c062_2_12 0 bpf_c062_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_2_12 (mix_q_src_c062_2_12 mix_q_c062_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_13 (mix_i_src_c062_2_13 0 bpf_c062_2 0) vcvs gain=5.555702330196e-01
SMIXI_c062_2_13 (mix_i_src_c062_2_13 mix_i_c062_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_13 (mix_q_src_c062_2_13 0 bpf_c062_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_2_13 (mix_q_src_c062_2_13 mix_q_c062_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_14 (mix_i_src_c062_2_14 0 bpf_c062_2 0) vcvs gain=8.314696123025e-01
SMIXI_c062_2_14 (mix_i_src_c062_2_14 mix_i_c062_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_14 (mix_q_src_c062_2_14 0 bpf_c062_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_2_14 (mix_q_src_c062_2_14 mix_q_c062_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_2_15 (mix_i_src_c062_2_15 0 bpf_c062_2 0) vcvs gain=9.807852804032e-01
SMIXI_c062_2_15 (mix_i_src_c062_2_15 mix_i_c062_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_2_15 (mix_q_src_c062_2_15 0 bpf_c062_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_2_15 (mix_q_src_c062_2_15 mix_q_c062_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c062_2 (mix_i_c062_2 0) resistor r=1G
RMIXQ_c062_2 (mix_q_c062_2 0) resistor r=1G
RINTI_c062_2 (mix_i_c062_2 Icar_c062_2) resistor r=1k
CINTI_c062_2 (Icar_c062_2 0) capacitor c=80p
RINTQ_c062_2 (mix_q_c062_2 Qcar_c062_2) resistor r=1k
CINTQ_c062_2 (Qcar_c062_2 0) capacitor c=80p

// bl062, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c062_3 (bl062 n_cbpf_c062_3) capacitor c=2.533029591058e-14
LBPF_c062_3 (n_cbpf_c062_3 bpf_c062_3) inductor l=1.000000000000e-06
RBPF_c062_3 (bpf_c062_3 0) resistor r=3.141592653590e+02
EMIXI_c062_3_00 (mix_i_src_c062_3_00 0 bpf_c062_3 0) vcvs gain=9.807852804032e-01
SMIXI_c062_3_00 (mix_i_src_c062_3_00 mix_i_c062_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_00 (mix_q_src_c062_3_00 0 bpf_c062_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_3_00 (mix_q_src_c062_3_00 mix_q_c062_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_01 (mix_i_src_c062_3_01 0 bpf_c062_3 0) vcvs gain=8.314696123025e-01
SMIXI_c062_3_01 (mix_i_src_c062_3_01 mix_i_c062_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_01 (mix_q_src_c062_3_01 0 bpf_c062_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_3_01 (mix_q_src_c062_3_01 mix_q_c062_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_02 (mix_i_src_c062_3_02 0 bpf_c062_3 0) vcvs gain=5.555702330196e-01
SMIXI_c062_3_02 (mix_i_src_c062_3_02 mix_i_c062_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_02 (mix_q_src_c062_3_02 0 bpf_c062_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_3_02 (mix_q_src_c062_3_02 mix_q_c062_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_03 (mix_i_src_c062_3_03 0 bpf_c062_3 0) vcvs gain=1.950903220161e-01
SMIXI_c062_3_03 (mix_i_src_c062_3_03 mix_i_c062_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_03 (mix_q_src_c062_3_03 0 bpf_c062_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_3_03 (mix_q_src_c062_3_03 mix_q_c062_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_04 (mix_i_src_c062_3_04 0 bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_3_04 (mix_i_src_c062_3_04 mix_i_c062_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_04 (mix_q_src_c062_3_04 0 bpf_c062_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c062_3_04 (mix_q_src_c062_3_04 mix_q_c062_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_05 (mix_i_src_c062_3_05 0 bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_3_05 (mix_i_src_c062_3_05 mix_i_c062_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_05 (mix_q_src_c062_3_05 0 bpf_c062_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c062_3_05 (mix_q_src_c062_3_05 mix_q_c062_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_06 (mix_i_src_c062_3_06 0 bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_3_06 (mix_i_src_c062_3_06 mix_i_c062_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_06 (mix_q_src_c062_3_06 0 bpf_c062_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c062_3_06 (mix_q_src_c062_3_06 mix_q_c062_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_07 (mix_i_src_c062_3_07 0 bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_3_07 (mix_i_src_c062_3_07 mix_i_c062_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_07 (mix_q_src_c062_3_07 0 bpf_c062_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c062_3_07 (mix_q_src_c062_3_07 mix_q_c062_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_08 (mix_i_src_c062_3_08 0 bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c062_3_08 (mix_i_src_c062_3_08 mix_i_c062_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_08 (mix_q_src_c062_3_08 0 bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_3_08 (mix_q_src_c062_3_08 mix_q_c062_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_09 (mix_i_src_c062_3_09 0 bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c062_3_09 (mix_i_src_c062_3_09 mix_i_c062_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_09 (mix_q_src_c062_3_09 0 bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_3_09 (mix_q_src_c062_3_09 mix_q_c062_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_10 (mix_i_src_c062_3_10 0 bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c062_3_10 (mix_i_src_c062_3_10 mix_i_c062_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_10 (mix_q_src_c062_3_10 0 bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_3_10 (mix_q_src_c062_3_10 mix_q_c062_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_11 (mix_i_src_c062_3_11 0 bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c062_3_11 (mix_i_src_c062_3_11 mix_i_c062_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_11 (mix_q_src_c062_3_11 0 bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_3_11 (mix_q_src_c062_3_11 mix_q_c062_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_12 (mix_i_src_c062_3_12 0 bpf_c062_3 0) vcvs gain=1.950903220161e-01
SMIXI_c062_3_12 (mix_i_src_c062_3_12 mix_i_c062_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_12 (mix_q_src_c062_3_12 0 bpf_c062_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c062_3_12 (mix_q_src_c062_3_12 mix_q_c062_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_13 (mix_i_src_c062_3_13 0 bpf_c062_3 0) vcvs gain=5.555702330196e-01
SMIXI_c062_3_13 (mix_i_src_c062_3_13 mix_i_c062_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_13 (mix_q_src_c062_3_13 0 bpf_c062_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c062_3_13 (mix_q_src_c062_3_13 mix_q_c062_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_14 (mix_i_src_c062_3_14 0 bpf_c062_3 0) vcvs gain=8.314696123025e-01
SMIXI_c062_3_14 (mix_i_src_c062_3_14 mix_i_c062_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_14 (mix_q_src_c062_3_14 0 bpf_c062_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c062_3_14 (mix_q_src_c062_3_14 mix_q_c062_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c062_3_15 (mix_i_src_c062_3_15 0 bpf_c062_3 0) vcvs gain=9.807852804032e-01
SMIXI_c062_3_15 (mix_i_src_c062_3_15 mix_i_c062_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c062_3_15 (mix_q_src_c062_3_15 0 bpf_c062_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c062_3_15 (mix_q_src_c062_3_15 mix_q_c062_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c062_3 (mix_i_c062_3 0) resistor r=1G
RMIXQ_c062_3 (mix_q_c062_3 0) resistor r=1G
RINTI_c062_3 (mix_i_c062_3 Icar_c062_3) resistor r=1k
CINTI_c062_3 (Icar_c062_3 0) capacitor c=80p
RINTQ_c062_3 (mix_q_c062_3 Qcar_c062_3) resistor r=1k
CINTQ_c062_3 (Qcar_c062_3 0) capacitor c=80p

// bl063, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c063_0 (bl063 n_cbpf_c063_0) capacitor c=4.052847345694e-13
LBPF_c063_0 (n_cbpf_c063_0 bpf_c063_0) inductor l=1.000000000000e-06
RBPF_c063_0 (bpf_c063_0 0) resistor r=7.853981633974e+01
EMIXI_c063_0_00 (mix_i_src_c063_0_00 0 bpf_c063_0 0) vcvs gain=9.807852804032e-01
SMIXI_c063_0_00 (mix_i_src_c063_0_00 mix_i_c063_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_00 (mix_q_src_c063_0_00 0 bpf_c063_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_0_00 (mix_q_src_c063_0_00 mix_q_c063_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_01 (mix_i_src_c063_0_01 0 bpf_c063_0 0) vcvs gain=8.314696123025e-01
SMIXI_c063_0_01 (mix_i_src_c063_0_01 mix_i_c063_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_01 (mix_q_src_c063_0_01 0 bpf_c063_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_0_01 (mix_q_src_c063_0_01 mix_q_c063_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_02 (mix_i_src_c063_0_02 0 bpf_c063_0 0) vcvs gain=5.555702330196e-01
SMIXI_c063_0_02 (mix_i_src_c063_0_02 mix_i_c063_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_02 (mix_q_src_c063_0_02 0 bpf_c063_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_0_02 (mix_q_src_c063_0_02 mix_q_c063_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_03 (mix_i_src_c063_0_03 0 bpf_c063_0 0) vcvs gain=1.950903220161e-01
SMIXI_c063_0_03 (mix_i_src_c063_0_03 mix_i_c063_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_03 (mix_q_src_c063_0_03 0 bpf_c063_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_0_03 (mix_q_src_c063_0_03 mix_q_c063_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_04 (mix_i_src_c063_0_04 0 bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_0_04 (mix_i_src_c063_0_04 mix_i_c063_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_04 (mix_q_src_c063_0_04 0 bpf_c063_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_0_04 (mix_q_src_c063_0_04 mix_q_c063_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_05 (mix_i_src_c063_0_05 0 bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_0_05 (mix_i_src_c063_0_05 mix_i_c063_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_05 (mix_q_src_c063_0_05 0 bpf_c063_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_0_05 (mix_q_src_c063_0_05 mix_q_c063_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_06 (mix_i_src_c063_0_06 0 bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_0_06 (mix_i_src_c063_0_06 mix_i_c063_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_06 (mix_q_src_c063_0_06 0 bpf_c063_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_0_06 (mix_q_src_c063_0_06 mix_q_c063_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_07 (mix_i_src_c063_0_07 0 bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_0_07 (mix_i_src_c063_0_07 mix_i_c063_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_07 (mix_q_src_c063_0_07 0 bpf_c063_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_0_07 (mix_q_src_c063_0_07 mix_q_c063_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_08 (mix_i_src_c063_0_08 0 bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_0_08 (mix_i_src_c063_0_08 mix_i_c063_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_08 (mix_q_src_c063_0_08 0 bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_0_08 (mix_q_src_c063_0_08 mix_q_c063_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_09 (mix_i_src_c063_0_09 0 bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_0_09 (mix_i_src_c063_0_09 mix_i_c063_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_09 (mix_q_src_c063_0_09 0 bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_0_09 (mix_q_src_c063_0_09 mix_q_c063_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_10 (mix_i_src_c063_0_10 0 bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_0_10 (mix_i_src_c063_0_10 mix_i_c063_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_10 (mix_q_src_c063_0_10 0 bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_0_10 (mix_q_src_c063_0_10 mix_q_c063_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_11 (mix_i_src_c063_0_11 0 bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_0_11 (mix_i_src_c063_0_11 mix_i_c063_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_11 (mix_q_src_c063_0_11 0 bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_0_11 (mix_q_src_c063_0_11 mix_q_c063_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_12 (mix_i_src_c063_0_12 0 bpf_c063_0 0) vcvs gain=1.950903220161e-01
SMIXI_c063_0_12 (mix_i_src_c063_0_12 mix_i_c063_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_12 (mix_q_src_c063_0_12 0 bpf_c063_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_0_12 (mix_q_src_c063_0_12 mix_q_c063_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_13 (mix_i_src_c063_0_13 0 bpf_c063_0 0) vcvs gain=5.555702330196e-01
SMIXI_c063_0_13 (mix_i_src_c063_0_13 mix_i_c063_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_13 (mix_q_src_c063_0_13 0 bpf_c063_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_0_13 (mix_q_src_c063_0_13 mix_q_c063_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_14 (mix_i_src_c063_0_14 0 bpf_c063_0 0) vcvs gain=8.314696123025e-01
SMIXI_c063_0_14 (mix_i_src_c063_0_14 mix_i_c063_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_14 (mix_q_src_c063_0_14 0 bpf_c063_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_0_14 (mix_q_src_c063_0_14 mix_q_c063_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_0_15 (mix_i_src_c063_0_15 0 bpf_c063_0 0) vcvs gain=9.807852804032e-01
SMIXI_c063_0_15 (mix_i_src_c063_0_15 mix_i_c063_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_0_15 (mix_q_src_c063_0_15 0 bpf_c063_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_0_15 (mix_q_src_c063_0_15 mix_q_c063_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c063_0 (mix_i_c063_0 0) resistor r=1G
RMIXQ_c063_0 (mix_q_c063_0 0) resistor r=1G
RINTI_c063_0 (mix_i_c063_0 Icar_c063_0) resistor r=1k
CINTI_c063_0 (Icar_c063_0 0) capacitor c=80p
RINTQ_c063_0 (mix_q_c063_0 Qcar_c063_0) resistor r=1k
CINTQ_c063_0 (Qcar_c063_0 0) capacitor c=80p

// bl063, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c063_1 (bl063 n_cbpf_c063_1) capacitor c=1.013211836423e-13
LBPF_c063_1 (n_cbpf_c063_1 bpf_c063_1) inductor l=1.000000000000e-06
RBPF_c063_1 (bpf_c063_1 0) resistor r=1.570796326795e+02
EMIXI_c063_1_00 (mix_i_src_c063_1_00 0 bpf_c063_1 0) vcvs gain=9.807852804032e-01
SMIXI_c063_1_00 (mix_i_src_c063_1_00 mix_i_c063_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_00 (mix_q_src_c063_1_00 0 bpf_c063_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_1_00 (mix_q_src_c063_1_00 mix_q_c063_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_01 (mix_i_src_c063_1_01 0 bpf_c063_1 0) vcvs gain=8.314696123025e-01
SMIXI_c063_1_01 (mix_i_src_c063_1_01 mix_i_c063_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_01 (mix_q_src_c063_1_01 0 bpf_c063_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_1_01 (mix_q_src_c063_1_01 mix_q_c063_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_02 (mix_i_src_c063_1_02 0 bpf_c063_1 0) vcvs gain=5.555702330196e-01
SMIXI_c063_1_02 (mix_i_src_c063_1_02 mix_i_c063_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_02 (mix_q_src_c063_1_02 0 bpf_c063_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_1_02 (mix_q_src_c063_1_02 mix_q_c063_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_03 (mix_i_src_c063_1_03 0 bpf_c063_1 0) vcvs gain=1.950903220161e-01
SMIXI_c063_1_03 (mix_i_src_c063_1_03 mix_i_c063_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_03 (mix_q_src_c063_1_03 0 bpf_c063_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_1_03 (mix_q_src_c063_1_03 mix_q_c063_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_04 (mix_i_src_c063_1_04 0 bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_1_04 (mix_i_src_c063_1_04 mix_i_c063_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_04 (mix_q_src_c063_1_04 0 bpf_c063_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_1_04 (mix_q_src_c063_1_04 mix_q_c063_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_05 (mix_i_src_c063_1_05 0 bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_1_05 (mix_i_src_c063_1_05 mix_i_c063_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_05 (mix_q_src_c063_1_05 0 bpf_c063_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_1_05 (mix_q_src_c063_1_05 mix_q_c063_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_06 (mix_i_src_c063_1_06 0 bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_1_06 (mix_i_src_c063_1_06 mix_i_c063_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_06 (mix_q_src_c063_1_06 0 bpf_c063_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_1_06 (mix_q_src_c063_1_06 mix_q_c063_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_07 (mix_i_src_c063_1_07 0 bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_1_07 (mix_i_src_c063_1_07 mix_i_c063_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_07 (mix_q_src_c063_1_07 0 bpf_c063_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_1_07 (mix_q_src_c063_1_07 mix_q_c063_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_08 (mix_i_src_c063_1_08 0 bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_1_08 (mix_i_src_c063_1_08 mix_i_c063_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_08 (mix_q_src_c063_1_08 0 bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_1_08 (mix_q_src_c063_1_08 mix_q_c063_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_09 (mix_i_src_c063_1_09 0 bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_1_09 (mix_i_src_c063_1_09 mix_i_c063_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_09 (mix_q_src_c063_1_09 0 bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_1_09 (mix_q_src_c063_1_09 mix_q_c063_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_10 (mix_i_src_c063_1_10 0 bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_1_10 (mix_i_src_c063_1_10 mix_i_c063_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_10 (mix_q_src_c063_1_10 0 bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_1_10 (mix_q_src_c063_1_10 mix_q_c063_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_11 (mix_i_src_c063_1_11 0 bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_1_11 (mix_i_src_c063_1_11 mix_i_c063_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_11 (mix_q_src_c063_1_11 0 bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_1_11 (mix_q_src_c063_1_11 mix_q_c063_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_12 (mix_i_src_c063_1_12 0 bpf_c063_1 0) vcvs gain=1.950903220161e-01
SMIXI_c063_1_12 (mix_i_src_c063_1_12 mix_i_c063_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_12 (mix_q_src_c063_1_12 0 bpf_c063_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_1_12 (mix_q_src_c063_1_12 mix_q_c063_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_13 (mix_i_src_c063_1_13 0 bpf_c063_1 0) vcvs gain=5.555702330196e-01
SMIXI_c063_1_13 (mix_i_src_c063_1_13 mix_i_c063_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_13 (mix_q_src_c063_1_13 0 bpf_c063_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_1_13 (mix_q_src_c063_1_13 mix_q_c063_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_14 (mix_i_src_c063_1_14 0 bpf_c063_1 0) vcvs gain=8.314696123025e-01
SMIXI_c063_1_14 (mix_i_src_c063_1_14 mix_i_c063_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_14 (mix_q_src_c063_1_14 0 bpf_c063_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_1_14 (mix_q_src_c063_1_14 mix_q_c063_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_1_15 (mix_i_src_c063_1_15 0 bpf_c063_1 0) vcvs gain=9.807852804032e-01
SMIXI_c063_1_15 (mix_i_src_c063_1_15 mix_i_c063_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_1_15 (mix_q_src_c063_1_15 0 bpf_c063_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_1_15 (mix_q_src_c063_1_15 mix_q_c063_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c063_1 (mix_i_c063_1 0) resistor r=1G
RMIXQ_c063_1 (mix_q_c063_1 0) resistor r=1G
RINTI_c063_1 (mix_i_c063_1 Icar_c063_1) resistor r=1k
CINTI_c063_1 (Icar_c063_1 0) capacitor c=80p
RINTQ_c063_1 (mix_q_c063_1 Qcar_c063_1) resistor r=1k
CINTQ_c063_1 (Qcar_c063_1 0) capacitor c=80p

// bl063, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c063_2 (bl063 n_cbpf_c063_2) capacitor c=4.503163717437e-14
LBPF_c063_2 (n_cbpf_c063_2 bpf_c063_2) inductor l=1.000000000000e-06
RBPF_c063_2 (bpf_c063_2 0) resistor r=2.356194490192e+02
EMIXI_c063_2_00 (mix_i_src_c063_2_00 0 bpf_c063_2 0) vcvs gain=9.807852804032e-01
SMIXI_c063_2_00 (mix_i_src_c063_2_00 mix_i_c063_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_00 (mix_q_src_c063_2_00 0 bpf_c063_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_2_00 (mix_q_src_c063_2_00 mix_q_c063_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_01 (mix_i_src_c063_2_01 0 bpf_c063_2 0) vcvs gain=8.314696123025e-01
SMIXI_c063_2_01 (mix_i_src_c063_2_01 mix_i_c063_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_01 (mix_q_src_c063_2_01 0 bpf_c063_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_2_01 (mix_q_src_c063_2_01 mix_q_c063_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_02 (mix_i_src_c063_2_02 0 bpf_c063_2 0) vcvs gain=5.555702330196e-01
SMIXI_c063_2_02 (mix_i_src_c063_2_02 mix_i_c063_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_02 (mix_q_src_c063_2_02 0 bpf_c063_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_2_02 (mix_q_src_c063_2_02 mix_q_c063_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_03 (mix_i_src_c063_2_03 0 bpf_c063_2 0) vcvs gain=1.950903220161e-01
SMIXI_c063_2_03 (mix_i_src_c063_2_03 mix_i_c063_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_03 (mix_q_src_c063_2_03 0 bpf_c063_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_2_03 (mix_q_src_c063_2_03 mix_q_c063_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_04 (mix_i_src_c063_2_04 0 bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_2_04 (mix_i_src_c063_2_04 mix_i_c063_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_04 (mix_q_src_c063_2_04 0 bpf_c063_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_2_04 (mix_q_src_c063_2_04 mix_q_c063_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_05 (mix_i_src_c063_2_05 0 bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_2_05 (mix_i_src_c063_2_05 mix_i_c063_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_05 (mix_q_src_c063_2_05 0 bpf_c063_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_2_05 (mix_q_src_c063_2_05 mix_q_c063_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_06 (mix_i_src_c063_2_06 0 bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_2_06 (mix_i_src_c063_2_06 mix_i_c063_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_06 (mix_q_src_c063_2_06 0 bpf_c063_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_2_06 (mix_q_src_c063_2_06 mix_q_c063_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_07 (mix_i_src_c063_2_07 0 bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_2_07 (mix_i_src_c063_2_07 mix_i_c063_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_07 (mix_q_src_c063_2_07 0 bpf_c063_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_2_07 (mix_q_src_c063_2_07 mix_q_c063_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_08 (mix_i_src_c063_2_08 0 bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_2_08 (mix_i_src_c063_2_08 mix_i_c063_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_08 (mix_q_src_c063_2_08 0 bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_2_08 (mix_q_src_c063_2_08 mix_q_c063_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_09 (mix_i_src_c063_2_09 0 bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_2_09 (mix_i_src_c063_2_09 mix_i_c063_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_09 (mix_q_src_c063_2_09 0 bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_2_09 (mix_q_src_c063_2_09 mix_q_c063_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_10 (mix_i_src_c063_2_10 0 bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_2_10 (mix_i_src_c063_2_10 mix_i_c063_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_10 (mix_q_src_c063_2_10 0 bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_2_10 (mix_q_src_c063_2_10 mix_q_c063_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_11 (mix_i_src_c063_2_11 0 bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_2_11 (mix_i_src_c063_2_11 mix_i_c063_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_11 (mix_q_src_c063_2_11 0 bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_2_11 (mix_q_src_c063_2_11 mix_q_c063_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_12 (mix_i_src_c063_2_12 0 bpf_c063_2 0) vcvs gain=1.950903220161e-01
SMIXI_c063_2_12 (mix_i_src_c063_2_12 mix_i_c063_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_12 (mix_q_src_c063_2_12 0 bpf_c063_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_2_12 (mix_q_src_c063_2_12 mix_q_c063_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_13 (mix_i_src_c063_2_13 0 bpf_c063_2 0) vcvs gain=5.555702330196e-01
SMIXI_c063_2_13 (mix_i_src_c063_2_13 mix_i_c063_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_13 (mix_q_src_c063_2_13 0 bpf_c063_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_2_13 (mix_q_src_c063_2_13 mix_q_c063_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_14 (mix_i_src_c063_2_14 0 bpf_c063_2 0) vcvs gain=8.314696123025e-01
SMIXI_c063_2_14 (mix_i_src_c063_2_14 mix_i_c063_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_14 (mix_q_src_c063_2_14 0 bpf_c063_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_2_14 (mix_q_src_c063_2_14 mix_q_c063_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_2_15 (mix_i_src_c063_2_15 0 bpf_c063_2 0) vcvs gain=9.807852804032e-01
SMIXI_c063_2_15 (mix_i_src_c063_2_15 mix_i_c063_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_2_15 (mix_q_src_c063_2_15 0 bpf_c063_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_2_15 (mix_q_src_c063_2_15 mix_q_c063_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c063_2 (mix_i_c063_2 0) resistor r=1G
RMIXQ_c063_2 (mix_q_c063_2 0) resistor r=1G
RINTI_c063_2 (mix_i_c063_2 Icar_c063_2) resistor r=1k
CINTI_c063_2 (Icar_c063_2 0) capacitor c=80p
RINTQ_c063_2 (mix_q_c063_2 Qcar_c063_2) resistor r=1k
CINTQ_c063_2 (Qcar_c063_2 0) capacitor c=80p

// bl063, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c063_3 (bl063 n_cbpf_c063_3) capacitor c=2.533029591058e-14
LBPF_c063_3 (n_cbpf_c063_3 bpf_c063_3) inductor l=1.000000000000e-06
RBPF_c063_3 (bpf_c063_3 0) resistor r=3.141592653590e+02
EMIXI_c063_3_00 (mix_i_src_c063_3_00 0 bpf_c063_3 0) vcvs gain=9.807852804032e-01
SMIXI_c063_3_00 (mix_i_src_c063_3_00 mix_i_c063_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_00 (mix_q_src_c063_3_00 0 bpf_c063_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_3_00 (mix_q_src_c063_3_00 mix_q_c063_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_01 (mix_i_src_c063_3_01 0 bpf_c063_3 0) vcvs gain=8.314696123025e-01
SMIXI_c063_3_01 (mix_i_src_c063_3_01 mix_i_c063_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_01 (mix_q_src_c063_3_01 0 bpf_c063_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_3_01 (mix_q_src_c063_3_01 mix_q_c063_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_02 (mix_i_src_c063_3_02 0 bpf_c063_3 0) vcvs gain=5.555702330196e-01
SMIXI_c063_3_02 (mix_i_src_c063_3_02 mix_i_c063_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_02 (mix_q_src_c063_3_02 0 bpf_c063_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_3_02 (mix_q_src_c063_3_02 mix_q_c063_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_03 (mix_i_src_c063_3_03 0 bpf_c063_3 0) vcvs gain=1.950903220161e-01
SMIXI_c063_3_03 (mix_i_src_c063_3_03 mix_i_c063_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_03 (mix_q_src_c063_3_03 0 bpf_c063_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_3_03 (mix_q_src_c063_3_03 mix_q_c063_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_04 (mix_i_src_c063_3_04 0 bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_3_04 (mix_i_src_c063_3_04 mix_i_c063_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_04 (mix_q_src_c063_3_04 0 bpf_c063_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c063_3_04 (mix_q_src_c063_3_04 mix_q_c063_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_05 (mix_i_src_c063_3_05 0 bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_3_05 (mix_i_src_c063_3_05 mix_i_c063_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_05 (mix_q_src_c063_3_05 0 bpf_c063_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c063_3_05 (mix_q_src_c063_3_05 mix_q_c063_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_06 (mix_i_src_c063_3_06 0 bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_3_06 (mix_i_src_c063_3_06 mix_i_c063_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_06 (mix_q_src_c063_3_06 0 bpf_c063_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c063_3_06 (mix_q_src_c063_3_06 mix_q_c063_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_07 (mix_i_src_c063_3_07 0 bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_3_07 (mix_i_src_c063_3_07 mix_i_c063_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_07 (mix_q_src_c063_3_07 0 bpf_c063_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c063_3_07 (mix_q_src_c063_3_07 mix_q_c063_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_08 (mix_i_src_c063_3_08 0 bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c063_3_08 (mix_i_src_c063_3_08 mix_i_c063_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_08 (mix_q_src_c063_3_08 0 bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_3_08 (mix_q_src_c063_3_08 mix_q_c063_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_09 (mix_i_src_c063_3_09 0 bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c063_3_09 (mix_i_src_c063_3_09 mix_i_c063_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_09 (mix_q_src_c063_3_09 0 bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_3_09 (mix_q_src_c063_3_09 mix_q_c063_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_10 (mix_i_src_c063_3_10 0 bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c063_3_10 (mix_i_src_c063_3_10 mix_i_c063_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_10 (mix_q_src_c063_3_10 0 bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_3_10 (mix_q_src_c063_3_10 mix_q_c063_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_11 (mix_i_src_c063_3_11 0 bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c063_3_11 (mix_i_src_c063_3_11 mix_i_c063_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_11 (mix_q_src_c063_3_11 0 bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_3_11 (mix_q_src_c063_3_11 mix_q_c063_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_12 (mix_i_src_c063_3_12 0 bpf_c063_3 0) vcvs gain=1.950903220161e-01
SMIXI_c063_3_12 (mix_i_src_c063_3_12 mix_i_c063_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_12 (mix_q_src_c063_3_12 0 bpf_c063_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c063_3_12 (mix_q_src_c063_3_12 mix_q_c063_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_13 (mix_i_src_c063_3_13 0 bpf_c063_3 0) vcvs gain=5.555702330196e-01
SMIXI_c063_3_13 (mix_i_src_c063_3_13 mix_i_c063_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_13 (mix_q_src_c063_3_13 0 bpf_c063_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c063_3_13 (mix_q_src_c063_3_13 mix_q_c063_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_14 (mix_i_src_c063_3_14 0 bpf_c063_3 0) vcvs gain=8.314696123025e-01
SMIXI_c063_3_14 (mix_i_src_c063_3_14 mix_i_c063_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_14 (mix_q_src_c063_3_14 0 bpf_c063_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c063_3_14 (mix_q_src_c063_3_14 mix_q_c063_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c063_3_15 (mix_i_src_c063_3_15 0 bpf_c063_3 0) vcvs gain=9.807852804032e-01
SMIXI_c063_3_15 (mix_i_src_c063_3_15 mix_i_c063_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c063_3_15 (mix_q_src_c063_3_15 0 bpf_c063_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c063_3_15 (mix_q_src_c063_3_15 mix_q_c063_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c063_3 (mix_i_c063_3 0) resistor r=1G
RMIXQ_c063_3 (mix_q_c063_3 0) resistor r=1G
RINTI_c063_3 (mix_i_c063_3 Icar_c063_3) resistor r=1k
CINTI_c063_3 (Icar_c063_3 0) capacitor c=80p
RINTQ_c063_3 (mix_q_c063_3 Qcar_c063_3) resistor r=1k
CINTQ_c063_3 (Qcar_c063_3 0) capacitor c=80p

// bl064, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c064_0 (bl064 n_cbpf_c064_0) capacitor c=4.052847345694e-13
LBPF_c064_0 (n_cbpf_c064_0 bpf_c064_0) inductor l=1.000000000000e-06
RBPF_c064_0 (bpf_c064_0 0) resistor r=7.853981633974e+01
EMIXI_c064_0_00 (mix_i_src_c064_0_00 0 bpf_c064_0 0) vcvs gain=9.807852804032e-01
SMIXI_c064_0_00 (mix_i_src_c064_0_00 mix_i_c064_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_00 (mix_q_src_c064_0_00 0 bpf_c064_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_0_00 (mix_q_src_c064_0_00 mix_q_c064_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_01 (mix_i_src_c064_0_01 0 bpf_c064_0 0) vcvs gain=8.314696123025e-01
SMIXI_c064_0_01 (mix_i_src_c064_0_01 mix_i_c064_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_01 (mix_q_src_c064_0_01 0 bpf_c064_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_0_01 (mix_q_src_c064_0_01 mix_q_c064_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_02 (mix_i_src_c064_0_02 0 bpf_c064_0 0) vcvs gain=5.555702330196e-01
SMIXI_c064_0_02 (mix_i_src_c064_0_02 mix_i_c064_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_02 (mix_q_src_c064_0_02 0 bpf_c064_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_0_02 (mix_q_src_c064_0_02 mix_q_c064_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_03 (mix_i_src_c064_0_03 0 bpf_c064_0 0) vcvs gain=1.950903220161e-01
SMIXI_c064_0_03 (mix_i_src_c064_0_03 mix_i_c064_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_03 (mix_q_src_c064_0_03 0 bpf_c064_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_0_03 (mix_q_src_c064_0_03 mix_q_c064_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_04 (mix_i_src_c064_0_04 0 bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_0_04 (mix_i_src_c064_0_04 mix_i_c064_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_04 (mix_q_src_c064_0_04 0 bpf_c064_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_0_04 (mix_q_src_c064_0_04 mix_q_c064_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_05 (mix_i_src_c064_0_05 0 bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_0_05 (mix_i_src_c064_0_05 mix_i_c064_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_05 (mix_q_src_c064_0_05 0 bpf_c064_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_0_05 (mix_q_src_c064_0_05 mix_q_c064_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_06 (mix_i_src_c064_0_06 0 bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_0_06 (mix_i_src_c064_0_06 mix_i_c064_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_06 (mix_q_src_c064_0_06 0 bpf_c064_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_0_06 (mix_q_src_c064_0_06 mix_q_c064_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_07 (mix_i_src_c064_0_07 0 bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_0_07 (mix_i_src_c064_0_07 mix_i_c064_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_07 (mix_q_src_c064_0_07 0 bpf_c064_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_0_07 (mix_q_src_c064_0_07 mix_q_c064_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_08 (mix_i_src_c064_0_08 0 bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_0_08 (mix_i_src_c064_0_08 mix_i_c064_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_08 (mix_q_src_c064_0_08 0 bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_0_08 (mix_q_src_c064_0_08 mix_q_c064_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_09 (mix_i_src_c064_0_09 0 bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_0_09 (mix_i_src_c064_0_09 mix_i_c064_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_09 (mix_q_src_c064_0_09 0 bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_0_09 (mix_q_src_c064_0_09 mix_q_c064_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_10 (mix_i_src_c064_0_10 0 bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_0_10 (mix_i_src_c064_0_10 mix_i_c064_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_10 (mix_q_src_c064_0_10 0 bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_0_10 (mix_q_src_c064_0_10 mix_q_c064_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_11 (mix_i_src_c064_0_11 0 bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_0_11 (mix_i_src_c064_0_11 mix_i_c064_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_11 (mix_q_src_c064_0_11 0 bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_0_11 (mix_q_src_c064_0_11 mix_q_c064_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_12 (mix_i_src_c064_0_12 0 bpf_c064_0 0) vcvs gain=1.950903220161e-01
SMIXI_c064_0_12 (mix_i_src_c064_0_12 mix_i_c064_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_12 (mix_q_src_c064_0_12 0 bpf_c064_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_0_12 (mix_q_src_c064_0_12 mix_q_c064_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_13 (mix_i_src_c064_0_13 0 bpf_c064_0 0) vcvs gain=5.555702330196e-01
SMIXI_c064_0_13 (mix_i_src_c064_0_13 mix_i_c064_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_13 (mix_q_src_c064_0_13 0 bpf_c064_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_0_13 (mix_q_src_c064_0_13 mix_q_c064_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_14 (mix_i_src_c064_0_14 0 bpf_c064_0 0) vcvs gain=8.314696123025e-01
SMIXI_c064_0_14 (mix_i_src_c064_0_14 mix_i_c064_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_14 (mix_q_src_c064_0_14 0 bpf_c064_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_0_14 (mix_q_src_c064_0_14 mix_q_c064_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_0_15 (mix_i_src_c064_0_15 0 bpf_c064_0 0) vcvs gain=9.807852804032e-01
SMIXI_c064_0_15 (mix_i_src_c064_0_15 mix_i_c064_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_0_15 (mix_q_src_c064_0_15 0 bpf_c064_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_0_15 (mix_q_src_c064_0_15 mix_q_c064_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c064_0 (mix_i_c064_0 0) resistor r=1G
RMIXQ_c064_0 (mix_q_c064_0 0) resistor r=1G
RINTI_c064_0 (mix_i_c064_0 Icar_c064_0) resistor r=1k
CINTI_c064_0 (Icar_c064_0 0) capacitor c=80p
RINTQ_c064_0 (mix_q_c064_0 Qcar_c064_0) resistor r=1k
CINTQ_c064_0 (Qcar_c064_0 0) capacitor c=80p
save bpf_c064_0 Icar_c064_0 Qcar_c064_0

// bl064, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c064_1 (bl064 n_cbpf_c064_1) capacitor c=1.013211836423e-13
LBPF_c064_1 (n_cbpf_c064_1 bpf_c064_1) inductor l=1.000000000000e-06
RBPF_c064_1 (bpf_c064_1 0) resistor r=1.570796326795e+02
EMIXI_c064_1_00 (mix_i_src_c064_1_00 0 bpf_c064_1 0) vcvs gain=9.807852804032e-01
SMIXI_c064_1_00 (mix_i_src_c064_1_00 mix_i_c064_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_00 (mix_q_src_c064_1_00 0 bpf_c064_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_1_00 (mix_q_src_c064_1_00 mix_q_c064_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_01 (mix_i_src_c064_1_01 0 bpf_c064_1 0) vcvs gain=8.314696123025e-01
SMIXI_c064_1_01 (mix_i_src_c064_1_01 mix_i_c064_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_01 (mix_q_src_c064_1_01 0 bpf_c064_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_1_01 (mix_q_src_c064_1_01 mix_q_c064_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_02 (mix_i_src_c064_1_02 0 bpf_c064_1 0) vcvs gain=5.555702330196e-01
SMIXI_c064_1_02 (mix_i_src_c064_1_02 mix_i_c064_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_02 (mix_q_src_c064_1_02 0 bpf_c064_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_1_02 (mix_q_src_c064_1_02 mix_q_c064_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_03 (mix_i_src_c064_1_03 0 bpf_c064_1 0) vcvs gain=1.950903220161e-01
SMIXI_c064_1_03 (mix_i_src_c064_1_03 mix_i_c064_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_03 (mix_q_src_c064_1_03 0 bpf_c064_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_1_03 (mix_q_src_c064_1_03 mix_q_c064_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_04 (mix_i_src_c064_1_04 0 bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_1_04 (mix_i_src_c064_1_04 mix_i_c064_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_04 (mix_q_src_c064_1_04 0 bpf_c064_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_1_04 (mix_q_src_c064_1_04 mix_q_c064_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_05 (mix_i_src_c064_1_05 0 bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_1_05 (mix_i_src_c064_1_05 mix_i_c064_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_05 (mix_q_src_c064_1_05 0 bpf_c064_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_1_05 (mix_q_src_c064_1_05 mix_q_c064_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_06 (mix_i_src_c064_1_06 0 bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_1_06 (mix_i_src_c064_1_06 mix_i_c064_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_06 (mix_q_src_c064_1_06 0 bpf_c064_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_1_06 (mix_q_src_c064_1_06 mix_q_c064_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_07 (mix_i_src_c064_1_07 0 bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_1_07 (mix_i_src_c064_1_07 mix_i_c064_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_07 (mix_q_src_c064_1_07 0 bpf_c064_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_1_07 (mix_q_src_c064_1_07 mix_q_c064_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_08 (mix_i_src_c064_1_08 0 bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_1_08 (mix_i_src_c064_1_08 mix_i_c064_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_08 (mix_q_src_c064_1_08 0 bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_1_08 (mix_q_src_c064_1_08 mix_q_c064_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_09 (mix_i_src_c064_1_09 0 bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_1_09 (mix_i_src_c064_1_09 mix_i_c064_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_09 (mix_q_src_c064_1_09 0 bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_1_09 (mix_q_src_c064_1_09 mix_q_c064_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_10 (mix_i_src_c064_1_10 0 bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_1_10 (mix_i_src_c064_1_10 mix_i_c064_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_10 (mix_q_src_c064_1_10 0 bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_1_10 (mix_q_src_c064_1_10 mix_q_c064_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_11 (mix_i_src_c064_1_11 0 bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_1_11 (mix_i_src_c064_1_11 mix_i_c064_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_11 (mix_q_src_c064_1_11 0 bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_1_11 (mix_q_src_c064_1_11 mix_q_c064_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_12 (mix_i_src_c064_1_12 0 bpf_c064_1 0) vcvs gain=1.950903220161e-01
SMIXI_c064_1_12 (mix_i_src_c064_1_12 mix_i_c064_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_12 (mix_q_src_c064_1_12 0 bpf_c064_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_1_12 (mix_q_src_c064_1_12 mix_q_c064_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_13 (mix_i_src_c064_1_13 0 bpf_c064_1 0) vcvs gain=5.555702330196e-01
SMIXI_c064_1_13 (mix_i_src_c064_1_13 mix_i_c064_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_13 (mix_q_src_c064_1_13 0 bpf_c064_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_1_13 (mix_q_src_c064_1_13 mix_q_c064_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_14 (mix_i_src_c064_1_14 0 bpf_c064_1 0) vcvs gain=8.314696123025e-01
SMIXI_c064_1_14 (mix_i_src_c064_1_14 mix_i_c064_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_14 (mix_q_src_c064_1_14 0 bpf_c064_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_1_14 (mix_q_src_c064_1_14 mix_q_c064_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_1_15 (mix_i_src_c064_1_15 0 bpf_c064_1 0) vcvs gain=9.807852804032e-01
SMIXI_c064_1_15 (mix_i_src_c064_1_15 mix_i_c064_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_1_15 (mix_q_src_c064_1_15 0 bpf_c064_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_1_15 (mix_q_src_c064_1_15 mix_q_c064_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c064_1 (mix_i_c064_1 0) resistor r=1G
RMIXQ_c064_1 (mix_q_c064_1 0) resistor r=1G
RINTI_c064_1 (mix_i_c064_1 Icar_c064_1) resistor r=1k
CINTI_c064_1 (Icar_c064_1 0) capacitor c=80p
RINTQ_c064_1 (mix_q_c064_1 Qcar_c064_1) resistor r=1k
CINTQ_c064_1 (Qcar_c064_1 0) capacitor c=80p
save bpf_c064_1 Icar_c064_1 Qcar_c064_1

// bl064, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c064_2 (bl064 n_cbpf_c064_2) capacitor c=4.503163717437e-14
LBPF_c064_2 (n_cbpf_c064_2 bpf_c064_2) inductor l=1.000000000000e-06
RBPF_c064_2 (bpf_c064_2 0) resistor r=2.356194490192e+02
EMIXI_c064_2_00 (mix_i_src_c064_2_00 0 bpf_c064_2 0) vcvs gain=9.807852804032e-01
SMIXI_c064_2_00 (mix_i_src_c064_2_00 mix_i_c064_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_00 (mix_q_src_c064_2_00 0 bpf_c064_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_2_00 (mix_q_src_c064_2_00 mix_q_c064_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_01 (mix_i_src_c064_2_01 0 bpf_c064_2 0) vcvs gain=8.314696123025e-01
SMIXI_c064_2_01 (mix_i_src_c064_2_01 mix_i_c064_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_01 (mix_q_src_c064_2_01 0 bpf_c064_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_2_01 (mix_q_src_c064_2_01 mix_q_c064_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_02 (mix_i_src_c064_2_02 0 bpf_c064_2 0) vcvs gain=5.555702330196e-01
SMIXI_c064_2_02 (mix_i_src_c064_2_02 mix_i_c064_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_02 (mix_q_src_c064_2_02 0 bpf_c064_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_2_02 (mix_q_src_c064_2_02 mix_q_c064_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_03 (mix_i_src_c064_2_03 0 bpf_c064_2 0) vcvs gain=1.950903220161e-01
SMIXI_c064_2_03 (mix_i_src_c064_2_03 mix_i_c064_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_03 (mix_q_src_c064_2_03 0 bpf_c064_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_2_03 (mix_q_src_c064_2_03 mix_q_c064_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_04 (mix_i_src_c064_2_04 0 bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_2_04 (mix_i_src_c064_2_04 mix_i_c064_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_04 (mix_q_src_c064_2_04 0 bpf_c064_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_2_04 (mix_q_src_c064_2_04 mix_q_c064_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_05 (mix_i_src_c064_2_05 0 bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_2_05 (mix_i_src_c064_2_05 mix_i_c064_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_05 (mix_q_src_c064_2_05 0 bpf_c064_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_2_05 (mix_q_src_c064_2_05 mix_q_c064_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_06 (mix_i_src_c064_2_06 0 bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_2_06 (mix_i_src_c064_2_06 mix_i_c064_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_06 (mix_q_src_c064_2_06 0 bpf_c064_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_2_06 (mix_q_src_c064_2_06 mix_q_c064_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_07 (mix_i_src_c064_2_07 0 bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_2_07 (mix_i_src_c064_2_07 mix_i_c064_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_07 (mix_q_src_c064_2_07 0 bpf_c064_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_2_07 (mix_q_src_c064_2_07 mix_q_c064_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_08 (mix_i_src_c064_2_08 0 bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_2_08 (mix_i_src_c064_2_08 mix_i_c064_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_08 (mix_q_src_c064_2_08 0 bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_2_08 (mix_q_src_c064_2_08 mix_q_c064_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_09 (mix_i_src_c064_2_09 0 bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_2_09 (mix_i_src_c064_2_09 mix_i_c064_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_09 (mix_q_src_c064_2_09 0 bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_2_09 (mix_q_src_c064_2_09 mix_q_c064_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_10 (mix_i_src_c064_2_10 0 bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_2_10 (mix_i_src_c064_2_10 mix_i_c064_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_10 (mix_q_src_c064_2_10 0 bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_2_10 (mix_q_src_c064_2_10 mix_q_c064_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_11 (mix_i_src_c064_2_11 0 bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_2_11 (mix_i_src_c064_2_11 mix_i_c064_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_11 (mix_q_src_c064_2_11 0 bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_2_11 (mix_q_src_c064_2_11 mix_q_c064_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_12 (mix_i_src_c064_2_12 0 bpf_c064_2 0) vcvs gain=1.950903220161e-01
SMIXI_c064_2_12 (mix_i_src_c064_2_12 mix_i_c064_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_12 (mix_q_src_c064_2_12 0 bpf_c064_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_2_12 (mix_q_src_c064_2_12 mix_q_c064_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_13 (mix_i_src_c064_2_13 0 bpf_c064_2 0) vcvs gain=5.555702330196e-01
SMIXI_c064_2_13 (mix_i_src_c064_2_13 mix_i_c064_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_13 (mix_q_src_c064_2_13 0 bpf_c064_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_2_13 (mix_q_src_c064_2_13 mix_q_c064_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_14 (mix_i_src_c064_2_14 0 bpf_c064_2 0) vcvs gain=8.314696123025e-01
SMIXI_c064_2_14 (mix_i_src_c064_2_14 mix_i_c064_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_14 (mix_q_src_c064_2_14 0 bpf_c064_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_2_14 (mix_q_src_c064_2_14 mix_q_c064_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_2_15 (mix_i_src_c064_2_15 0 bpf_c064_2 0) vcvs gain=9.807852804032e-01
SMIXI_c064_2_15 (mix_i_src_c064_2_15 mix_i_c064_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_2_15 (mix_q_src_c064_2_15 0 bpf_c064_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_2_15 (mix_q_src_c064_2_15 mix_q_c064_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c064_2 (mix_i_c064_2 0) resistor r=1G
RMIXQ_c064_2 (mix_q_c064_2 0) resistor r=1G
RINTI_c064_2 (mix_i_c064_2 Icar_c064_2) resistor r=1k
CINTI_c064_2 (Icar_c064_2 0) capacitor c=80p
RINTQ_c064_2 (mix_q_c064_2 Qcar_c064_2) resistor r=1k
CINTQ_c064_2 (Qcar_c064_2 0) capacitor c=80p
save bpf_c064_2 Icar_c064_2 Qcar_c064_2

// bl064, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c064_3 (bl064 n_cbpf_c064_3) capacitor c=2.533029591058e-14
LBPF_c064_3 (n_cbpf_c064_3 bpf_c064_3) inductor l=1.000000000000e-06
RBPF_c064_3 (bpf_c064_3 0) resistor r=3.141592653590e+02
EMIXI_c064_3_00 (mix_i_src_c064_3_00 0 bpf_c064_3 0) vcvs gain=9.807852804032e-01
SMIXI_c064_3_00 (mix_i_src_c064_3_00 mix_i_c064_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_00 (mix_q_src_c064_3_00 0 bpf_c064_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_3_00 (mix_q_src_c064_3_00 mix_q_c064_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_01 (mix_i_src_c064_3_01 0 bpf_c064_3 0) vcvs gain=8.314696123025e-01
SMIXI_c064_3_01 (mix_i_src_c064_3_01 mix_i_c064_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_01 (mix_q_src_c064_3_01 0 bpf_c064_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_3_01 (mix_q_src_c064_3_01 mix_q_c064_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_02 (mix_i_src_c064_3_02 0 bpf_c064_3 0) vcvs gain=5.555702330196e-01
SMIXI_c064_3_02 (mix_i_src_c064_3_02 mix_i_c064_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_02 (mix_q_src_c064_3_02 0 bpf_c064_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_3_02 (mix_q_src_c064_3_02 mix_q_c064_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_03 (mix_i_src_c064_3_03 0 bpf_c064_3 0) vcvs gain=1.950903220161e-01
SMIXI_c064_3_03 (mix_i_src_c064_3_03 mix_i_c064_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_03 (mix_q_src_c064_3_03 0 bpf_c064_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_3_03 (mix_q_src_c064_3_03 mix_q_c064_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_04 (mix_i_src_c064_3_04 0 bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_3_04 (mix_i_src_c064_3_04 mix_i_c064_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_04 (mix_q_src_c064_3_04 0 bpf_c064_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c064_3_04 (mix_q_src_c064_3_04 mix_q_c064_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_05 (mix_i_src_c064_3_05 0 bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_3_05 (mix_i_src_c064_3_05 mix_i_c064_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_05 (mix_q_src_c064_3_05 0 bpf_c064_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c064_3_05 (mix_q_src_c064_3_05 mix_q_c064_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_06 (mix_i_src_c064_3_06 0 bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_3_06 (mix_i_src_c064_3_06 mix_i_c064_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_06 (mix_q_src_c064_3_06 0 bpf_c064_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c064_3_06 (mix_q_src_c064_3_06 mix_q_c064_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_07 (mix_i_src_c064_3_07 0 bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_3_07 (mix_i_src_c064_3_07 mix_i_c064_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_07 (mix_q_src_c064_3_07 0 bpf_c064_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c064_3_07 (mix_q_src_c064_3_07 mix_q_c064_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_08 (mix_i_src_c064_3_08 0 bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c064_3_08 (mix_i_src_c064_3_08 mix_i_c064_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_08 (mix_q_src_c064_3_08 0 bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_3_08 (mix_q_src_c064_3_08 mix_q_c064_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_09 (mix_i_src_c064_3_09 0 bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c064_3_09 (mix_i_src_c064_3_09 mix_i_c064_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_09 (mix_q_src_c064_3_09 0 bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_3_09 (mix_q_src_c064_3_09 mix_q_c064_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_10 (mix_i_src_c064_3_10 0 bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c064_3_10 (mix_i_src_c064_3_10 mix_i_c064_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_10 (mix_q_src_c064_3_10 0 bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_3_10 (mix_q_src_c064_3_10 mix_q_c064_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_11 (mix_i_src_c064_3_11 0 bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c064_3_11 (mix_i_src_c064_3_11 mix_i_c064_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_11 (mix_q_src_c064_3_11 0 bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_3_11 (mix_q_src_c064_3_11 mix_q_c064_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_12 (mix_i_src_c064_3_12 0 bpf_c064_3 0) vcvs gain=1.950903220161e-01
SMIXI_c064_3_12 (mix_i_src_c064_3_12 mix_i_c064_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_12 (mix_q_src_c064_3_12 0 bpf_c064_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c064_3_12 (mix_q_src_c064_3_12 mix_q_c064_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_13 (mix_i_src_c064_3_13 0 bpf_c064_3 0) vcvs gain=5.555702330196e-01
SMIXI_c064_3_13 (mix_i_src_c064_3_13 mix_i_c064_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_13 (mix_q_src_c064_3_13 0 bpf_c064_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c064_3_13 (mix_q_src_c064_3_13 mix_q_c064_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_14 (mix_i_src_c064_3_14 0 bpf_c064_3 0) vcvs gain=8.314696123025e-01
SMIXI_c064_3_14 (mix_i_src_c064_3_14 mix_i_c064_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_14 (mix_q_src_c064_3_14 0 bpf_c064_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c064_3_14 (mix_q_src_c064_3_14 mix_q_c064_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c064_3_15 (mix_i_src_c064_3_15 0 bpf_c064_3 0) vcvs gain=9.807852804032e-01
SMIXI_c064_3_15 (mix_i_src_c064_3_15 mix_i_c064_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c064_3_15 (mix_q_src_c064_3_15 0 bpf_c064_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c064_3_15 (mix_q_src_c064_3_15 mix_q_c064_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c064_3 (mix_i_c064_3 0) resistor r=1G
RMIXQ_c064_3 (mix_q_c064_3 0) resistor r=1G
RINTI_c064_3 (mix_i_c064_3 Icar_c064_3) resistor r=1k
CINTI_c064_3 (Icar_c064_3 0) capacitor c=80p
RINTQ_c064_3 (mix_q_c064_3 Qcar_c064_3) resistor r=1k
CINTQ_c064_3 (Qcar_c064_3 0) capacitor c=80p
save bpf_c064_3 Icar_c064_3 Qcar_c064_3

// bl065, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c065_0 (bl065 n_cbpf_c065_0) capacitor c=4.052847345694e-13
LBPF_c065_0 (n_cbpf_c065_0 bpf_c065_0) inductor l=1.000000000000e-06
RBPF_c065_0 (bpf_c065_0 0) resistor r=7.853981633974e+01
EMIXI_c065_0_00 (mix_i_src_c065_0_00 0 bpf_c065_0 0) vcvs gain=9.807852804032e-01
SMIXI_c065_0_00 (mix_i_src_c065_0_00 mix_i_c065_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_00 (mix_q_src_c065_0_00 0 bpf_c065_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_0_00 (mix_q_src_c065_0_00 mix_q_c065_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_01 (mix_i_src_c065_0_01 0 bpf_c065_0 0) vcvs gain=8.314696123025e-01
SMIXI_c065_0_01 (mix_i_src_c065_0_01 mix_i_c065_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_01 (mix_q_src_c065_0_01 0 bpf_c065_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_0_01 (mix_q_src_c065_0_01 mix_q_c065_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_02 (mix_i_src_c065_0_02 0 bpf_c065_0 0) vcvs gain=5.555702330196e-01
SMIXI_c065_0_02 (mix_i_src_c065_0_02 mix_i_c065_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_02 (mix_q_src_c065_0_02 0 bpf_c065_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_0_02 (mix_q_src_c065_0_02 mix_q_c065_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_03 (mix_i_src_c065_0_03 0 bpf_c065_0 0) vcvs gain=1.950903220161e-01
SMIXI_c065_0_03 (mix_i_src_c065_0_03 mix_i_c065_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_03 (mix_q_src_c065_0_03 0 bpf_c065_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_0_03 (mix_q_src_c065_0_03 mix_q_c065_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_04 (mix_i_src_c065_0_04 0 bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_0_04 (mix_i_src_c065_0_04 mix_i_c065_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_04 (mix_q_src_c065_0_04 0 bpf_c065_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_0_04 (mix_q_src_c065_0_04 mix_q_c065_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_05 (mix_i_src_c065_0_05 0 bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_0_05 (mix_i_src_c065_0_05 mix_i_c065_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_05 (mix_q_src_c065_0_05 0 bpf_c065_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_0_05 (mix_q_src_c065_0_05 mix_q_c065_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_06 (mix_i_src_c065_0_06 0 bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_0_06 (mix_i_src_c065_0_06 mix_i_c065_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_06 (mix_q_src_c065_0_06 0 bpf_c065_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_0_06 (mix_q_src_c065_0_06 mix_q_c065_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_07 (mix_i_src_c065_0_07 0 bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_0_07 (mix_i_src_c065_0_07 mix_i_c065_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_07 (mix_q_src_c065_0_07 0 bpf_c065_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_0_07 (mix_q_src_c065_0_07 mix_q_c065_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_08 (mix_i_src_c065_0_08 0 bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_0_08 (mix_i_src_c065_0_08 mix_i_c065_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_08 (mix_q_src_c065_0_08 0 bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_0_08 (mix_q_src_c065_0_08 mix_q_c065_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_09 (mix_i_src_c065_0_09 0 bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_0_09 (mix_i_src_c065_0_09 mix_i_c065_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_09 (mix_q_src_c065_0_09 0 bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_0_09 (mix_q_src_c065_0_09 mix_q_c065_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_10 (mix_i_src_c065_0_10 0 bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_0_10 (mix_i_src_c065_0_10 mix_i_c065_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_10 (mix_q_src_c065_0_10 0 bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_0_10 (mix_q_src_c065_0_10 mix_q_c065_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_11 (mix_i_src_c065_0_11 0 bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_0_11 (mix_i_src_c065_0_11 mix_i_c065_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_11 (mix_q_src_c065_0_11 0 bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_0_11 (mix_q_src_c065_0_11 mix_q_c065_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_12 (mix_i_src_c065_0_12 0 bpf_c065_0 0) vcvs gain=1.950903220161e-01
SMIXI_c065_0_12 (mix_i_src_c065_0_12 mix_i_c065_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_12 (mix_q_src_c065_0_12 0 bpf_c065_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_0_12 (mix_q_src_c065_0_12 mix_q_c065_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_13 (mix_i_src_c065_0_13 0 bpf_c065_0 0) vcvs gain=5.555702330196e-01
SMIXI_c065_0_13 (mix_i_src_c065_0_13 mix_i_c065_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_13 (mix_q_src_c065_0_13 0 bpf_c065_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_0_13 (mix_q_src_c065_0_13 mix_q_c065_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_14 (mix_i_src_c065_0_14 0 bpf_c065_0 0) vcvs gain=8.314696123025e-01
SMIXI_c065_0_14 (mix_i_src_c065_0_14 mix_i_c065_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_14 (mix_q_src_c065_0_14 0 bpf_c065_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_0_14 (mix_q_src_c065_0_14 mix_q_c065_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_0_15 (mix_i_src_c065_0_15 0 bpf_c065_0 0) vcvs gain=9.807852804032e-01
SMIXI_c065_0_15 (mix_i_src_c065_0_15 mix_i_c065_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_0_15 (mix_q_src_c065_0_15 0 bpf_c065_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_0_15 (mix_q_src_c065_0_15 mix_q_c065_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c065_0 (mix_i_c065_0 0) resistor r=1G
RMIXQ_c065_0 (mix_q_c065_0 0) resistor r=1G
RINTI_c065_0 (mix_i_c065_0 Icar_c065_0) resistor r=1k
CINTI_c065_0 (Icar_c065_0 0) capacitor c=80p
RINTQ_c065_0 (mix_q_c065_0 Qcar_c065_0) resistor r=1k
CINTQ_c065_0 (Qcar_c065_0 0) capacitor c=80p

// bl065, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c065_1 (bl065 n_cbpf_c065_1) capacitor c=1.013211836423e-13
LBPF_c065_1 (n_cbpf_c065_1 bpf_c065_1) inductor l=1.000000000000e-06
RBPF_c065_1 (bpf_c065_1 0) resistor r=1.570796326795e+02
EMIXI_c065_1_00 (mix_i_src_c065_1_00 0 bpf_c065_1 0) vcvs gain=9.807852804032e-01
SMIXI_c065_1_00 (mix_i_src_c065_1_00 mix_i_c065_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_00 (mix_q_src_c065_1_00 0 bpf_c065_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_1_00 (mix_q_src_c065_1_00 mix_q_c065_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_01 (mix_i_src_c065_1_01 0 bpf_c065_1 0) vcvs gain=8.314696123025e-01
SMIXI_c065_1_01 (mix_i_src_c065_1_01 mix_i_c065_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_01 (mix_q_src_c065_1_01 0 bpf_c065_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_1_01 (mix_q_src_c065_1_01 mix_q_c065_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_02 (mix_i_src_c065_1_02 0 bpf_c065_1 0) vcvs gain=5.555702330196e-01
SMIXI_c065_1_02 (mix_i_src_c065_1_02 mix_i_c065_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_02 (mix_q_src_c065_1_02 0 bpf_c065_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_1_02 (mix_q_src_c065_1_02 mix_q_c065_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_03 (mix_i_src_c065_1_03 0 bpf_c065_1 0) vcvs gain=1.950903220161e-01
SMIXI_c065_1_03 (mix_i_src_c065_1_03 mix_i_c065_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_03 (mix_q_src_c065_1_03 0 bpf_c065_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_1_03 (mix_q_src_c065_1_03 mix_q_c065_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_04 (mix_i_src_c065_1_04 0 bpf_c065_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_1_04 (mix_i_src_c065_1_04 mix_i_c065_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_04 (mix_q_src_c065_1_04 0 bpf_c065_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_1_04 (mix_q_src_c065_1_04 mix_q_c065_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_05 (mix_i_src_c065_1_05 0 bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_1_05 (mix_i_src_c065_1_05 mix_i_c065_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_05 (mix_q_src_c065_1_05 0 bpf_c065_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_1_05 (mix_q_src_c065_1_05 mix_q_c065_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_06 (mix_i_src_c065_1_06 0 bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_1_06 (mix_i_src_c065_1_06 mix_i_c065_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_06 (mix_q_src_c065_1_06 0 bpf_c065_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_1_06 (mix_q_src_c065_1_06 mix_q_c065_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_07 (mix_i_src_c065_1_07 0 bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_1_07 (mix_i_src_c065_1_07 mix_i_c065_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_07 (mix_q_src_c065_1_07 0 bpf_c065_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_1_07 (mix_q_src_c065_1_07 mix_q_c065_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_08 (mix_i_src_c065_1_08 0 bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_1_08 (mix_i_src_c065_1_08 mix_i_c065_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_08 (mix_q_src_c065_1_08 0 bpf_c065_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_1_08 (mix_q_src_c065_1_08 mix_q_c065_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_09 (mix_i_src_c065_1_09 0 bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_1_09 (mix_i_src_c065_1_09 mix_i_c065_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_09 (mix_q_src_c065_1_09 0 bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_1_09 (mix_q_src_c065_1_09 mix_q_c065_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_10 (mix_i_src_c065_1_10 0 bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_1_10 (mix_i_src_c065_1_10 mix_i_c065_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_10 (mix_q_src_c065_1_10 0 bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_1_10 (mix_q_src_c065_1_10 mix_q_c065_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_11 (mix_i_src_c065_1_11 0 bpf_c065_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_1_11 (mix_i_src_c065_1_11 mix_i_c065_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_11 (mix_q_src_c065_1_11 0 bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_1_11 (mix_q_src_c065_1_11 mix_q_c065_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_12 (mix_i_src_c065_1_12 0 bpf_c065_1 0) vcvs gain=1.950903220161e-01
SMIXI_c065_1_12 (mix_i_src_c065_1_12 mix_i_c065_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_12 (mix_q_src_c065_1_12 0 bpf_c065_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_1_12 (mix_q_src_c065_1_12 mix_q_c065_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_13 (mix_i_src_c065_1_13 0 bpf_c065_1 0) vcvs gain=5.555702330196e-01
SMIXI_c065_1_13 (mix_i_src_c065_1_13 mix_i_c065_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_13 (mix_q_src_c065_1_13 0 bpf_c065_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_1_13 (mix_q_src_c065_1_13 mix_q_c065_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_14 (mix_i_src_c065_1_14 0 bpf_c065_1 0) vcvs gain=8.314696123025e-01
SMIXI_c065_1_14 (mix_i_src_c065_1_14 mix_i_c065_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_14 (mix_q_src_c065_1_14 0 bpf_c065_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_1_14 (mix_q_src_c065_1_14 mix_q_c065_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_1_15 (mix_i_src_c065_1_15 0 bpf_c065_1 0) vcvs gain=9.807852804032e-01
SMIXI_c065_1_15 (mix_i_src_c065_1_15 mix_i_c065_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_1_15 (mix_q_src_c065_1_15 0 bpf_c065_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_1_15 (mix_q_src_c065_1_15 mix_q_c065_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c065_1 (mix_i_c065_1 0) resistor r=1G
RMIXQ_c065_1 (mix_q_c065_1 0) resistor r=1G
RINTI_c065_1 (mix_i_c065_1 Icar_c065_1) resistor r=1k
CINTI_c065_1 (Icar_c065_1 0) capacitor c=80p
RINTQ_c065_1 (mix_q_c065_1 Qcar_c065_1) resistor r=1k
CINTQ_c065_1 (Qcar_c065_1 0) capacitor c=80p

// bl065, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c065_2 (bl065 n_cbpf_c065_2) capacitor c=4.503163717437e-14
LBPF_c065_2 (n_cbpf_c065_2 bpf_c065_2) inductor l=1.000000000000e-06
RBPF_c065_2 (bpf_c065_2 0) resistor r=2.356194490192e+02
EMIXI_c065_2_00 (mix_i_src_c065_2_00 0 bpf_c065_2 0) vcvs gain=9.807852804032e-01
SMIXI_c065_2_00 (mix_i_src_c065_2_00 mix_i_c065_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_00 (mix_q_src_c065_2_00 0 bpf_c065_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_2_00 (mix_q_src_c065_2_00 mix_q_c065_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_01 (mix_i_src_c065_2_01 0 bpf_c065_2 0) vcvs gain=8.314696123025e-01
SMIXI_c065_2_01 (mix_i_src_c065_2_01 mix_i_c065_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_01 (mix_q_src_c065_2_01 0 bpf_c065_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_2_01 (mix_q_src_c065_2_01 mix_q_c065_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_02 (mix_i_src_c065_2_02 0 bpf_c065_2 0) vcvs gain=5.555702330196e-01
SMIXI_c065_2_02 (mix_i_src_c065_2_02 mix_i_c065_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_02 (mix_q_src_c065_2_02 0 bpf_c065_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_2_02 (mix_q_src_c065_2_02 mix_q_c065_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_03 (mix_i_src_c065_2_03 0 bpf_c065_2 0) vcvs gain=1.950903220161e-01
SMIXI_c065_2_03 (mix_i_src_c065_2_03 mix_i_c065_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_03 (mix_q_src_c065_2_03 0 bpf_c065_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_2_03 (mix_q_src_c065_2_03 mix_q_c065_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_04 (mix_i_src_c065_2_04 0 bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_2_04 (mix_i_src_c065_2_04 mix_i_c065_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_04 (mix_q_src_c065_2_04 0 bpf_c065_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_2_04 (mix_q_src_c065_2_04 mix_q_c065_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_05 (mix_i_src_c065_2_05 0 bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_2_05 (mix_i_src_c065_2_05 mix_i_c065_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_05 (mix_q_src_c065_2_05 0 bpf_c065_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_2_05 (mix_q_src_c065_2_05 mix_q_c065_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_06 (mix_i_src_c065_2_06 0 bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_2_06 (mix_i_src_c065_2_06 mix_i_c065_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_06 (mix_q_src_c065_2_06 0 bpf_c065_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_2_06 (mix_q_src_c065_2_06 mix_q_c065_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_07 (mix_i_src_c065_2_07 0 bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_2_07 (mix_i_src_c065_2_07 mix_i_c065_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_07 (mix_q_src_c065_2_07 0 bpf_c065_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_2_07 (mix_q_src_c065_2_07 mix_q_c065_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_08 (mix_i_src_c065_2_08 0 bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_2_08 (mix_i_src_c065_2_08 mix_i_c065_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_08 (mix_q_src_c065_2_08 0 bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_2_08 (mix_q_src_c065_2_08 mix_q_c065_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_09 (mix_i_src_c065_2_09 0 bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_2_09 (mix_i_src_c065_2_09 mix_i_c065_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_09 (mix_q_src_c065_2_09 0 bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_2_09 (mix_q_src_c065_2_09 mix_q_c065_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_10 (mix_i_src_c065_2_10 0 bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_2_10 (mix_i_src_c065_2_10 mix_i_c065_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_10 (mix_q_src_c065_2_10 0 bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_2_10 (mix_q_src_c065_2_10 mix_q_c065_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_11 (mix_i_src_c065_2_11 0 bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_2_11 (mix_i_src_c065_2_11 mix_i_c065_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_11 (mix_q_src_c065_2_11 0 bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_2_11 (mix_q_src_c065_2_11 mix_q_c065_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_12 (mix_i_src_c065_2_12 0 bpf_c065_2 0) vcvs gain=1.950903220161e-01
SMIXI_c065_2_12 (mix_i_src_c065_2_12 mix_i_c065_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_12 (mix_q_src_c065_2_12 0 bpf_c065_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_2_12 (mix_q_src_c065_2_12 mix_q_c065_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_13 (mix_i_src_c065_2_13 0 bpf_c065_2 0) vcvs gain=5.555702330196e-01
SMIXI_c065_2_13 (mix_i_src_c065_2_13 mix_i_c065_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_13 (mix_q_src_c065_2_13 0 bpf_c065_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_2_13 (mix_q_src_c065_2_13 mix_q_c065_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_14 (mix_i_src_c065_2_14 0 bpf_c065_2 0) vcvs gain=8.314696123025e-01
SMIXI_c065_2_14 (mix_i_src_c065_2_14 mix_i_c065_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_14 (mix_q_src_c065_2_14 0 bpf_c065_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_2_14 (mix_q_src_c065_2_14 mix_q_c065_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_2_15 (mix_i_src_c065_2_15 0 bpf_c065_2 0) vcvs gain=9.807852804032e-01
SMIXI_c065_2_15 (mix_i_src_c065_2_15 mix_i_c065_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_2_15 (mix_q_src_c065_2_15 0 bpf_c065_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_2_15 (mix_q_src_c065_2_15 mix_q_c065_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c065_2 (mix_i_c065_2 0) resistor r=1G
RMIXQ_c065_2 (mix_q_c065_2 0) resistor r=1G
RINTI_c065_2 (mix_i_c065_2 Icar_c065_2) resistor r=1k
CINTI_c065_2 (Icar_c065_2 0) capacitor c=80p
RINTQ_c065_2 (mix_q_c065_2 Qcar_c065_2) resistor r=1k
CINTQ_c065_2 (Qcar_c065_2 0) capacitor c=80p

// bl065, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c065_3 (bl065 n_cbpf_c065_3) capacitor c=2.533029591058e-14
LBPF_c065_3 (n_cbpf_c065_3 bpf_c065_3) inductor l=1.000000000000e-06
RBPF_c065_3 (bpf_c065_3 0) resistor r=3.141592653590e+02
EMIXI_c065_3_00 (mix_i_src_c065_3_00 0 bpf_c065_3 0) vcvs gain=9.807852804032e-01
SMIXI_c065_3_00 (mix_i_src_c065_3_00 mix_i_c065_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_00 (mix_q_src_c065_3_00 0 bpf_c065_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_3_00 (mix_q_src_c065_3_00 mix_q_c065_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_01 (mix_i_src_c065_3_01 0 bpf_c065_3 0) vcvs gain=8.314696123025e-01
SMIXI_c065_3_01 (mix_i_src_c065_3_01 mix_i_c065_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_01 (mix_q_src_c065_3_01 0 bpf_c065_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_3_01 (mix_q_src_c065_3_01 mix_q_c065_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_02 (mix_i_src_c065_3_02 0 bpf_c065_3 0) vcvs gain=5.555702330196e-01
SMIXI_c065_3_02 (mix_i_src_c065_3_02 mix_i_c065_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_02 (mix_q_src_c065_3_02 0 bpf_c065_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_3_02 (mix_q_src_c065_3_02 mix_q_c065_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_03 (mix_i_src_c065_3_03 0 bpf_c065_3 0) vcvs gain=1.950903220161e-01
SMIXI_c065_3_03 (mix_i_src_c065_3_03 mix_i_c065_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_03 (mix_q_src_c065_3_03 0 bpf_c065_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_3_03 (mix_q_src_c065_3_03 mix_q_c065_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_04 (mix_i_src_c065_3_04 0 bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_3_04 (mix_i_src_c065_3_04 mix_i_c065_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_04 (mix_q_src_c065_3_04 0 bpf_c065_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c065_3_04 (mix_q_src_c065_3_04 mix_q_c065_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_05 (mix_i_src_c065_3_05 0 bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_3_05 (mix_i_src_c065_3_05 mix_i_c065_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_05 (mix_q_src_c065_3_05 0 bpf_c065_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c065_3_05 (mix_q_src_c065_3_05 mix_q_c065_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_06 (mix_i_src_c065_3_06 0 bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_3_06 (mix_i_src_c065_3_06 mix_i_c065_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_06 (mix_q_src_c065_3_06 0 bpf_c065_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c065_3_06 (mix_q_src_c065_3_06 mix_q_c065_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_07 (mix_i_src_c065_3_07 0 bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_3_07 (mix_i_src_c065_3_07 mix_i_c065_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_07 (mix_q_src_c065_3_07 0 bpf_c065_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c065_3_07 (mix_q_src_c065_3_07 mix_q_c065_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_08 (mix_i_src_c065_3_08 0 bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c065_3_08 (mix_i_src_c065_3_08 mix_i_c065_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_08 (mix_q_src_c065_3_08 0 bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_3_08 (mix_q_src_c065_3_08 mix_q_c065_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_09 (mix_i_src_c065_3_09 0 bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c065_3_09 (mix_i_src_c065_3_09 mix_i_c065_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_09 (mix_q_src_c065_3_09 0 bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_3_09 (mix_q_src_c065_3_09 mix_q_c065_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_10 (mix_i_src_c065_3_10 0 bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c065_3_10 (mix_i_src_c065_3_10 mix_i_c065_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_10 (mix_q_src_c065_3_10 0 bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_3_10 (mix_q_src_c065_3_10 mix_q_c065_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_11 (mix_i_src_c065_3_11 0 bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c065_3_11 (mix_i_src_c065_3_11 mix_i_c065_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_11 (mix_q_src_c065_3_11 0 bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_3_11 (mix_q_src_c065_3_11 mix_q_c065_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_12 (mix_i_src_c065_3_12 0 bpf_c065_3 0) vcvs gain=1.950903220161e-01
SMIXI_c065_3_12 (mix_i_src_c065_3_12 mix_i_c065_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_12 (mix_q_src_c065_3_12 0 bpf_c065_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c065_3_12 (mix_q_src_c065_3_12 mix_q_c065_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_13 (mix_i_src_c065_3_13 0 bpf_c065_3 0) vcvs gain=5.555702330196e-01
SMIXI_c065_3_13 (mix_i_src_c065_3_13 mix_i_c065_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_13 (mix_q_src_c065_3_13 0 bpf_c065_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c065_3_13 (mix_q_src_c065_3_13 mix_q_c065_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_14 (mix_i_src_c065_3_14 0 bpf_c065_3 0) vcvs gain=8.314696123025e-01
SMIXI_c065_3_14 (mix_i_src_c065_3_14 mix_i_c065_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_14 (mix_q_src_c065_3_14 0 bpf_c065_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c065_3_14 (mix_q_src_c065_3_14 mix_q_c065_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c065_3_15 (mix_i_src_c065_3_15 0 bpf_c065_3 0) vcvs gain=9.807852804032e-01
SMIXI_c065_3_15 (mix_i_src_c065_3_15 mix_i_c065_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c065_3_15 (mix_q_src_c065_3_15 0 bpf_c065_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c065_3_15 (mix_q_src_c065_3_15 mix_q_c065_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c065_3 (mix_i_c065_3 0) resistor r=1G
RMIXQ_c065_3 (mix_q_c065_3 0) resistor r=1G
RINTI_c065_3 (mix_i_c065_3 Icar_c065_3) resistor r=1k
CINTI_c065_3 (Icar_c065_3 0) capacitor c=80p
RINTQ_c065_3 (mix_q_c065_3 Qcar_c065_3) resistor r=1k
CINTQ_c065_3 (Qcar_c065_3 0) capacitor c=80p

// bl066, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c066_0 (bl066 n_cbpf_c066_0) capacitor c=4.052847345694e-13
LBPF_c066_0 (n_cbpf_c066_0 bpf_c066_0) inductor l=1.000000000000e-06
RBPF_c066_0 (bpf_c066_0 0) resistor r=7.853981633974e+01
EMIXI_c066_0_00 (mix_i_src_c066_0_00 0 bpf_c066_0 0) vcvs gain=9.807852804032e-01
SMIXI_c066_0_00 (mix_i_src_c066_0_00 mix_i_c066_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_00 (mix_q_src_c066_0_00 0 bpf_c066_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_0_00 (mix_q_src_c066_0_00 mix_q_c066_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_01 (mix_i_src_c066_0_01 0 bpf_c066_0 0) vcvs gain=8.314696123025e-01
SMIXI_c066_0_01 (mix_i_src_c066_0_01 mix_i_c066_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_01 (mix_q_src_c066_0_01 0 bpf_c066_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_0_01 (mix_q_src_c066_0_01 mix_q_c066_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_02 (mix_i_src_c066_0_02 0 bpf_c066_0 0) vcvs gain=5.555702330196e-01
SMIXI_c066_0_02 (mix_i_src_c066_0_02 mix_i_c066_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_02 (mix_q_src_c066_0_02 0 bpf_c066_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_0_02 (mix_q_src_c066_0_02 mix_q_c066_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_03 (mix_i_src_c066_0_03 0 bpf_c066_0 0) vcvs gain=1.950903220161e-01
SMIXI_c066_0_03 (mix_i_src_c066_0_03 mix_i_c066_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_03 (mix_q_src_c066_0_03 0 bpf_c066_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_0_03 (mix_q_src_c066_0_03 mix_q_c066_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_04 (mix_i_src_c066_0_04 0 bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_0_04 (mix_i_src_c066_0_04 mix_i_c066_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_04 (mix_q_src_c066_0_04 0 bpf_c066_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_0_04 (mix_q_src_c066_0_04 mix_q_c066_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_05 (mix_i_src_c066_0_05 0 bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_0_05 (mix_i_src_c066_0_05 mix_i_c066_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_05 (mix_q_src_c066_0_05 0 bpf_c066_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_0_05 (mix_q_src_c066_0_05 mix_q_c066_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_06 (mix_i_src_c066_0_06 0 bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_0_06 (mix_i_src_c066_0_06 mix_i_c066_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_06 (mix_q_src_c066_0_06 0 bpf_c066_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_0_06 (mix_q_src_c066_0_06 mix_q_c066_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_07 (mix_i_src_c066_0_07 0 bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_0_07 (mix_i_src_c066_0_07 mix_i_c066_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_07 (mix_q_src_c066_0_07 0 bpf_c066_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_0_07 (mix_q_src_c066_0_07 mix_q_c066_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_08 (mix_i_src_c066_0_08 0 bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_0_08 (mix_i_src_c066_0_08 mix_i_c066_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_08 (mix_q_src_c066_0_08 0 bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_0_08 (mix_q_src_c066_0_08 mix_q_c066_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_09 (mix_i_src_c066_0_09 0 bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_0_09 (mix_i_src_c066_0_09 mix_i_c066_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_09 (mix_q_src_c066_0_09 0 bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_0_09 (mix_q_src_c066_0_09 mix_q_c066_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_10 (mix_i_src_c066_0_10 0 bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_0_10 (mix_i_src_c066_0_10 mix_i_c066_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_10 (mix_q_src_c066_0_10 0 bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_0_10 (mix_q_src_c066_0_10 mix_q_c066_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_11 (mix_i_src_c066_0_11 0 bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_0_11 (mix_i_src_c066_0_11 mix_i_c066_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_11 (mix_q_src_c066_0_11 0 bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_0_11 (mix_q_src_c066_0_11 mix_q_c066_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_12 (mix_i_src_c066_0_12 0 bpf_c066_0 0) vcvs gain=1.950903220161e-01
SMIXI_c066_0_12 (mix_i_src_c066_0_12 mix_i_c066_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_12 (mix_q_src_c066_0_12 0 bpf_c066_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_0_12 (mix_q_src_c066_0_12 mix_q_c066_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_13 (mix_i_src_c066_0_13 0 bpf_c066_0 0) vcvs gain=5.555702330196e-01
SMIXI_c066_0_13 (mix_i_src_c066_0_13 mix_i_c066_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_13 (mix_q_src_c066_0_13 0 bpf_c066_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_0_13 (mix_q_src_c066_0_13 mix_q_c066_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_14 (mix_i_src_c066_0_14 0 bpf_c066_0 0) vcvs gain=8.314696123025e-01
SMIXI_c066_0_14 (mix_i_src_c066_0_14 mix_i_c066_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_14 (mix_q_src_c066_0_14 0 bpf_c066_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_0_14 (mix_q_src_c066_0_14 mix_q_c066_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_0_15 (mix_i_src_c066_0_15 0 bpf_c066_0 0) vcvs gain=9.807852804032e-01
SMIXI_c066_0_15 (mix_i_src_c066_0_15 mix_i_c066_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_0_15 (mix_q_src_c066_0_15 0 bpf_c066_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_0_15 (mix_q_src_c066_0_15 mix_q_c066_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c066_0 (mix_i_c066_0 0) resistor r=1G
RMIXQ_c066_0 (mix_q_c066_0 0) resistor r=1G
RINTI_c066_0 (mix_i_c066_0 Icar_c066_0) resistor r=1k
CINTI_c066_0 (Icar_c066_0 0) capacitor c=80p
RINTQ_c066_0 (mix_q_c066_0 Qcar_c066_0) resistor r=1k
CINTQ_c066_0 (Qcar_c066_0 0) capacitor c=80p

// bl066, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c066_1 (bl066 n_cbpf_c066_1) capacitor c=1.013211836423e-13
LBPF_c066_1 (n_cbpf_c066_1 bpf_c066_1) inductor l=1.000000000000e-06
RBPF_c066_1 (bpf_c066_1 0) resistor r=1.570796326795e+02
EMIXI_c066_1_00 (mix_i_src_c066_1_00 0 bpf_c066_1 0) vcvs gain=9.807852804032e-01
SMIXI_c066_1_00 (mix_i_src_c066_1_00 mix_i_c066_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_00 (mix_q_src_c066_1_00 0 bpf_c066_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_1_00 (mix_q_src_c066_1_00 mix_q_c066_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_01 (mix_i_src_c066_1_01 0 bpf_c066_1 0) vcvs gain=8.314696123025e-01
SMIXI_c066_1_01 (mix_i_src_c066_1_01 mix_i_c066_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_01 (mix_q_src_c066_1_01 0 bpf_c066_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_1_01 (mix_q_src_c066_1_01 mix_q_c066_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_02 (mix_i_src_c066_1_02 0 bpf_c066_1 0) vcvs gain=5.555702330196e-01
SMIXI_c066_1_02 (mix_i_src_c066_1_02 mix_i_c066_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_02 (mix_q_src_c066_1_02 0 bpf_c066_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_1_02 (mix_q_src_c066_1_02 mix_q_c066_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_03 (mix_i_src_c066_1_03 0 bpf_c066_1 0) vcvs gain=1.950903220161e-01
SMIXI_c066_1_03 (mix_i_src_c066_1_03 mix_i_c066_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_03 (mix_q_src_c066_1_03 0 bpf_c066_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_1_03 (mix_q_src_c066_1_03 mix_q_c066_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_04 (mix_i_src_c066_1_04 0 bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_1_04 (mix_i_src_c066_1_04 mix_i_c066_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_04 (mix_q_src_c066_1_04 0 bpf_c066_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_1_04 (mix_q_src_c066_1_04 mix_q_c066_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_05 (mix_i_src_c066_1_05 0 bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_1_05 (mix_i_src_c066_1_05 mix_i_c066_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_05 (mix_q_src_c066_1_05 0 bpf_c066_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_1_05 (mix_q_src_c066_1_05 mix_q_c066_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_06 (mix_i_src_c066_1_06 0 bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_1_06 (mix_i_src_c066_1_06 mix_i_c066_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_06 (mix_q_src_c066_1_06 0 bpf_c066_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_1_06 (mix_q_src_c066_1_06 mix_q_c066_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_07 (mix_i_src_c066_1_07 0 bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_1_07 (mix_i_src_c066_1_07 mix_i_c066_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_07 (mix_q_src_c066_1_07 0 bpf_c066_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_1_07 (mix_q_src_c066_1_07 mix_q_c066_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_08 (mix_i_src_c066_1_08 0 bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_1_08 (mix_i_src_c066_1_08 mix_i_c066_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_08 (mix_q_src_c066_1_08 0 bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_1_08 (mix_q_src_c066_1_08 mix_q_c066_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_09 (mix_i_src_c066_1_09 0 bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_1_09 (mix_i_src_c066_1_09 mix_i_c066_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_09 (mix_q_src_c066_1_09 0 bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_1_09 (mix_q_src_c066_1_09 mix_q_c066_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_10 (mix_i_src_c066_1_10 0 bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_1_10 (mix_i_src_c066_1_10 mix_i_c066_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_10 (mix_q_src_c066_1_10 0 bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_1_10 (mix_q_src_c066_1_10 mix_q_c066_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_11 (mix_i_src_c066_1_11 0 bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_1_11 (mix_i_src_c066_1_11 mix_i_c066_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_11 (mix_q_src_c066_1_11 0 bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_1_11 (mix_q_src_c066_1_11 mix_q_c066_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_12 (mix_i_src_c066_1_12 0 bpf_c066_1 0) vcvs gain=1.950903220161e-01
SMIXI_c066_1_12 (mix_i_src_c066_1_12 mix_i_c066_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_12 (mix_q_src_c066_1_12 0 bpf_c066_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_1_12 (mix_q_src_c066_1_12 mix_q_c066_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_13 (mix_i_src_c066_1_13 0 bpf_c066_1 0) vcvs gain=5.555702330196e-01
SMIXI_c066_1_13 (mix_i_src_c066_1_13 mix_i_c066_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_13 (mix_q_src_c066_1_13 0 bpf_c066_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_1_13 (mix_q_src_c066_1_13 mix_q_c066_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_14 (mix_i_src_c066_1_14 0 bpf_c066_1 0) vcvs gain=8.314696123025e-01
SMIXI_c066_1_14 (mix_i_src_c066_1_14 mix_i_c066_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_14 (mix_q_src_c066_1_14 0 bpf_c066_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_1_14 (mix_q_src_c066_1_14 mix_q_c066_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_1_15 (mix_i_src_c066_1_15 0 bpf_c066_1 0) vcvs gain=9.807852804032e-01
SMIXI_c066_1_15 (mix_i_src_c066_1_15 mix_i_c066_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_1_15 (mix_q_src_c066_1_15 0 bpf_c066_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_1_15 (mix_q_src_c066_1_15 mix_q_c066_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c066_1 (mix_i_c066_1 0) resistor r=1G
RMIXQ_c066_1 (mix_q_c066_1 0) resistor r=1G
RINTI_c066_1 (mix_i_c066_1 Icar_c066_1) resistor r=1k
CINTI_c066_1 (Icar_c066_1 0) capacitor c=80p
RINTQ_c066_1 (mix_q_c066_1 Qcar_c066_1) resistor r=1k
CINTQ_c066_1 (Qcar_c066_1 0) capacitor c=80p

// bl066, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c066_2 (bl066 n_cbpf_c066_2) capacitor c=4.503163717437e-14
LBPF_c066_2 (n_cbpf_c066_2 bpf_c066_2) inductor l=1.000000000000e-06
RBPF_c066_2 (bpf_c066_2 0) resistor r=2.356194490192e+02
EMIXI_c066_2_00 (mix_i_src_c066_2_00 0 bpf_c066_2 0) vcvs gain=9.807852804032e-01
SMIXI_c066_2_00 (mix_i_src_c066_2_00 mix_i_c066_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_00 (mix_q_src_c066_2_00 0 bpf_c066_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_2_00 (mix_q_src_c066_2_00 mix_q_c066_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_01 (mix_i_src_c066_2_01 0 bpf_c066_2 0) vcvs gain=8.314696123025e-01
SMIXI_c066_2_01 (mix_i_src_c066_2_01 mix_i_c066_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_01 (mix_q_src_c066_2_01 0 bpf_c066_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_2_01 (mix_q_src_c066_2_01 mix_q_c066_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_02 (mix_i_src_c066_2_02 0 bpf_c066_2 0) vcvs gain=5.555702330196e-01
SMIXI_c066_2_02 (mix_i_src_c066_2_02 mix_i_c066_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_02 (mix_q_src_c066_2_02 0 bpf_c066_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_2_02 (mix_q_src_c066_2_02 mix_q_c066_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_03 (mix_i_src_c066_2_03 0 bpf_c066_2 0) vcvs gain=1.950903220161e-01
SMIXI_c066_2_03 (mix_i_src_c066_2_03 mix_i_c066_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_03 (mix_q_src_c066_2_03 0 bpf_c066_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_2_03 (mix_q_src_c066_2_03 mix_q_c066_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_04 (mix_i_src_c066_2_04 0 bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_2_04 (mix_i_src_c066_2_04 mix_i_c066_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_04 (mix_q_src_c066_2_04 0 bpf_c066_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_2_04 (mix_q_src_c066_2_04 mix_q_c066_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_05 (mix_i_src_c066_2_05 0 bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_2_05 (mix_i_src_c066_2_05 mix_i_c066_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_05 (mix_q_src_c066_2_05 0 bpf_c066_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_2_05 (mix_q_src_c066_2_05 mix_q_c066_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_06 (mix_i_src_c066_2_06 0 bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_2_06 (mix_i_src_c066_2_06 mix_i_c066_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_06 (mix_q_src_c066_2_06 0 bpf_c066_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_2_06 (mix_q_src_c066_2_06 mix_q_c066_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_07 (mix_i_src_c066_2_07 0 bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_2_07 (mix_i_src_c066_2_07 mix_i_c066_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_07 (mix_q_src_c066_2_07 0 bpf_c066_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_2_07 (mix_q_src_c066_2_07 mix_q_c066_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_08 (mix_i_src_c066_2_08 0 bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_2_08 (mix_i_src_c066_2_08 mix_i_c066_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_08 (mix_q_src_c066_2_08 0 bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_2_08 (mix_q_src_c066_2_08 mix_q_c066_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_09 (mix_i_src_c066_2_09 0 bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_2_09 (mix_i_src_c066_2_09 mix_i_c066_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_09 (mix_q_src_c066_2_09 0 bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_2_09 (mix_q_src_c066_2_09 mix_q_c066_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_10 (mix_i_src_c066_2_10 0 bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_2_10 (mix_i_src_c066_2_10 mix_i_c066_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_10 (mix_q_src_c066_2_10 0 bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_2_10 (mix_q_src_c066_2_10 mix_q_c066_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_11 (mix_i_src_c066_2_11 0 bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_2_11 (mix_i_src_c066_2_11 mix_i_c066_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_11 (mix_q_src_c066_2_11 0 bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_2_11 (mix_q_src_c066_2_11 mix_q_c066_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_12 (mix_i_src_c066_2_12 0 bpf_c066_2 0) vcvs gain=1.950903220161e-01
SMIXI_c066_2_12 (mix_i_src_c066_2_12 mix_i_c066_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_12 (mix_q_src_c066_2_12 0 bpf_c066_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_2_12 (mix_q_src_c066_2_12 mix_q_c066_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_13 (mix_i_src_c066_2_13 0 bpf_c066_2 0) vcvs gain=5.555702330196e-01
SMIXI_c066_2_13 (mix_i_src_c066_2_13 mix_i_c066_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_13 (mix_q_src_c066_2_13 0 bpf_c066_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_2_13 (mix_q_src_c066_2_13 mix_q_c066_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_14 (mix_i_src_c066_2_14 0 bpf_c066_2 0) vcvs gain=8.314696123025e-01
SMIXI_c066_2_14 (mix_i_src_c066_2_14 mix_i_c066_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_14 (mix_q_src_c066_2_14 0 bpf_c066_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_2_14 (mix_q_src_c066_2_14 mix_q_c066_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_2_15 (mix_i_src_c066_2_15 0 bpf_c066_2 0) vcvs gain=9.807852804032e-01
SMIXI_c066_2_15 (mix_i_src_c066_2_15 mix_i_c066_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_2_15 (mix_q_src_c066_2_15 0 bpf_c066_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_2_15 (mix_q_src_c066_2_15 mix_q_c066_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c066_2 (mix_i_c066_2 0) resistor r=1G
RMIXQ_c066_2 (mix_q_c066_2 0) resistor r=1G
RINTI_c066_2 (mix_i_c066_2 Icar_c066_2) resistor r=1k
CINTI_c066_2 (Icar_c066_2 0) capacitor c=80p
RINTQ_c066_2 (mix_q_c066_2 Qcar_c066_2) resistor r=1k
CINTQ_c066_2 (Qcar_c066_2 0) capacitor c=80p

// bl066, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c066_3 (bl066 n_cbpf_c066_3) capacitor c=2.533029591058e-14
LBPF_c066_3 (n_cbpf_c066_3 bpf_c066_3) inductor l=1.000000000000e-06
RBPF_c066_3 (bpf_c066_3 0) resistor r=3.141592653590e+02
EMIXI_c066_3_00 (mix_i_src_c066_3_00 0 bpf_c066_3 0) vcvs gain=9.807852804032e-01
SMIXI_c066_3_00 (mix_i_src_c066_3_00 mix_i_c066_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_00 (mix_q_src_c066_3_00 0 bpf_c066_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_3_00 (mix_q_src_c066_3_00 mix_q_c066_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_01 (mix_i_src_c066_3_01 0 bpf_c066_3 0) vcvs gain=8.314696123025e-01
SMIXI_c066_3_01 (mix_i_src_c066_3_01 mix_i_c066_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_01 (mix_q_src_c066_3_01 0 bpf_c066_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_3_01 (mix_q_src_c066_3_01 mix_q_c066_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_02 (mix_i_src_c066_3_02 0 bpf_c066_3 0) vcvs gain=5.555702330196e-01
SMIXI_c066_3_02 (mix_i_src_c066_3_02 mix_i_c066_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_02 (mix_q_src_c066_3_02 0 bpf_c066_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_3_02 (mix_q_src_c066_3_02 mix_q_c066_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_03 (mix_i_src_c066_3_03 0 bpf_c066_3 0) vcvs gain=1.950903220161e-01
SMIXI_c066_3_03 (mix_i_src_c066_3_03 mix_i_c066_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_03 (mix_q_src_c066_3_03 0 bpf_c066_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_3_03 (mix_q_src_c066_3_03 mix_q_c066_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_04 (mix_i_src_c066_3_04 0 bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_3_04 (mix_i_src_c066_3_04 mix_i_c066_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_04 (mix_q_src_c066_3_04 0 bpf_c066_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c066_3_04 (mix_q_src_c066_3_04 mix_q_c066_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_05 (mix_i_src_c066_3_05 0 bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_3_05 (mix_i_src_c066_3_05 mix_i_c066_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_05 (mix_q_src_c066_3_05 0 bpf_c066_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c066_3_05 (mix_q_src_c066_3_05 mix_q_c066_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_06 (mix_i_src_c066_3_06 0 bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_3_06 (mix_i_src_c066_3_06 mix_i_c066_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_06 (mix_q_src_c066_3_06 0 bpf_c066_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c066_3_06 (mix_q_src_c066_3_06 mix_q_c066_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_07 (mix_i_src_c066_3_07 0 bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_3_07 (mix_i_src_c066_3_07 mix_i_c066_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_07 (mix_q_src_c066_3_07 0 bpf_c066_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c066_3_07 (mix_q_src_c066_3_07 mix_q_c066_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_08 (mix_i_src_c066_3_08 0 bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c066_3_08 (mix_i_src_c066_3_08 mix_i_c066_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_08 (mix_q_src_c066_3_08 0 bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_3_08 (mix_q_src_c066_3_08 mix_q_c066_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_09 (mix_i_src_c066_3_09 0 bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c066_3_09 (mix_i_src_c066_3_09 mix_i_c066_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_09 (mix_q_src_c066_3_09 0 bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_3_09 (mix_q_src_c066_3_09 mix_q_c066_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_10 (mix_i_src_c066_3_10 0 bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c066_3_10 (mix_i_src_c066_3_10 mix_i_c066_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_10 (mix_q_src_c066_3_10 0 bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_3_10 (mix_q_src_c066_3_10 mix_q_c066_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_11 (mix_i_src_c066_3_11 0 bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c066_3_11 (mix_i_src_c066_3_11 mix_i_c066_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_11 (mix_q_src_c066_3_11 0 bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_3_11 (mix_q_src_c066_3_11 mix_q_c066_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_12 (mix_i_src_c066_3_12 0 bpf_c066_3 0) vcvs gain=1.950903220161e-01
SMIXI_c066_3_12 (mix_i_src_c066_3_12 mix_i_c066_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_12 (mix_q_src_c066_3_12 0 bpf_c066_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c066_3_12 (mix_q_src_c066_3_12 mix_q_c066_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_13 (mix_i_src_c066_3_13 0 bpf_c066_3 0) vcvs gain=5.555702330196e-01
SMIXI_c066_3_13 (mix_i_src_c066_3_13 mix_i_c066_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_13 (mix_q_src_c066_3_13 0 bpf_c066_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c066_3_13 (mix_q_src_c066_3_13 mix_q_c066_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_14 (mix_i_src_c066_3_14 0 bpf_c066_3 0) vcvs gain=8.314696123025e-01
SMIXI_c066_3_14 (mix_i_src_c066_3_14 mix_i_c066_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_14 (mix_q_src_c066_3_14 0 bpf_c066_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c066_3_14 (mix_q_src_c066_3_14 mix_q_c066_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c066_3_15 (mix_i_src_c066_3_15 0 bpf_c066_3 0) vcvs gain=9.807852804032e-01
SMIXI_c066_3_15 (mix_i_src_c066_3_15 mix_i_c066_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c066_3_15 (mix_q_src_c066_3_15 0 bpf_c066_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c066_3_15 (mix_q_src_c066_3_15 mix_q_c066_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c066_3 (mix_i_c066_3 0) resistor r=1G
RMIXQ_c066_3 (mix_q_c066_3 0) resistor r=1G
RINTI_c066_3 (mix_i_c066_3 Icar_c066_3) resistor r=1k
CINTI_c066_3 (Icar_c066_3 0) capacitor c=80p
RINTQ_c066_3 (mix_q_c066_3 Qcar_c066_3) resistor r=1k
CINTQ_c066_3 (Qcar_c066_3 0) capacitor c=80p

// bl067, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c067_0 (bl067 n_cbpf_c067_0) capacitor c=4.052847345694e-13
LBPF_c067_0 (n_cbpf_c067_0 bpf_c067_0) inductor l=1.000000000000e-06
RBPF_c067_0 (bpf_c067_0 0) resistor r=7.853981633974e+01
EMIXI_c067_0_00 (mix_i_src_c067_0_00 0 bpf_c067_0 0) vcvs gain=9.807852804032e-01
SMIXI_c067_0_00 (mix_i_src_c067_0_00 mix_i_c067_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_00 (mix_q_src_c067_0_00 0 bpf_c067_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_0_00 (mix_q_src_c067_0_00 mix_q_c067_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_01 (mix_i_src_c067_0_01 0 bpf_c067_0 0) vcvs gain=8.314696123025e-01
SMIXI_c067_0_01 (mix_i_src_c067_0_01 mix_i_c067_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_01 (mix_q_src_c067_0_01 0 bpf_c067_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_0_01 (mix_q_src_c067_0_01 mix_q_c067_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_02 (mix_i_src_c067_0_02 0 bpf_c067_0 0) vcvs gain=5.555702330196e-01
SMIXI_c067_0_02 (mix_i_src_c067_0_02 mix_i_c067_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_02 (mix_q_src_c067_0_02 0 bpf_c067_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_0_02 (mix_q_src_c067_0_02 mix_q_c067_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_03 (mix_i_src_c067_0_03 0 bpf_c067_0 0) vcvs gain=1.950903220161e-01
SMIXI_c067_0_03 (mix_i_src_c067_0_03 mix_i_c067_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_03 (mix_q_src_c067_0_03 0 bpf_c067_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_0_03 (mix_q_src_c067_0_03 mix_q_c067_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_04 (mix_i_src_c067_0_04 0 bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_0_04 (mix_i_src_c067_0_04 mix_i_c067_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_04 (mix_q_src_c067_0_04 0 bpf_c067_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_0_04 (mix_q_src_c067_0_04 mix_q_c067_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_05 (mix_i_src_c067_0_05 0 bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_0_05 (mix_i_src_c067_0_05 mix_i_c067_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_05 (mix_q_src_c067_0_05 0 bpf_c067_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_0_05 (mix_q_src_c067_0_05 mix_q_c067_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_06 (mix_i_src_c067_0_06 0 bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_0_06 (mix_i_src_c067_0_06 mix_i_c067_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_06 (mix_q_src_c067_0_06 0 bpf_c067_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_0_06 (mix_q_src_c067_0_06 mix_q_c067_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_07 (mix_i_src_c067_0_07 0 bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_0_07 (mix_i_src_c067_0_07 mix_i_c067_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_07 (mix_q_src_c067_0_07 0 bpf_c067_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_0_07 (mix_q_src_c067_0_07 mix_q_c067_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_08 (mix_i_src_c067_0_08 0 bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_0_08 (mix_i_src_c067_0_08 mix_i_c067_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_08 (mix_q_src_c067_0_08 0 bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_0_08 (mix_q_src_c067_0_08 mix_q_c067_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_09 (mix_i_src_c067_0_09 0 bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_0_09 (mix_i_src_c067_0_09 mix_i_c067_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_09 (mix_q_src_c067_0_09 0 bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_0_09 (mix_q_src_c067_0_09 mix_q_c067_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_10 (mix_i_src_c067_0_10 0 bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_0_10 (mix_i_src_c067_0_10 mix_i_c067_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_10 (mix_q_src_c067_0_10 0 bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_0_10 (mix_q_src_c067_0_10 mix_q_c067_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_11 (mix_i_src_c067_0_11 0 bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_0_11 (mix_i_src_c067_0_11 mix_i_c067_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_11 (mix_q_src_c067_0_11 0 bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_0_11 (mix_q_src_c067_0_11 mix_q_c067_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_12 (mix_i_src_c067_0_12 0 bpf_c067_0 0) vcvs gain=1.950903220161e-01
SMIXI_c067_0_12 (mix_i_src_c067_0_12 mix_i_c067_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_12 (mix_q_src_c067_0_12 0 bpf_c067_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_0_12 (mix_q_src_c067_0_12 mix_q_c067_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_13 (mix_i_src_c067_0_13 0 bpf_c067_0 0) vcvs gain=5.555702330196e-01
SMIXI_c067_0_13 (mix_i_src_c067_0_13 mix_i_c067_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_13 (mix_q_src_c067_0_13 0 bpf_c067_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_0_13 (mix_q_src_c067_0_13 mix_q_c067_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_14 (mix_i_src_c067_0_14 0 bpf_c067_0 0) vcvs gain=8.314696123025e-01
SMIXI_c067_0_14 (mix_i_src_c067_0_14 mix_i_c067_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_14 (mix_q_src_c067_0_14 0 bpf_c067_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_0_14 (mix_q_src_c067_0_14 mix_q_c067_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_0_15 (mix_i_src_c067_0_15 0 bpf_c067_0 0) vcvs gain=9.807852804032e-01
SMIXI_c067_0_15 (mix_i_src_c067_0_15 mix_i_c067_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_0_15 (mix_q_src_c067_0_15 0 bpf_c067_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_0_15 (mix_q_src_c067_0_15 mix_q_c067_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c067_0 (mix_i_c067_0 0) resistor r=1G
RMIXQ_c067_0 (mix_q_c067_0 0) resistor r=1G
RINTI_c067_0 (mix_i_c067_0 Icar_c067_0) resistor r=1k
CINTI_c067_0 (Icar_c067_0 0) capacitor c=80p
RINTQ_c067_0 (mix_q_c067_0 Qcar_c067_0) resistor r=1k
CINTQ_c067_0 (Qcar_c067_0 0) capacitor c=80p

// bl067, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c067_1 (bl067 n_cbpf_c067_1) capacitor c=1.013211836423e-13
LBPF_c067_1 (n_cbpf_c067_1 bpf_c067_1) inductor l=1.000000000000e-06
RBPF_c067_1 (bpf_c067_1 0) resistor r=1.570796326795e+02
EMIXI_c067_1_00 (mix_i_src_c067_1_00 0 bpf_c067_1 0) vcvs gain=9.807852804032e-01
SMIXI_c067_1_00 (mix_i_src_c067_1_00 mix_i_c067_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_00 (mix_q_src_c067_1_00 0 bpf_c067_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_1_00 (mix_q_src_c067_1_00 mix_q_c067_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_01 (mix_i_src_c067_1_01 0 bpf_c067_1 0) vcvs gain=8.314696123025e-01
SMIXI_c067_1_01 (mix_i_src_c067_1_01 mix_i_c067_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_01 (mix_q_src_c067_1_01 0 bpf_c067_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_1_01 (mix_q_src_c067_1_01 mix_q_c067_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_02 (mix_i_src_c067_1_02 0 bpf_c067_1 0) vcvs gain=5.555702330196e-01
SMIXI_c067_1_02 (mix_i_src_c067_1_02 mix_i_c067_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_02 (mix_q_src_c067_1_02 0 bpf_c067_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_1_02 (mix_q_src_c067_1_02 mix_q_c067_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_03 (mix_i_src_c067_1_03 0 bpf_c067_1 0) vcvs gain=1.950903220161e-01
SMIXI_c067_1_03 (mix_i_src_c067_1_03 mix_i_c067_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_03 (mix_q_src_c067_1_03 0 bpf_c067_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_1_03 (mix_q_src_c067_1_03 mix_q_c067_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_04 (mix_i_src_c067_1_04 0 bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_1_04 (mix_i_src_c067_1_04 mix_i_c067_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_04 (mix_q_src_c067_1_04 0 bpf_c067_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_1_04 (mix_q_src_c067_1_04 mix_q_c067_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_05 (mix_i_src_c067_1_05 0 bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_1_05 (mix_i_src_c067_1_05 mix_i_c067_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_05 (mix_q_src_c067_1_05 0 bpf_c067_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_1_05 (mix_q_src_c067_1_05 mix_q_c067_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_06 (mix_i_src_c067_1_06 0 bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_1_06 (mix_i_src_c067_1_06 mix_i_c067_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_06 (mix_q_src_c067_1_06 0 bpf_c067_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_1_06 (mix_q_src_c067_1_06 mix_q_c067_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_07 (mix_i_src_c067_1_07 0 bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_1_07 (mix_i_src_c067_1_07 mix_i_c067_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_07 (mix_q_src_c067_1_07 0 bpf_c067_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_1_07 (mix_q_src_c067_1_07 mix_q_c067_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_08 (mix_i_src_c067_1_08 0 bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_1_08 (mix_i_src_c067_1_08 mix_i_c067_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_08 (mix_q_src_c067_1_08 0 bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_1_08 (mix_q_src_c067_1_08 mix_q_c067_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_09 (mix_i_src_c067_1_09 0 bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_1_09 (mix_i_src_c067_1_09 mix_i_c067_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_09 (mix_q_src_c067_1_09 0 bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_1_09 (mix_q_src_c067_1_09 mix_q_c067_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_10 (mix_i_src_c067_1_10 0 bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_1_10 (mix_i_src_c067_1_10 mix_i_c067_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_10 (mix_q_src_c067_1_10 0 bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_1_10 (mix_q_src_c067_1_10 mix_q_c067_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_11 (mix_i_src_c067_1_11 0 bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_1_11 (mix_i_src_c067_1_11 mix_i_c067_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_11 (mix_q_src_c067_1_11 0 bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_1_11 (mix_q_src_c067_1_11 mix_q_c067_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_12 (mix_i_src_c067_1_12 0 bpf_c067_1 0) vcvs gain=1.950903220161e-01
SMIXI_c067_1_12 (mix_i_src_c067_1_12 mix_i_c067_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_12 (mix_q_src_c067_1_12 0 bpf_c067_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_1_12 (mix_q_src_c067_1_12 mix_q_c067_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_13 (mix_i_src_c067_1_13 0 bpf_c067_1 0) vcvs gain=5.555702330196e-01
SMIXI_c067_1_13 (mix_i_src_c067_1_13 mix_i_c067_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_13 (mix_q_src_c067_1_13 0 bpf_c067_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_1_13 (mix_q_src_c067_1_13 mix_q_c067_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_14 (mix_i_src_c067_1_14 0 bpf_c067_1 0) vcvs gain=8.314696123025e-01
SMIXI_c067_1_14 (mix_i_src_c067_1_14 mix_i_c067_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_14 (mix_q_src_c067_1_14 0 bpf_c067_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_1_14 (mix_q_src_c067_1_14 mix_q_c067_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_1_15 (mix_i_src_c067_1_15 0 bpf_c067_1 0) vcvs gain=9.807852804032e-01
SMIXI_c067_1_15 (mix_i_src_c067_1_15 mix_i_c067_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_1_15 (mix_q_src_c067_1_15 0 bpf_c067_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_1_15 (mix_q_src_c067_1_15 mix_q_c067_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c067_1 (mix_i_c067_1 0) resistor r=1G
RMIXQ_c067_1 (mix_q_c067_1 0) resistor r=1G
RINTI_c067_1 (mix_i_c067_1 Icar_c067_1) resistor r=1k
CINTI_c067_1 (Icar_c067_1 0) capacitor c=80p
RINTQ_c067_1 (mix_q_c067_1 Qcar_c067_1) resistor r=1k
CINTQ_c067_1 (Qcar_c067_1 0) capacitor c=80p

// bl067, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c067_2 (bl067 n_cbpf_c067_2) capacitor c=4.503163717437e-14
LBPF_c067_2 (n_cbpf_c067_2 bpf_c067_2) inductor l=1.000000000000e-06
RBPF_c067_2 (bpf_c067_2 0) resistor r=2.356194490192e+02
EMIXI_c067_2_00 (mix_i_src_c067_2_00 0 bpf_c067_2 0) vcvs gain=9.807852804032e-01
SMIXI_c067_2_00 (mix_i_src_c067_2_00 mix_i_c067_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_00 (mix_q_src_c067_2_00 0 bpf_c067_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_2_00 (mix_q_src_c067_2_00 mix_q_c067_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_01 (mix_i_src_c067_2_01 0 bpf_c067_2 0) vcvs gain=8.314696123025e-01
SMIXI_c067_2_01 (mix_i_src_c067_2_01 mix_i_c067_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_01 (mix_q_src_c067_2_01 0 bpf_c067_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_2_01 (mix_q_src_c067_2_01 mix_q_c067_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_02 (mix_i_src_c067_2_02 0 bpf_c067_2 0) vcvs gain=5.555702330196e-01
SMIXI_c067_2_02 (mix_i_src_c067_2_02 mix_i_c067_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_02 (mix_q_src_c067_2_02 0 bpf_c067_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_2_02 (mix_q_src_c067_2_02 mix_q_c067_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_03 (mix_i_src_c067_2_03 0 bpf_c067_2 0) vcvs gain=1.950903220161e-01
SMIXI_c067_2_03 (mix_i_src_c067_2_03 mix_i_c067_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_03 (mix_q_src_c067_2_03 0 bpf_c067_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_2_03 (mix_q_src_c067_2_03 mix_q_c067_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_04 (mix_i_src_c067_2_04 0 bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_2_04 (mix_i_src_c067_2_04 mix_i_c067_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_04 (mix_q_src_c067_2_04 0 bpf_c067_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_2_04 (mix_q_src_c067_2_04 mix_q_c067_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_05 (mix_i_src_c067_2_05 0 bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_2_05 (mix_i_src_c067_2_05 mix_i_c067_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_05 (mix_q_src_c067_2_05 0 bpf_c067_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_2_05 (mix_q_src_c067_2_05 mix_q_c067_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_06 (mix_i_src_c067_2_06 0 bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_2_06 (mix_i_src_c067_2_06 mix_i_c067_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_06 (mix_q_src_c067_2_06 0 bpf_c067_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_2_06 (mix_q_src_c067_2_06 mix_q_c067_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_07 (mix_i_src_c067_2_07 0 bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_2_07 (mix_i_src_c067_2_07 mix_i_c067_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_07 (mix_q_src_c067_2_07 0 bpf_c067_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_2_07 (mix_q_src_c067_2_07 mix_q_c067_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_08 (mix_i_src_c067_2_08 0 bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_2_08 (mix_i_src_c067_2_08 mix_i_c067_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_08 (mix_q_src_c067_2_08 0 bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_2_08 (mix_q_src_c067_2_08 mix_q_c067_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_09 (mix_i_src_c067_2_09 0 bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_2_09 (mix_i_src_c067_2_09 mix_i_c067_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_09 (mix_q_src_c067_2_09 0 bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_2_09 (mix_q_src_c067_2_09 mix_q_c067_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_10 (mix_i_src_c067_2_10 0 bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_2_10 (mix_i_src_c067_2_10 mix_i_c067_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_10 (mix_q_src_c067_2_10 0 bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_2_10 (mix_q_src_c067_2_10 mix_q_c067_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_11 (mix_i_src_c067_2_11 0 bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_2_11 (mix_i_src_c067_2_11 mix_i_c067_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_11 (mix_q_src_c067_2_11 0 bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_2_11 (mix_q_src_c067_2_11 mix_q_c067_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_12 (mix_i_src_c067_2_12 0 bpf_c067_2 0) vcvs gain=1.950903220161e-01
SMIXI_c067_2_12 (mix_i_src_c067_2_12 mix_i_c067_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_12 (mix_q_src_c067_2_12 0 bpf_c067_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_2_12 (mix_q_src_c067_2_12 mix_q_c067_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_13 (mix_i_src_c067_2_13 0 bpf_c067_2 0) vcvs gain=5.555702330196e-01
SMIXI_c067_2_13 (mix_i_src_c067_2_13 mix_i_c067_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_13 (mix_q_src_c067_2_13 0 bpf_c067_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_2_13 (mix_q_src_c067_2_13 mix_q_c067_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_14 (mix_i_src_c067_2_14 0 bpf_c067_2 0) vcvs gain=8.314696123025e-01
SMIXI_c067_2_14 (mix_i_src_c067_2_14 mix_i_c067_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_14 (mix_q_src_c067_2_14 0 bpf_c067_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_2_14 (mix_q_src_c067_2_14 mix_q_c067_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_2_15 (mix_i_src_c067_2_15 0 bpf_c067_2 0) vcvs gain=9.807852804032e-01
SMIXI_c067_2_15 (mix_i_src_c067_2_15 mix_i_c067_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_2_15 (mix_q_src_c067_2_15 0 bpf_c067_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_2_15 (mix_q_src_c067_2_15 mix_q_c067_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c067_2 (mix_i_c067_2 0) resistor r=1G
RMIXQ_c067_2 (mix_q_c067_2 0) resistor r=1G
RINTI_c067_2 (mix_i_c067_2 Icar_c067_2) resistor r=1k
CINTI_c067_2 (Icar_c067_2 0) capacitor c=80p
RINTQ_c067_2 (mix_q_c067_2 Qcar_c067_2) resistor r=1k
CINTQ_c067_2 (Qcar_c067_2 0) capacitor c=80p

// bl067, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c067_3 (bl067 n_cbpf_c067_3) capacitor c=2.533029591058e-14
LBPF_c067_3 (n_cbpf_c067_3 bpf_c067_3) inductor l=1.000000000000e-06
RBPF_c067_3 (bpf_c067_3 0) resistor r=3.141592653590e+02
EMIXI_c067_3_00 (mix_i_src_c067_3_00 0 bpf_c067_3 0) vcvs gain=9.807852804032e-01
SMIXI_c067_3_00 (mix_i_src_c067_3_00 mix_i_c067_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_00 (mix_q_src_c067_3_00 0 bpf_c067_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_3_00 (mix_q_src_c067_3_00 mix_q_c067_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_01 (mix_i_src_c067_3_01 0 bpf_c067_3 0) vcvs gain=8.314696123025e-01
SMIXI_c067_3_01 (mix_i_src_c067_3_01 mix_i_c067_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_01 (mix_q_src_c067_3_01 0 bpf_c067_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_3_01 (mix_q_src_c067_3_01 mix_q_c067_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_02 (mix_i_src_c067_3_02 0 bpf_c067_3 0) vcvs gain=5.555702330196e-01
SMIXI_c067_3_02 (mix_i_src_c067_3_02 mix_i_c067_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_02 (mix_q_src_c067_3_02 0 bpf_c067_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_3_02 (mix_q_src_c067_3_02 mix_q_c067_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_03 (mix_i_src_c067_3_03 0 bpf_c067_3 0) vcvs gain=1.950903220161e-01
SMIXI_c067_3_03 (mix_i_src_c067_3_03 mix_i_c067_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_03 (mix_q_src_c067_3_03 0 bpf_c067_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_3_03 (mix_q_src_c067_3_03 mix_q_c067_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_04 (mix_i_src_c067_3_04 0 bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_3_04 (mix_i_src_c067_3_04 mix_i_c067_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_04 (mix_q_src_c067_3_04 0 bpf_c067_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c067_3_04 (mix_q_src_c067_3_04 mix_q_c067_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_05 (mix_i_src_c067_3_05 0 bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_3_05 (mix_i_src_c067_3_05 mix_i_c067_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_05 (mix_q_src_c067_3_05 0 bpf_c067_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c067_3_05 (mix_q_src_c067_3_05 mix_q_c067_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_06 (mix_i_src_c067_3_06 0 bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_3_06 (mix_i_src_c067_3_06 mix_i_c067_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_06 (mix_q_src_c067_3_06 0 bpf_c067_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c067_3_06 (mix_q_src_c067_3_06 mix_q_c067_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_07 (mix_i_src_c067_3_07 0 bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_3_07 (mix_i_src_c067_3_07 mix_i_c067_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_07 (mix_q_src_c067_3_07 0 bpf_c067_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c067_3_07 (mix_q_src_c067_3_07 mix_q_c067_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_08 (mix_i_src_c067_3_08 0 bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c067_3_08 (mix_i_src_c067_3_08 mix_i_c067_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_08 (mix_q_src_c067_3_08 0 bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_3_08 (mix_q_src_c067_3_08 mix_q_c067_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_09 (mix_i_src_c067_3_09 0 bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c067_3_09 (mix_i_src_c067_3_09 mix_i_c067_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_09 (mix_q_src_c067_3_09 0 bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_3_09 (mix_q_src_c067_3_09 mix_q_c067_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_10 (mix_i_src_c067_3_10 0 bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c067_3_10 (mix_i_src_c067_3_10 mix_i_c067_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_10 (mix_q_src_c067_3_10 0 bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_3_10 (mix_q_src_c067_3_10 mix_q_c067_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_11 (mix_i_src_c067_3_11 0 bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c067_3_11 (mix_i_src_c067_3_11 mix_i_c067_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_11 (mix_q_src_c067_3_11 0 bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_3_11 (mix_q_src_c067_3_11 mix_q_c067_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_12 (mix_i_src_c067_3_12 0 bpf_c067_3 0) vcvs gain=1.950903220161e-01
SMIXI_c067_3_12 (mix_i_src_c067_3_12 mix_i_c067_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_12 (mix_q_src_c067_3_12 0 bpf_c067_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c067_3_12 (mix_q_src_c067_3_12 mix_q_c067_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_13 (mix_i_src_c067_3_13 0 bpf_c067_3 0) vcvs gain=5.555702330196e-01
SMIXI_c067_3_13 (mix_i_src_c067_3_13 mix_i_c067_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_13 (mix_q_src_c067_3_13 0 bpf_c067_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c067_3_13 (mix_q_src_c067_3_13 mix_q_c067_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_14 (mix_i_src_c067_3_14 0 bpf_c067_3 0) vcvs gain=8.314696123025e-01
SMIXI_c067_3_14 (mix_i_src_c067_3_14 mix_i_c067_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_14 (mix_q_src_c067_3_14 0 bpf_c067_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c067_3_14 (mix_q_src_c067_3_14 mix_q_c067_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c067_3_15 (mix_i_src_c067_3_15 0 bpf_c067_3 0) vcvs gain=9.807852804032e-01
SMIXI_c067_3_15 (mix_i_src_c067_3_15 mix_i_c067_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c067_3_15 (mix_q_src_c067_3_15 0 bpf_c067_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c067_3_15 (mix_q_src_c067_3_15 mix_q_c067_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c067_3 (mix_i_c067_3 0) resistor r=1G
RMIXQ_c067_3 (mix_q_c067_3 0) resistor r=1G
RINTI_c067_3 (mix_i_c067_3 Icar_c067_3) resistor r=1k
CINTI_c067_3 (Icar_c067_3 0) capacitor c=80p
RINTQ_c067_3 (mix_q_c067_3 Qcar_c067_3) resistor r=1k
CINTQ_c067_3 (Qcar_c067_3 0) capacitor c=80p

// bl068, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c068_0 (bl068 n_cbpf_c068_0) capacitor c=4.052847345694e-13
LBPF_c068_0 (n_cbpf_c068_0 bpf_c068_0) inductor l=1.000000000000e-06
RBPF_c068_0 (bpf_c068_0 0) resistor r=7.853981633974e+01
EMIXI_c068_0_00 (mix_i_src_c068_0_00 0 bpf_c068_0 0) vcvs gain=9.807852804032e-01
SMIXI_c068_0_00 (mix_i_src_c068_0_00 mix_i_c068_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_00 (mix_q_src_c068_0_00 0 bpf_c068_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_0_00 (mix_q_src_c068_0_00 mix_q_c068_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_01 (mix_i_src_c068_0_01 0 bpf_c068_0 0) vcvs gain=8.314696123025e-01
SMIXI_c068_0_01 (mix_i_src_c068_0_01 mix_i_c068_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_01 (mix_q_src_c068_0_01 0 bpf_c068_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_0_01 (mix_q_src_c068_0_01 mix_q_c068_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_02 (mix_i_src_c068_0_02 0 bpf_c068_0 0) vcvs gain=5.555702330196e-01
SMIXI_c068_0_02 (mix_i_src_c068_0_02 mix_i_c068_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_02 (mix_q_src_c068_0_02 0 bpf_c068_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_0_02 (mix_q_src_c068_0_02 mix_q_c068_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_03 (mix_i_src_c068_0_03 0 bpf_c068_0 0) vcvs gain=1.950903220161e-01
SMIXI_c068_0_03 (mix_i_src_c068_0_03 mix_i_c068_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_03 (mix_q_src_c068_0_03 0 bpf_c068_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_0_03 (mix_q_src_c068_0_03 mix_q_c068_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_04 (mix_i_src_c068_0_04 0 bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_0_04 (mix_i_src_c068_0_04 mix_i_c068_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_04 (mix_q_src_c068_0_04 0 bpf_c068_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_0_04 (mix_q_src_c068_0_04 mix_q_c068_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_05 (mix_i_src_c068_0_05 0 bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_0_05 (mix_i_src_c068_0_05 mix_i_c068_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_05 (mix_q_src_c068_0_05 0 bpf_c068_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_0_05 (mix_q_src_c068_0_05 mix_q_c068_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_06 (mix_i_src_c068_0_06 0 bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_0_06 (mix_i_src_c068_0_06 mix_i_c068_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_06 (mix_q_src_c068_0_06 0 bpf_c068_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_0_06 (mix_q_src_c068_0_06 mix_q_c068_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_07 (mix_i_src_c068_0_07 0 bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_0_07 (mix_i_src_c068_0_07 mix_i_c068_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_07 (mix_q_src_c068_0_07 0 bpf_c068_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_0_07 (mix_q_src_c068_0_07 mix_q_c068_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_08 (mix_i_src_c068_0_08 0 bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_0_08 (mix_i_src_c068_0_08 mix_i_c068_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_08 (mix_q_src_c068_0_08 0 bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_0_08 (mix_q_src_c068_0_08 mix_q_c068_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_09 (mix_i_src_c068_0_09 0 bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_0_09 (mix_i_src_c068_0_09 mix_i_c068_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_09 (mix_q_src_c068_0_09 0 bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_0_09 (mix_q_src_c068_0_09 mix_q_c068_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_10 (mix_i_src_c068_0_10 0 bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_0_10 (mix_i_src_c068_0_10 mix_i_c068_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_10 (mix_q_src_c068_0_10 0 bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_0_10 (mix_q_src_c068_0_10 mix_q_c068_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_11 (mix_i_src_c068_0_11 0 bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_0_11 (mix_i_src_c068_0_11 mix_i_c068_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_11 (mix_q_src_c068_0_11 0 bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_0_11 (mix_q_src_c068_0_11 mix_q_c068_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_12 (mix_i_src_c068_0_12 0 bpf_c068_0 0) vcvs gain=1.950903220161e-01
SMIXI_c068_0_12 (mix_i_src_c068_0_12 mix_i_c068_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_12 (mix_q_src_c068_0_12 0 bpf_c068_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_0_12 (mix_q_src_c068_0_12 mix_q_c068_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_13 (mix_i_src_c068_0_13 0 bpf_c068_0 0) vcvs gain=5.555702330196e-01
SMIXI_c068_0_13 (mix_i_src_c068_0_13 mix_i_c068_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_13 (mix_q_src_c068_0_13 0 bpf_c068_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_0_13 (mix_q_src_c068_0_13 mix_q_c068_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_14 (mix_i_src_c068_0_14 0 bpf_c068_0 0) vcvs gain=8.314696123025e-01
SMIXI_c068_0_14 (mix_i_src_c068_0_14 mix_i_c068_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_14 (mix_q_src_c068_0_14 0 bpf_c068_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_0_14 (mix_q_src_c068_0_14 mix_q_c068_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_0_15 (mix_i_src_c068_0_15 0 bpf_c068_0 0) vcvs gain=9.807852804032e-01
SMIXI_c068_0_15 (mix_i_src_c068_0_15 mix_i_c068_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_0_15 (mix_q_src_c068_0_15 0 bpf_c068_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_0_15 (mix_q_src_c068_0_15 mix_q_c068_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c068_0 (mix_i_c068_0 0) resistor r=1G
RMIXQ_c068_0 (mix_q_c068_0 0) resistor r=1G
RINTI_c068_0 (mix_i_c068_0 Icar_c068_0) resistor r=1k
CINTI_c068_0 (Icar_c068_0 0) capacitor c=80p
RINTQ_c068_0 (mix_q_c068_0 Qcar_c068_0) resistor r=1k
CINTQ_c068_0 (Qcar_c068_0 0) capacitor c=80p

// bl068, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c068_1 (bl068 n_cbpf_c068_1) capacitor c=1.013211836423e-13
LBPF_c068_1 (n_cbpf_c068_1 bpf_c068_1) inductor l=1.000000000000e-06
RBPF_c068_1 (bpf_c068_1 0) resistor r=1.570796326795e+02
EMIXI_c068_1_00 (mix_i_src_c068_1_00 0 bpf_c068_1 0) vcvs gain=9.807852804032e-01
SMIXI_c068_1_00 (mix_i_src_c068_1_00 mix_i_c068_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_00 (mix_q_src_c068_1_00 0 bpf_c068_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_1_00 (mix_q_src_c068_1_00 mix_q_c068_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_01 (mix_i_src_c068_1_01 0 bpf_c068_1 0) vcvs gain=8.314696123025e-01
SMIXI_c068_1_01 (mix_i_src_c068_1_01 mix_i_c068_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_01 (mix_q_src_c068_1_01 0 bpf_c068_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_1_01 (mix_q_src_c068_1_01 mix_q_c068_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_02 (mix_i_src_c068_1_02 0 bpf_c068_1 0) vcvs gain=5.555702330196e-01
SMIXI_c068_1_02 (mix_i_src_c068_1_02 mix_i_c068_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_02 (mix_q_src_c068_1_02 0 bpf_c068_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_1_02 (mix_q_src_c068_1_02 mix_q_c068_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_03 (mix_i_src_c068_1_03 0 bpf_c068_1 0) vcvs gain=1.950903220161e-01
SMIXI_c068_1_03 (mix_i_src_c068_1_03 mix_i_c068_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_03 (mix_q_src_c068_1_03 0 bpf_c068_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_1_03 (mix_q_src_c068_1_03 mix_q_c068_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_04 (mix_i_src_c068_1_04 0 bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_1_04 (mix_i_src_c068_1_04 mix_i_c068_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_04 (mix_q_src_c068_1_04 0 bpf_c068_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_1_04 (mix_q_src_c068_1_04 mix_q_c068_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_05 (mix_i_src_c068_1_05 0 bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_1_05 (mix_i_src_c068_1_05 mix_i_c068_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_05 (mix_q_src_c068_1_05 0 bpf_c068_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_1_05 (mix_q_src_c068_1_05 mix_q_c068_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_06 (mix_i_src_c068_1_06 0 bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_1_06 (mix_i_src_c068_1_06 mix_i_c068_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_06 (mix_q_src_c068_1_06 0 bpf_c068_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_1_06 (mix_q_src_c068_1_06 mix_q_c068_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_07 (mix_i_src_c068_1_07 0 bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_1_07 (mix_i_src_c068_1_07 mix_i_c068_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_07 (mix_q_src_c068_1_07 0 bpf_c068_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_1_07 (mix_q_src_c068_1_07 mix_q_c068_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_08 (mix_i_src_c068_1_08 0 bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_1_08 (mix_i_src_c068_1_08 mix_i_c068_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_08 (mix_q_src_c068_1_08 0 bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_1_08 (mix_q_src_c068_1_08 mix_q_c068_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_09 (mix_i_src_c068_1_09 0 bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_1_09 (mix_i_src_c068_1_09 mix_i_c068_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_09 (mix_q_src_c068_1_09 0 bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_1_09 (mix_q_src_c068_1_09 mix_q_c068_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_10 (mix_i_src_c068_1_10 0 bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_1_10 (mix_i_src_c068_1_10 mix_i_c068_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_10 (mix_q_src_c068_1_10 0 bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_1_10 (mix_q_src_c068_1_10 mix_q_c068_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_11 (mix_i_src_c068_1_11 0 bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_1_11 (mix_i_src_c068_1_11 mix_i_c068_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_11 (mix_q_src_c068_1_11 0 bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_1_11 (mix_q_src_c068_1_11 mix_q_c068_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_12 (mix_i_src_c068_1_12 0 bpf_c068_1 0) vcvs gain=1.950903220161e-01
SMIXI_c068_1_12 (mix_i_src_c068_1_12 mix_i_c068_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_12 (mix_q_src_c068_1_12 0 bpf_c068_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_1_12 (mix_q_src_c068_1_12 mix_q_c068_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_13 (mix_i_src_c068_1_13 0 bpf_c068_1 0) vcvs gain=5.555702330196e-01
SMIXI_c068_1_13 (mix_i_src_c068_1_13 mix_i_c068_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_13 (mix_q_src_c068_1_13 0 bpf_c068_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_1_13 (mix_q_src_c068_1_13 mix_q_c068_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_14 (mix_i_src_c068_1_14 0 bpf_c068_1 0) vcvs gain=8.314696123025e-01
SMIXI_c068_1_14 (mix_i_src_c068_1_14 mix_i_c068_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_14 (mix_q_src_c068_1_14 0 bpf_c068_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_1_14 (mix_q_src_c068_1_14 mix_q_c068_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_1_15 (mix_i_src_c068_1_15 0 bpf_c068_1 0) vcvs gain=9.807852804032e-01
SMIXI_c068_1_15 (mix_i_src_c068_1_15 mix_i_c068_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_1_15 (mix_q_src_c068_1_15 0 bpf_c068_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_1_15 (mix_q_src_c068_1_15 mix_q_c068_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c068_1 (mix_i_c068_1 0) resistor r=1G
RMIXQ_c068_1 (mix_q_c068_1 0) resistor r=1G
RINTI_c068_1 (mix_i_c068_1 Icar_c068_1) resistor r=1k
CINTI_c068_1 (Icar_c068_1 0) capacitor c=80p
RINTQ_c068_1 (mix_q_c068_1 Qcar_c068_1) resistor r=1k
CINTQ_c068_1 (Qcar_c068_1 0) capacitor c=80p

// bl068, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c068_2 (bl068 n_cbpf_c068_2) capacitor c=4.503163717437e-14
LBPF_c068_2 (n_cbpf_c068_2 bpf_c068_2) inductor l=1.000000000000e-06
RBPF_c068_2 (bpf_c068_2 0) resistor r=2.356194490192e+02
EMIXI_c068_2_00 (mix_i_src_c068_2_00 0 bpf_c068_2 0) vcvs gain=9.807852804032e-01
SMIXI_c068_2_00 (mix_i_src_c068_2_00 mix_i_c068_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_00 (mix_q_src_c068_2_00 0 bpf_c068_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_2_00 (mix_q_src_c068_2_00 mix_q_c068_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_01 (mix_i_src_c068_2_01 0 bpf_c068_2 0) vcvs gain=8.314696123025e-01
SMIXI_c068_2_01 (mix_i_src_c068_2_01 mix_i_c068_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_01 (mix_q_src_c068_2_01 0 bpf_c068_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_2_01 (mix_q_src_c068_2_01 mix_q_c068_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_02 (mix_i_src_c068_2_02 0 bpf_c068_2 0) vcvs gain=5.555702330196e-01
SMIXI_c068_2_02 (mix_i_src_c068_2_02 mix_i_c068_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_02 (mix_q_src_c068_2_02 0 bpf_c068_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_2_02 (mix_q_src_c068_2_02 mix_q_c068_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_03 (mix_i_src_c068_2_03 0 bpf_c068_2 0) vcvs gain=1.950903220161e-01
SMIXI_c068_2_03 (mix_i_src_c068_2_03 mix_i_c068_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_03 (mix_q_src_c068_2_03 0 bpf_c068_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_2_03 (mix_q_src_c068_2_03 mix_q_c068_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_04 (mix_i_src_c068_2_04 0 bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_2_04 (mix_i_src_c068_2_04 mix_i_c068_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_04 (mix_q_src_c068_2_04 0 bpf_c068_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_2_04 (mix_q_src_c068_2_04 mix_q_c068_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_05 (mix_i_src_c068_2_05 0 bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_2_05 (mix_i_src_c068_2_05 mix_i_c068_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_05 (mix_q_src_c068_2_05 0 bpf_c068_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_2_05 (mix_q_src_c068_2_05 mix_q_c068_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_06 (mix_i_src_c068_2_06 0 bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_2_06 (mix_i_src_c068_2_06 mix_i_c068_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_06 (mix_q_src_c068_2_06 0 bpf_c068_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_2_06 (mix_q_src_c068_2_06 mix_q_c068_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_07 (mix_i_src_c068_2_07 0 bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_2_07 (mix_i_src_c068_2_07 mix_i_c068_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_07 (mix_q_src_c068_2_07 0 bpf_c068_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_2_07 (mix_q_src_c068_2_07 mix_q_c068_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_08 (mix_i_src_c068_2_08 0 bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_2_08 (mix_i_src_c068_2_08 mix_i_c068_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_08 (mix_q_src_c068_2_08 0 bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_2_08 (mix_q_src_c068_2_08 mix_q_c068_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_09 (mix_i_src_c068_2_09 0 bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_2_09 (mix_i_src_c068_2_09 mix_i_c068_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_09 (mix_q_src_c068_2_09 0 bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_2_09 (mix_q_src_c068_2_09 mix_q_c068_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_10 (mix_i_src_c068_2_10 0 bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_2_10 (mix_i_src_c068_2_10 mix_i_c068_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_10 (mix_q_src_c068_2_10 0 bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_2_10 (mix_q_src_c068_2_10 mix_q_c068_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_11 (mix_i_src_c068_2_11 0 bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_2_11 (mix_i_src_c068_2_11 mix_i_c068_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_11 (mix_q_src_c068_2_11 0 bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_2_11 (mix_q_src_c068_2_11 mix_q_c068_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_12 (mix_i_src_c068_2_12 0 bpf_c068_2 0) vcvs gain=1.950903220161e-01
SMIXI_c068_2_12 (mix_i_src_c068_2_12 mix_i_c068_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_12 (mix_q_src_c068_2_12 0 bpf_c068_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_2_12 (mix_q_src_c068_2_12 mix_q_c068_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_13 (mix_i_src_c068_2_13 0 bpf_c068_2 0) vcvs gain=5.555702330196e-01
SMIXI_c068_2_13 (mix_i_src_c068_2_13 mix_i_c068_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_13 (mix_q_src_c068_2_13 0 bpf_c068_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_2_13 (mix_q_src_c068_2_13 mix_q_c068_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_14 (mix_i_src_c068_2_14 0 bpf_c068_2 0) vcvs gain=8.314696123025e-01
SMIXI_c068_2_14 (mix_i_src_c068_2_14 mix_i_c068_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_14 (mix_q_src_c068_2_14 0 bpf_c068_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_2_14 (mix_q_src_c068_2_14 mix_q_c068_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_2_15 (mix_i_src_c068_2_15 0 bpf_c068_2 0) vcvs gain=9.807852804032e-01
SMIXI_c068_2_15 (mix_i_src_c068_2_15 mix_i_c068_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_2_15 (mix_q_src_c068_2_15 0 bpf_c068_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_2_15 (mix_q_src_c068_2_15 mix_q_c068_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c068_2 (mix_i_c068_2 0) resistor r=1G
RMIXQ_c068_2 (mix_q_c068_2 0) resistor r=1G
RINTI_c068_2 (mix_i_c068_2 Icar_c068_2) resistor r=1k
CINTI_c068_2 (Icar_c068_2 0) capacitor c=80p
RINTQ_c068_2 (mix_q_c068_2 Qcar_c068_2) resistor r=1k
CINTQ_c068_2 (Qcar_c068_2 0) capacitor c=80p

// bl068, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c068_3 (bl068 n_cbpf_c068_3) capacitor c=2.533029591058e-14
LBPF_c068_3 (n_cbpf_c068_3 bpf_c068_3) inductor l=1.000000000000e-06
RBPF_c068_3 (bpf_c068_3 0) resistor r=3.141592653590e+02
EMIXI_c068_3_00 (mix_i_src_c068_3_00 0 bpf_c068_3 0) vcvs gain=9.807852804032e-01
SMIXI_c068_3_00 (mix_i_src_c068_3_00 mix_i_c068_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_00 (mix_q_src_c068_3_00 0 bpf_c068_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_3_00 (mix_q_src_c068_3_00 mix_q_c068_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_01 (mix_i_src_c068_3_01 0 bpf_c068_3 0) vcvs gain=8.314696123025e-01
SMIXI_c068_3_01 (mix_i_src_c068_3_01 mix_i_c068_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_01 (mix_q_src_c068_3_01 0 bpf_c068_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_3_01 (mix_q_src_c068_3_01 mix_q_c068_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_02 (mix_i_src_c068_3_02 0 bpf_c068_3 0) vcvs gain=5.555702330196e-01
SMIXI_c068_3_02 (mix_i_src_c068_3_02 mix_i_c068_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_02 (mix_q_src_c068_3_02 0 bpf_c068_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_3_02 (mix_q_src_c068_3_02 mix_q_c068_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_03 (mix_i_src_c068_3_03 0 bpf_c068_3 0) vcvs gain=1.950903220161e-01
SMIXI_c068_3_03 (mix_i_src_c068_3_03 mix_i_c068_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_03 (mix_q_src_c068_3_03 0 bpf_c068_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_3_03 (mix_q_src_c068_3_03 mix_q_c068_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_04 (mix_i_src_c068_3_04 0 bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_3_04 (mix_i_src_c068_3_04 mix_i_c068_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_04 (mix_q_src_c068_3_04 0 bpf_c068_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c068_3_04 (mix_q_src_c068_3_04 mix_q_c068_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_05 (mix_i_src_c068_3_05 0 bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_3_05 (mix_i_src_c068_3_05 mix_i_c068_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_05 (mix_q_src_c068_3_05 0 bpf_c068_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c068_3_05 (mix_q_src_c068_3_05 mix_q_c068_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_06 (mix_i_src_c068_3_06 0 bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_3_06 (mix_i_src_c068_3_06 mix_i_c068_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_06 (mix_q_src_c068_3_06 0 bpf_c068_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c068_3_06 (mix_q_src_c068_3_06 mix_q_c068_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_07 (mix_i_src_c068_3_07 0 bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_3_07 (mix_i_src_c068_3_07 mix_i_c068_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_07 (mix_q_src_c068_3_07 0 bpf_c068_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c068_3_07 (mix_q_src_c068_3_07 mix_q_c068_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_08 (mix_i_src_c068_3_08 0 bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c068_3_08 (mix_i_src_c068_3_08 mix_i_c068_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_08 (mix_q_src_c068_3_08 0 bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_3_08 (mix_q_src_c068_3_08 mix_q_c068_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_09 (mix_i_src_c068_3_09 0 bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c068_3_09 (mix_i_src_c068_3_09 mix_i_c068_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_09 (mix_q_src_c068_3_09 0 bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_3_09 (mix_q_src_c068_3_09 mix_q_c068_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_10 (mix_i_src_c068_3_10 0 bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c068_3_10 (mix_i_src_c068_3_10 mix_i_c068_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_10 (mix_q_src_c068_3_10 0 bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_3_10 (mix_q_src_c068_3_10 mix_q_c068_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_11 (mix_i_src_c068_3_11 0 bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c068_3_11 (mix_i_src_c068_3_11 mix_i_c068_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_11 (mix_q_src_c068_3_11 0 bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_3_11 (mix_q_src_c068_3_11 mix_q_c068_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_12 (mix_i_src_c068_3_12 0 bpf_c068_3 0) vcvs gain=1.950903220161e-01
SMIXI_c068_3_12 (mix_i_src_c068_3_12 mix_i_c068_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_12 (mix_q_src_c068_3_12 0 bpf_c068_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c068_3_12 (mix_q_src_c068_3_12 mix_q_c068_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_13 (mix_i_src_c068_3_13 0 bpf_c068_3 0) vcvs gain=5.555702330196e-01
SMIXI_c068_3_13 (mix_i_src_c068_3_13 mix_i_c068_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_13 (mix_q_src_c068_3_13 0 bpf_c068_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c068_3_13 (mix_q_src_c068_3_13 mix_q_c068_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_14 (mix_i_src_c068_3_14 0 bpf_c068_3 0) vcvs gain=8.314696123025e-01
SMIXI_c068_3_14 (mix_i_src_c068_3_14 mix_i_c068_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_14 (mix_q_src_c068_3_14 0 bpf_c068_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c068_3_14 (mix_q_src_c068_3_14 mix_q_c068_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c068_3_15 (mix_i_src_c068_3_15 0 bpf_c068_3 0) vcvs gain=9.807852804032e-01
SMIXI_c068_3_15 (mix_i_src_c068_3_15 mix_i_c068_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c068_3_15 (mix_q_src_c068_3_15 0 bpf_c068_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c068_3_15 (mix_q_src_c068_3_15 mix_q_c068_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c068_3 (mix_i_c068_3 0) resistor r=1G
RMIXQ_c068_3 (mix_q_c068_3 0) resistor r=1G
RINTI_c068_3 (mix_i_c068_3 Icar_c068_3) resistor r=1k
CINTI_c068_3 (Icar_c068_3 0) capacitor c=80p
RINTQ_c068_3 (mix_q_c068_3 Qcar_c068_3) resistor r=1k
CINTQ_c068_3 (Qcar_c068_3 0) capacitor c=80p

// bl069, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c069_0 (bl069 n_cbpf_c069_0) capacitor c=4.052847345694e-13
LBPF_c069_0 (n_cbpf_c069_0 bpf_c069_0) inductor l=1.000000000000e-06
RBPF_c069_0 (bpf_c069_0 0) resistor r=7.853981633974e+01
EMIXI_c069_0_00 (mix_i_src_c069_0_00 0 bpf_c069_0 0) vcvs gain=9.807852804032e-01
SMIXI_c069_0_00 (mix_i_src_c069_0_00 mix_i_c069_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_00 (mix_q_src_c069_0_00 0 bpf_c069_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_0_00 (mix_q_src_c069_0_00 mix_q_c069_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_01 (mix_i_src_c069_0_01 0 bpf_c069_0 0) vcvs gain=8.314696123025e-01
SMIXI_c069_0_01 (mix_i_src_c069_0_01 mix_i_c069_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_01 (mix_q_src_c069_0_01 0 bpf_c069_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_0_01 (mix_q_src_c069_0_01 mix_q_c069_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_02 (mix_i_src_c069_0_02 0 bpf_c069_0 0) vcvs gain=5.555702330196e-01
SMIXI_c069_0_02 (mix_i_src_c069_0_02 mix_i_c069_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_02 (mix_q_src_c069_0_02 0 bpf_c069_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_0_02 (mix_q_src_c069_0_02 mix_q_c069_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_03 (mix_i_src_c069_0_03 0 bpf_c069_0 0) vcvs gain=1.950903220161e-01
SMIXI_c069_0_03 (mix_i_src_c069_0_03 mix_i_c069_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_03 (mix_q_src_c069_0_03 0 bpf_c069_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_0_03 (mix_q_src_c069_0_03 mix_q_c069_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_04 (mix_i_src_c069_0_04 0 bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_0_04 (mix_i_src_c069_0_04 mix_i_c069_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_04 (mix_q_src_c069_0_04 0 bpf_c069_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_0_04 (mix_q_src_c069_0_04 mix_q_c069_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_05 (mix_i_src_c069_0_05 0 bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_0_05 (mix_i_src_c069_0_05 mix_i_c069_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_05 (mix_q_src_c069_0_05 0 bpf_c069_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_0_05 (mix_q_src_c069_0_05 mix_q_c069_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_06 (mix_i_src_c069_0_06 0 bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_0_06 (mix_i_src_c069_0_06 mix_i_c069_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_06 (mix_q_src_c069_0_06 0 bpf_c069_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_0_06 (mix_q_src_c069_0_06 mix_q_c069_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_07 (mix_i_src_c069_0_07 0 bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_0_07 (mix_i_src_c069_0_07 mix_i_c069_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_07 (mix_q_src_c069_0_07 0 bpf_c069_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_0_07 (mix_q_src_c069_0_07 mix_q_c069_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_08 (mix_i_src_c069_0_08 0 bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_0_08 (mix_i_src_c069_0_08 mix_i_c069_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_08 (mix_q_src_c069_0_08 0 bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_0_08 (mix_q_src_c069_0_08 mix_q_c069_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_09 (mix_i_src_c069_0_09 0 bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_0_09 (mix_i_src_c069_0_09 mix_i_c069_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_09 (mix_q_src_c069_0_09 0 bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_0_09 (mix_q_src_c069_0_09 mix_q_c069_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_10 (mix_i_src_c069_0_10 0 bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_0_10 (mix_i_src_c069_0_10 mix_i_c069_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_10 (mix_q_src_c069_0_10 0 bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_0_10 (mix_q_src_c069_0_10 mix_q_c069_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_11 (mix_i_src_c069_0_11 0 bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_0_11 (mix_i_src_c069_0_11 mix_i_c069_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_11 (mix_q_src_c069_0_11 0 bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_0_11 (mix_q_src_c069_0_11 mix_q_c069_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_12 (mix_i_src_c069_0_12 0 bpf_c069_0 0) vcvs gain=1.950903220161e-01
SMIXI_c069_0_12 (mix_i_src_c069_0_12 mix_i_c069_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_12 (mix_q_src_c069_0_12 0 bpf_c069_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_0_12 (mix_q_src_c069_0_12 mix_q_c069_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_13 (mix_i_src_c069_0_13 0 bpf_c069_0 0) vcvs gain=5.555702330196e-01
SMIXI_c069_0_13 (mix_i_src_c069_0_13 mix_i_c069_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_13 (mix_q_src_c069_0_13 0 bpf_c069_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_0_13 (mix_q_src_c069_0_13 mix_q_c069_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_14 (mix_i_src_c069_0_14 0 bpf_c069_0 0) vcvs gain=8.314696123025e-01
SMIXI_c069_0_14 (mix_i_src_c069_0_14 mix_i_c069_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_14 (mix_q_src_c069_0_14 0 bpf_c069_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_0_14 (mix_q_src_c069_0_14 mix_q_c069_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_0_15 (mix_i_src_c069_0_15 0 bpf_c069_0 0) vcvs gain=9.807852804032e-01
SMIXI_c069_0_15 (mix_i_src_c069_0_15 mix_i_c069_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_0_15 (mix_q_src_c069_0_15 0 bpf_c069_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_0_15 (mix_q_src_c069_0_15 mix_q_c069_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c069_0 (mix_i_c069_0 0) resistor r=1G
RMIXQ_c069_0 (mix_q_c069_0 0) resistor r=1G
RINTI_c069_0 (mix_i_c069_0 Icar_c069_0) resistor r=1k
CINTI_c069_0 (Icar_c069_0 0) capacitor c=80p
RINTQ_c069_0 (mix_q_c069_0 Qcar_c069_0) resistor r=1k
CINTQ_c069_0 (Qcar_c069_0 0) capacitor c=80p

// bl069, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c069_1 (bl069 n_cbpf_c069_1) capacitor c=1.013211836423e-13
LBPF_c069_1 (n_cbpf_c069_1 bpf_c069_1) inductor l=1.000000000000e-06
RBPF_c069_1 (bpf_c069_1 0) resistor r=1.570796326795e+02
EMIXI_c069_1_00 (mix_i_src_c069_1_00 0 bpf_c069_1 0) vcvs gain=9.807852804032e-01
SMIXI_c069_1_00 (mix_i_src_c069_1_00 mix_i_c069_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_00 (mix_q_src_c069_1_00 0 bpf_c069_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_1_00 (mix_q_src_c069_1_00 mix_q_c069_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_01 (mix_i_src_c069_1_01 0 bpf_c069_1 0) vcvs gain=8.314696123025e-01
SMIXI_c069_1_01 (mix_i_src_c069_1_01 mix_i_c069_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_01 (mix_q_src_c069_1_01 0 bpf_c069_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_1_01 (mix_q_src_c069_1_01 mix_q_c069_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_02 (mix_i_src_c069_1_02 0 bpf_c069_1 0) vcvs gain=5.555702330196e-01
SMIXI_c069_1_02 (mix_i_src_c069_1_02 mix_i_c069_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_02 (mix_q_src_c069_1_02 0 bpf_c069_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_1_02 (mix_q_src_c069_1_02 mix_q_c069_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_03 (mix_i_src_c069_1_03 0 bpf_c069_1 0) vcvs gain=1.950903220161e-01
SMIXI_c069_1_03 (mix_i_src_c069_1_03 mix_i_c069_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_03 (mix_q_src_c069_1_03 0 bpf_c069_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_1_03 (mix_q_src_c069_1_03 mix_q_c069_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_04 (mix_i_src_c069_1_04 0 bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_1_04 (mix_i_src_c069_1_04 mix_i_c069_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_04 (mix_q_src_c069_1_04 0 bpf_c069_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_1_04 (mix_q_src_c069_1_04 mix_q_c069_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_05 (mix_i_src_c069_1_05 0 bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_1_05 (mix_i_src_c069_1_05 mix_i_c069_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_05 (mix_q_src_c069_1_05 0 bpf_c069_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_1_05 (mix_q_src_c069_1_05 mix_q_c069_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_06 (mix_i_src_c069_1_06 0 bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_1_06 (mix_i_src_c069_1_06 mix_i_c069_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_06 (mix_q_src_c069_1_06 0 bpf_c069_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_1_06 (mix_q_src_c069_1_06 mix_q_c069_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_07 (mix_i_src_c069_1_07 0 bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_1_07 (mix_i_src_c069_1_07 mix_i_c069_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_07 (mix_q_src_c069_1_07 0 bpf_c069_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_1_07 (mix_q_src_c069_1_07 mix_q_c069_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_08 (mix_i_src_c069_1_08 0 bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_1_08 (mix_i_src_c069_1_08 mix_i_c069_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_08 (mix_q_src_c069_1_08 0 bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_1_08 (mix_q_src_c069_1_08 mix_q_c069_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_09 (mix_i_src_c069_1_09 0 bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_1_09 (mix_i_src_c069_1_09 mix_i_c069_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_09 (mix_q_src_c069_1_09 0 bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_1_09 (mix_q_src_c069_1_09 mix_q_c069_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_10 (mix_i_src_c069_1_10 0 bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_1_10 (mix_i_src_c069_1_10 mix_i_c069_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_10 (mix_q_src_c069_1_10 0 bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_1_10 (mix_q_src_c069_1_10 mix_q_c069_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_11 (mix_i_src_c069_1_11 0 bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_1_11 (mix_i_src_c069_1_11 mix_i_c069_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_11 (mix_q_src_c069_1_11 0 bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_1_11 (mix_q_src_c069_1_11 mix_q_c069_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_12 (mix_i_src_c069_1_12 0 bpf_c069_1 0) vcvs gain=1.950903220161e-01
SMIXI_c069_1_12 (mix_i_src_c069_1_12 mix_i_c069_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_12 (mix_q_src_c069_1_12 0 bpf_c069_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_1_12 (mix_q_src_c069_1_12 mix_q_c069_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_13 (mix_i_src_c069_1_13 0 bpf_c069_1 0) vcvs gain=5.555702330196e-01
SMIXI_c069_1_13 (mix_i_src_c069_1_13 mix_i_c069_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_13 (mix_q_src_c069_1_13 0 bpf_c069_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_1_13 (mix_q_src_c069_1_13 mix_q_c069_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_14 (mix_i_src_c069_1_14 0 bpf_c069_1 0) vcvs gain=8.314696123025e-01
SMIXI_c069_1_14 (mix_i_src_c069_1_14 mix_i_c069_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_14 (mix_q_src_c069_1_14 0 bpf_c069_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_1_14 (mix_q_src_c069_1_14 mix_q_c069_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_1_15 (mix_i_src_c069_1_15 0 bpf_c069_1 0) vcvs gain=9.807852804032e-01
SMIXI_c069_1_15 (mix_i_src_c069_1_15 mix_i_c069_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_1_15 (mix_q_src_c069_1_15 0 bpf_c069_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_1_15 (mix_q_src_c069_1_15 mix_q_c069_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c069_1 (mix_i_c069_1 0) resistor r=1G
RMIXQ_c069_1 (mix_q_c069_1 0) resistor r=1G
RINTI_c069_1 (mix_i_c069_1 Icar_c069_1) resistor r=1k
CINTI_c069_1 (Icar_c069_1 0) capacitor c=80p
RINTQ_c069_1 (mix_q_c069_1 Qcar_c069_1) resistor r=1k
CINTQ_c069_1 (Qcar_c069_1 0) capacitor c=80p

// bl069, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c069_2 (bl069 n_cbpf_c069_2) capacitor c=4.503163717437e-14
LBPF_c069_2 (n_cbpf_c069_2 bpf_c069_2) inductor l=1.000000000000e-06
RBPF_c069_2 (bpf_c069_2 0) resistor r=2.356194490192e+02
EMIXI_c069_2_00 (mix_i_src_c069_2_00 0 bpf_c069_2 0) vcvs gain=9.807852804032e-01
SMIXI_c069_2_00 (mix_i_src_c069_2_00 mix_i_c069_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_00 (mix_q_src_c069_2_00 0 bpf_c069_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_2_00 (mix_q_src_c069_2_00 mix_q_c069_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_01 (mix_i_src_c069_2_01 0 bpf_c069_2 0) vcvs gain=8.314696123025e-01
SMIXI_c069_2_01 (mix_i_src_c069_2_01 mix_i_c069_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_01 (mix_q_src_c069_2_01 0 bpf_c069_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_2_01 (mix_q_src_c069_2_01 mix_q_c069_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_02 (mix_i_src_c069_2_02 0 bpf_c069_2 0) vcvs gain=5.555702330196e-01
SMIXI_c069_2_02 (mix_i_src_c069_2_02 mix_i_c069_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_02 (mix_q_src_c069_2_02 0 bpf_c069_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_2_02 (mix_q_src_c069_2_02 mix_q_c069_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_03 (mix_i_src_c069_2_03 0 bpf_c069_2 0) vcvs gain=1.950903220161e-01
SMIXI_c069_2_03 (mix_i_src_c069_2_03 mix_i_c069_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_03 (mix_q_src_c069_2_03 0 bpf_c069_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_2_03 (mix_q_src_c069_2_03 mix_q_c069_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_04 (mix_i_src_c069_2_04 0 bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_2_04 (mix_i_src_c069_2_04 mix_i_c069_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_04 (mix_q_src_c069_2_04 0 bpf_c069_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_2_04 (mix_q_src_c069_2_04 mix_q_c069_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_05 (mix_i_src_c069_2_05 0 bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_2_05 (mix_i_src_c069_2_05 mix_i_c069_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_05 (mix_q_src_c069_2_05 0 bpf_c069_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_2_05 (mix_q_src_c069_2_05 mix_q_c069_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_06 (mix_i_src_c069_2_06 0 bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_2_06 (mix_i_src_c069_2_06 mix_i_c069_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_06 (mix_q_src_c069_2_06 0 bpf_c069_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_2_06 (mix_q_src_c069_2_06 mix_q_c069_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_07 (mix_i_src_c069_2_07 0 bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_2_07 (mix_i_src_c069_2_07 mix_i_c069_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_07 (mix_q_src_c069_2_07 0 bpf_c069_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_2_07 (mix_q_src_c069_2_07 mix_q_c069_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_08 (mix_i_src_c069_2_08 0 bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_2_08 (mix_i_src_c069_2_08 mix_i_c069_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_08 (mix_q_src_c069_2_08 0 bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_2_08 (mix_q_src_c069_2_08 mix_q_c069_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_09 (mix_i_src_c069_2_09 0 bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_2_09 (mix_i_src_c069_2_09 mix_i_c069_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_09 (mix_q_src_c069_2_09 0 bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_2_09 (mix_q_src_c069_2_09 mix_q_c069_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_10 (mix_i_src_c069_2_10 0 bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_2_10 (mix_i_src_c069_2_10 mix_i_c069_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_10 (mix_q_src_c069_2_10 0 bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_2_10 (mix_q_src_c069_2_10 mix_q_c069_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_11 (mix_i_src_c069_2_11 0 bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_2_11 (mix_i_src_c069_2_11 mix_i_c069_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_11 (mix_q_src_c069_2_11 0 bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_2_11 (mix_q_src_c069_2_11 mix_q_c069_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_12 (mix_i_src_c069_2_12 0 bpf_c069_2 0) vcvs gain=1.950903220161e-01
SMIXI_c069_2_12 (mix_i_src_c069_2_12 mix_i_c069_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_12 (mix_q_src_c069_2_12 0 bpf_c069_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_2_12 (mix_q_src_c069_2_12 mix_q_c069_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_13 (mix_i_src_c069_2_13 0 bpf_c069_2 0) vcvs gain=5.555702330196e-01
SMIXI_c069_2_13 (mix_i_src_c069_2_13 mix_i_c069_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_13 (mix_q_src_c069_2_13 0 bpf_c069_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_2_13 (mix_q_src_c069_2_13 mix_q_c069_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_14 (mix_i_src_c069_2_14 0 bpf_c069_2 0) vcvs gain=8.314696123025e-01
SMIXI_c069_2_14 (mix_i_src_c069_2_14 mix_i_c069_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_14 (mix_q_src_c069_2_14 0 bpf_c069_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_2_14 (mix_q_src_c069_2_14 mix_q_c069_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_2_15 (mix_i_src_c069_2_15 0 bpf_c069_2 0) vcvs gain=9.807852804032e-01
SMIXI_c069_2_15 (mix_i_src_c069_2_15 mix_i_c069_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_2_15 (mix_q_src_c069_2_15 0 bpf_c069_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_2_15 (mix_q_src_c069_2_15 mix_q_c069_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c069_2 (mix_i_c069_2 0) resistor r=1G
RMIXQ_c069_2 (mix_q_c069_2 0) resistor r=1G
RINTI_c069_2 (mix_i_c069_2 Icar_c069_2) resistor r=1k
CINTI_c069_2 (Icar_c069_2 0) capacitor c=80p
RINTQ_c069_2 (mix_q_c069_2 Qcar_c069_2) resistor r=1k
CINTQ_c069_2 (Qcar_c069_2 0) capacitor c=80p

// bl069, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c069_3 (bl069 n_cbpf_c069_3) capacitor c=2.533029591058e-14
LBPF_c069_3 (n_cbpf_c069_3 bpf_c069_3) inductor l=1.000000000000e-06
RBPF_c069_3 (bpf_c069_3 0) resistor r=3.141592653590e+02
EMIXI_c069_3_00 (mix_i_src_c069_3_00 0 bpf_c069_3 0) vcvs gain=9.807852804032e-01
SMIXI_c069_3_00 (mix_i_src_c069_3_00 mix_i_c069_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_00 (mix_q_src_c069_3_00 0 bpf_c069_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_3_00 (mix_q_src_c069_3_00 mix_q_c069_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_01 (mix_i_src_c069_3_01 0 bpf_c069_3 0) vcvs gain=8.314696123025e-01
SMIXI_c069_3_01 (mix_i_src_c069_3_01 mix_i_c069_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_01 (mix_q_src_c069_3_01 0 bpf_c069_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_3_01 (mix_q_src_c069_3_01 mix_q_c069_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_02 (mix_i_src_c069_3_02 0 bpf_c069_3 0) vcvs gain=5.555702330196e-01
SMIXI_c069_3_02 (mix_i_src_c069_3_02 mix_i_c069_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_02 (mix_q_src_c069_3_02 0 bpf_c069_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_3_02 (mix_q_src_c069_3_02 mix_q_c069_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_03 (mix_i_src_c069_3_03 0 bpf_c069_3 0) vcvs gain=1.950903220161e-01
SMIXI_c069_3_03 (mix_i_src_c069_3_03 mix_i_c069_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_03 (mix_q_src_c069_3_03 0 bpf_c069_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_3_03 (mix_q_src_c069_3_03 mix_q_c069_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_04 (mix_i_src_c069_3_04 0 bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_3_04 (mix_i_src_c069_3_04 mix_i_c069_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_04 (mix_q_src_c069_3_04 0 bpf_c069_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c069_3_04 (mix_q_src_c069_3_04 mix_q_c069_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_05 (mix_i_src_c069_3_05 0 bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_3_05 (mix_i_src_c069_3_05 mix_i_c069_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_05 (mix_q_src_c069_3_05 0 bpf_c069_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c069_3_05 (mix_q_src_c069_3_05 mix_q_c069_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_06 (mix_i_src_c069_3_06 0 bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_3_06 (mix_i_src_c069_3_06 mix_i_c069_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_06 (mix_q_src_c069_3_06 0 bpf_c069_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c069_3_06 (mix_q_src_c069_3_06 mix_q_c069_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_07 (mix_i_src_c069_3_07 0 bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_3_07 (mix_i_src_c069_3_07 mix_i_c069_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_07 (mix_q_src_c069_3_07 0 bpf_c069_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c069_3_07 (mix_q_src_c069_3_07 mix_q_c069_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_08 (mix_i_src_c069_3_08 0 bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c069_3_08 (mix_i_src_c069_3_08 mix_i_c069_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_08 (mix_q_src_c069_3_08 0 bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_3_08 (mix_q_src_c069_3_08 mix_q_c069_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_09 (mix_i_src_c069_3_09 0 bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c069_3_09 (mix_i_src_c069_3_09 mix_i_c069_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_09 (mix_q_src_c069_3_09 0 bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_3_09 (mix_q_src_c069_3_09 mix_q_c069_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_10 (mix_i_src_c069_3_10 0 bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c069_3_10 (mix_i_src_c069_3_10 mix_i_c069_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_10 (mix_q_src_c069_3_10 0 bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_3_10 (mix_q_src_c069_3_10 mix_q_c069_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_11 (mix_i_src_c069_3_11 0 bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c069_3_11 (mix_i_src_c069_3_11 mix_i_c069_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_11 (mix_q_src_c069_3_11 0 bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_3_11 (mix_q_src_c069_3_11 mix_q_c069_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_12 (mix_i_src_c069_3_12 0 bpf_c069_3 0) vcvs gain=1.950903220161e-01
SMIXI_c069_3_12 (mix_i_src_c069_3_12 mix_i_c069_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_12 (mix_q_src_c069_3_12 0 bpf_c069_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c069_3_12 (mix_q_src_c069_3_12 mix_q_c069_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_13 (mix_i_src_c069_3_13 0 bpf_c069_3 0) vcvs gain=5.555702330196e-01
SMIXI_c069_3_13 (mix_i_src_c069_3_13 mix_i_c069_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_13 (mix_q_src_c069_3_13 0 bpf_c069_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c069_3_13 (mix_q_src_c069_3_13 mix_q_c069_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_14 (mix_i_src_c069_3_14 0 bpf_c069_3 0) vcvs gain=8.314696123025e-01
SMIXI_c069_3_14 (mix_i_src_c069_3_14 mix_i_c069_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_14 (mix_q_src_c069_3_14 0 bpf_c069_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c069_3_14 (mix_q_src_c069_3_14 mix_q_c069_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c069_3_15 (mix_i_src_c069_3_15 0 bpf_c069_3 0) vcvs gain=9.807852804032e-01
SMIXI_c069_3_15 (mix_i_src_c069_3_15 mix_i_c069_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c069_3_15 (mix_q_src_c069_3_15 0 bpf_c069_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c069_3_15 (mix_q_src_c069_3_15 mix_q_c069_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c069_3 (mix_i_c069_3 0) resistor r=1G
RMIXQ_c069_3 (mix_q_c069_3 0) resistor r=1G
RINTI_c069_3 (mix_i_c069_3 Icar_c069_3) resistor r=1k
CINTI_c069_3 (Icar_c069_3 0) capacitor c=80p
RINTQ_c069_3 (mix_q_c069_3 Qcar_c069_3) resistor r=1k
CINTQ_c069_3 (Qcar_c069_3 0) capacitor c=80p

// bl070, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c070_0 (bl070 n_cbpf_c070_0) capacitor c=4.052847345694e-13
LBPF_c070_0 (n_cbpf_c070_0 bpf_c070_0) inductor l=1.000000000000e-06
RBPF_c070_0 (bpf_c070_0 0) resistor r=7.853981633974e+01
EMIXI_c070_0_00 (mix_i_src_c070_0_00 0 bpf_c070_0 0) vcvs gain=9.807852804032e-01
SMIXI_c070_0_00 (mix_i_src_c070_0_00 mix_i_c070_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_00 (mix_q_src_c070_0_00 0 bpf_c070_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_0_00 (mix_q_src_c070_0_00 mix_q_c070_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_01 (mix_i_src_c070_0_01 0 bpf_c070_0 0) vcvs gain=8.314696123025e-01
SMIXI_c070_0_01 (mix_i_src_c070_0_01 mix_i_c070_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_01 (mix_q_src_c070_0_01 0 bpf_c070_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_0_01 (mix_q_src_c070_0_01 mix_q_c070_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_02 (mix_i_src_c070_0_02 0 bpf_c070_0 0) vcvs gain=5.555702330196e-01
SMIXI_c070_0_02 (mix_i_src_c070_0_02 mix_i_c070_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_02 (mix_q_src_c070_0_02 0 bpf_c070_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_0_02 (mix_q_src_c070_0_02 mix_q_c070_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_03 (mix_i_src_c070_0_03 0 bpf_c070_0 0) vcvs gain=1.950903220161e-01
SMIXI_c070_0_03 (mix_i_src_c070_0_03 mix_i_c070_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_03 (mix_q_src_c070_0_03 0 bpf_c070_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_0_03 (mix_q_src_c070_0_03 mix_q_c070_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_04 (mix_i_src_c070_0_04 0 bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_0_04 (mix_i_src_c070_0_04 mix_i_c070_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_04 (mix_q_src_c070_0_04 0 bpf_c070_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_0_04 (mix_q_src_c070_0_04 mix_q_c070_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_05 (mix_i_src_c070_0_05 0 bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_0_05 (mix_i_src_c070_0_05 mix_i_c070_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_05 (mix_q_src_c070_0_05 0 bpf_c070_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_0_05 (mix_q_src_c070_0_05 mix_q_c070_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_06 (mix_i_src_c070_0_06 0 bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_0_06 (mix_i_src_c070_0_06 mix_i_c070_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_06 (mix_q_src_c070_0_06 0 bpf_c070_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_0_06 (mix_q_src_c070_0_06 mix_q_c070_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_07 (mix_i_src_c070_0_07 0 bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_0_07 (mix_i_src_c070_0_07 mix_i_c070_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_07 (mix_q_src_c070_0_07 0 bpf_c070_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_0_07 (mix_q_src_c070_0_07 mix_q_c070_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_08 (mix_i_src_c070_0_08 0 bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_0_08 (mix_i_src_c070_0_08 mix_i_c070_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_08 (mix_q_src_c070_0_08 0 bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_0_08 (mix_q_src_c070_0_08 mix_q_c070_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_09 (mix_i_src_c070_0_09 0 bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_0_09 (mix_i_src_c070_0_09 mix_i_c070_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_09 (mix_q_src_c070_0_09 0 bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_0_09 (mix_q_src_c070_0_09 mix_q_c070_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_10 (mix_i_src_c070_0_10 0 bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_0_10 (mix_i_src_c070_0_10 mix_i_c070_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_10 (mix_q_src_c070_0_10 0 bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_0_10 (mix_q_src_c070_0_10 mix_q_c070_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_11 (mix_i_src_c070_0_11 0 bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_0_11 (mix_i_src_c070_0_11 mix_i_c070_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_11 (mix_q_src_c070_0_11 0 bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c070_0_11 (mix_q_src_c070_0_11 mix_q_c070_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_12 (mix_i_src_c070_0_12 0 bpf_c070_0 0) vcvs gain=1.950903220161e-01
SMIXI_c070_0_12 (mix_i_src_c070_0_12 mix_i_c070_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_12 (mix_q_src_c070_0_12 0 bpf_c070_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c070_0_12 (mix_q_src_c070_0_12 mix_q_c070_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_13 (mix_i_src_c070_0_13 0 bpf_c070_0 0) vcvs gain=5.555702330196e-01
SMIXI_c070_0_13 (mix_i_src_c070_0_13 mix_i_c070_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_13 (mix_q_src_c070_0_13 0 bpf_c070_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_0_13 (mix_q_src_c070_0_13 mix_q_c070_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_14 (mix_i_src_c070_0_14 0 bpf_c070_0 0) vcvs gain=8.314696123025e-01
SMIXI_c070_0_14 (mix_i_src_c070_0_14 mix_i_c070_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_14 (mix_q_src_c070_0_14 0 bpf_c070_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_0_14 (mix_q_src_c070_0_14 mix_q_c070_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_0_15 (mix_i_src_c070_0_15 0 bpf_c070_0 0) vcvs gain=9.807852804032e-01
SMIXI_c070_0_15 (mix_i_src_c070_0_15 mix_i_c070_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_0_15 (mix_q_src_c070_0_15 0 bpf_c070_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_0_15 (mix_q_src_c070_0_15 mix_q_c070_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c070_0 (mix_i_c070_0 0) resistor r=1G
RMIXQ_c070_0 (mix_q_c070_0 0) resistor r=1G
RINTI_c070_0 (mix_i_c070_0 Icar_c070_0) resistor r=1k
CINTI_c070_0 (Icar_c070_0 0) capacitor c=80p
RINTQ_c070_0 (mix_q_c070_0 Qcar_c070_0) resistor r=1k
CINTQ_c070_0 (Qcar_c070_0 0) capacitor c=80p

// bl070, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c070_1 (bl070 n_cbpf_c070_1) capacitor c=1.013211836423e-13
LBPF_c070_1 (n_cbpf_c070_1 bpf_c070_1) inductor l=1.000000000000e-06
RBPF_c070_1 (bpf_c070_1 0) resistor r=1.570796326795e+02
EMIXI_c070_1_00 (mix_i_src_c070_1_00 0 bpf_c070_1 0) vcvs gain=9.807852804032e-01
SMIXI_c070_1_00 (mix_i_src_c070_1_00 mix_i_c070_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_00 (mix_q_src_c070_1_00 0 bpf_c070_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_1_00 (mix_q_src_c070_1_00 mix_q_c070_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_01 (mix_i_src_c070_1_01 0 bpf_c070_1 0) vcvs gain=8.314696123025e-01
SMIXI_c070_1_01 (mix_i_src_c070_1_01 mix_i_c070_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_01 (mix_q_src_c070_1_01 0 bpf_c070_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_1_01 (mix_q_src_c070_1_01 mix_q_c070_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_02 (mix_i_src_c070_1_02 0 bpf_c070_1 0) vcvs gain=5.555702330196e-01
SMIXI_c070_1_02 (mix_i_src_c070_1_02 mix_i_c070_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_02 (mix_q_src_c070_1_02 0 bpf_c070_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_1_02 (mix_q_src_c070_1_02 mix_q_c070_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_03 (mix_i_src_c070_1_03 0 bpf_c070_1 0) vcvs gain=1.950903220161e-01
SMIXI_c070_1_03 (mix_i_src_c070_1_03 mix_i_c070_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_03 (mix_q_src_c070_1_03 0 bpf_c070_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_1_03 (mix_q_src_c070_1_03 mix_q_c070_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_04 (mix_i_src_c070_1_04 0 bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_1_04 (mix_i_src_c070_1_04 mix_i_c070_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_04 (mix_q_src_c070_1_04 0 bpf_c070_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_1_04 (mix_q_src_c070_1_04 mix_q_c070_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_05 (mix_i_src_c070_1_05 0 bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_1_05 (mix_i_src_c070_1_05 mix_i_c070_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_05 (mix_q_src_c070_1_05 0 bpf_c070_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_1_05 (mix_q_src_c070_1_05 mix_q_c070_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_06 (mix_i_src_c070_1_06 0 bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_1_06 (mix_i_src_c070_1_06 mix_i_c070_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_06 (mix_q_src_c070_1_06 0 bpf_c070_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_1_06 (mix_q_src_c070_1_06 mix_q_c070_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_07 (mix_i_src_c070_1_07 0 bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_1_07 (mix_i_src_c070_1_07 mix_i_c070_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_07 (mix_q_src_c070_1_07 0 bpf_c070_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_1_07 (mix_q_src_c070_1_07 mix_q_c070_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_08 (mix_i_src_c070_1_08 0 bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_1_08 (mix_i_src_c070_1_08 mix_i_c070_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_08 (mix_q_src_c070_1_08 0 bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_1_08 (mix_q_src_c070_1_08 mix_q_c070_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_09 (mix_i_src_c070_1_09 0 bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_1_09 (mix_i_src_c070_1_09 mix_i_c070_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_09 (mix_q_src_c070_1_09 0 bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_1_09 (mix_q_src_c070_1_09 mix_q_c070_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_10 (mix_i_src_c070_1_10 0 bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_1_10 (mix_i_src_c070_1_10 mix_i_c070_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_10 (mix_q_src_c070_1_10 0 bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_1_10 (mix_q_src_c070_1_10 mix_q_c070_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_11 (mix_i_src_c070_1_11 0 bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_1_11 (mix_i_src_c070_1_11 mix_i_c070_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_11 (mix_q_src_c070_1_11 0 bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c070_1_11 (mix_q_src_c070_1_11 mix_q_c070_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_12 (mix_i_src_c070_1_12 0 bpf_c070_1 0) vcvs gain=1.950903220161e-01
SMIXI_c070_1_12 (mix_i_src_c070_1_12 mix_i_c070_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_12 (mix_q_src_c070_1_12 0 bpf_c070_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c070_1_12 (mix_q_src_c070_1_12 mix_q_c070_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_13 (mix_i_src_c070_1_13 0 bpf_c070_1 0) vcvs gain=5.555702330196e-01
SMIXI_c070_1_13 (mix_i_src_c070_1_13 mix_i_c070_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_13 (mix_q_src_c070_1_13 0 bpf_c070_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_1_13 (mix_q_src_c070_1_13 mix_q_c070_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_14 (mix_i_src_c070_1_14 0 bpf_c070_1 0) vcvs gain=8.314696123025e-01
SMIXI_c070_1_14 (mix_i_src_c070_1_14 mix_i_c070_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_14 (mix_q_src_c070_1_14 0 bpf_c070_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_1_14 (mix_q_src_c070_1_14 mix_q_c070_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_1_15 (mix_i_src_c070_1_15 0 bpf_c070_1 0) vcvs gain=9.807852804032e-01
SMIXI_c070_1_15 (mix_i_src_c070_1_15 mix_i_c070_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_1_15 (mix_q_src_c070_1_15 0 bpf_c070_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_1_15 (mix_q_src_c070_1_15 mix_q_c070_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c070_1 (mix_i_c070_1 0) resistor r=1G
RMIXQ_c070_1 (mix_q_c070_1 0) resistor r=1G
RINTI_c070_1 (mix_i_c070_1 Icar_c070_1) resistor r=1k
CINTI_c070_1 (Icar_c070_1 0) capacitor c=80p
RINTQ_c070_1 (mix_q_c070_1 Qcar_c070_1) resistor r=1k
CINTQ_c070_1 (Qcar_c070_1 0) capacitor c=80p

// bl070, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c070_2 (bl070 n_cbpf_c070_2) capacitor c=4.503163717437e-14
LBPF_c070_2 (n_cbpf_c070_2 bpf_c070_2) inductor l=1.000000000000e-06
RBPF_c070_2 (bpf_c070_2 0) resistor r=2.356194490192e+02
EMIXI_c070_2_00 (mix_i_src_c070_2_00 0 bpf_c070_2 0) vcvs gain=9.807852804032e-01
SMIXI_c070_2_00 (mix_i_src_c070_2_00 mix_i_c070_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_00 (mix_q_src_c070_2_00 0 bpf_c070_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_2_00 (mix_q_src_c070_2_00 mix_q_c070_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_01 (mix_i_src_c070_2_01 0 bpf_c070_2 0) vcvs gain=8.314696123025e-01
SMIXI_c070_2_01 (mix_i_src_c070_2_01 mix_i_c070_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_01 (mix_q_src_c070_2_01 0 bpf_c070_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_2_01 (mix_q_src_c070_2_01 mix_q_c070_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_02 (mix_i_src_c070_2_02 0 bpf_c070_2 0) vcvs gain=5.555702330196e-01
SMIXI_c070_2_02 (mix_i_src_c070_2_02 mix_i_c070_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_02 (mix_q_src_c070_2_02 0 bpf_c070_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_2_02 (mix_q_src_c070_2_02 mix_q_c070_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_03 (mix_i_src_c070_2_03 0 bpf_c070_2 0) vcvs gain=1.950903220161e-01
SMIXI_c070_2_03 (mix_i_src_c070_2_03 mix_i_c070_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_03 (mix_q_src_c070_2_03 0 bpf_c070_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_2_03 (mix_q_src_c070_2_03 mix_q_c070_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_04 (mix_i_src_c070_2_04 0 bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_2_04 (mix_i_src_c070_2_04 mix_i_c070_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_04 (mix_q_src_c070_2_04 0 bpf_c070_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_2_04 (mix_q_src_c070_2_04 mix_q_c070_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_05 (mix_i_src_c070_2_05 0 bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_2_05 (mix_i_src_c070_2_05 mix_i_c070_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_05 (mix_q_src_c070_2_05 0 bpf_c070_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_2_05 (mix_q_src_c070_2_05 mix_q_c070_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_06 (mix_i_src_c070_2_06 0 bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_2_06 (mix_i_src_c070_2_06 mix_i_c070_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_06 (mix_q_src_c070_2_06 0 bpf_c070_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_2_06 (mix_q_src_c070_2_06 mix_q_c070_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_07 (mix_i_src_c070_2_07 0 bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_2_07 (mix_i_src_c070_2_07 mix_i_c070_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_07 (mix_q_src_c070_2_07 0 bpf_c070_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_2_07 (mix_q_src_c070_2_07 mix_q_c070_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_08 (mix_i_src_c070_2_08 0 bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_2_08 (mix_i_src_c070_2_08 mix_i_c070_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_08 (mix_q_src_c070_2_08 0 bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_2_08 (mix_q_src_c070_2_08 mix_q_c070_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_09 (mix_i_src_c070_2_09 0 bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_2_09 (mix_i_src_c070_2_09 mix_i_c070_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_09 (mix_q_src_c070_2_09 0 bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_2_09 (mix_q_src_c070_2_09 mix_q_c070_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_10 (mix_i_src_c070_2_10 0 bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_2_10 (mix_i_src_c070_2_10 mix_i_c070_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_10 (mix_q_src_c070_2_10 0 bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_2_10 (mix_q_src_c070_2_10 mix_q_c070_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_11 (mix_i_src_c070_2_11 0 bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_2_11 (mix_i_src_c070_2_11 mix_i_c070_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_11 (mix_q_src_c070_2_11 0 bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c070_2_11 (mix_q_src_c070_2_11 mix_q_c070_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_12 (mix_i_src_c070_2_12 0 bpf_c070_2 0) vcvs gain=1.950903220161e-01
SMIXI_c070_2_12 (mix_i_src_c070_2_12 mix_i_c070_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_12 (mix_q_src_c070_2_12 0 bpf_c070_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c070_2_12 (mix_q_src_c070_2_12 mix_q_c070_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_13 (mix_i_src_c070_2_13 0 bpf_c070_2 0) vcvs gain=5.555702330196e-01
SMIXI_c070_2_13 (mix_i_src_c070_2_13 mix_i_c070_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_13 (mix_q_src_c070_2_13 0 bpf_c070_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_2_13 (mix_q_src_c070_2_13 mix_q_c070_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_14 (mix_i_src_c070_2_14 0 bpf_c070_2 0) vcvs gain=8.314696123025e-01
SMIXI_c070_2_14 (mix_i_src_c070_2_14 mix_i_c070_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_14 (mix_q_src_c070_2_14 0 bpf_c070_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_2_14 (mix_q_src_c070_2_14 mix_q_c070_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_2_15 (mix_i_src_c070_2_15 0 bpf_c070_2 0) vcvs gain=9.807852804032e-01
SMIXI_c070_2_15 (mix_i_src_c070_2_15 mix_i_c070_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_2_15 (mix_q_src_c070_2_15 0 bpf_c070_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_2_15 (mix_q_src_c070_2_15 mix_q_c070_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c070_2 (mix_i_c070_2 0) resistor r=1G
RMIXQ_c070_2 (mix_q_c070_2 0) resistor r=1G
RINTI_c070_2 (mix_i_c070_2 Icar_c070_2) resistor r=1k
CINTI_c070_2 (Icar_c070_2 0) capacitor c=80p
RINTQ_c070_2 (mix_q_c070_2 Qcar_c070_2) resistor r=1k
CINTQ_c070_2 (Qcar_c070_2 0) capacitor c=80p

// bl070, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c070_3 (bl070 n_cbpf_c070_3) capacitor c=2.533029591058e-14
LBPF_c070_3 (n_cbpf_c070_3 bpf_c070_3) inductor l=1.000000000000e-06
RBPF_c070_3 (bpf_c070_3 0) resistor r=3.141592653590e+02
EMIXI_c070_3_00 (mix_i_src_c070_3_00 0 bpf_c070_3 0) vcvs gain=9.807852804032e-01
SMIXI_c070_3_00 (mix_i_src_c070_3_00 mix_i_c070_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_00 (mix_q_src_c070_3_00 0 bpf_c070_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_3_00 (mix_q_src_c070_3_00 mix_q_c070_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_01 (mix_i_src_c070_3_01 0 bpf_c070_3 0) vcvs gain=8.314696123025e-01
SMIXI_c070_3_01 (mix_i_src_c070_3_01 mix_i_c070_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_01 (mix_q_src_c070_3_01 0 bpf_c070_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_3_01 (mix_q_src_c070_3_01 mix_q_c070_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_02 (mix_i_src_c070_3_02 0 bpf_c070_3 0) vcvs gain=5.555702330196e-01
SMIXI_c070_3_02 (mix_i_src_c070_3_02 mix_i_c070_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_02 (mix_q_src_c070_3_02 0 bpf_c070_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_3_02 (mix_q_src_c070_3_02 mix_q_c070_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_03 (mix_i_src_c070_3_03 0 bpf_c070_3 0) vcvs gain=1.950903220161e-01
SMIXI_c070_3_03 (mix_i_src_c070_3_03 mix_i_c070_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_03 (mix_q_src_c070_3_03 0 bpf_c070_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_3_03 (mix_q_src_c070_3_03 mix_q_c070_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_04 (mix_i_src_c070_3_04 0 bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_3_04 (mix_i_src_c070_3_04 mix_i_c070_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_04 (mix_q_src_c070_3_04 0 bpf_c070_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c070_3_04 (mix_q_src_c070_3_04 mix_q_c070_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_05 (mix_i_src_c070_3_05 0 bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_3_05 (mix_i_src_c070_3_05 mix_i_c070_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_05 (mix_q_src_c070_3_05 0 bpf_c070_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c070_3_05 (mix_q_src_c070_3_05 mix_q_c070_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_06 (mix_i_src_c070_3_06 0 bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_3_06 (mix_i_src_c070_3_06 mix_i_c070_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_06 (mix_q_src_c070_3_06 0 bpf_c070_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c070_3_06 (mix_q_src_c070_3_06 mix_q_c070_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_07 (mix_i_src_c070_3_07 0 bpf_c070_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_3_07 (mix_i_src_c070_3_07 mix_i_c070_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_07 (mix_q_src_c070_3_07 0 bpf_c070_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c070_3_07 (mix_q_src_c070_3_07 mix_q_c070_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_08 (mix_i_src_c070_3_08 0 bpf_c070_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c070_3_08 (mix_i_src_c070_3_08 mix_i_c070_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_08 (mix_q_src_c070_3_08 0 bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_3_08 (mix_q_src_c070_3_08 mix_q_c070_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_09 (mix_i_src_c070_3_09 0 bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c070_3_09 (mix_i_src_c070_3_09 mix_i_c070_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_09 (mix_q_src_c070_3_09 0 bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_3_09 (mix_q_src_c070_3_09 mix_q_c070_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_10 (mix_i_src_c070_3_10 0 bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c070_3_10 (mix_i_src_c070_3_10 mix_i_c070_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_10 (mix_q_src_c070_3_10 0 bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_3_10 (mix_q_src_c070_3_10 mix_q_c070_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_11 (mix_i_src_c070_3_11 0 bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c070_3_11 (mix_i_src_c070_3_11 mix_i_c070_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_11 (mix_q_src_c070_3_11 0 bpf_c070_3 0) vcvs gain=-9.807852804032e-01
