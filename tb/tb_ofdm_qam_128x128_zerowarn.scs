SMIXI_c028_0_09 (mix_i_src_c028_0_09 mix_i_c028_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_09 (mix_q_src_c028_0_09 0 bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_0_09 (mix_q_src_c028_0_09 mix_q_c028_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_10 (mix_i_src_c028_0_10 0 bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_0_10 (mix_i_src_c028_0_10 mix_i_c028_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_10 (mix_q_src_c028_0_10 0 bpf_c028_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_0_10 (mix_q_src_c028_0_10 mix_q_c028_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_11 (mix_i_src_c028_0_11 0 bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_0_11 (mix_i_src_c028_0_11 mix_i_c028_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_11 (mix_q_src_c028_0_11 0 bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_0_11 (mix_q_src_c028_0_11 mix_q_c028_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_12 (mix_i_src_c028_0_12 0 bpf_c028_0 0) vcvs gain=1.950903220161e-01
SMIXI_c028_0_12 (mix_i_src_c028_0_12 mix_i_c028_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_12 (mix_q_src_c028_0_12 0 bpf_c028_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_0_12 (mix_q_src_c028_0_12 mix_q_c028_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_13 (mix_i_src_c028_0_13 0 bpf_c028_0 0) vcvs gain=5.555702330196e-01
SMIXI_c028_0_13 (mix_i_src_c028_0_13 mix_i_c028_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_13 (mix_q_src_c028_0_13 0 bpf_c028_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_0_13 (mix_q_src_c028_0_13 mix_q_c028_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_14 (mix_i_src_c028_0_14 0 bpf_c028_0 0) vcvs gain=8.314696123025e-01
SMIXI_c028_0_14 (mix_i_src_c028_0_14 mix_i_c028_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_14 (mix_q_src_c028_0_14 0 bpf_c028_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_0_14 (mix_q_src_c028_0_14 mix_q_c028_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_0_15 (mix_i_src_c028_0_15 0 bpf_c028_0 0) vcvs gain=9.807852804032e-01
SMIXI_c028_0_15 (mix_i_src_c028_0_15 mix_i_c028_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_0_15 (mix_q_src_c028_0_15 0 bpf_c028_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_0_15 (mix_q_src_c028_0_15 mix_q_c028_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c028_0 (mix_i_c028_0 0) resistor r=1G
RMIXQ_c028_0 (mix_q_c028_0 0) resistor r=1G
RINTI_c028_0 (mix_i_c028_0 Icar_c028_0) resistor r=1k
CINTI_c028_0 (Icar_c028_0 0) capacitor c=80p
RINTQ_c028_0 (mix_q_c028_0 Qcar_c028_0) resistor r=1k
CINTQ_c028_0 (Qcar_c028_0 0) capacitor c=80p

// bl028, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c028_1 (bl028 n_cbpf_c028_1) capacitor c=1.013211836423e-13
LBPF_c028_1 (n_cbpf_c028_1 bpf_c028_1) inductor l=1.000000000000e-06
RBPF_c028_1 (bpf_c028_1 0) resistor r=1.570796326795e+02
EMIXI_c028_1_00 (mix_i_src_c028_1_00 0 bpf_c028_1 0) vcvs gain=9.807852804032e-01
SMIXI_c028_1_00 (mix_i_src_c028_1_00 mix_i_c028_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_00 (mix_q_src_c028_1_00 0 bpf_c028_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_1_00 (mix_q_src_c028_1_00 mix_q_c028_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_01 (mix_i_src_c028_1_01 0 bpf_c028_1 0) vcvs gain=8.314696123025e-01
SMIXI_c028_1_01 (mix_i_src_c028_1_01 mix_i_c028_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_01 (mix_q_src_c028_1_01 0 bpf_c028_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_1_01 (mix_q_src_c028_1_01 mix_q_c028_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_02 (mix_i_src_c028_1_02 0 bpf_c028_1 0) vcvs gain=5.555702330196e-01
SMIXI_c028_1_02 (mix_i_src_c028_1_02 mix_i_c028_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_02 (mix_q_src_c028_1_02 0 bpf_c028_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_1_02 (mix_q_src_c028_1_02 mix_q_c028_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_03 (mix_i_src_c028_1_03 0 bpf_c028_1 0) vcvs gain=1.950903220161e-01
SMIXI_c028_1_03 (mix_i_src_c028_1_03 mix_i_c028_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_03 (mix_q_src_c028_1_03 0 bpf_c028_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_1_03 (mix_q_src_c028_1_03 mix_q_c028_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_04 (mix_i_src_c028_1_04 0 bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_1_04 (mix_i_src_c028_1_04 mix_i_c028_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_04 (mix_q_src_c028_1_04 0 bpf_c028_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_1_04 (mix_q_src_c028_1_04 mix_q_c028_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_05 (mix_i_src_c028_1_05 0 bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_1_05 (mix_i_src_c028_1_05 mix_i_c028_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_05 (mix_q_src_c028_1_05 0 bpf_c028_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_1_05 (mix_q_src_c028_1_05 mix_q_c028_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_06 (mix_i_src_c028_1_06 0 bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c028_1_06 (mix_i_src_c028_1_06 mix_i_c028_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_06 (mix_q_src_c028_1_06 0 bpf_c028_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_1_06 (mix_q_src_c028_1_06 mix_q_c028_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_07 (mix_i_src_c028_1_07 0 bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_1_07 (mix_i_src_c028_1_07 mix_i_c028_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_07 (mix_q_src_c028_1_07 0 bpf_c028_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_1_07 (mix_q_src_c028_1_07 mix_q_c028_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_08 (mix_i_src_c028_1_08 0 bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_1_08 (mix_i_src_c028_1_08 mix_i_c028_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_08 (mix_q_src_c028_1_08 0 bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_1_08 (mix_q_src_c028_1_08 mix_q_c028_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_09 (mix_i_src_c028_1_09 0 bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c028_1_09 (mix_i_src_c028_1_09 mix_i_c028_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_09 (mix_q_src_c028_1_09 0 bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_1_09 (mix_q_src_c028_1_09 mix_q_c028_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_10 (mix_i_src_c028_1_10 0 bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_1_10 (mix_i_src_c028_1_10 mix_i_c028_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_10 (mix_q_src_c028_1_10 0 bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_1_10 (mix_q_src_c028_1_10 mix_q_c028_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_11 (mix_i_src_c028_1_11 0 bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_1_11 (mix_i_src_c028_1_11 mix_i_c028_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_11 (mix_q_src_c028_1_11 0 bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_1_11 (mix_q_src_c028_1_11 mix_q_c028_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_12 (mix_i_src_c028_1_12 0 bpf_c028_1 0) vcvs gain=1.950903220161e-01
SMIXI_c028_1_12 (mix_i_src_c028_1_12 mix_i_c028_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_12 (mix_q_src_c028_1_12 0 bpf_c028_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_1_12 (mix_q_src_c028_1_12 mix_q_c028_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_13 (mix_i_src_c028_1_13 0 bpf_c028_1 0) vcvs gain=5.555702330196e-01
SMIXI_c028_1_13 (mix_i_src_c028_1_13 mix_i_c028_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_13 (mix_q_src_c028_1_13 0 bpf_c028_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_1_13 (mix_q_src_c028_1_13 mix_q_c028_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_14 (mix_i_src_c028_1_14 0 bpf_c028_1 0) vcvs gain=8.314696123025e-01
SMIXI_c028_1_14 (mix_i_src_c028_1_14 mix_i_c028_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_14 (mix_q_src_c028_1_14 0 bpf_c028_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_1_14 (mix_q_src_c028_1_14 mix_q_c028_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_1_15 (mix_i_src_c028_1_15 0 bpf_c028_1 0) vcvs gain=9.807852804032e-01
SMIXI_c028_1_15 (mix_i_src_c028_1_15 mix_i_c028_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_1_15 (mix_q_src_c028_1_15 0 bpf_c028_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_1_15 (mix_q_src_c028_1_15 mix_q_c028_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c028_1 (mix_i_c028_1 0) resistor r=1G
RMIXQ_c028_1 (mix_q_c028_1 0) resistor r=1G
RINTI_c028_1 (mix_i_c028_1 Icar_c028_1) resistor r=1k
CINTI_c028_1 (Icar_c028_1 0) capacitor c=80p
RINTQ_c028_1 (mix_q_c028_1 Qcar_c028_1) resistor r=1k
CINTQ_c028_1 (Qcar_c028_1 0) capacitor c=80p

// bl028, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c028_2 (bl028 n_cbpf_c028_2) capacitor c=4.503163717437e-14
LBPF_c028_2 (n_cbpf_c028_2 bpf_c028_2) inductor l=1.000000000000e-06
RBPF_c028_2 (bpf_c028_2 0) resistor r=2.356194490192e+02
EMIXI_c028_2_00 (mix_i_src_c028_2_00 0 bpf_c028_2 0) vcvs gain=9.807852804032e-01
SMIXI_c028_2_00 (mix_i_src_c028_2_00 mix_i_c028_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_00 (mix_q_src_c028_2_00 0 bpf_c028_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_2_00 (mix_q_src_c028_2_00 mix_q_c028_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_01 (mix_i_src_c028_2_01 0 bpf_c028_2 0) vcvs gain=8.314696123025e-01
SMIXI_c028_2_01 (mix_i_src_c028_2_01 mix_i_c028_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_01 (mix_q_src_c028_2_01 0 bpf_c028_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_2_01 (mix_q_src_c028_2_01 mix_q_c028_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_02 (mix_i_src_c028_2_02 0 bpf_c028_2 0) vcvs gain=5.555702330196e-01
SMIXI_c028_2_02 (mix_i_src_c028_2_02 mix_i_c028_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_02 (mix_q_src_c028_2_02 0 bpf_c028_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_2_02 (mix_q_src_c028_2_02 mix_q_c028_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_03 (mix_i_src_c028_2_03 0 bpf_c028_2 0) vcvs gain=1.950903220161e-01
SMIXI_c028_2_03 (mix_i_src_c028_2_03 mix_i_c028_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_03 (mix_q_src_c028_2_03 0 bpf_c028_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_2_03 (mix_q_src_c028_2_03 mix_q_c028_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_04 (mix_i_src_c028_2_04 0 bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_2_04 (mix_i_src_c028_2_04 mix_i_c028_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_04 (mix_q_src_c028_2_04 0 bpf_c028_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_2_04 (mix_q_src_c028_2_04 mix_q_c028_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_05 (mix_i_src_c028_2_05 0 bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_2_05 (mix_i_src_c028_2_05 mix_i_c028_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_05 (mix_q_src_c028_2_05 0 bpf_c028_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_2_05 (mix_q_src_c028_2_05 mix_q_c028_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_06 (mix_i_src_c028_2_06 0 bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c028_2_06 (mix_i_src_c028_2_06 mix_i_c028_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_06 (mix_q_src_c028_2_06 0 bpf_c028_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_2_06 (mix_q_src_c028_2_06 mix_q_c028_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_07 (mix_i_src_c028_2_07 0 bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_2_07 (mix_i_src_c028_2_07 mix_i_c028_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_07 (mix_q_src_c028_2_07 0 bpf_c028_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_2_07 (mix_q_src_c028_2_07 mix_q_c028_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_08 (mix_i_src_c028_2_08 0 bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_2_08 (mix_i_src_c028_2_08 mix_i_c028_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_08 (mix_q_src_c028_2_08 0 bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_2_08 (mix_q_src_c028_2_08 mix_q_c028_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_09 (mix_i_src_c028_2_09 0 bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c028_2_09 (mix_i_src_c028_2_09 mix_i_c028_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_09 (mix_q_src_c028_2_09 0 bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_2_09 (mix_q_src_c028_2_09 mix_q_c028_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_10 (mix_i_src_c028_2_10 0 bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_2_10 (mix_i_src_c028_2_10 mix_i_c028_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_10 (mix_q_src_c028_2_10 0 bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_2_10 (mix_q_src_c028_2_10 mix_q_c028_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_11 (mix_i_src_c028_2_11 0 bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_2_11 (mix_i_src_c028_2_11 mix_i_c028_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_11 (mix_q_src_c028_2_11 0 bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_2_11 (mix_q_src_c028_2_11 mix_q_c028_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_12 (mix_i_src_c028_2_12 0 bpf_c028_2 0) vcvs gain=1.950903220161e-01
SMIXI_c028_2_12 (mix_i_src_c028_2_12 mix_i_c028_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_12 (mix_q_src_c028_2_12 0 bpf_c028_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_2_12 (mix_q_src_c028_2_12 mix_q_c028_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_13 (mix_i_src_c028_2_13 0 bpf_c028_2 0) vcvs gain=5.555702330196e-01
SMIXI_c028_2_13 (mix_i_src_c028_2_13 mix_i_c028_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_13 (mix_q_src_c028_2_13 0 bpf_c028_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_2_13 (mix_q_src_c028_2_13 mix_q_c028_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_14 (mix_i_src_c028_2_14 0 bpf_c028_2 0) vcvs gain=8.314696123025e-01
SMIXI_c028_2_14 (mix_i_src_c028_2_14 mix_i_c028_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_14 (mix_q_src_c028_2_14 0 bpf_c028_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_2_14 (mix_q_src_c028_2_14 mix_q_c028_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_2_15 (mix_i_src_c028_2_15 0 bpf_c028_2 0) vcvs gain=9.807852804032e-01
SMIXI_c028_2_15 (mix_i_src_c028_2_15 mix_i_c028_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_2_15 (mix_q_src_c028_2_15 0 bpf_c028_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_2_15 (mix_q_src_c028_2_15 mix_q_c028_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c028_2 (mix_i_c028_2 0) resistor r=1G
RMIXQ_c028_2 (mix_q_c028_2 0) resistor r=1G
RINTI_c028_2 (mix_i_c028_2 Icar_c028_2) resistor r=1k
CINTI_c028_2 (Icar_c028_2 0) capacitor c=80p
RINTQ_c028_2 (mix_q_c028_2 Qcar_c028_2) resistor r=1k
CINTQ_c028_2 (Qcar_c028_2 0) capacitor c=80p

// bl028, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c028_3 (bl028 n_cbpf_c028_3) capacitor c=2.533029591058e-14
LBPF_c028_3 (n_cbpf_c028_3 bpf_c028_3) inductor l=1.000000000000e-06
RBPF_c028_3 (bpf_c028_3 0) resistor r=3.141592653590e+02
EMIXI_c028_3_00 (mix_i_src_c028_3_00 0 bpf_c028_3 0) vcvs gain=9.807852804032e-01
SMIXI_c028_3_00 (mix_i_src_c028_3_00 mix_i_c028_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_00 (mix_q_src_c028_3_00 0 bpf_c028_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_3_00 (mix_q_src_c028_3_00 mix_q_c028_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_01 (mix_i_src_c028_3_01 0 bpf_c028_3 0) vcvs gain=8.314696123025e-01
SMIXI_c028_3_01 (mix_i_src_c028_3_01 mix_i_c028_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_01 (mix_q_src_c028_3_01 0 bpf_c028_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_3_01 (mix_q_src_c028_3_01 mix_q_c028_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_02 (mix_i_src_c028_3_02 0 bpf_c028_3 0) vcvs gain=5.555702330196e-01
SMIXI_c028_3_02 (mix_i_src_c028_3_02 mix_i_c028_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_02 (mix_q_src_c028_3_02 0 bpf_c028_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_3_02 (mix_q_src_c028_3_02 mix_q_c028_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_03 (mix_i_src_c028_3_03 0 bpf_c028_3 0) vcvs gain=1.950903220161e-01
SMIXI_c028_3_03 (mix_i_src_c028_3_03 mix_i_c028_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_03 (mix_q_src_c028_3_03 0 bpf_c028_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_3_03 (mix_q_src_c028_3_03 mix_q_c028_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_04 (mix_i_src_c028_3_04 0 bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_3_04 (mix_i_src_c028_3_04 mix_i_c028_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_04 (mix_q_src_c028_3_04 0 bpf_c028_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c028_3_04 (mix_q_src_c028_3_04 mix_q_c028_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_05 (mix_i_src_c028_3_05 0 bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_3_05 (mix_i_src_c028_3_05 mix_i_c028_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_05 (mix_q_src_c028_3_05 0 bpf_c028_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c028_3_05 (mix_q_src_c028_3_05 mix_q_c028_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_06 (mix_i_src_c028_3_06 0 bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c028_3_06 (mix_i_src_c028_3_06 mix_i_c028_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_06 (mix_q_src_c028_3_06 0 bpf_c028_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c028_3_06 (mix_q_src_c028_3_06 mix_q_c028_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_07 (mix_i_src_c028_3_07 0 bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_3_07 (mix_i_src_c028_3_07 mix_i_c028_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_07 (mix_q_src_c028_3_07 0 bpf_c028_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c028_3_07 (mix_q_src_c028_3_07 mix_q_c028_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_08 (mix_i_src_c028_3_08 0 bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c028_3_08 (mix_i_src_c028_3_08 mix_i_c028_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_08 (mix_q_src_c028_3_08 0 bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_3_08 (mix_q_src_c028_3_08 mix_q_c028_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_09 (mix_i_src_c028_3_09 0 bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c028_3_09 (mix_i_src_c028_3_09 mix_i_c028_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_09 (mix_q_src_c028_3_09 0 bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_3_09 (mix_q_src_c028_3_09 mix_q_c028_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_10 (mix_i_src_c028_3_10 0 bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c028_3_10 (mix_i_src_c028_3_10 mix_i_c028_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_10 (mix_q_src_c028_3_10 0 bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_3_10 (mix_q_src_c028_3_10 mix_q_c028_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_11 (mix_i_src_c028_3_11 0 bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c028_3_11 (mix_i_src_c028_3_11 mix_i_c028_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_11 (mix_q_src_c028_3_11 0 bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_3_11 (mix_q_src_c028_3_11 mix_q_c028_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_12 (mix_i_src_c028_3_12 0 bpf_c028_3 0) vcvs gain=1.950903220161e-01
SMIXI_c028_3_12 (mix_i_src_c028_3_12 mix_i_c028_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_12 (mix_q_src_c028_3_12 0 bpf_c028_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c028_3_12 (mix_q_src_c028_3_12 mix_q_c028_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_13 (mix_i_src_c028_3_13 0 bpf_c028_3 0) vcvs gain=5.555702330196e-01
SMIXI_c028_3_13 (mix_i_src_c028_3_13 mix_i_c028_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_13 (mix_q_src_c028_3_13 0 bpf_c028_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c028_3_13 (mix_q_src_c028_3_13 mix_q_c028_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_14 (mix_i_src_c028_3_14 0 bpf_c028_3 0) vcvs gain=8.314696123025e-01
SMIXI_c028_3_14 (mix_i_src_c028_3_14 mix_i_c028_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_14 (mix_q_src_c028_3_14 0 bpf_c028_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c028_3_14 (mix_q_src_c028_3_14 mix_q_c028_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c028_3_15 (mix_i_src_c028_3_15 0 bpf_c028_3 0) vcvs gain=9.807852804032e-01
SMIXI_c028_3_15 (mix_i_src_c028_3_15 mix_i_c028_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c028_3_15 (mix_q_src_c028_3_15 0 bpf_c028_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c028_3_15 (mix_q_src_c028_3_15 mix_q_c028_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c028_3 (mix_i_c028_3 0) resistor r=1G
RMIXQ_c028_3 (mix_q_c028_3 0) resistor r=1G
RINTI_c028_3 (mix_i_c028_3 Icar_c028_3) resistor r=1k
CINTI_c028_3 (Icar_c028_3 0) capacitor c=80p
RINTQ_c028_3 (mix_q_c028_3 Qcar_c028_3) resistor r=1k
CINTQ_c028_3 (Qcar_c028_3 0) capacitor c=80p

// bl029, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c029_0 (bl029 n_cbpf_c029_0) capacitor c=4.052847345694e-13
LBPF_c029_0 (n_cbpf_c029_0 bpf_c029_0) inductor l=1.000000000000e-06
RBPF_c029_0 (bpf_c029_0 0) resistor r=7.853981633974e+01
EMIXI_c029_0_00 (mix_i_src_c029_0_00 0 bpf_c029_0 0) vcvs gain=9.807852804032e-01
SMIXI_c029_0_00 (mix_i_src_c029_0_00 mix_i_c029_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_00 (mix_q_src_c029_0_00 0 bpf_c029_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_0_00 (mix_q_src_c029_0_00 mix_q_c029_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_01 (mix_i_src_c029_0_01 0 bpf_c029_0 0) vcvs gain=8.314696123025e-01
SMIXI_c029_0_01 (mix_i_src_c029_0_01 mix_i_c029_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_01 (mix_q_src_c029_0_01 0 bpf_c029_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_0_01 (mix_q_src_c029_0_01 mix_q_c029_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_02 (mix_i_src_c029_0_02 0 bpf_c029_0 0) vcvs gain=5.555702330196e-01
SMIXI_c029_0_02 (mix_i_src_c029_0_02 mix_i_c029_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_02 (mix_q_src_c029_0_02 0 bpf_c029_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_0_02 (mix_q_src_c029_0_02 mix_q_c029_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_03 (mix_i_src_c029_0_03 0 bpf_c029_0 0) vcvs gain=1.950903220161e-01
SMIXI_c029_0_03 (mix_i_src_c029_0_03 mix_i_c029_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_03 (mix_q_src_c029_0_03 0 bpf_c029_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_0_03 (mix_q_src_c029_0_03 mix_q_c029_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_04 (mix_i_src_c029_0_04 0 bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_0_04 (mix_i_src_c029_0_04 mix_i_c029_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_04 (mix_q_src_c029_0_04 0 bpf_c029_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_0_04 (mix_q_src_c029_0_04 mix_q_c029_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_05 (mix_i_src_c029_0_05 0 bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_0_05 (mix_i_src_c029_0_05 mix_i_c029_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_05 (mix_q_src_c029_0_05 0 bpf_c029_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_0_05 (mix_q_src_c029_0_05 mix_q_c029_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_06 (mix_i_src_c029_0_06 0 bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_0_06 (mix_i_src_c029_0_06 mix_i_c029_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_06 (mix_q_src_c029_0_06 0 bpf_c029_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_0_06 (mix_q_src_c029_0_06 mix_q_c029_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_07 (mix_i_src_c029_0_07 0 bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_0_07 (mix_i_src_c029_0_07 mix_i_c029_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_07 (mix_q_src_c029_0_07 0 bpf_c029_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_0_07 (mix_q_src_c029_0_07 mix_q_c029_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_08 (mix_i_src_c029_0_08 0 bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_0_08 (mix_i_src_c029_0_08 mix_i_c029_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_08 (mix_q_src_c029_0_08 0 bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_0_08 (mix_q_src_c029_0_08 mix_q_c029_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_09 (mix_i_src_c029_0_09 0 bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_0_09 (mix_i_src_c029_0_09 mix_i_c029_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_09 (mix_q_src_c029_0_09 0 bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_0_09 (mix_q_src_c029_0_09 mix_q_c029_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_10 (mix_i_src_c029_0_10 0 bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_0_10 (mix_i_src_c029_0_10 mix_i_c029_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_10 (mix_q_src_c029_0_10 0 bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_0_10 (mix_q_src_c029_0_10 mix_q_c029_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_11 (mix_i_src_c029_0_11 0 bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_0_11 (mix_i_src_c029_0_11 mix_i_c029_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_11 (mix_q_src_c029_0_11 0 bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_0_11 (mix_q_src_c029_0_11 mix_q_c029_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_12 (mix_i_src_c029_0_12 0 bpf_c029_0 0) vcvs gain=1.950903220161e-01
SMIXI_c029_0_12 (mix_i_src_c029_0_12 mix_i_c029_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_12 (mix_q_src_c029_0_12 0 bpf_c029_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_0_12 (mix_q_src_c029_0_12 mix_q_c029_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_13 (mix_i_src_c029_0_13 0 bpf_c029_0 0) vcvs gain=5.555702330196e-01
SMIXI_c029_0_13 (mix_i_src_c029_0_13 mix_i_c029_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_13 (mix_q_src_c029_0_13 0 bpf_c029_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_0_13 (mix_q_src_c029_0_13 mix_q_c029_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_14 (mix_i_src_c029_0_14 0 bpf_c029_0 0) vcvs gain=8.314696123025e-01
SMIXI_c029_0_14 (mix_i_src_c029_0_14 mix_i_c029_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_14 (mix_q_src_c029_0_14 0 bpf_c029_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_0_14 (mix_q_src_c029_0_14 mix_q_c029_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_0_15 (mix_i_src_c029_0_15 0 bpf_c029_0 0) vcvs gain=9.807852804032e-01
SMIXI_c029_0_15 (mix_i_src_c029_0_15 mix_i_c029_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_0_15 (mix_q_src_c029_0_15 0 bpf_c029_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_0_15 (mix_q_src_c029_0_15 mix_q_c029_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c029_0 (mix_i_c029_0 0) resistor r=1G
RMIXQ_c029_0 (mix_q_c029_0 0) resistor r=1G
RINTI_c029_0 (mix_i_c029_0 Icar_c029_0) resistor r=1k
CINTI_c029_0 (Icar_c029_0 0) capacitor c=80p
RINTQ_c029_0 (mix_q_c029_0 Qcar_c029_0) resistor r=1k
CINTQ_c029_0 (Qcar_c029_0 0) capacitor c=80p

// bl029, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c029_1 (bl029 n_cbpf_c029_1) capacitor c=1.013211836423e-13
LBPF_c029_1 (n_cbpf_c029_1 bpf_c029_1) inductor l=1.000000000000e-06
RBPF_c029_1 (bpf_c029_1 0) resistor r=1.570796326795e+02
EMIXI_c029_1_00 (mix_i_src_c029_1_00 0 bpf_c029_1 0) vcvs gain=9.807852804032e-01
SMIXI_c029_1_00 (mix_i_src_c029_1_00 mix_i_c029_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_00 (mix_q_src_c029_1_00 0 bpf_c029_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_1_00 (mix_q_src_c029_1_00 mix_q_c029_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_01 (mix_i_src_c029_1_01 0 bpf_c029_1 0) vcvs gain=8.314696123025e-01
SMIXI_c029_1_01 (mix_i_src_c029_1_01 mix_i_c029_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_01 (mix_q_src_c029_1_01 0 bpf_c029_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_1_01 (mix_q_src_c029_1_01 mix_q_c029_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_02 (mix_i_src_c029_1_02 0 bpf_c029_1 0) vcvs gain=5.555702330196e-01
SMIXI_c029_1_02 (mix_i_src_c029_1_02 mix_i_c029_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_02 (mix_q_src_c029_1_02 0 bpf_c029_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_1_02 (mix_q_src_c029_1_02 mix_q_c029_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_03 (mix_i_src_c029_1_03 0 bpf_c029_1 0) vcvs gain=1.950903220161e-01
SMIXI_c029_1_03 (mix_i_src_c029_1_03 mix_i_c029_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_03 (mix_q_src_c029_1_03 0 bpf_c029_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_1_03 (mix_q_src_c029_1_03 mix_q_c029_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_04 (mix_i_src_c029_1_04 0 bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_1_04 (mix_i_src_c029_1_04 mix_i_c029_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_04 (mix_q_src_c029_1_04 0 bpf_c029_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_1_04 (mix_q_src_c029_1_04 mix_q_c029_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_05 (mix_i_src_c029_1_05 0 bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_1_05 (mix_i_src_c029_1_05 mix_i_c029_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_05 (mix_q_src_c029_1_05 0 bpf_c029_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_1_05 (mix_q_src_c029_1_05 mix_q_c029_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_06 (mix_i_src_c029_1_06 0 bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_1_06 (mix_i_src_c029_1_06 mix_i_c029_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_06 (mix_q_src_c029_1_06 0 bpf_c029_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_1_06 (mix_q_src_c029_1_06 mix_q_c029_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_07 (mix_i_src_c029_1_07 0 bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_1_07 (mix_i_src_c029_1_07 mix_i_c029_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_07 (mix_q_src_c029_1_07 0 bpf_c029_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_1_07 (mix_q_src_c029_1_07 mix_q_c029_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_08 (mix_i_src_c029_1_08 0 bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_1_08 (mix_i_src_c029_1_08 mix_i_c029_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_08 (mix_q_src_c029_1_08 0 bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_1_08 (mix_q_src_c029_1_08 mix_q_c029_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_09 (mix_i_src_c029_1_09 0 bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_1_09 (mix_i_src_c029_1_09 mix_i_c029_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_09 (mix_q_src_c029_1_09 0 bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_1_09 (mix_q_src_c029_1_09 mix_q_c029_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_10 (mix_i_src_c029_1_10 0 bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_1_10 (mix_i_src_c029_1_10 mix_i_c029_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_10 (mix_q_src_c029_1_10 0 bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_1_10 (mix_q_src_c029_1_10 mix_q_c029_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_11 (mix_i_src_c029_1_11 0 bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_1_11 (mix_i_src_c029_1_11 mix_i_c029_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_11 (mix_q_src_c029_1_11 0 bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_1_11 (mix_q_src_c029_1_11 mix_q_c029_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_12 (mix_i_src_c029_1_12 0 bpf_c029_1 0) vcvs gain=1.950903220161e-01
SMIXI_c029_1_12 (mix_i_src_c029_1_12 mix_i_c029_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_12 (mix_q_src_c029_1_12 0 bpf_c029_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_1_12 (mix_q_src_c029_1_12 mix_q_c029_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_13 (mix_i_src_c029_1_13 0 bpf_c029_1 0) vcvs gain=5.555702330196e-01
SMIXI_c029_1_13 (mix_i_src_c029_1_13 mix_i_c029_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_13 (mix_q_src_c029_1_13 0 bpf_c029_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_1_13 (mix_q_src_c029_1_13 mix_q_c029_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_14 (mix_i_src_c029_1_14 0 bpf_c029_1 0) vcvs gain=8.314696123025e-01
SMIXI_c029_1_14 (mix_i_src_c029_1_14 mix_i_c029_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_14 (mix_q_src_c029_1_14 0 bpf_c029_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_1_14 (mix_q_src_c029_1_14 mix_q_c029_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_1_15 (mix_i_src_c029_1_15 0 bpf_c029_1 0) vcvs gain=9.807852804032e-01
SMIXI_c029_1_15 (mix_i_src_c029_1_15 mix_i_c029_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_1_15 (mix_q_src_c029_1_15 0 bpf_c029_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_1_15 (mix_q_src_c029_1_15 mix_q_c029_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c029_1 (mix_i_c029_1 0) resistor r=1G
RMIXQ_c029_1 (mix_q_c029_1 0) resistor r=1G
RINTI_c029_1 (mix_i_c029_1 Icar_c029_1) resistor r=1k
CINTI_c029_1 (Icar_c029_1 0) capacitor c=80p
RINTQ_c029_1 (mix_q_c029_1 Qcar_c029_1) resistor r=1k
CINTQ_c029_1 (Qcar_c029_1 0) capacitor c=80p

// bl029, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c029_2 (bl029 n_cbpf_c029_2) capacitor c=4.503163717437e-14
LBPF_c029_2 (n_cbpf_c029_2 bpf_c029_2) inductor l=1.000000000000e-06
RBPF_c029_2 (bpf_c029_2 0) resistor r=2.356194490192e+02
EMIXI_c029_2_00 (mix_i_src_c029_2_00 0 bpf_c029_2 0) vcvs gain=9.807852804032e-01
SMIXI_c029_2_00 (mix_i_src_c029_2_00 mix_i_c029_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_00 (mix_q_src_c029_2_00 0 bpf_c029_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_2_00 (mix_q_src_c029_2_00 mix_q_c029_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_01 (mix_i_src_c029_2_01 0 bpf_c029_2 0) vcvs gain=8.314696123025e-01
SMIXI_c029_2_01 (mix_i_src_c029_2_01 mix_i_c029_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_01 (mix_q_src_c029_2_01 0 bpf_c029_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_2_01 (mix_q_src_c029_2_01 mix_q_c029_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_02 (mix_i_src_c029_2_02 0 bpf_c029_2 0) vcvs gain=5.555702330196e-01
SMIXI_c029_2_02 (mix_i_src_c029_2_02 mix_i_c029_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_02 (mix_q_src_c029_2_02 0 bpf_c029_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_2_02 (mix_q_src_c029_2_02 mix_q_c029_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_03 (mix_i_src_c029_2_03 0 bpf_c029_2 0) vcvs gain=1.950903220161e-01
SMIXI_c029_2_03 (mix_i_src_c029_2_03 mix_i_c029_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_03 (mix_q_src_c029_2_03 0 bpf_c029_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_2_03 (mix_q_src_c029_2_03 mix_q_c029_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_04 (mix_i_src_c029_2_04 0 bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_2_04 (mix_i_src_c029_2_04 mix_i_c029_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_04 (mix_q_src_c029_2_04 0 bpf_c029_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_2_04 (mix_q_src_c029_2_04 mix_q_c029_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_05 (mix_i_src_c029_2_05 0 bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_2_05 (mix_i_src_c029_2_05 mix_i_c029_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_05 (mix_q_src_c029_2_05 0 bpf_c029_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_2_05 (mix_q_src_c029_2_05 mix_q_c029_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_06 (mix_i_src_c029_2_06 0 bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_2_06 (mix_i_src_c029_2_06 mix_i_c029_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_06 (mix_q_src_c029_2_06 0 bpf_c029_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_2_06 (mix_q_src_c029_2_06 mix_q_c029_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_07 (mix_i_src_c029_2_07 0 bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_2_07 (mix_i_src_c029_2_07 mix_i_c029_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_07 (mix_q_src_c029_2_07 0 bpf_c029_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_2_07 (mix_q_src_c029_2_07 mix_q_c029_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_08 (mix_i_src_c029_2_08 0 bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_2_08 (mix_i_src_c029_2_08 mix_i_c029_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_08 (mix_q_src_c029_2_08 0 bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_2_08 (mix_q_src_c029_2_08 mix_q_c029_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_09 (mix_i_src_c029_2_09 0 bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_2_09 (mix_i_src_c029_2_09 mix_i_c029_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_09 (mix_q_src_c029_2_09 0 bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_2_09 (mix_q_src_c029_2_09 mix_q_c029_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_10 (mix_i_src_c029_2_10 0 bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_2_10 (mix_i_src_c029_2_10 mix_i_c029_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_10 (mix_q_src_c029_2_10 0 bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_2_10 (mix_q_src_c029_2_10 mix_q_c029_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_11 (mix_i_src_c029_2_11 0 bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_2_11 (mix_i_src_c029_2_11 mix_i_c029_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_11 (mix_q_src_c029_2_11 0 bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_2_11 (mix_q_src_c029_2_11 mix_q_c029_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_12 (mix_i_src_c029_2_12 0 bpf_c029_2 0) vcvs gain=1.950903220161e-01
SMIXI_c029_2_12 (mix_i_src_c029_2_12 mix_i_c029_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_12 (mix_q_src_c029_2_12 0 bpf_c029_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_2_12 (mix_q_src_c029_2_12 mix_q_c029_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_13 (mix_i_src_c029_2_13 0 bpf_c029_2 0) vcvs gain=5.555702330196e-01
SMIXI_c029_2_13 (mix_i_src_c029_2_13 mix_i_c029_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_13 (mix_q_src_c029_2_13 0 bpf_c029_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_2_13 (mix_q_src_c029_2_13 mix_q_c029_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_14 (mix_i_src_c029_2_14 0 bpf_c029_2 0) vcvs gain=8.314696123025e-01
SMIXI_c029_2_14 (mix_i_src_c029_2_14 mix_i_c029_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_14 (mix_q_src_c029_2_14 0 bpf_c029_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_2_14 (mix_q_src_c029_2_14 mix_q_c029_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_2_15 (mix_i_src_c029_2_15 0 bpf_c029_2 0) vcvs gain=9.807852804032e-01
SMIXI_c029_2_15 (mix_i_src_c029_2_15 mix_i_c029_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_2_15 (mix_q_src_c029_2_15 0 bpf_c029_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_2_15 (mix_q_src_c029_2_15 mix_q_c029_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c029_2 (mix_i_c029_2 0) resistor r=1G
RMIXQ_c029_2 (mix_q_c029_2 0) resistor r=1G
RINTI_c029_2 (mix_i_c029_2 Icar_c029_2) resistor r=1k
CINTI_c029_2 (Icar_c029_2 0) capacitor c=80p
RINTQ_c029_2 (mix_q_c029_2 Qcar_c029_2) resistor r=1k
CINTQ_c029_2 (Qcar_c029_2 0) capacitor c=80p

// bl029, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c029_3 (bl029 n_cbpf_c029_3) capacitor c=2.533029591058e-14
LBPF_c029_3 (n_cbpf_c029_3 bpf_c029_3) inductor l=1.000000000000e-06
RBPF_c029_3 (bpf_c029_3 0) resistor r=3.141592653590e+02
EMIXI_c029_3_00 (mix_i_src_c029_3_00 0 bpf_c029_3 0) vcvs gain=9.807852804032e-01
SMIXI_c029_3_00 (mix_i_src_c029_3_00 mix_i_c029_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_00 (mix_q_src_c029_3_00 0 bpf_c029_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_3_00 (mix_q_src_c029_3_00 mix_q_c029_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_01 (mix_i_src_c029_3_01 0 bpf_c029_3 0) vcvs gain=8.314696123025e-01
SMIXI_c029_3_01 (mix_i_src_c029_3_01 mix_i_c029_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_01 (mix_q_src_c029_3_01 0 bpf_c029_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_3_01 (mix_q_src_c029_3_01 mix_q_c029_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_02 (mix_i_src_c029_3_02 0 bpf_c029_3 0) vcvs gain=5.555702330196e-01
SMIXI_c029_3_02 (mix_i_src_c029_3_02 mix_i_c029_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_02 (mix_q_src_c029_3_02 0 bpf_c029_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_3_02 (mix_q_src_c029_3_02 mix_q_c029_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_03 (mix_i_src_c029_3_03 0 bpf_c029_3 0) vcvs gain=1.950903220161e-01
SMIXI_c029_3_03 (mix_i_src_c029_3_03 mix_i_c029_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_03 (mix_q_src_c029_3_03 0 bpf_c029_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_3_03 (mix_q_src_c029_3_03 mix_q_c029_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_04 (mix_i_src_c029_3_04 0 bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_3_04 (mix_i_src_c029_3_04 mix_i_c029_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_04 (mix_q_src_c029_3_04 0 bpf_c029_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c029_3_04 (mix_q_src_c029_3_04 mix_q_c029_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_05 (mix_i_src_c029_3_05 0 bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_3_05 (mix_i_src_c029_3_05 mix_i_c029_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_05 (mix_q_src_c029_3_05 0 bpf_c029_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c029_3_05 (mix_q_src_c029_3_05 mix_q_c029_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_06 (mix_i_src_c029_3_06 0 bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_3_06 (mix_i_src_c029_3_06 mix_i_c029_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_06 (mix_q_src_c029_3_06 0 bpf_c029_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c029_3_06 (mix_q_src_c029_3_06 mix_q_c029_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_07 (mix_i_src_c029_3_07 0 bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_3_07 (mix_i_src_c029_3_07 mix_i_c029_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_07 (mix_q_src_c029_3_07 0 bpf_c029_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c029_3_07 (mix_q_src_c029_3_07 mix_q_c029_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_08 (mix_i_src_c029_3_08 0 bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c029_3_08 (mix_i_src_c029_3_08 mix_i_c029_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_08 (mix_q_src_c029_3_08 0 bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_3_08 (mix_q_src_c029_3_08 mix_q_c029_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_09 (mix_i_src_c029_3_09 0 bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c029_3_09 (mix_i_src_c029_3_09 mix_i_c029_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_09 (mix_q_src_c029_3_09 0 bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_3_09 (mix_q_src_c029_3_09 mix_q_c029_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_10 (mix_i_src_c029_3_10 0 bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c029_3_10 (mix_i_src_c029_3_10 mix_i_c029_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_10 (mix_q_src_c029_3_10 0 bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_3_10 (mix_q_src_c029_3_10 mix_q_c029_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_11 (mix_i_src_c029_3_11 0 bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c029_3_11 (mix_i_src_c029_3_11 mix_i_c029_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_11 (mix_q_src_c029_3_11 0 bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_3_11 (mix_q_src_c029_3_11 mix_q_c029_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_12 (mix_i_src_c029_3_12 0 bpf_c029_3 0) vcvs gain=1.950903220161e-01
SMIXI_c029_3_12 (mix_i_src_c029_3_12 mix_i_c029_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_12 (mix_q_src_c029_3_12 0 bpf_c029_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c029_3_12 (mix_q_src_c029_3_12 mix_q_c029_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_13 (mix_i_src_c029_3_13 0 bpf_c029_3 0) vcvs gain=5.555702330196e-01
SMIXI_c029_3_13 (mix_i_src_c029_3_13 mix_i_c029_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_13 (mix_q_src_c029_3_13 0 bpf_c029_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c029_3_13 (mix_q_src_c029_3_13 mix_q_c029_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_14 (mix_i_src_c029_3_14 0 bpf_c029_3 0) vcvs gain=8.314696123025e-01
SMIXI_c029_3_14 (mix_i_src_c029_3_14 mix_i_c029_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_14 (mix_q_src_c029_3_14 0 bpf_c029_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c029_3_14 (mix_q_src_c029_3_14 mix_q_c029_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c029_3_15 (mix_i_src_c029_3_15 0 bpf_c029_3 0) vcvs gain=9.807852804032e-01
SMIXI_c029_3_15 (mix_i_src_c029_3_15 mix_i_c029_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c029_3_15 (mix_q_src_c029_3_15 0 bpf_c029_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c029_3_15 (mix_q_src_c029_3_15 mix_q_c029_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c029_3 (mix_i_c029_3 0) resistor r=1G
RMIXQ_c029_3 (mix_q_c029_3 0) resistor r=1G
RINTI_c029_3 (mix_i_c029_3 Icar_c029_3) resistor r=1k
CINTI_c029_3 (Icar_c029_3 0) capacitor c=80p
RINTQ_c029_3 (mix_q_c029_3 Qcar_c029_3) resistor r=1k
CINTQ_c029_3 (Qcar_c029_3 0) capacitor c=80p

// bl030, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c030_0 (bl030 n_cbpf_c030_0) capacitor c=4.052847345694e-13
LBPF_c030_0 (n_cbpf_c030_0 bpf_c030_0) inductor l=1.000000000000e-06
RBPF_c030_0 (bpf_c030_0 0) resistor r=7.853981633974e+01
EMIXI_c030_0_00 (mix_i_src_c030_0_00 0 bpf_c030_0 0) vcvs gain=9.807852804032e-01
SMIXI_c030_0_00 (mix_i_src_c030_0_00 mix_i_c030_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_00 (mix_q_src_c030_0_00 0 bpf_c030_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_0_00 (mix_q_src_c030_0_00 mix_q_c030_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_01 (mix_i_src_c030_0_01 0 bpf_c030_0 0) vcvs gain=8.314696123025e-01
SMIXI_c030_0_01 (mix_i_src_c030_0_01 mix_i_c030_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_01 (mix_q_src_c030_0_01 0 bpf_c030_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_0_01 (mix_q_src_c030_0_01 mix_q_c030_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_02 (mix_i_src_c030_0_02 0 bpf_c030_0 0) vcvs gain=5.555702330196e-01
SMIXI_c030_0_02 (mix_i_src_c030_0_02 mix_i_c030_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_02 (mix_q_src_c030_0_02 0 bpf_c030_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_0_02 (mix_q_src_c030_0_02 mix_q_c030_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_03 (mix_i_src_c030_0_03 0 bpf_c030_0 0) vcvs gain=1.950903220161e-01
SMIXI_c030_0_03 (mix_i_src_c030_0_03 mix_i_c030_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_03 (mix_q_src_c030_0_03 0 bpf_c030_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_0_03 (mix_q_src_c030_0_03 mix_q_c030_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_04 (mix_i_src_c030_0_04 0 bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_0_04 (mix_i_src_c030_0_04 mix_i_c030_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_04 (mix_q_src_c030_0_04 0 bpf_c030_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_0_04 (mix_q_src_c030_0_04 mix_q_c030_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_05 (mix_i_src_c030_0_05 0 bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_0_05 (mix_i_src_c030_0_05 mix_i_c030_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_05 (mix_q_src_c030_0_05 0 bpf_c030_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_0_05 (mix_q_src_c030_0_05 mix_q_c030_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_06 (mix_i_src_c030_0_06 0 bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_0_06 (mix_i_src_c030_0_06 mix_i_c030_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_06 (mix_q_src_c030_0_06 0 bpf_c030_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_0_06 (mix_q_src_c030_0_06 mix_q_c030_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_07 (mix_i_src_c030_0_07 0 bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_0_07 (mix_i_src_c030_0_07 mix_i_c030_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_07 (mix_q_src_c030_0_07 0 bpf_c030_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_0_07 (mix_q_src_c030_0_07 mix_q_c030_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_08 (mix_i_src_c030_0_08 0 bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_0_08 (mix_i_src_c030_0_08 mix_i_c030_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_08 (mix_q_src_c030_0_08 0 bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_0_08 (mix_q_src_c030_0_08 mix_q_c030_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_09 (mix_i_src_c030_0_09 0 bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_0_09 (mix_i_src_c030_0_09 mix_i_c030_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_09 (mix_q_src_c030_0_09 0 bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_0_09 (mix_q_src_c030_0_09 mix_q_c030_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_10 (mix_i_src_c030_0_10 0 bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_0_10 (mix_i_src_c030_0_10 mix_i_c030_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_10 (mix_q_src_c030_0_10 0 bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_0_10 (mix_q_src_c030_0_10 mix_q_c030_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_11 (mix_i_src_c030_0_11 0 bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_0_11 (mix_i_src_c030_0_11 mix_i_c030_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_11 (mix_q_src_c030_0_11 0 bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_0_11 (mix_q_src_c030_0_11 mix_q_c030_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_12 (mix_i_src_c030_0_12 0 bpf_c030_0 0) vcvs gain=1.950903220161e-01
SMIXI_c030_0_12 (mix_i_src_c030_0_12 mix_i_c030_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_12 (mix_q_src_c030_0_12 0 bpf_c030_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_0_12 (mix_q_src_c030_0_12 mix_q_c030_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_13 (mix_i_src_c030_0_13 0 bpf_c030_0 0) vcvs gain=5.555702330196e-01
SMIXI_c030_0_13 (mix_i_src_c030_0_13 mix_i_c030_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_13 (mix_q_src_c030_0_13 0 bpf_c030_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_0_13 (mix_q_src_c030_0_13 mix_q_c030_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_14 (mix_i_src_c030_0_14 0 bpf_c030_0 0) vcvs gain=8.314696123025e-01
SMIXI_c030_0_14 (mix_i_src_c030_0_14 mix_i_c030_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_14 (mix_q_src_c030_0_14 0 bpf_c030_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_0_14 (mix_q_src_c030_0_14 mix_q_c030_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_0_15 (mix_i_src_c030_0_15 0 bpf_c030_0 0) vcvs gain=9.807852804032e-01
SMIXI_c030_0_15 (mix_i_src_c030_0_15 mix_i_c030_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_0_15 (mix_q_src_c030_0_15 0 bpf_c030_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_0_15 (mix_q_src_c030_0_15 mix_q_c030_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c030_0 (mix_i_c030_0 0) resistor r=1G
RMIXQ_c030_0 (mix_q_c030_0 0) resistor r=1G
RINTI_c030_0 (mix_i_c030_0 Icar_c030_0) resistor r=1k
CINTI_c030_0 (Icar_c030_0 0) capacitor c=80p
RINTQ_c030_0 (mix_q_c030_0 Qcar_c030_0) resistor r=1k
CINTQ_c030_0 (Qcar_c030_0 0) capacitor c=80p

// bl030, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c030_1 (bl030 n_cbpf_c030_1) capacitor c=1.013211836423e-13
LBPF_c030_1 (n_cbpf_c030_1 bpf_c030_1) inductor l=1.000000000000e-06
RBPF_c030_1 (bpf_c030_1 0) resistor r=1.570796326795e+02
EMIXI_c030_1_00 (mix_i_src_c030_1_00 0 bpf_c030_1 0) vcvs gain=9.807852804032e-01
SMIXI_c030_1_00 (mix_i_src_c030_1_00 mix_i_c030_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_00 (mix_q_src_c030_1_00 0 bpf_c030_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_1_00 (mix_q_src_c030_1_00 mix_q_c030_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_01 (mix_i_src_c030_1_01 0 bpf_c030_1 0) vcvs gain=8.314696123025e-01
SMIXI_c030_1_01 (mix_i_src_c030_1_01 mix_i_c030_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_01 (mix_q_src_c030_1_01 0 bpf_c030_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_1_01 (mix_q_src_c030_1_01 mix_q_c030_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_02 (mix_i_src_c030_1_02 0 bpf_c030_1 0) vcvs gain=5.555702330196e-01
SMIXI_c030_1_02 (mix_i_src_c030_1_02 mix_i_c030_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_02 (mix_q_src_c030_1_02 0 bpf_c030_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_1_02 (mix_q_src_c030_1_02 mix_q_c030_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_03 (mix_i_src_c030_1_03 0 bpf_c030_1 0) vcvs gain=1.950903220161e-01
SMIXI_c030_1_03 (mix_i_src_c030_1_03 mix_i_c030_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_03 (mix_q_src_c030_1_03 0 bpf_c030_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_1_03 (mix_q_src_c030_1_03 mix_q_c030_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_04 (mix_i_src_c030_1_04 0 bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_1_04 (mix_i_src_c030_1_04 mix_i_c030_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_04 (mix_q_src_c030_1_04 0 bpf_c030_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_1_04 (mix_q_src_c030_1_04 mix_q_c030_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_05 (mix_i_src_c030_1_05 0 bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_1_05 (mix_i_src_c030_1_05 mix_i_c030_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_05 (mix_q_src_c030_1_05 0 bpf_c030_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_1_05 (mix_q_src_c030_1_05 mix_q_c030_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_06 (mix_i_src_c030_1_06 0 bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_1_06 (mix_i_src_c030_1_06 mix_i_c030_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_06 (mix_q_src_c030_1_06 0 bpf_c030_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_1_06 (mix_q_src_c030_1_06 mix_q_c030_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_07 (mix_i_src_c030_1_07 0 bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_1_07 (mix_i_src_c030_1_07 mix_i_c030_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_07 (mix_q_src_c030_1_07 0 bpf_c030_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_1_07 (mix_q_src_c030_1_07 mix_q_c030_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_08 (mix_i_src_c030_1_08 0 bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_1_08 (mix_i_src_c030_1_08 mix_i_c030_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_08 (mix_q_src_c030_1_08 0 bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_1_08 (mix_q_src_c030_1_08 mix_q_c030_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_09 (mix_i_src_c030_1_09 0 bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_1_09 (mix_i_src_c030_1_09 mix_i_c030_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_09 (mix_q_src_c030_1_09 0 bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_1_09 (mix_q_src_c030_1_09 mix_q_c030_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_10 (mix_i_src_c030_1_10 0 bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_1_10 (mix_i_src_c030_1_10 mix_i_c030_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_10 (mix_q_src_c030_1_10 0 bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_1_10 (mix_q_src_c030_1_10 mix_q_c030_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_11 (mix_i_src_c030_1_11 0 bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_1_11 (mix_i_src_c030_1_11 mix_i_c030_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_11 (mix_q_src_c030_1_11 0 bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_1_11 (mix_q_src_c030_1_11 mix_q_c030_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_12 (mix_i_src_c030_1_12 0 bpf_c030_1 0) vcvs gain=1.950903220161e-01
SMIXI_c030_1_12 (mix_i_src_c030_1_12 mix_i_c030_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_12 (mix_q_src_c030_1_12 0 bpf_c030_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_1_12 (mix_q_src_c030_1_12 mix_q_c030_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_13 (mix_i_src_c030_1_13 0 bpf_c030_1 0) vcvs gain=5.555702330196e-01
SMIXI_c030_1_13 (mix_i_src_c030_1_13 mix_i_c030_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_13 (mix_q_src_c030_1_13 0 bpf_c030_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_1_13 (mix_q_src_c030_1_13 mix_q_c030_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_14 (mix_i_src_c030_1_14 0 bpf_c030_1 0) vcvs gain=8.314696123025e-01
SMIXI_c030_1_14 (mix_i_src_c030_1_14 mix_i_c030_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_14 (mix_q_src_c030_1_14 0 bpf_c030_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_1_14 (mix_q_src_c030_1_14 mix_q_c030_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_1_15 (mix_i_src_c030_1_15 0 bpf_c030_1 0) vcvs gain=9.807852804032e-01
SMIXI_c030_1_15 (mix_i_src_c030_1_15 mix_i_c030_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_1_15 (mix_q_src_c030_1_15 0 bpf_c030_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_1_15 (mix_q_src_c030_1_15 mix_q_c030_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c030_1 (mix_i_c030_1 0) resistor r=1G
RMIXQ_c030_1 (mix_q_c030_1 0) resistor r=1G
RINTI_c030_1 (mix_i_c030_1 Icar_c030_1) resistor r=1k
CINTI_c030_1 (Icar_c030_1 0) capacitor c=80p
RINTQ_c030_1 (mix_q_c030_1 Qcar_c030_1) resistor r=1k
CINTQ_c030_1 (Qcar_c030_1 0) capacitor c=80p

// bl030, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c030_2 (bl030 n_cbpf_c030_2) capacitor c=4.503163717437e-14
LBPF_c030_2 (n_cbpf_c030_2 bpf_c030_2) inductor l=1.000000000000e-06
RBPF_c030_2 (bpf_c030_2 0) resistor r=2.356194490192e+02
EMIXI_c030_2_00 (mix_i_src_c030_2_00 0 bpf_c030_2 0) vcvs gain=9.807852804032e-01
SMIXI_c030_2_00 (mix_i_src_c030_2_00 mix_i_c030_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_00 (mix_q_src_c030_2_00 0 bpf_c030_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_2_00 (mix_q_src_c030_2_00 mix_q_c030_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_01 (mix_i_src_c030_2_01 0 bpf_c030_2 0) vcvs gain=8.314696123025e-01
SMIXI_c030_2_01 (mix_i_src_c030_2_01 mix_i_c030_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_01 (mix_q_src_c030_2_01 0 bpf_c030_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_2_01 (mix_q_src_c030_2_01 mix_q_c030_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_02 (mix_i_src_c030_2_02 0 bpf_c030_2 0) vcvs gain=5.555702330196e-01
SMIXI_c030_2_02 (mix_i_src_c030_2_02 mix_i_c030_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_02 (mix_q_src_c030_2_02 0 bpf_c030_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_2_02 (mix_q_src_c030_2_02 mix_q_c030_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_03 (mix_i_src_c030_2_03 0 bpf_c030_2 0) vcvs gain=1.950903220161e-01
SMIXI_c030_2_03 (mix_i_src_c030_2_03 mix_i_c030_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_03 (mix_q_src_c030_2_03 0 bpf_c030_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_2_03 (mix_q_src_c030_2_03 mix_q_c030_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_04 (mix_i_src_c030_2_04 0 bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_2_04 (mix_i_src_c030_2_04 mix_i_c030_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_04 (mix_q_src_c030_2_04 0 bpf_c030_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_2_04 (mix_q_src_c030_2_04 mix_q_c030_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_05 (mix_i_src_c030_2_05 0 bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_2_05 (mix_i_src_c030_2_05 mix_i_c030_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_05 (mix_q_src_c030_2_05 0 bpf_c030_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_2_05 (mix_q_src_c030_2_05 mix_q_c030_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_06 (mix_i_src_c030_2_06 0 bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_2_06 (mix_i_src_c030_2_06 mix_i_c030_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_06 (mix_q_src_c030_2_06 0 bpf_c030_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_2_06 (mix_q_src_c030_2_06 mix_q_c030_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_07 (mix_i_src_c030_2_07 0 bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_2_07 (mix_i_src_c030_2_07 mix_i_c030_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_07 (mix_q_src_c030_2_07 0 bpf_c030_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_2_07 (mix_q_src_c030_2_07 mix_q_c030_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_08 (mix_i_src_c030_2_08 0 bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_2_08 (mix_i_src_c030_2_08 mix_i_c030_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_08 (mix_q_src_c030_2_08 0 bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_2_08 (mix_q_src_c030_2_08 mix_q_c030_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_09 (mix_i_src_c030_2_09 0 bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_2_09 (mix_i_src_c030_2_09 mix_i_c030_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_09 (mix_q_src_c030_2_09 0 bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_2_09 (mix_q_src_c030_2_09 mix_q_c030_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_10 (mix_i_src_c030_2_10 0 bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_2_10 (mix_i_src_c030_2_10 mix_i_c030_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_10 (mix_q_src_c030_2_10 0 bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_2_10 (mix_q_src_c030_2_10 mix_q_c030_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_11 (mix_i_src_c030_2_11 0 bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_2_11 (mix_i_src_c030_2_11 mix_i_c030_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_11 (mix_q_src_c030_2_11 0 bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_2_11 (mix_q_src_c030_2_11 mix_q_c030_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_12 (mix_i_src_c030_2_12 0 bpf_c030_2 0) vcvs gain=1.950903220161e-01
SMIXI_c030_2_12 (mix_i_src_c030_2_12 mix_i_c030_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_12 (mix_q_src_c030_2_12 0 bpf_c030_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_2_12 (mix_q_src_c030_2_12 mix_q_c030_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_13 (mix_i_src_c030_2_13 0 bpf_c030_2 0) vcvs gain=5.555702330196e-01
SMIXI_c030_2_13 (mix_i_src_c030_2_13 mix_i_c030_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_13 (mix_q_src_c030_2_13 0 bpf_c030_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_2_13 (mix_q_src_c030_2_13 mix_q_c030_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_14 (mix_i_src_c030_2_14 0 bpf_c030_2 0) vcvs gain=8.314696123025e-01
SMIXI_c030_2_14 (mix_i_src_c030_2_14 mix_i_c030_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_14 (mix_q_src_c030_2_14 0 bpf_c030_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_2_14 (mix_q_src_c030_2_14 mix_q_c030_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_2_15 (mix_i_src_c030_2_15 0 bpf_c030_2 0) vcvs gain=9.807852804032e-01
SMIXI_c030_2_15 (mix_i_src_c030_2_15 mix_i_c030_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_2_15 (mix_q_src_c030_2_15 0 bpf_c030_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_2_15 (mix_q_src_c030_2_15 mix_q_c030_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c030_2 (mix_i_c030_2 0) resistor r=1G
RMIXQ_c030_2 (mix_q_c030_2 0) resistor r=1G
RINTI_c030_2 (mix_i_c030_2 Icar_c030_2) resistor r=1k
CINTI_c030_2 (Icar_c030_2 0) capacitor c=80p
RINTQ_c030_2 (mix_q_c030_2 Qcar_c030_2) resistor r=1k
CINTQ_c030_2 (Qcar_c030_2 0) capacitor c=80p

// bl030, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c030_3 (bl030 n_cbpf_c030_3) capacitor c=2.533029591058e-14
LBPF_c030_3 (n_cbpf_c030_3 bpf_c030_3) inductor l=1.000000000000e-06
RBPF_c030_3 (bpf_c030_3 0) resistor r=3.141592653590e+02
EMIXI_c030_3_00 (mix_i_src_c030_3_00 0 bpf_c030_3 0) vcvs gain=9.807852804032e-01
SMIXI_c030_3_00 (mix_i_src_c030_3_00 mix_i_c030_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_00 (mix_q_src_c030_3_00 0 bpf_c030_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_3_00 (mix_q_src_c030_3_00 mix_q_c030_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_01 (mix_i_src_c030_3_01 0 bpf_c030_3 0) vcvs gain=8.314696123025e-01
SMIXI_c030_3_01 (mix_i_src_c030_3_01 mix_i_c030_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_01 (mix_q_src_c030_3_01 0 bpf_c030_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_3_01 (mix_q_src_c030_3_01 mix_q_c030_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_02 (mix_i_src_c030_3_02 0 bpf_c030_3 0) vcvs gain=5.555702330196e-01
SMIXI_c030_3_02 (mix_i_src_c030_3_02 mix_i_c030_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_02 (mix_q_src_c030_3_02 0 bpf_c030_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_3_02 (mix_q_src_c030_3_02 mix_q_c030_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_03 (mix_i_src_c030_3_03 0 bpf_c030_3 0) vcvs gain=1.950903220161e-01
SMIXI_c030_3_03 (mix_i_src_c030_3_03 mix_i_c030_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_03 (mix_q_src_c030_3_03 0 bpf_c030_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_3_03 (mix_q_src_c030_3_03 mix_q_c030_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_04 (mix_i_src_c030_3_04 0 bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_3_04 (mix_i_src_c030_3_04 mix_i_c030_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_04 (mix_q_src_c030_3_04 0 bpf_c030_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c030_3_04 (mix_q_src_c030_3_04 mix_q_c030_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_05 (mix_i_src_c030_3_05 0 bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_3_05 (mix_i_src_c030_3_05 mix_i_c030_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_05 (mix_q_src_c030_3_05 0 bpf_c030_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c030_3_05 (mix_q_src_c030_3_05 mix_q_c030_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_06 (mix_i_src_c030_3_06 0 bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_3_06 (mix_i_src_c030_3_06 mix_i_c030_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_06 (mix_q_src_c030_3_06 0 bpf_c030_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c030_3_06 (mix_q_src_c030_3_06 mix_q_c030_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_07 (mix_i_src_c030_3_07 0 bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_3_07 (mix_i_src_c030_3_07 mix_i_c030_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_07 (mix_q_src_c030_3_07 0 bpf_c030_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c030_3_07 (mix_q_src_c030_3_07 mix_q_c030_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_08 (mix_i_src_c030_3_08 0 bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c030_3_08 (mix_i_src_c030_3_08 mix_i_c030_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_08 (mix_q_src_c030_3_08 0 bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_3_08 (mix_q_src_c030_3_08 mix_q_c030_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_09 (mix_i_src_c030_3_09 0 bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c030_3_09 (mix_i_src_c030_3_09 mix_i_c030_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_09 (mix_q_src_c030_3_09 0 bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_3_09 (mix_q_src_c030_3_09 mix_q_c030_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_10 (mix_i_src_c030_3_10 0 bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c030_3_10 (mix_i_src_c030_3_10 mix_i_c030_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_10 (mix_q_src_c030_3_10 0 bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_3_10 (mix_q_src_c030_3_10 mix_q_c030_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_11 (mix_i_src_c030_3_11 0 bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c030_3_11 (mix_i_src_c030_3_11 mix_i_c030_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_11 (mix_q_src_c030_3_11 0 bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_3_11 (mix_q_src_c030_3_11 mix_q_c030_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_12 (mix_i_src_c030_3_12 0 bpf_c030_3 0) vcvs gain=1.950903220161e-01
SMIXI_c030_3_12 (mix_i_src_c030_3_12 mix_i_c030_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_12 (mix_q_src_c030_3_12 0 bpf_c030_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c030_3_12 (mix_q_src_c030_3_12 mix_q_c030_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_13 (mix_i_src_c030_3_13 0 bpf_c030_3 0) vcvs gain=5.555702330196e-01
SMIXI_c030_3_13 (mix_i_src_c030_3_13 mix_i_c030_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_13 (mix_q_src_c030_3_13 0 bpf_c030_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c030_3_13 (mix_q_src_c030_3_13 mix_q_c030_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_14 (mix_i_src_c030_3_14 0 bpf_c030_3 0) vcvs gain=8.314696123025e-01
SMIXI_c030_3_14 (mix_i_src_c030_3_14 mix_i_c030_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_14 (mix_q_src_c030_3_14 0 bpf_c030_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c030_3_14 (mix_q_src_c030_3_14 mix_q_c030_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c030_3_15 (mix_i_src_c030_3_15 0 bpf_c030_3 0) vcvs gain=9.807852804032e-01
SMIXI_c030_3_15 (mix_i_src_c030_3_15 mix_i_c030_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c030_3_15 (mix_q_src_c030_3_15 0 bpf_c030_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c030_3_15 (mix_q_src_c030_3_15 mix_q_c030_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c030_3 (mix_i_c030_3 0) resistor r=1G
RMIXQ_c030_3 (mix_q_c030_3 0) resistor r=1G
RINTI_c030_3 (mix_i_c030_3 Icar_c030_3) resistor r=1k
CINTI_c030_3 (Icar_c030_3 0) capacitor c=80p
RINTQ_c030_3 (mix_q_c030_3 Qcar_c030_3) resistor r=1k
CINTQ_c030_3 (Qcar_c030_3 0) capacitor c=80p

// bl031, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c031_0 (bl031 n_cbpf_c031_0) capacitor c=4.052847345694e-13
LBPF_c031_0 (n_cbpf_c031_0 bpf_c031_0) inductor l=1.000000000000e-06
RBPF_c031_0 (bpf_c031_0 0) resistor r=7.853981633974e+01
EMIXI_c031_0_00 (mix_i_src_c031_0_00 0 bpf_c031_0 0) vcvs gain=9.807852804032e-01
SMIXI_c031_0_00 (mix_i_src_c031_0_00 mix_i_c031_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_00 (mix_q_src_c031_0_00 0 bpf_c031_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_0_00 (mix_q_src_c031_0_00 mix_q_c031_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_01 (mix_i_src_c031_0_01 0 bpf_c031_0 0) vcvs gain=8.314696123025e-01
SMIXI_c031_0_01 (mix_i_src_c031_0_01 mix_i_c031_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_01 (mix_q_src_c031_0_01 0 bpf_c031_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_0_01 (mix_q_src_c031_0_01 mix_q_c031_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_02 (mix_i_src_c031_0_02 0 bpf_c031_0 0) vcvs gain=5.555702330196e-01
SMIXI_c031_0_02 (mix_i_src_c031_0_02 mix_i_c031_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_02 (mix_q_src_c031_0_02 0 bpf_c031_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_0_02 (mix_q_src_c031_0_02 mix_q_c031_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_03 (mix_i_src_c031_0_03 0 bpf_c031_0 0) vcvs gain=1.950903220161e-01
SMIXI_c031_0_03 (mix_i_src_c031_0_03 mix_i_c031_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_03 (mix_q_src_c031_0_03 0 bpf_c031_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_0_03 (mix_q_src_c031_0_03 mix_q_c031_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_04 (mix_i_src_c031_0_04 0 bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_0_04 (mix_i_src_c031_0_04 mix_i_c031_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_04 (mix_q_src_c031_0_04 0 bpf_c031_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_0_04 (mix_q_src_c031_0_04 mix_q_c031_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_05 (mix_i_src_c031_0_05 0 bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_0_05 (mix_i_src_c031_0_05 mix_i_c031_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_05 (mix_q_src_c031_0_05 0 bpf_c031_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_0_05 (mix_q_src_c031_0_05 mix_q_c031_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_06 (mix_i_src_c031_0_06 0 bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_0_06 (mix_i_src_c031_0_06 mix_i_c031_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_06 (mix_q_src_c031_0_06 0 bpf_c031_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_0_06 (mix_q_src_c031_0_06 mix_q_c031_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_07 (mix_i_src_c031_0_07 0 bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_0_07 (mix_i_src_c031_0_07 mix_i_c031_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_07 (mix_q_src_c031_0_07 0 bpf_c031_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_0_07 (mix_q_src_c031_0_07 mix_q_c031_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_08 (mix_i_src_c031_0_08 0 bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_0_08 (mix_i_src_c031_0_08 mix_i_c031_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_08 (mix_q_src_c031_0_08 0 bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_0_08 (mix_q_src_c031_0_08 mix_q_c031_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_09 (mix_i_src_c031_0_09 0 bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_0_09 (mix_i_src_c031_0_09 mix_i_c031_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_09 (mix_q_src_c031_0_09 0 bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_0_09 (mix_q_src_c031_0_09 mix_q_c031_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_10 (mix_i_src_c031_0_10 0 bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_0_10 (mix_i_src_c031_0_10 mix_i_c031_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_10 (mix_q_src_c031_0_10 0 bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_0_10 (mix_q_src_c031_0_10 mix_q_c031_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_11 (mix_i_src_c031_0_11 0 bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_0_11 (mix_i_src_c031_0_11 mix_i_c031_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_11 (mix_q_src_c031_0_11 0 bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_0_11 (mix_q_src_c031_0_11 mix_q_c031_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_12 (mix_i_src_c031_0_12 0 bpf_c031_0 0) vcvs gain=1.950903220161e-01
SMIXI_c031_0_12 (mix_i_src_c031_0_12 mix_i_c031_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_12 (mix_q_src_c031_0_12 0 bpf_c031_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_0_12 (mix_q_src_c031_0_12 mix_q_c031_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_13 (mix_i_src_c031_0_13 0 bpf_c031_0 0) vcvs gain=5.555702330196e-01
SMIXI_c031_0_13 (mix_i_src_c031_0_13 mix_i_c031_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_13 (mix_q_src_c031_0_13 0 bpf_c031_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_0_13 (mix_q_src_c031_0_13 mix_q_c031_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_14 (mix_i_src_c031_0_14 0 bpf_c031_0 0) vcvs gain=8.314696123025e-01
SMIXI_c031_0_14 (mix_i_src_c031_0_14 mix_i_c031_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_14 (mix_q_src_c031_0_14 0 bpf_c031_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_0_14 (mix_q_src_c031_0_14 mix_q_c031_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_0_15 (mix_i_src_c031_0_15 0 bpf_c031_0 0) vcvs gain=9.807852804032e-01
SMIXI_c031_0_15 (mix_i_src_c031_0_15 mix_i_c031_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_0_15 (mix_q_src_c031_0_15 0 bpf_c031_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_0_15 (mix_q_src_c031_0_15 mix_q_c031_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c031_0 (mix_i_c031_0 0) resistor r=1G
RMIXQ_c031_0 (mix_q_c031_0 0) resistor r=1G
RINTI_c031_0 (mix_i_c031_0 Icar_c031_0) resistor r=1k
CINTI_c031_0 (Icar_c031_0 0) capacitor c=80p
RINTQ_c031_0 (mix_q_c031_0 Qcar_c031_0) resistor r=1k
CINTQ_c031_0 (Qcar_c031_0 0) capacitor c=80p

// bl031, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c031_1 (bl031 n_cbpf_c031_1) capacitor c=1.013211836423e-13
LBPF_c031_1 (n_cbpf_c031_1 bpf_c031_1) inductor l=1.000000000000e-06
RBPF_c031_1 (bpf_c031_1 0) resistor r=1.570796326795e+02
EMIXI_c031_1_00 (mix_i_src_c031_1_00 0 bpf_c031_1 0) vcvs gain=9.807852804032e-01
SMIXI_c031_1_00 (mix_i_src_c031_1_00 mix_i_c031_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_00 (mix_q_src_c031_1_00 0 bpf_c031_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_1_00 (mix_q_src_c031_1_00 mix_q_c031_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_01 (mix_i_src_c031_1_01 0 bpf_c031_1 0) vcvs gain=8.314696123025e-01
SMIXI_c031_1_01 (mix_i_src_c031_1_01 mix_i_c031_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_01 (mix_q_src_c031_1_01 0 bpf_c031_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_1_01 (mix_q_src_c031_1_01 mix_q_c031_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_02 (mix_i_src_c031_1_02 0 bpf_c031_1 0) vcvs gain=5.555702330196e-01
SMIXI_c031_1_02 (mix_i_src_c031_1_02 mix_i_c031_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_02 (mix_q_src_c031_1_02 0 bpf_c031_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_1_02 (mix_q_src_c031_1_02 mix_q_c031_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_03 (mix_i_src_c031_1_03 0 bpf_c031_1 0) vcvs gain=1.950903220161e-01
SMIXI_c031_1_03 (mix_i_src_c031_1_03 mix_i_c031_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_03 (mix_q_src_c031_1_03 0 bpf_c031_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_1_03 (mix_q_src_c031_1_03 mix_q_c031_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_04 (mix_i_src_c031_1_04 0 bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_1_04 (mix_i_src_c031_1_04 mix_i_c031_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_04 (mix_q_src_c031_1_04 0 bpf_c031_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_1_04 (mix_q_src_c031_1_04 mix_q_c031_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_05 (mix_i_src_c031_1_05 0 bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_1_05 (mix_i_src_c031_1_05 mix_i_c031_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_05 (mix_q_src_c031_1_05 0 bpf_c031_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_1_05 (mix_q_src_c031_1_05 mix_q_c031_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_06 (mix_i_src_c031_1_06 0 bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_1_06 (mix_i_src_c031_1_06 mix_i_c031_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_06 (mix_q_src_c031_1_06 0 bpf_c031_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_1_06 (mix_q_src_c031_1_06 mix_q_c031_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_07 (mix_i_src_c031_1_07 0 bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_1_07 (mix_i_src_c031_1_07 mix_i_c031_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_07 (mix_q_src_c031_1_07 0 bpf_c031_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_1_07 (mix_q_src_c031_1_07 mix_q_c031_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_08 (mix_i_src_c031_1_08 0 bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_1_08 (mix_i_src_c031_1_08 mix_i_c031_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_08 (mix_q_src_c031_1_08 0 bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_1_08 (mix_q_src_c031_1_08 mix_q_c031_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_09 (mix_i_src_c031_1_09 0 bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_1_09 (mix_i_src_c031_1_09 mix_i_c031_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_09 (mix_q_src_c031_1_09 0 bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_1_09 (mix_q_src_c031_1_09 mix_q_c031_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_10 (mix_i_src_c031_1_10 0 bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_1_10 (mix_i_src_c031_1_10 mix_i_c031_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_10 (mix_q_src_c031_1_10 0 bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_1_10 (mix_q_src_c031_1_10 mix_q_c031_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_11 (mix_i_src_c031_1_11 0 bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_1_11 (mix_i_src_c031_1_11 mix_i_c031_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_11 (mix_q_src_c031_1_11 0 bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_1_11 (mix_q_src_c031_1_11 mix_q_c031_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_12 (mix_i_src_c031_1_12 0 bpf_c031_1 0) vcvs gain=1.950903220161e-01
SMIXI_c031_1_12 (mix_i_src_c031_1_12 mix_i_c031_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_12 (mix_q_src_c031_1_12 0 bpf_c031_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_1_12 (mix_q_src_c031_1_12 mix_q_c031_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_13 (mix_i_src_c031_1_13 0 bpf_c031_1 0) vcvs gain=5.555702330196e-01
SMIXI_c031_1_13 (mix_i_src_c031_1_13 mix_i_c031_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_13 (mix_q_src_c031_1_13 0 bpf_c031_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_1_13 (mix_q_src_c031_1_13 mix_q_c031_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_14 (mix_i_src_c031_1_14 0 bpf_c031_1 0) vcvs gain=8.314696123025e-01
SMIXI_c031_1_14 (mix_i_src_c031_1_14 mix_i_c031_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_14 (mix_q_src_c031_1_14 0 bpf_c031_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_1_14 (mix_q_src_c031_1_14 mix_q_c031_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_1_15 (mix_i_src_c031_1_15 0 bpf_c031_1 0) vcvs gain=9.807852804032e-01
SMIXI_c031_1_15 (mix_i_src_c031_1_15 mix_i_c031_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_1_15 (mix_q_src_c031_1_15 0 bpf_c031_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_1_15 (mix_q_src_c031_1_15 mix_q_c031_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c031_1 (mix_i_c031_1 0) resistor r=1G
RMIXQ_c031_1 (mix_q_c031_1 0) resistor r=1G
RINTI_c031_1 (mix_i_c031_1 Icar_c031_1) resistor r=1k
CINTI_c031_1 (Icar_c031_1 0) capacitor c=80p
RINTQ_c031_1 (mix_q_c031_1 Qcar_c031_1) resistor r=1k
CINTQ_c031_1 (Qcar_c031_1 0) capacitor c=80p

// bl031, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c031_2 (bl031 n_cbpf_c031_2) capacitor c=4.503163717437e-14
LBPF_c031_2 (n_cbpf_c031_2 bpf_c031_2) inductor l=1.000000000000e-06
RBPF_c031_2 (bpf_c031_2 0) resistor r=2.356194490192e+02
EMIXI_c031_2_00 (mix_i_src_c031_2_00 0 bpf_c031_2 0) vcvs gain=9.807852804032e-01
SMIXI_c031_2_00 (mix_i_src_c031_2_00 mix_i_c031_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_00 (mix_q_src_c031_2_00 0 bpf_c031_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_2_00 (mix_q_src_c031_2_00 mix_q_c031_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_01 (mix_i_src_c031_2_01 0 bpf_c031_2 0) vcvs gain=8.314696123025e-01
SMIXI_c031_2_01 (mix_i_src_c031_2_01 mix_i_c031_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_01 (mix_q_src_c031_2_01 0 bpf_c031_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_2_01 (mix_q_src_c031_2_01 mix_q_c031_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_02 (mix_i_src_c031_2_02 0 bpf_c031_2 0) vcvs gain=5.555702330196e-01
SMIXI_c031_2_02 (mix_i_src_c031_2_02 mix_i_c031_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_02 (mix_q_src_c031_2_02 0 bpf_c031_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_2_02 (mix_q_src_c031_2_02 mix_q_c031_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_03 (mix_i_src_c031_2_03 0 bpf_c031_2 0) vcvs gain=1.950903220161e-01
SMIXI_c031_2_03 (mix_i_src_c031_2_03 mix_i_c031_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_03 (mix_q_src_c031_2_03 0 bpf_c031_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_2_03 (mix_q_src_c031_2_03 mix_q_c031_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_04 (mix_i_src_c031_2_04 0 bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_2_04 (mix_i_src_c031_2_04 mix_i_c031_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_04 (mix_q_src_c031_2_04 0 bpf_c031_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_2_04 (mix_q_src_c031_2_04 mix_q_c031_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_05 (mix_i_src_c031_2_05 0 bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_2_05 (mix_i_src_c031_2_05 mix_i_c031_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_05 (mix_q_src_c031_2_05 0 bpf_c031_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_2_05 (mix_q_src_c031_2_05 mix_q_c031_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_06 (mix_i_src_c031_2_06 0 bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_2_06 (mix_i_src_c031_2_06 mix_i_c031_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_06 (mix_q_src_c031_2_06 0 bpf_c031_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_2_06 (mix_q_src_c031_2_06 mix_q_c031_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_07 (mix_i_src_c031_2_07 0 bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_2_07 (mix_i_src_c031_2_07 mix_i_c031_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_07 (mix_q_src_c031_2_07 0 bpf_c031_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_2_07 (mix_q_src_c031_2_07 mix_q_c031_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_08 (mix_i_src_c031_2_08 0 bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_2_08 (mix_i_src_c031_2_08 mix_i_c031_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_08 (mix_q_src_c031_2_08 0 bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_2_08 (mix_q_src_c031_2_08 mix_q_c031_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_09 (mix_i_src_c031_2_09 0 bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_2_09 (mix_i_src_c031_2_09 mix_i_c031_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_09 (mix_q_src_c031_2_09 0 bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_2_09 (mix_q_src_c031_2_09 mix_q_c031_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_10 (mix_i_src_c031_2_10 0 bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_2_10 (mix_i_src_c031_2_10 mix_i_c031_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_10 (mix_q_src_c031_2_10 0 bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_2_10 (mix_q_src_c031_2_10 mix_q_c031_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_11 (mix_i_src_c031_2_11 0 bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_2_11 (mix_i_src_c031_2_11 mix_i_c031_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_11 (mix_q_src_c031_2_11 0 bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_2_11 (mix_q_src_c031_2_11 mix_q_c031_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_12 (mix_i_src_c031_2_12 0 bpf_c031_2 0) vcvs gain=1.950903220161e-01
SMIXI_c031_2_12 (mix_i_src_c031_2_12 mix_i_c031_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_12 (mix_q_src_c031_2_12 0 bpf_c031_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_2_12 (mix_q_src_c031_2_12 mix_q_c031_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_13 (mix_i_src_c031_2_13 0 bpf_c031_2 0) vcvs gain=5.555702330196e-01
SMIXI_c031_2_13 (mix_i_src_c031_2_13 mix_i_c031_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_13 (mix_q_src_c031_2_13 0 bpf_c031_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_2_13 (mix_q_src_c031_2_13 mix_q_c031_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_14 (mix_i_src_c031_2_14 0 bpf_c031_2 0) vcvs gain=8.314696123025e-01
SMIXI_c031_2_14 (mix_i_src_c031_2_14 mix_i_c031_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_14 (mix_q_src_c031_2_14 0 bpf_c031_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_2_14 (mix_q_src_c031_2_14 mix_q_c031_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_2_15 (mix_i_src_c031_2_15 0 bpf_c031_2 0) vcvs gain=9.807852804032e-01
SMIXI_c031_2_15 (mix_i_src_c031_2_15 mix_i_c031_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_2_15 (mix_q_src_c031_2_15 0 bpf_c031_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_2_15 (mix_q_src_c031_2_15 mix_q_c031_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c031_2 (mix_i_c031_2 0) resistor r=1G
RMIXQ_c031_2 (mix_q_c031_2 0) resistor r=1G
RINTI_c031_2 (mix_i_c031_2 Icar_c031_2) resistor r=1k
CINTI_c031_2 (Icar_c031_2 0) capacitor c=80p
RINTQ_c031_2 (mix_q_c031_2 Qcar_c031_2) resistor r=1k
CINTQ_c031_2 (Qcar_c031_2 0) capacitor c=80p

// bl031, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c031_3 (bl031 n_cbpf_c031_3) capacitor c=2.533029591058e-14
LBPF_c031_3 (n_cbpf_c031_3 bpf_c031_3) inductor l=1.000000000000e-06
RBPF_c031_3 (bpf_c031_3 0) resistor r=3.141592653590e+02
EMIXI_c031_3_00 (mix_i_src_c031_3_00 0 bpf_c031_3 0) vcvs gain=9.807852804032e-01
SMIXI_c031_3_00 (mix_i_src_c031_3_00 mix_i_c031_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_00 (mix_q_src_c031_3_00 0 bpf_c031_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_3_00 (mix_q_src_c031_3_00 mix_q_c031_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_01 (mix_i_src_c031_3_01 0 bpf_c031_3 0) vcvs gain=8.314696123025e-01
SMIXI_c031_3_01 (mix_i_src_c031_3_01 mix_i_c031_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_01 (mix_q_src_c031_3_01 0 bpf_c031_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_3_01 (mix_q_src_c031_3_01 mix_q_c031_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_02 (mix_i_src_c031_3_02 0 bpf_c031_3 0) vcvs gain=5.555702330196e-01
SMIXI_c031_3_02 (mix_i_src_c031_3_02 mix_i_c031_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_02 (mix_q_src_c031_3_02 0 bpf_c031_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_3_02 (mix_q_src_c031_3_02 mix_q_c031_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_03 (mix_i_src_c031_3_03 0 bpf_c031_3 0) vcvs gain=1.950903220161e-01
SMIXI_c031_3_03 (mix_i_src_c031_3_03 mix_i_c031_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_03 (mix_q_src_c031_3_03 0 bpf_c031_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_3_03 (mix_q_src_c031_3_03 mix_q_c031_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_04 (mix_i_src_c031_3_04 0 bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_3_04 (mix_i_src_c031_3_04 mix_i_c031_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_04 (mix_q_src_c031_3_04 0 bpf_c031_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c031_3_04 (mix_q_src_c031_3_04 mix_q_c031_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_05 (mix_i_src_c031_3_05 0 bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_3_05 (mix_i_src_c031_3_05 mix_i_c031_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_05 (mix_q_src_c031_3_05 0 bpf_c031_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c031_3_05 (mix_q_src_c031_3_05 mix_q_c031_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_06 (mix_i_src_c031_3_06 0 bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_3_06 (mix_i_src_c031_3_06 mix_i_c031_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_06 (mix_q_src_c031_3_06 0 bpf_c031_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c031_3_06 (mix_q_src_c031_3_06 mix_q_c031_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_07 (mix_i_src_c031_3_07 0 bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_3_07 (mix_i_src_c031_3_07 mix_i_c031_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_07 (mix_q_src_c031_3_07 0 bpf_c031_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c031_3_07 (mix_q_src_c031_3_07 mix_q_c031_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_08 (mix_i_src_c031_3_08 0 bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c031_3_08 (mix_i_src_c031_3_08 mix_i_c031_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_08 (mix_q_src_c031_3_08 0 bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_3_08 (mix_q_src_c031_3_08 mix_q_c031_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_09 (mix_i_src_c031_3_09 0 bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c031_3_09 (mix_i_src_c031_3_09 mix_i_c031_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_09 (mix_q_src_c031_3_09 0 bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_3_09 (mix_q_src_c031_3_09 mix_q_c031_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_10 (mix_i_src_c031_3_10 0 bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c031_3_10 (mix_i_src_c031_3_10 mix_i_c031_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_10 (mix_q_src_c031_3_10 0 bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_3_10 (mix_q_src_c031_3_10 mix_q_c031_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_11 (mix_i_src_c031_3_11 0 bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c031_3_11 (mix_i_src_c031_3_11 mix_i_c031_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_11 (mix_q_src_c031_3_11 0 bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_3_11 (mix_q_src_c031_3_11 mix_q_c031_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_12 (mix_i_src_c031_3_12 0 bpf_c031_3 0) vcvs gain=1.950903220161e-01
SMIXI_c031_3_12 (mix_i_src_c031_3_12 mix_i_c031_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_12 (mix_q_src_c031_3_12 0 bpf_c031_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c031_3_12 (mix_q_src_c031_3_12 mix_q_c031_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_13 (mix_i_src_c031_3_13 0 bpf_c031_3 0) vcvs gain=5.555702330196e-01
SMIXI_c031_3_13 (mix_i_src_c031_3_13 mix_i_c031_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_13 (mix_q_src_c031_3_13 0 bpf_c031_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c031_3_13 (mix_q_src_c031_3_13 mix_q_c031_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_14 (mix_i_src_c031_3_14 0 bpf_c031_3 0) vcvs gain=8.314696123025e-01
SMIXI_c031_3_14 (mix_i_src_c031_3_14 mix_i_c031_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_14 (mix_q_src_c031_3_14 0 bpf_c031_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c031_3_14 (mix_q_src_c031_3_14 mix_q_c031_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c031_3_15 (mix_i_src_c031_3_15 0 bpf_c031_3 0) vcvs gain=9.807852804032e-01
SMIXI_c031_3_15 (mix_i_src_c031_3_15 mix_i_c031_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c031_3_15 (mix_q_src_c031_3_15 0 bpf_c031_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c031_3_15 (mix_q_src_c031_3_15 mix_q_c031_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c031_3 (mix_i_c031_3 0) resistor r=1G
RMIXQ_c031_3 (mix_q_c031_3 0) resistor r=1G
RINTI_c031_3 (mix_i_c031_3 Icar_c031_3) resistor r=1k
CINTI_c031_3 (Icar_c031_3 0) capacitor c=80p
RINTQ_c031_3 (mix_q_c031_3 Qcar_c031_3) resistor r=1k
CINTQ_c031_3 (Qcar_c031_3 0) capacitor c=80p

// bl032, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c032_0 (bl032 n_cbpf_c032_0) capacitor c=4.052847345694e-13
LBPF_c032_0 (n_cbpf_c032_0 bpf_c032_0) inductor l=1.000000000000e-06
RBPF_c032_0 (bpf_c032_0 0) resistor r=7.853981633974e+01
EMIXI_c032_0_00 (mix_i_src_c032_0_00 0 bpf_c032_0 0) vcvs gain=9.807852804032e-01
SMIXI_c032_0_00 (mix_i_src_c032_0_00 mix_i_c032_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_00 (mix_q_src_c032_0_00 0 bpf_c032_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_0_00 (mix_q_src_c032_0_00 mix_q_c032_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_01 (mix_i_src_c032_0_01 0 bpf_c032_0 0) vcvs gain=8.314696123025e-01
SMIXI_c032_0_01 (mix_i_src_c032_0_01 mix_i_c032_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_01 (mix_q_src_c032_0_01 0 bpf_c032_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_0_01 (mix_q_src_c032_0_01 mix_q_c032_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_02 (mix_i_src_c032_0_02 0 bpf_c032_0 0) vcvs gain=5.555702330196e-01
SMIXI_c032_0_02 (mix_i_src_c032_0_02 mix_i_c032_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_02 (mix_q_src_c032_0_02 0 bpf_c032_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_0_02 (mix_q_src_c032_0_02 mix_q_c032_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_03 (mix_i_src_c032_0_03 0 bpf_c032_0 0) vcvs gain=1.950903220161e-01
SMIXI_c032_0_03 (mix_i_src_c032_0_03 mix_i_c032_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_03 (mix_q_src_c032_0_03 0 bpf_c032_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_0_03 (mix_q_src_c032_0_03 mix_q_c032_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_04 (mix_i_src_c032_0_04 0 bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_0_04 (mix_i_src_c032_0_04 mix_i_c032_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_04 (mix_q_src_c032_0_04 0 bpf_c032_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_0_04 (mix_q_src_c032_0_04 mix_q_c032_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_05 (mix_i_src_c032_0_05 0 bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_0_05 (mix_i_src_c032_0_05 mix_i_c032_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_05 (mix_q_src_c032_0_05 0 bpf_c032_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_0_05 (mix_q_src_c032_0_05 mix_q_c032_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_06 (mix_i_src_c032_0_06 0 bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_0_06 (mix_i_src_c032_0_06 mix_i_c032_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_06 (mix_q_src_c032_0_06 0 bpf_c032_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_0_06 (mix_q_src_c032_0_06 mix_q_c032_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_07 (mix_i_src_c032_0_07 0 bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_0_07 (mix_i_src_c032_0_07 mix_i_c032_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_07 (mix_q_src_c032_0_07 0 bpf_c032_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_0_07 (mix_q_src_c032_0_07 mix_q_c032_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_08 (mix_i_src_c032_0_08 0 bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_0_08 (mix_i_src_c032_0_08 mix_i_c032_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_08 (mix_q_src_c032_0_08 0 bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_0_08 (mix_q_src_c032_0_08 mix_q_c032_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_09 (mix_i_src_c032_0_09 0 bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_0_09 (mix_i_src_c032_0_09 mix_i_c032_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_09 (mix_q_src_c032_0_09 0 bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_0_09 (mix_q_src_c032_0_09 mix_q_c032_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_10 (mix_i_src_c032_0_10 0 bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_0_10 (mix_i_src_c032_0_10 mix_i_c032_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_10 (mix_q_src_c032_0_10 0 bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_0_10 (mix_q_src_c032_0_10 mix_q_c032_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_11 (mix_i_src_c032_0_11 0 bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_0_11 (mix_i_src_c032_0_11 mix_i_c032_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_11 (mix_q_src_c032_0_11 0 bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_0_11 (mix_q_src_c032_0_11 mix_q_c032_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_12 (mix_i_src_c032_0_12 0 bpf_c032_0 0) vcvs gain=1.950903220161e-01
SMIXI_c032_0_12 (mix_i_src_c032_0_12 mix_i_c032_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_12 (mix_q_src_c032_0_12 0 bpf_c032_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_0_12 (mix_q_src_c032_0_12 mix_q_c032_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_13 (mix_i_src_c032_0_13 0 bpf_c032_0 0) vcvs gain=5.555702330196e-01
SMIXI_c032_0_13 (mix_i_src_c032_0_13 mix_i_c032_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_13 (mix_q_src_c032_0_13 0 bpf_c032_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_0_13 (mix_q_src_c032_0_13 mix_q_c032_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_14 (mix_i_src_c032_0_14 0 bpf_c032_0 0) vcvs gain=8.314696123025e-01
SMIXI_c032_0_14 (mix_i_src_c032_0_14 mix_i_c032_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_14 (mix_q_src_c032_0_14 0 bpf_c032_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_0_14 (mix_q_src_c032_0_14 mix_q_c032_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_0_15 (mix_i_src_c032_0_15 0 bpf_c032_0 0) vcvs gain=9.807852804032e-01
SMIXI_c032_0_15 (mix_i_src_c032_0_15 mix_i_c032_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_0_15 (mix_q_src_c032_0_15 0 bpf_c032_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_0_15 (mix_q_src_c032_0_15 mix_q_c032_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c032_0 (mix_i_c032_0 0) resistor r=1G
RMIXQ_c032_0 (mix_q_c032_0 0) resistor r=1G
RINTI_c032_0 (mix_i_c032_0 Icar_c032_0) resistor r=1k
CINTI_c032_0 (Icar_c032_0 0) capacitor c=80p
RINTQ_c032_0 (mix_q_c032_0 Qcar_c032_0) resistor r=1k
CINTQ_c032_0 (Qcar_c032_0 0) capacitor c=80p

// bl032, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c032_1 (bl032 n_cbpf_c032_1) capacitor c=1.013211836423e-13
LBPF_c032_1 (n_cbpf_c032_1 bpf_c032_1) inductor l=1.000000000000e-06
RBPF_c032_1 (bpf_c032_1 0) resistor r=1.570796326795e+02
EMIXI_c032_1_00 (mix_i_src_c032_1_00 0 bpf_c032_1 0) vcvs gain=9.807852804032e-01
SMIXI_c032_1_00 (mix_i_src_c032_1_00 mix_i_c032_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_00 (mix_q_src_c032_1_00 0 bpf_c032_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_1_00 (mix_q_src_c032_1_00 mix_q_c032_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_01 (mix_i_src_c032_1_01 0 bpf_c032_1 0) vcvs gain=8.314696123025e-01
SMIXI_c032_1_01 (mix_i_src_c032_1_01 mix_i_c032_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_01 (mix_q_src_c032_1_01 0 bpf_c032_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_1_01 (mix_q_src_c032_1_01 mix_q_c032_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_02 (mix_i_src_c032_1_02 0 bpf_c032_1 0) vcvs gain=5.555702330196e-01
SMIXI_c032_1_02 (mix_i_src_c032_1_02 mix_i_c032_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_02 (mix_q_src_c032_1_02 0 bpf_c032_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_1_02 (mix_q_src_c032_1_02 mix_q_c032_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_03 (mix_i_src_c032_1_03 0 bpf_c032_1 0) vcvs gain=1.950903220161e-01
SMIXI_c032_1_03 (mix_i_src_c032_1_03 mix_i_c032_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_03 (mix_q_src_c032_1_03 0 bpf_c032_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_1_03 (mix_q_src_c032_1_03 mix_q_c032_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_04 (mix_i_src_c032_1_04 0 bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_1_04 (mix_i_src_c032_1_04 mix_i_c032_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_04 (mix_q_src_c032_1_04 0 bpf_c032_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_1_04 (mix_q_src_c032_1_04 mix_q_c032_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_05 (mix_i_src_c032_1_05 0 bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_1_05 (mix_i_src_c032_1_05 mix_i_c032_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_05 (mix_q_src_c032_1_05 0 bpf_c032_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_1_05 (mix_q_src_c032_1_05 mix_q_c032_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_06 (mix_i_src_c032_1_06 0 bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_1_06 (mix_i_src_c032_1_06 mix_i_c032_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_06 (mix_q_src_c032_1_06 0 bpf_c032_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_1_06 (mix_q_src_c032_1_06 mix_q_c032_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_07 (mix_i_src_c032_1_07 0 bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_1_07 (mix_i_src_c032_1_07 mix_i_c032_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_07 (mix_q_src_c032_1_07 0 bpf_c032_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_1_07 (mix_q_src_c032_1_07 mix_q_c032_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_08 (mix_i_src_c032_1_08 0 bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_1_08 (mix_i_src_c032_1_08 mix_i_c032_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_08 (mix_q_src_c032_1_08 0 bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_1_08 (mix_q_src_c032_1_08 mix_q_c032_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_09 (mix_i_src_c032_1_09 0 bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_1_09 (mix_i_src_c032_1_09 mix_i_c032_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_09 (mix_q_src_c032_1_09 0 bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_1_09 (mix_q_src_c032_1_09 mix_q_c032_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_10 (mix_i_src_c032_1_10 0 bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_1_10 (mix_i_src_c032_1_10 mix_i_c032_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_10 (mix_q_src_c032_1_10 0 bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_1_10 (mix_q_src_c032_1_10 mix_q_c032_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_11 (mix_i_src_c032_1_11 0 bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_1_11 (mix_i_src_c032_1_11 mix_i_c032_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_11 (mix_q_src_c032_1_11 0 bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_1_11 (mix_q_src_c032_1_11 mix_q_c032_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_12 (mix_i_src_c032_1_12 0 bpf_c032_1 0) vcvs gain=1.950903220161e-01
SMIXI_c032_1_12 (mix_i_src_c032_1_12 mix_i_c032_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_12 (mix_q_src_c032_1_12 0 bpf_c032_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_1_12 (mix_q_src_c032_1_12 mix_q_c032_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_13 (mix_i_src_c032_1_13 0 bpf_c032_1 0) vcvs gain=5.555702330196e-01
SMIXI_c032_1_13 (mix_i_src_c032_1_13 mix_i_c032_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_13 (mix_q_src_c032_1_13 0 bpf_c032_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_1_13 (mix_q_src_c032_1_13 mix_q_c032_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_14 (mix_i_src_c032_1_14 0 bpf_c032_1 0) vcvs gain=8.314696123025e-01
SMIXI_c032_1_14 (mix_i_src_c032_1_14 mix_i_c032_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_14 (mix_q_src_c032_1_14 0 bpf_c032_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_1_14 (mix_q_src_c032_1_14 mix_q_c032_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_1_15 (mix_i_src_c032_1_15 0 bpf_c032_1 0) vcvs gain=9.807852804032e-01
SMIXI_c032_1_15 (mix_i_src_c032_1_15 mix_i_c032_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_1_15 (mix_q_src_c032_1_15 0 bpf_c032_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_1_15 (mix_q_src_c032_1_15 mix_q_c032_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c032_1 (mix_i_c032_1 0) resistor r=1G
RMIXQ_c032_1 (mix_q_c032_1 0) resistor r=1G
RINTI_c032_1 (mix_i_c032_1 Icar_c032_1) resistor r=1k
CINTI_c032_1 (Icar_c032_1 0) capacitor c=80p
RINTQ_c032_1 (mix_q_c032_1 Qcar_c032_1) resistor r=1k
CINTQ_c032_1 (Qcar_c032_1 0) capacitor c=80p

// bl032, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c032_2 (bl032 n_cbpf_c032_2) capacitor c=4.503163717437e-14
LBPF_c032_2 (n_cbpf_c032_2 bpf_c032_2) inductor l=1.000000000000e-06
RBPF_c032_2 (bpf_c032_2 0) resistor r=2.356194490192e+02
EMIXI_c032_2_00 (mix_i_src_c032_2_00 0 bpf_c032_2 0) vcvs gain=9.807852804032e-01
SMIXI_c032_2_00 (mix_i_src_c032_2_00 mix_i_c032_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_00 (mix_q_src_c032_2_00 0 bpf_c032_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_2_00 (mix_q_src_c032_2_00 mix_q_c032_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_01 (mix_i_src_c032_2_01 0 bpf_c032_2 0) vcvs gain=8.314696123025e-01
SMIXI_c032_2_01 (mix_i_src_c032_2_01 mix_i_c032_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_01 (mix_q_src_c032_2_01 0 bpf_c032_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_2_01 (mix_q_src_c032_2_01 mix_q_c032_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_02 (mix_i_src_c032_2_02 0 bpf_c032_2 0) vcvs gain=5.555702330196e-01
SMIXI_c032_2_02 (mix_i_src_c032_2_02 mix_i_c032_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_02 (mix_q_src_c032_2_02 0 bpf_c032_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_2_02 (mix_q_src_c032_2_02 mix_q_c032_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_03 (mix_i_src_c032_2_03 0 bpf_c032_2 0) vcvs gain=1.950903220161e-01
SMIXI_c032_2_03 (mix_i_src_c032_2_03 mix_i_c032_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_03 (mix_q_src_c032_2_03 0 bpf_c032_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_2_03 (mix_q_src_c032_2_03 mix_q_c032_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_04 (mix_i_src_c032_2_04 0 bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_2_04 (mix_i_src_c032_2_04 mix_i_c032_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_04 (mix_q_src_c032_2_04 0 bpf_c032_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_2_04 (mix_q_src_c032_2_04 mix_q_c032_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_05 (mix_i_src_c032_2_05 0 bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_2_05 (mix_i_src_c032_2_05 mix_i_c032_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_05 (mix_q_src_c032_2_05 0 bpf_c032_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_2_05 (mix_q_src_c032_2_05 mix_q_c032_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_06 (mix_i_src_c032_2_06 0 bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_2_06 (mix_i_src_c032_2_06 mix_i_c032_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_06 (mix_q_src_c032_2_06 0 bpf_c032_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_2_06 (mix_q_src_c032_2_06 mix_q_c032_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_07 (mix_i_src_c032_2_07 0 bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_2_07 (mix_i_src_c032_2_07 mix_i_c032_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_07 (mix_q_src_c032_2_07 0 bpf_c032_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_2_07 (mix_q_src_c032_2_07 mix_q_c032_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_08 (mix_i_src_c032_2_08 0 bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_2_08 (mix_i_src_c032_2_08 mix_i_c032_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_08 (mix_q_src_c032_2_08 0 bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_2_08 (mix_q_src_c032_2_08 mix_q_c032_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_09 (mix_i_src_c032_2_09 0 bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_2_09 (mix_i_src_c032_2_09 mix_i_c032_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_09 (mix_q_src_c032_2_09 0 bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_2_09 (mix_q_src_c032_2_09 mix_q_c032_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_10 (mix_i_src_c032_2_10 0 bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_2_10 (mix_i_src_c032_2_10 mix_i_c032_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_10 (mix_q_src_c032_2_10 0 bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_2_10 (mix_q_src_c032_2_10 mix_q_c032_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_11 (mix_i_src_c032_2_11 0 bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_2_11 (mix_i_src_c032_2_11 mix_i_c032_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_11 (mix_q_src_c032_2_11 0 bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_2_11 (mix_q_src_c032_2_11 mix_q_c032_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_12 (mix_i_src_c032_2_12 0 bpf_c032_2 0) vcvs gain=1.950903220161e-01
SMIXI_c032_2_12 (mix_i_src_c032_2_12 mix_i_c032_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_12 (mix_q_src_c032_2_12 0 bpf_c032_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_2_12 (mix_q_src_c032_2_12 mix_q_c032_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_13 (mix_i_src_c032_2_13 0 bpf_c032_2 0) vcvs gain=5.555702330196e-01
SMIXI_c032_2_13 (mix_i_src_c032_2_13 mix_i_c032_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_13 (mix_q_src_c032_2_13 0 bpf_c032_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_2_13 (mix_q_src_c032_2_13 mix_q_c032_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_14 (mix_i_src_c032_2_14 0 bpf_c032_2 0) vcvs gain=8.314696123025e-01
SMIXI_c032_2_14 (mix_i_src_c032_2_14 mix_i_c032_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_14 (mix_q_src_c032_2_14 0 bpf_c032_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_2_14 (mix_q_src_c032_2_14 mix_q_c032_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_2_15 (mix_i_src_c032_2_15 0 bpf_c032_2 0) vcvs gain=9.807852804032e-01
SMIXI_c032_2_15 (mix_i_src_c032_2_15 mix_i_c032_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_2_15 (mix_q_src_c032_2_15 0 bpf_c032_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_2_15 (mix_q_src_c032_2_15 mix_q_c032_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c032_2 (mix_i_c032_2 0) resistor r=1G
RMIXQ_c032_2 (mix_q_c032_2 0) resistor r=1G
RINTI_c032_2 (mix_i_c032_2 Icar_c032_2) resistor r=1k
CINTI_c032_2 (Icar_c032_2 0) capacitor c=80p
RINTQ_c032_2 (mix_q_c032_2 Qcar_c032_2) resistor r=1k
CINTQ_c032_2 (Qcar_c032_2 0) capacitor c=80p

// bl032, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c032_3 (bl032 n_cbpf_c032_3) capacitor c=2.533029591058e-14
LBPF_c032_3 (n_cbpf_c032_3 bpf_c032_3) inductor l=1.000000000000e-06
RBPF_c032_3 (bpf_c032_3 0) resistor r=3.141592653590e+02
EMIXI_c032_3_00 (mix_i_src_c032_3_00 0 bpf_c032_3 0) vcvs gain=9.807852804032e-01
SMIXI_c032_3_00 (mix_i_src_c032_3_00 mix_i_c032_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_00 (mix_q_src_c032_3_00 0 bpf_c032_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_3_00 (mix_q_src_c032_3_00 mix_q_c032_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_01 (mix_i_src_c032_3_01 0 bpf_c032_3 0) vcvs gain=8.314696123025e-01
SMIXI_c032_3_01 (mix_i_src_c032_3_01 mix_i_c032_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_01 (mix_q_src_c032_3_01 0 bpf_c032_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_3_01 (mix_q_src_c032_3_01 mix_q_c032_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_02 (mix_i_src_c032_3_02 0 bpf_c032_3 0) vcvs gain=5.555702330196e-01
SMIXI_c032_3_02 (mix_i_src_c032_3_02 mix_i_c032_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_02 (mix_q_src_c032_3_02 0 bpf_c032_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_3_02 (mix_q_src_c032_3_02 mix_q_c032_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_03 (mix_i_src_c032_3_03 0 bpf_c032_3 0) vcvs gain=1.950903220161e-01
SMIXI_c032_3_03 (mix_i_src_c032_3_03 mix_i_c032_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_03 (mix_q_src_c032_3_03 0 bpf_c032_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_3_03 (mix_q_src_c032_3_03 mix_q_c032_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_04 (mix_i_src_c032_3_04 0 bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_3_04 (mix_i_src_c032_3_04 mix_i_c032_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_04 (mix_q_src_c032_3_04 0 bpf_c032_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c032_3_04 (mix_q_src_c032_3_04 mix_q_c032_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_05 (mix_i_src_c032_3_05 0 bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_3_05 (mix_i_src_c032_3_05 mix_i_c032_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_05 (mix_q_src_c032_3_05 0 bpf_c032_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c032_3_05 (mix_q_src_c032_3_05 mix_q_c032_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_06 (mix_i_src_c032_3_06 0 bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_3_06 (mix_i_src_c032_3_06 mix_i_c032_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_06 (mix_q_src_c032_3_06 0 bpf_c032_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c032_3_06 (mix_q_src_c032_3_06 mix_q_c032_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_07 (mix_i_src_c032_3_07 0 bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_3_07 (mix_i_src_c032_3_07 mix_i_c032_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_07 (mix_q_src_c032_3_07 0 bpf_c032_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c032_3_07 (mix_q_src_c032_3_07 mix_q_c032_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_08 (mix_i_src_c032_3_08 0 bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c032_3_08 (mix_i_src_c032_3_08 mix_i_c032_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_08 (mix_q_src_c032_3_08 0 bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_3_08 (mix_q_src_c032_3_08 mix_q_c032_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_09 (mix_i_src_c032_3_09 0 bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c032_3_09 (mix_i_src_c032_3_09 mix_i_c032_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_09 (mix_q_src_c032_3_09 0 bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_3_09 (mix_q_src_c032_3_09 mix_q_c032_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_10 (mix_i_src_c032_3_10 0 bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c032_3_10 (mix_i_src_c032_3_10 mix_i_c032_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_10 (mix_q_src_c032_3_10 0 bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_3_10 (mix_q_src_c032_3_10 mix_q_c032_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_11 (mix_i_src_c032_3_11 0 bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c032_3_11 (mix_i_src_c032_3_11 mix_i_c032_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_11 (mix_q_src_c032_3_11 0 bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_3_11 (mix_q_src_c032_3_11 mix_q_c032_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_12 (mix_i_src_c032_3_12 0 bpf_c032_3 0) vcvs gain=1.950903220161e-01
SMIXI_c032_3_12 (mix_i_src_c032_3_12 mix_i_c032_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_12 (mix_q_src_c032_3_12 0 bpf_c032_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c032_3_12 (mix_q_src_c032_3_12 mix_q_c032_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_13 (mix_i_src_c032_3_13 0 bpf_c032_3 0) vcvs gain=5.555702330196e-01
SMIXI_c032_3_13 (mix_i_src_c032_3_13 mix_i_c032_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_13 (mix_q_src_c032_3_13 0 bpf_c032_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c032_3_13 (mix_q_src_c032_3_13 mix_q_c032_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_14 (mix_i_src_c032_3_14 0 bpf_c032_3 0) vcvs gain=8.314696123025e-01
SMIXI_c032_3_14 (mix_i_src_c032_3_14 mix_i_c032_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_14 (mix_q_src_c032_3_14 0 bpf_c032_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c032_3_14 (mix_q_src_c032_3_14 mix_q_c032_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c032_3_15 (mix_i_src_c032_3_15 0 bpf_c032_3 0) vcvs gain=9.807852804032e-01
SMIXI_c032_3_15 (mix_i_src_c032_3_15 mix_i_c032_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c032_3_15 (mix_q_src_c032_3_15 0 bpf_c032_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c032_3_15 (mix_q_src_c032_3_15 mix_q_c032_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c032_3 (mix_i_c032_3 0) resistor r=1G
RMIXQ_c032_3 (mix_q_c032_3 0) resistor r=1G
RINTI_c032_3 (mix_i_c032_3 Icar_c032_3) resistor r=1k
CINTI_c032_3 (Icar_c032_3 0) capacitor c=80p
RINTQ_c032_3 (mix_q_c032_3 Qcar_c032_3) resistor r=1k
CINTQ_c032_3 (Qcar_c032_3 0) capacitor c=80p

// bl033, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c033_0 (bl033 n_cbpf_c033_0) capacitor c=4.052847345694e-13
LBPF_c033_0 (n_cbpf_c033_0 bpf_c033_0) inductor l=1.000000000000e-06
RBPF_c033_0 (bpf_c033_0 0) resistor r=7.853981633974e+01
EMIXI_c033_0_00 (mix_i_src_c033_0_00 0 bpf_c033_0 0) vcvs gain=9.807852804032e-01
SMIXI_c033_0_00 (mix_i_src_c033_0_00 mix_i_c033_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_00 (mix_q_src_c033_0_00 0 bpf_c033_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_0_00 (mix_q_src_c033_0_00 mix_q_c033_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_01 (mix_i_src_c033_0_01 0 bpf_c033_0 0) vcvs gain=8.314696123025e-01
SMIXI_c033_0_01 (mix_i_src_c033_0_01 mix_i_c033_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_01 (mix_q_src_c033_0_01 0 bpf_c033_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_0_01 (mix_q_src_c033_0_01 mix_q_c033_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_02 (mix_i_src_c033_0_02 0 bpf_c033_0 0) vcvs gain=5.555702330196e-01
SMIXI_c033_0_02 (mix_i_src_c033_0_02 mix_i_c033_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_02 (mix_q_src_c033_0_02 0 bpf_c033_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_0_02 (mix_q_src_c033_0_02 mix_q_c033_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_03 (mix_i_src_c033_0_03 0 bpf_c033_0 0) vcvs gain=1.950903220161e-01
SMIXI_c033_0_03 (mix_i_src_c033_0_03 mix_i_c033_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_03 (mix_q_src_c033_0_03 0 bpf_c033_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_0_03 (mix_q_src_c033_0_03 mix_q_c033_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_04 (mix_i_src_c033_0_04 0 bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_0_04 (mix_i_src_c033_0_04 mix_i_c033_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_04 (mix_q_src_c033_0_04 0 bpf_c033_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_0_04 (mix_q_src_c033_0_04 mix_q_c033_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_05 (mix_i_src_c033_0_05 0 bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_0_05 (mix_i_src_c033_0_05 mix_i_c033_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_05 (mix_q_src_c033_0_05 0 bpf_c033_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_0_05 (mix_q_src_c033_0_05 mix_q_c033_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_06 (mix_i_src_c033_0_06 0 bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_0_06 (mix_i_src_c033_0_06 mix_i_c033_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_06 (mix_q_src_c033_0_06 0 bpf_c033_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_0_06 (mix_q_src_c033_0_06 mix_q_c033_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_07 (mix_i_src_c033_0_07 0 bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_0_07 (mix_i_src_c033_0_07 mix_i_c033_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_07 (mix_q_src_c033_0_07 0 bpf_c033_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_0_07 (mix_q_src_c033_0_07 mix_q_c033_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_08 (mix_i_src_c033_0_08 0 bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_0_08 (mix_i_src_c033_0_08 mix_i_c033_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_08 (mix_q_src_c033_0_08 0 bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_0_08 (mix_q_src_c033_0_08 mix_q_c033_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_09 (mix_i_src_c033_0_09 0 bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_0_09 (mix_i_src_c033_0_09 mix_i_c033_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_09 (mix_q_src_c033_0_09 0 bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_0_09 (mix_q_src_c033_0_09 mix_q_c033_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_10 (mix_i_src_c033_0_10 0 bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_0_10 (mix_i_src_c033_0_10 mix_i_c033_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_10 (mix_q_src_c033_0_10 0 bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_0_10 (mix_q_src_c033_0_10 mix_q_c033_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_11 (mix_i_src_c033_0_11 0 bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_0_11 (mix_i_src_c033_0_11 mix_i_c033_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_11 (mix_q_src_c033_0_11 0 bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_0_11 (mix_q_src_c033_0_11 mix_q_c033_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_12 (mix_i_src_c033_0_12 0 bpf_c033_0 0) vcvs gain=1.950903220161e-01
SMIXI_c033_0_12 (mix_i_src_c033_0_12 mix_i_c033_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_12 (mix_q_src_c033_0_12 0 bpf_c033_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_0_12 (mix_q_src_c033_0_12 mix_q_c033_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_13 (mix_i_src_c033_0_13 0 bpf_c033_0 0) vcvs gain=5.555702330196e-01
SMIXI_c033_0_13 (mix_i_src_c033_0_13 mix_i_c033_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_13 (mix_q_src_c033_0_13 0 bpf_c033_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_0_13 (mix_q_src_c033_0_13 mix_q_c033_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_14 (mix_i_src_c033_0_14 0 bpf_c033_0 0) vcvs gain=8.314696123025e-01
SMIXI_c033_0_14 (mix_i_src_c033_0_14 mix_i_c033_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_14 (mix_q_src_c033_0_14 0 bpf_c033_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_0_14 (mix_q_src_c033_0_14 mix_q_c033_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_0_15 (mix_i_src_c033_0_15 0 bpf_c033_0 0) vcvs gain=9.807852804032e-01
SMIXI_c033_0_15 (mix_i_src_c033_0_15 mix_i_c033_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_0_15 (mix_q_src_c033_0_15 0 bpf_c033_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_0_15 (mix_q_src_c033_0_15 mix_q_c033_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c033_0 (mix_i_c033_0 0) resistor r=1G
RMIXQ_c033_0 (mix_q_c033_0 0) resistor r=1G
RINTI_c033_0 (mix_i_c033_0 Icar_c033_0) resistor r=1k
CINTI_c033_0 (Icar_c033_0 0) capacitor c=80p
RINTQ_c033_0 (mix_q_c033_0 Qcar_c033_0) resistor r=1k
CINTQ_c033_0 (Qcar_c033_0 0) capacitor c=80p

// bl033, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c033_1 (bl033 n_cbpf_c033_1) capacitor c=1.013211836423e-13
LBPF_c033_1 (n_cbpf_c033_1 bpf_c033_1) inductor l=1.000000000000e-06
RBPF_c033_1 (bpf_c033_1 0) resistor r=1.570796326795e+02
EMIXI_c033_1_00 (mix_i_src_c033_1_00 0 bpf_c033_1 0) vcvs gain=9.807852804032e-01
SMIXI_c033_1_00 (mix_i_src_c033_1_00 mix_i_c033_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_00 (mix_q_src_c033_1_00 0 bpf_c033_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_1_00 (mix_q_src_c033_1_00 mix_q_c033_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_01 (mix_i_src_c033_1_01 0 bpf_c033_1 0) vcvs gain=8.314696123025e-01
SMIXI_c033_1_01 (mix_i_src_c033_1_01 mix_i_c033_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_01 (mix_q_src_c033_1_01 0 bpf_c033_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_1_01 (mix_q_src_c033_1_01 mix_q_c033_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_02 (mix_i_src_c033_1_02 0 bpf_c033_1 0) vcvs gain=5.555702330196e-01
SMIXI_c033_1_02 (mix_i_src_c033_1_02 mix_i_c033_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_02 (mix_q_src_c033_1_02 0 bpf_c033_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_1_02 (mix_q_src_c033_1_02 mix_q_c033_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_03 (mix_i_src_c033_1_03 0 bpf_c033_1 0) vcvs gain=1.950903220161e-01
SMIXI_c033_1_03 (mix_i_src_c033_1_03 mix_i_c033_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_03 (mix_q_src_c033_1_03 0 bpf_c033_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_1_03 (mix_q_src_c033_1_03 mix_q_c033_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_04 (mix_i_src_c033_1_04 0 bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_1_04 (mix_i_src_c033_1_04 mix_i_c033_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_04 (mix_q_src_c033_1_04 0 bpf_c033_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_1_04 (mix_q_src_c033_1_04 mix_q_c033_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_05 (mix_i_src_c033_1_05 0 bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_1_05 (mix_i_src_c033_1_05 mix_i_c033_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_05 (mix_q_src_c033_1_05 0 bpf_c033_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_1_05 (mix_q_src_c033_1_05 mix_q_c033_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_06 (mix_i_src_c033_1_06 0 bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_1_06 (mix_i_src_c033_1_06 mix_i_c033_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_06 (mix_q_src_c033_1_06 0 bpf_c033_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_1_06 (mix_q_src_c033_1_06 mix_q_c033_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_07 (mix_i_src_c033_1_07 0 bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_1_07 (mix_i_src_c033_1_07 mix_i_c033_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_07 (mix_q_src_c033_1_07 0 bpf_c033_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_1_07 (mix_q_src_c033_1_07 mix_q_c033_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_08 (mix_i_src_c033_1_08 0 bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_1_08 (mix_i_src_c033_1_08 mix_i_c033_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_08 (mix_q_src_c033_1_08 0 bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_1_08 (mix_q_src_c033_1_08 mix_q_c033_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_09 (mix_i_src_c033_1_09 0 bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_1_09 (mix_i_src_c033_1_09 mix_i_c033_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_09 (mix_q_src_c033_1_09 0 bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_1_09 (mix_q_src_c033_1_09 mix_q_c033_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_10 (mix_i_src_c033_1_10 0 bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_1_10 (mix_i_src_c033_1_10 mix_i_c033_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_10 (mix_q_src_c033_1_10 0 bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_1_10 (mix_q_src_c033_1_10 mix_q_c033_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_11 (mix_i_src_c033_1_11 0 bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_1_11 (mix_i_src_c033_1_11 mix_i_c033_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_11 (mix_q_src_c033_1_11 0 bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_1_11 (mix_q_src_c033_1_11 mix_q_c033_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_12 (mix_i_src_c033_1_12 0 bpf_c033_1 0) vcvs gain=1.950903220161e-01
SMIXI_c033_1_12 (mix_i_src_c033_1_12 mix_i_c033_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_12 (mix_q_src_c033_1_12 0 bpf_c033_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_1_12 (mix_q_src_c033_1_12 mix_q_c033_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_13 (mix_i_src_c033_1_13 0 bpf_c033_1 0) vcvs gain=5.555702330196e-01
SMIXI_c033_1_13 (mix_i_src_c033_1_13 mix_i_c033_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_13 (mix_q_src_c033_1_13 0 bpf_c033_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_1_13 (mix_q_src_c033_1_13 mix_q_c033_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_14 (mix_i_src_c033_1_14 0 bpf_c033_1 0) vcvs gain=8.314696123025e-01
SMIXI_c033_1_14 (mix_i_src_c033_1_14 mix_i_c033_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_14 (mix_q_src_c033_1_14 0 bpf_c033_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_1_14 (mix_q_src_c033_1_14 mix_q_c033_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_1_15 (mix_i_src_c033_1_15 0 bpf_c033_1 0) vcvs gain=9.807852804032e-01
SMIXI_c033_1_15 (mix_i_src_c033_1_15 mix_i_c033_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_1_15 (mix_q_src_c033_1_15 0 bpf_c033_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_1_15 (mix_q_src_c033_1_15 mix_q_c033_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c033_1 (mix_i_c033_1 0) resistor r=1G
RMIXQ_c033_1 (mix_q_c033_1 0) resistor r=1G
RINTI_c033_1 (mix_i_c033_1 Icar_c033_1) resistor r=1k
CINTI_c033_1 (Icar_c033_1 0) capacitor c=80p
RINTQ_c033_1 (mix_q_c033_1 Qcar_c033_1) resistor r=1k
CINTQ_c033_1 (Qcar_c033_1 0) capacitor c=80p

// bl033, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c033_2 (bl033 n_cbpf_c033_2) capacitor c=4.503163717437e-14
LBPF_c033_2 (n_cbpf_c033_2 bpf_c033_2) inductor l=1.000000000000e-06
RBPF_c033_2 (bpf_c033_2 0) resistor r=2.356194490192e+02
EMIXI_c033_2_00 (mix_i_src_c033_2_00 0 bpf_c033_2 0) vcvs gain=9.807852804032e-01
SMIXI_c033_2_00 (mix_i_src_c033_2_00 mix_i_c033_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_00 (mix_q_src_c033_2_00 0 bpf_c033_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_2_00 (mix_q_src_c033_2_00 mix_q_c033_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_01 (mix_i_src_c033_2_01 0 bpf_c033_2 0) vcvs gain=8.314696123025e-01
SMIXI_c033_2_01 (mix_i_src_c033_2_01 mix_i_c033_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_01 (mix_q_src_c033_2_01 0 bpf_c033_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_2_01 (mix_q_src_c033_2_01 mix_q_c033_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_02 (mix_i_src_c033_2_02 0 bpf_c033_2 0) vcvs gain=5.555702330196e-01
SMIXI_c033_2_02 (mix_i_src_c033_2_02 mix_i_c033_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_02 (mix_q_src_c033_2_02 0 bpf_c033_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_2_02 (mix_q_src_c033_2_02 mix_q_c033_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_03 (mix_i_src_c033_2_03 0 bpf_c033_2 0) vcvs gain=1.950903220161e-01
SMIXI_c033_2_03 (mix_i_src_c033_2_03 mix_i_c033_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_03 (mix_q_src_c033_2_03 0 bpf_c033_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_2_03 (mix_q_src_c033_2_03 mix_q_c033_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_04 (mix_i_src_c033_2_04 0 bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_2_04 (mix_i_src_c033_2_04 mix_i_c033_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_04 (mix_q_src_c033_2_04 0 bpf_c033_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_2_04 (mix_q_src_c033_2_04 mix_q_c033_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_05 (mix_i_src_c033_2_05 0 bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_2_05 (mix_i_src_c033_2_05 mix_i_c033_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_05 (mix_q_src_c033_2_05 0 bpf_c033_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_2_05 (mix_q_src_c033_2_05 mix_q_c033_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_06 (mix_i_src_c033_2_06 0 bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_2_06 (mix_i_src_c033_2_06 mix_i_c033_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_06 (mix_q_src_c033_2_06 0 bpf_c033_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_2_06 (mix_q_src_c033_2_06 mix_q_c033_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_07 (mix_i_src_c033_2_07 0 bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_2_07 (mix_i_src_c033_2_07 mix_i_c033_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_07 (mix_q_src_c033_2_07 0 bpf_c033_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_2_07 (mix_q_src_c033_2_07 mix_q_c033_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_08 (mix_i_src_c033_2_08 0 bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_2_08 (mix_i_src_c033_2_08 mix_i_c033_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_08 (mix_q_src_c033_2_08 0 bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_2_08 (mix_q_src_c033_2_08 mix_q_c033_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_09 (mix_i_src_c033_2_09 0 bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_2_09 (mix_i_src_c033_2_09 mix_i_c033_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_09 (mix_q_src_c033_2_09 0 bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_2_09 (mix_q_src_c033_2_09 mix_q_c033_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_10 (mix_i_src_c033_2_10 0 bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_2_10 (mix_i_src_c033_2_10 mix_i_c033_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_10 (mix_q_src_c033_2_10 0 bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_2_10 (mix_q_src_c033_2_10 mix_q_c033_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_11 (mix_i_src_c033_2_11 0 bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_2_11 (mix_i_src_c033_2_11 mix_i_c033_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_11 (mix_q_src_c033_2_11 0 bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_2_11 (mix_q_src_c033_2_11 mix_q_c033_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_12 (mix_i_src_c033_2_12 0 bpf_c033_2 0) vcvs gain=1.950903220161e-01
SMIXI_c033_2_12 (mix_i_src_c033_2_12 mix_i_c033_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_12 (mix_q_src_c033_2_12 0 bpf_c033_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_2_12 (mix_q_src_c033_2_12 mix_q_c033_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_13 (mix_i_src_c033_2_13 0 bpf_c033_2 0) vcvs gain=5.555702330196e-01
SMIXI_c033_2_13 (mix_i_src_c033_2_13 mix_i_c033_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_13 (mix_q_src_c033_2_13 0 bpf_c033_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_2_13 (mix_q_src_c033_2_13 mix_q_c033_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_14 (mix_i_src_c033_2_14 0 bpf_c033_2 0) vcvs gain=8.314696123025e-01
SMIXI_c033_2_14 (mix_i_src_c033_2_14 mix_i_c033_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_14 (mix_q_src_c033_2_14 0 bpf_c033_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_2_14 (mix_q_src_c033_2_14 mix_q_c033_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_2_15 (mix_i_src_c033_2_15 0 bpf_c033_2 0) vcvs gain=9.807852804032e-01
SMIXI_c033_2_15 (mix_i_src_c033_2_15 mix_i_c033_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_2_15 (mix_q_src_c033_2_15 0 bpf_c033_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_2_15 (mix_q_src_c033_2_15 mix_q_c033_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c033_2 (mix_i_c033_2 0) resistor r=1G
RMIXQ_c033_2 (mix_q_c033_2 0) resistor r=1G
RINTI_c033_2 (mix_i_c033_2 Icar_c033_2) resistor r=1k
CINTI_c033_2 (Icar_c033_2 0) capacitor c=80p
RINTQ_c033_2 (mix_q_c033_2 Qcar_c033_2) resistor r=1k
CINTQ_c033_2 (Qcar_c033_2 0) capacitor c=80p

// bl033, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c033_3 (bl033 n_cbpf_c033_3) capacitor c=2.533029591058e-14
LBPF_c033_3 (n_cbpf_c033_3 bpf_c033_3) inductor l=1.000000000000e-06
RBPF_c033_3 (bpf_c033_3 0) resistor r=3.141592653590e+02
EMIXI_c033_3_00 (mix_i_src_c033_3_00 0 bpf_c033_3 0) vcvs gain=9.807852804032e-01
SMIXI_c033_3_00 (mix_i_src_c033_3_00 mix_i_c033_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_00 (mix_q_src_c033_3_00 0 bpf_c033_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_3_00 (mix_q_src_c033_3_00 mix_q_c033_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_01 (mix_i_src_c033_3_01 0 bpf_c033_3 0) vcvs gain=8.314696123025e-01
SMIXI_c033_3_01 (mix_i_src_c033_3_01 mix_i_c033_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_01 (mix_q_src_c033_3_01 0 bpf_c033_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_3_01 (mix_q_src_c033_3_01 mix_q_c033_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_02 (mix_i_src_c033_3_02 0 bpf_c033_3 0) vcvs gain=5.555702330196e-01
SMIXI_c033_3_02 (mix_i_src_c033_3_02 mix_i_c033_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_02 (mix_q_src_c033_3_02 0 bpf_c033_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_3_02 (mix_q_src_c033_3_02 mix_q_c033_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_03 (mix_i_src_c033_3_03 0 bpf_c033_3 0) vcvs gain=1.950903220161e-01
SMIXI_c033_3_03 (mix_i_src_c033_3_03 mix_i_c033_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_03 (mix_q_src_c033_3_03 0 bpf_c033_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_3_03 (mix_q_src_c033_3_03 mix_q_c033_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_04 (mix_i_src_c033_3_04 0 bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_3_04 (mix_i_src_c033_3_04 mix_i_c033_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_04 (mix_q_src_c033_3_04 0 bpf_c033_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c033_3_04 (mix_q_src_c033_3_04 mix_q_c033_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_05 (mix_i_src_c033_3_05 0 bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_3_05 (mix_i_src_c033_3_05 mix_i_c033_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_05 (mix_q_src_c033_3_05 0 bpf_c033_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c033_3_05 (mix_q_src_c033_3_05 mix_q_c033_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_06 (mix_i_src_c033_3_06 0 bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_3_06 (mix_i_src_c033_3_06 mix_i_c033_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_06 (mix_q_src_c033_3_06 0 bpf_c033_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c033_3_06 (mix_q_src_c033_3_06 mix_q_c033_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_07 (mix_i_src_c033_3_07 0 bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_3_07 (mix_i_src_c033_3_07 mix_i_c033_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_07 (mix_q_src_c033_3_07 0 bpf_c033_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c033_3_07 (mix_q_src_c033_3_07 mix_q_c033_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_08 (mix_i_src_c033_3_08 0 bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c033_3_08 (mix_i_src_c033_3_08 mix_i_c033_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_08 (mix_q_src_c033_3_08 0 bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_3_08 (mix_q_src_c033_3_08 mix_q_c033_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_09 (mix_i_src_c033_3_09 0 bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c033_3_09 (mix_i_src_c033_3_09 mix_i_c033_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_09 (mix_q_src_c033_3_09 0 bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_3_09 (mix_q_src_c033_3_09 mix_q_c033_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_10 (mix_i_src_c033_3_10 0 bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c033_3_10 (mix_i_src_c033_3_10 mix_i_c033_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_10 (mix_q_src_c033_3_10 0 bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_3_10 (mix_q_src_c033_3_10 mix_q_c033_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_11 (mix_i_src_c033_3_11 0 bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c033_3_11 (mix_i_src_c033_3_11 mix_i_c033_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_11 (mix_q_src_c033_3_11 0 bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_3_11 (mix_q_src_c033_3_11 mix_q_c033_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_12 (mix_i_src_c033_3_12 0 bpf_c033_3 0) vcvs gain=1.950903220161e-01
SMIXI_c033_3_12 (mix_i_src_c033_3_12 mix_i_c033_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_12 (mix_q_src_c033_3_12 0 bpf_c033_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c033_3_12 (mix_q_src_c033_3_12 mix_q_c033_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_13 (mix_i_src_c033_3_13 0 bpf_c033_3 0) vcvs gain=5.555702330196e-01
SMIXI_c033_3_13 (mix_i_src_c033_3_13 mix_i_c033_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_13 (mix_q_src_c033_3_13 0 bpf_c033_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c033_3_13 (mix_q_src_c033_3_13 mix_q_c033_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_14 (mix_i_src_c033_3_14 0 bpf_c033_3 0) vcvs gain=8.314696123025e-01
SMIXI_c033_3_14 (mix_i_src_c033_3_14 mix_i_c033_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_14 (mix_q_src_c033_3_14 0 bpf_c033_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c033_3_14 (mix_q_src_c033_3_14 mix_q_c033_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c033_3_15 (mix_i_src_c033_3_15 0 bpf_c033_3 0) vcvs gain=9.807852804032e-01
SMIXI_c033_3_15 (mix_i_src_c033_3_15 mix_i_c033_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c033_3_15 (mix_q_src_c033_3_15 0 bpf_c033_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c033_3_15 (mix_q_src_c033_3_15 mix_q_c033_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c033_3 (mix_i_c033_3 0) resistor r=1G
RMIXQ_c033_3 (mix_q_c033_3 0) resistor r=1G
RINTI_c033_3 (mix_i_c033_3 Icar_c033_3) resistor r=1k
CINTI_c033_3 (Icar_c033_3 0) capacitor c=80p
RINTQ_c033_3 (mix_q_c033_3 Qcar_c033_3) resistor r=1k
CINTQ_c033_3 (Qcar_c033_3 0) capacitor c=80p

// bl034, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c034_0 (bl034 n_cbpf_c034_0) capacitor c=4.052847345694e-13
LBPF_c034_0 (n_cbpf_c034_0 bpf_c034_0) inductor l=1.000000000000e-06
RBPF_c034_0 (bpf_c034_0 0) resistor r=7.853981633974e+01
EMIXI_c034_0_00 (mix_i_src_c034_0_00 0 bpf_c034_0 0) vcvs gain=9.807852804032e-01
SMIXI_c034_0_00 (mix_i_src_c034_0_00 mix_i_c034_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_00 (mix_q_src_c034_0_00 0 bpf_c034_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_0_00 (mix_q_src_c034_0_00 mix_q_c034_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_01 (mix_i_src_c034_0_01 0 bpf_c034_0 0) vcvs gain=8.314696123025e-01
SMIXI_c034_0_01 (mix_i_src_c034_0_01 mix_i_c034_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_01 (mix_q_src_c034_0_01 0 bpf_c034_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_0_01 (mix_q_src_c034_0_01 mix_q_c034_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_02 (mix_i_src_c034_0_02 0 bpf_c034_0 0) vcvs gain=5.555702330196e-01
SMIXI_c034_0_02 (mix_i_src_c034_0_02 mix_i_c034_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_02 (mix_q_src_c034_0_02 0 bpf_c034_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_0_02 (mix_q_src_c034_0_02 mix_q_c034_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_03 (mix_i_src_c034_0_03 0 bpf_c034_0 0) vcvs gain=1.950903220161e-01
SMIXI_c034_0_03 (mix_i_src_c034_0_03 mix_i_c034_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_03 (mix_q_src_c034_0_03 0 bpf_c034_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_0_03 (mix_q_src_c034_0_03 mix_q_c034_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_04 (mix_i_src_c034_0_04 0 bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_0_04 (mix_i_src_c034_0_04 mix_i_c034_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_04 (mix_q_src_c034_0_04 0 bpf_c034_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_0_04 (mix_q_src_c034_0_04 mix_q_c034_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_05 (mix_i_src_c034_0_05 0 bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_0_05 (mix_i_src_c034_0_05 mix_i_c034_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_05 (mix_q_src_c034_0_05 0 bpf_c034_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_0_05 (mix_q_src_c034_0_05 mix_q_c034_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_06 (mix_i_src_c034_0_06 0 bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_0_06 (mix_i_src_c034_0_06 mix_i_c034_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_06 (mix_q_src_c034_0_06 0 bpf_c034_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_0_06 (mix_q_src_c034_0_06 mix_q_c034_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_07 (mix_i_src_c034_0_07 0 bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_0_07 (mix_i_src_c034_0_07 mix_i_c034_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_07 (mix_q_src_c034_0_07 0 bpf_c034_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_0_07 (mix_q_src_c034_0_07 mix_q_c034_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_08 (mix_i_src_c034_0_08 0 bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_0_08 (mix_i_src_c034_0_08 mix_i_c034_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_08 (mix_q_src_c034_0_08 0 bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_0_08 (mix_q_src_c034_0_08 mix_q_c034_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_09 (mix_i_src_c034_0_09 0 bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_0_09 (mix_i_src_c034_0_09 mix_i_c034_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_09 (mix_q_src_c034_0_09 0 bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_0_09 (mix_q_src_c034_0_09 mix_q_c034_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_10 (mix_i_src_c034_0_10 0 bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_0_10 (mix_i_src_c034_0_10 mix_i_c034_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_10 (mix_q_src_c034_0_10 0 bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_0_10 (mix_q_src_c034_0_10 mix_q_c034_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_11 (mix_i_src_c034_0_11 0 bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_0_11 (mix_i_src_c034_0_11 mix_i_c034_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_11 (mix_q_src_c034_0_11 0 bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_0_11 (mix_q_src_c034_0_11 mix_q_c034_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_12 (mix_i_src_c034_0_12 0 bpf_c034_0 0) vcvs gain=1.950903220161e-01
SMIXI_c034_0_12 (mix_i_src_c034_0_12 mix_i_c034_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_12 (mix_q_src_c034_0_12 0 bpf_c034_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_0_12 (mix_q_src_c034_0_12 mix_q_c034_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_13 (mix_i_src_c034_0_13 0 bpf_c034_0 0) vcvs gain=5.555702330196e-01
SMIXI_c034_0_13 (mix_i_src_c034_0_13 mix_i_c034_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_13 (mix_q_src_c034_0_13 0 bpf_c034_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_0_13 (mix_q_src_c034_0_13 mix_q_c034_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_14 (mix_i_src_c034_0_14 0 bpf_c034_0 0) vcvs gain=8.314696123025e-01
SMIXI_c034_0_14 (mix_i_src_c034_0_14 mix_i_c034_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_14 (mix_q_src_c034_0_14 0 bpf_c034_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_0_14 (mix_q_src_c034_0_14 mix_q_c034_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_0_15 (mix_i_src_c034_0_15 0 bpf_c034_0 0) vcvs gain=9.807852804032e-01
SMIXI_c034_0_15 (mix_i_src_c034_0_15 mix_i_c034_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_0_15 (mix_q_src_c034_0_15 0 bpf_c034_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_0_15 (mix_q_src_c034_0_15 mix_q_c034_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c034_0 (mix_i_c034_0 0) resistor r=1G
RMIXQ_c034_0 (mix_q_c034_0 0) resistor r=1G
RINTI_c034_0 (mix_i_c034_0 Icar_c034_0) resistor r=1k
CINTI_c034_0 (Icar_c034_0 0) capacitor c=80p
RINTQ_c034_0 (mix_q_c034_0 Qcar_c034_0) resistor r=1k
CINTQ_c034_0 (Qcar_c034_0 0) capacitor c=80p

// bl034, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c034_1 (bl034 n_cbpf_c034_1) capacitor c=1.013211836423e-13
LBPF_c034_1 (n_cbpf_c034_1 bpf_c034_1) inductor l=1.000000000000e-06
RBPF_c034_1 (bpf_c034_1 0) resistor r=1.570796326795e+02
EMIXI_c034_1_00 (mix_i_src_c034_1_00 0 bpf_c034_1 0) vcvs gain=9.807852804032e-01
SMIXI_c034_1_00 (mix_i_src_c034_1_00 mix_i_c034_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_00 (mix_q_src_c034_1_00 0 bpf_c034_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_1_00 (mix_q_src_c034_1_00 mix_q_c034_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_01 (mix_i_src_c034_1_01 0 bpf_c034_1 0) vcvs gain=8.314696123025e-01
SMIXI_c034_1_01 (mix_i_src_c034_1_01 mix_i_c034_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_01 (mix_q_src_c034_1_01 0 bpf_c034_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_1_01 (mix_q_src_c034_1_01 mix_q_c034_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_02 (mix_i_src_c034_1_02 0 bpf_c034_1 0) vcvs gain=5.555702330196e-01
SMIXI_c034_1_02 (mix_i_src_c034_1_02 mix_i_c034_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_02 (mix_q_src_c034_1_02 0 bpf_c034_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_1_02 (mix_q_src_c034_1_02 mix_q_c034_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_03 (mix_i_src_c034_1_03 0 bpf_c034_1 0) vcvs gain=1.950903220161e-01
SMIXI_c034_1_03 (mix_i_src_c034_1_03 mix_i_c034_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_03 (mix_q_src_c034_1_03 0 bpf_c034_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_1_03 (mix_q_src_c034_1_03 mix_q_c034_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_04 (mix_i_src_c034_1_04 0 bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_1_04 (mix_i_src_c034_1_04 mix_i_c034_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_04 (mix_q_src_c034_1_04 0 bpf_c034_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_1_04 (mix_q_src_c034_1_04 mix_q_c034_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_05 (mix_i_src_c034_1_05 0 bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_1_05 (mix_i_src_c034_1_05 mix_i_c034_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_05 (mix_q_src_c034_1_05 0 bpf_c034_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_1_05 (mix_q_src_c034_1_05 mix_q_c034_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_06 (mix_i_src_c034_1_06 0 bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_1_06 (mix_i_src_c034_1_06 mix_i_c034_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_06 (mix_q_src_c034_1_06 0 bpf_c034_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_1_06 (mix_q_src_c034_1_06 mix_q_c034_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_07 (mix_i_src_c034_1_07 0 bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_1_07 (mix_i_src_c034_1_07 mix_i_c034_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_07 (mix_q_src_c034_1_07 0 bpf_c034_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_1_07 (mix_q_src_c034_1_07 mix_q_c034_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_08 (mix_i_src_c034_1_08 0 bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_1_08 (mix_i_src_c034_1_08 mix_i_c034_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_08 (mix_q_src_c034_1_08 0 bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_1_08 (mix_q_src_c034_1_08 mix_q_c034_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_09 (mix_i_src_c034_1_09 0 bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_1_09 (mix_i_src_c034_1_09 mix_i_c034_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_09 (mix_q_src_c034_1_09 0 bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_1_09 (mix_q_src_c034_1_09 mix_q_c034_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_10 (mix_i_src_c034_1_10 0 bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_1_10 (mix_i_src_c034_1_10 mix_i_c034_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_10 (mix_q_src_c034_1_10 0 bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_1_10 (mix_q_src_c034_1_10 mix_q_c034_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_11 (mix_i_src_c034_1_11 0 bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_1_11 (mix_i_src_c034_1_11 mix_i_c034_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_11 (mix_q_src_c034_1_11 0 bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_1_11 (mix_q_src_c034_1_11 mix_q_c034_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_12 (mix_i_src_c034_1_12 0 bpf_c034_1 0) vcvs gain=1.950903220161e-01
SMIXI_c034_1_12 (mix_i_src_c034_1_12 mix_i_c034_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_12 (mix_q_src_c034_1_12 0 bpf_c034_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_1_12 (mix_q_src_c034_1_12 mix_q_c034_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_13 (mix_i_src_c034_1_13 0 bpf_c034_1 0) vcvs gain=5.555702330196e-01
SMIXI_c034_1_13 (mix_i_src_c034_1_13 mix_i_c034_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_13 (mix_q_src_c034_1_13 0 bpf_c034_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_1_13 (mix_q_src_c034_1_13 mix_q_c034_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_14 (mix_i_src_c034_1_14 0 bpf_c034_1 0) vcvs gain=8.314696123025e-01
SMIXI_c034_1_14 (mix_i_src_c034_1_14 mix_i_c034_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_14 (mix_q_src_c034_1_14 0 bpf_c034_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_1_14 (mix_q_src_c034_1_14 mix_q_c034_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_1_15 (mix_i_src_c034_1_15 0 bpf_c034_1 0) vcvs gain=9.807852804032e-01
SMIXI_c034_1_15 (mix_i_src_c034_1_15 mix_i_c034_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_1_15 (mix_q_src_c034_1_15 0 bpf_c034_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_1_15 (mix_q_src_c034_1_15 mix_q_c034_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c034_1 (mix_i_c034_1 0) resistor r=1G
RMIXQ_c034_1 (mix_q_c034_1 0) resistor r=1G
RINTI_c034_1 (mix_i_c034_1 Icar_c034_1) resistor r=1k
CINTI_c034_1 (Icar_c034_1 0) capacitor c=80p
RINTQ_c034_1 (mix_q_c034_1 Qcar_c034_1) resistor r=1k
CINTQ_c034_1 (Qcar_c034_1 0) capacitor c=80p

// bl034, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c034_2 (bl034 n_cbpf_c034_2) capacitor c=4.503163717437e-14
LBPF_c034_2 (n_cbpf_c034_2 bpf_c034_2) inductor l=1.000000000000e-06
RBPF_c034_2 (bpf_c034_2 0) resistor r=2.356194490192e+02
EMIXI_c034_2_00 (mix_i_src_c034_2_00 0 bpf_c034_2 0) vcvs gain=9.807852804032e-01
SMIXI_c034_2_00 (mix_i_src_c034_2_00 mix_i_c034_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_00 (mix_q_src_c034_2_00 0 bpf_c034_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_2_00 (mix_q_src_c034_2_00 mix_q_c034_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_01 (mix_i_src_c034_2_01 0 bpf_c034_2 0) vcvs gain=8.314696123025e-01
SMIXI_c034_2_01 (mix_i_src_c034_2_01 mix_i_c034_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_01 (mix_q_src_c034_2_01 0 bpf_c034_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_2_01 (mix_q_src_c034_2_01 mix_q_c034_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_02 (mix_i_src_c034_2_02 0 bpf_c034_2 0) vcvs gain=5.555702330196e-01
SMIXI_c034_2_02 (mix_i_src_c034_2_02 mix_i_c034_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_02 (mix_q_src_c034_2_02 0 bpf_c034_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_2_02 (mix_q_src_c034_2_02 mix_q_c034_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_03 (mix_i_src_c034_2_03 0 bpf_c034_2 0) vcvs gain=1.950903220161e-01
SMIXI_c034_2_03 (mix_i_src_c034_2_03 mix_i_c034_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_03 (mix_q_src_c034_2_03 0 bpf_c034_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_2_03 (mix_q_src_c034_2_03 mix_q_c034_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_04 (mix_i_src_c034_2_04 0 bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_2_04 (mix_i_src_c034_2_04 mix_i_c034_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_04 (mix_q_src_c034_2_04 0 bpf_c034_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_2_04 (mix_q_src_c034_2_04 mix_q_c034_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_05 (mix_i_src_c034_2_05 0 bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_2_05 (mix_i_src_c034_2_05 mix_i_c034_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_05 (mix_q_src_c034_2_05 0 bpf_c034_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_2_05 (mix_q_src_c034_2_05 mix_q_c034_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_06 (mix_i_src_c034_2_06 0 bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_2_06 (mix_i_src_c034_2_06 mix_i_c034_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_06 (mix_q_src_c034_2_06 0 bpf_c034_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_2_06 (mix_q_src_c034_2_06 mix_q_c034_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_07 (mix_i_src_c034_2_07 0 bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_2_07 (mix_i_src_c034_2_07 mix_i_c034_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_07 (mix_q_src_c034_2_07 0 bpf_c034_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_2_07 (mix_q_src_c034_2_07 mix_q_c034_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_08 (mix_i_src_c034_2_08 0 bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_2_08 (mix_i_src_c034_2_08 mix_i_c034_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_08 (mix_q_src_c034_2_08 0 bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_2_08 (mix_q_src_c034_2_08 mix_q_c034_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_09 (mix_i_src_c034_2_09 0 bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_2_09 (mix_i_src_c034_2_09 mix_i_c034_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_09 (mix_q_src_c034_2_09 0 bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_2_09 (mix_q_src_c034_2_09 mix_q_c034_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_10 (mix_i_src_c034_2_10 0 bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_2_10 (mix_i_src_c034_2_10 mix_i_c034_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_10 (mix_q_src_c034_2_10 0 bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_2_10 (mix_q_src_c034_2_10 mix_q_c034_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_11 (mix_i_src_c034_2_11 0 bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_2_11 (mix_i_src_c034_2_11 mix_i_c034_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_11 (mix_q_src_c034_2_11 0 bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_2_11 (mix_q_src_c034_2_11 mix_q_c034_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_12 (mix_i_src_c034_2_12 0 bpf_c034_2 0) vcvs gain=1.950903220161e-01
SMIXI_c034_2_12 (mix_i_src_c034_2_12 mix_i_c034_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_12 (mix_q_src_c034_2_12 0 bpf_c034_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_2_12 (mix_q_src_c034_2_12 mix_q_c034_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_13 (mix_i_src_c034_2_13 0 bpf_c034_2 0) vcvs gain=5.555702330196e-01
SMIXI_c034_2_13 (mix_i_src_c034_2_13 mix_i_c034_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_13 (mix_q_src_c034_2_13 0 bpf_c034_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_2_13 (mix_q_src_c034_2_13 mix_q_c034_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_14 (mix_i_src_c034_2_14 0 bpf_c034_2 0) vcvs gain=8.314696123025e-01
SMIXI_c034_2_14 (mix_i_src_c034_2_14 mix_i_c034_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_14 (mix_q_src_c034_2_14 0 bpf_c034_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_2_14 (mix_q_src_c034_2_14 mix_q_c034_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_2_15 (mix_i_src_c034_2_15 0 bpf_c034_2 0) vcvs gain=9.807852804032e-01
SMIXI_c034_2_15 (mix_i_src_c034_2_15 mix_i_c034_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_2_15 (mix_q_src_c034_2_15 0 bpf_c034_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_2_15 (mix_q_src_c034_2_15 mix_q_c034_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c034_2 (mix_i_c034_2 0) resistor r=1G
RMIXQ_c034_2 (mix_q_c034_2 0) resistor r=1G
RINTI_c034_2 (mix_i_c034_2 Icar_c034_2) resistor r=1k
CINTI_c034_2 (Icar_c034_2 0) capacitor c=80p
RINTQ_c034_2 (mix_q_c034_2 Qcar_c034_2) resistor r=1k
CINTQ_c034_2 (Qcar_c034_2 0) capacitor c=80p

// bl034, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c034_3 (bl034 n_cbpf_c034_3) capacitor c=2.533029591058e-14
LBPF_c034_3 (n_cbpf_c034_3 bpf_c034_3) inductor l=1.000000000000e-06
RBPF_c034_3 (bpf_c034_3 0) resistor r=3.141592653590e+02
EMIXI_c034_3_00 (mix_i_src_c034_3_00 0 bpf_c034_3 0) vcvs gain=9.807852804032e-01
SMIXI_c034_3_00 (mix_i_src_c034_3_00 mix_i_c034_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_00 (mix_q_src_c034_3_00 0 bpf_c034_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_3_00 (mix_q_src_c034_3_00 mix_q_c034_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_01 (mix_i_src_c034_3_01 0 bpf_c034_3 0) vcvs gain=8.314696123025e-01
SMIXI_c034_3_01 (mix_i_src_c034_3_01 mix_i_c034_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_01 (mix_q_src_c034_3_01 0 bpf_c034_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_3_01 (mix_q_src_c034_3_01 mix_q_c034_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_02 (mix_i_src_c034_3_02 0 bpf_c034_3 0) vcvs gain=5.555702330196e-01
SMIXI_c034_3_02 (mix_i_src_c034_3_02 mix_i_c034_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_02 (mix_q_src_c034_3_02 0 bpf_c034_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_3_02 (mix_q_src_c034_3_02 mix_q_c034_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_03 (mix_i_src_c034_3_03 0 bpf_c034_3 0) vcvs gain=1.950903220161e-01
SMIXI_c034_3_03 (mix_i_src_c034_3_03 mix_i_c034_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_03 (mix_q_src_c034_3_03 0 bpf_c034_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_3_03 (mix_q_src_c034_3_03 mix_q_c034_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_04 (mix_i_src_c034_3_04 0 bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_3_04 (mix_i_src_c034_3_04 mix_i_c034_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_04 (mix_q_src_c034_3_04 0 bpf_c034_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c034_3_04 (mix_q_src_c034_3_04 mix_q_c034_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_05 (mix_i_src_c034_3_05 0 bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_3_05 (mix_i_src_c034_3_05 mix_i_c034_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_05 (mix_q_src_c034_3_05 0 bpf_c034_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c034_3_05 (mix_q_src_c034_3_05 mix_q_c034_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_06 (mix_i_src_c034_3_06 0 bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_3_06 (mix_i_src_c034_3_06 mix_i_c034_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_06 (mix_q_src_c034_3_06 0 bpf_c034_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c034_3_06 (mix_q_src_c034_3_06 mix_q_c034_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_07 (mix_i_src_c034_3_07 0 bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_3_07 (mix_i_src_c034_3_07 mix_i_c034_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_07 (mix_q_src_c034_3_07 0 bpf_c034_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c034_3_07 (mix_q_src_c034_3_07 mix_q_c034_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_08 (mix_i_src_c034_3_08 0 bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c034_3_08 (mix_i_src_c034_3_08 mix_i_c034_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_08 (mix_q_src_c034_3_08 0 bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_3_08 (mix_q_src_c034_3_08 mix_q_c034_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_09 (mix_i_src_c034_3_09 0 bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c034_3_09 (mix_i_src_c034_3_09 mix_i_c034_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_09 (mix_q_src_c034_3_09 0 bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_3_09 (mix_q_src_c034_3_09 mix_q_c034_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_10 (mix_i_src_c034_3_10 0 bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c034_3_10 (mix_i_src_c034_3_10 mix_i_c034_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_10 (mix_q_src_c034_3_10 0 bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_3_10 (mix_q_src_c034_3_10 mix_q_c034_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_11 (mix_i_src_c034_3_11 0 bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c034_3_11 (mix_i_src_c034_3_11 mix_i_c034_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_11 (mix_q_src_c034_3_11 0 bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_3_11 (mix_q_src_c034_3_11 mix_q_c034_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_12 (mix_i_src_c034_3_12 0 bpf_c034_3 0) vcvs gain=1.950903220161e-01
SMIXI_c034_3_12 (mix_i_src_c034_3_12 mix_i_c034_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_12 (mix_q_src_c034_3_12 0 bpf_c034_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c034_3_12 (mix_q_src_c034_3_12 mix_q_c034_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_13 (mix_i_src_c034_3_13 0 bpf_c034_3 0) vcvs gain=5.555702330196e-01
SMIXI_c034_3_13 (mix_i_src_c034_3_13 mix_i_c034_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_13 (mix_q_src_c034_3_13 0 bpf_c034_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c034_3_13 (mix_q_src_c034_3_13 mix_q_c034_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_14 (mix_i_src_c034_3_14 0 bpf_c034_3 0) vcvs gain=8.314696123025e-01
SMIXI_c034_3_14 (mix_i_src_c034_3_14 mix_i_c034_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_14 (mix_q_src_c034_3_14 0 bpf_c034_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c034_3_14 (mix_q_src_c034_3_14 mix_q_c034_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c034_3_15 (mix_i_src_c034_3_15 0 bpf_c034_3 0) vcvs gain=9.807852804032e-01
SMIXI_c034_3_15 (mix_i_src_c034_3_15 mix_i_c034_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c034_3_15 (mix_q_src_c034_3_15 0 bpf_c034_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c034_3_15 (mix_q_src_c034_3_15 mix_q_c034_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c034_3 (mix_i_c034_3 0) resistor r=1G
RMIXQ_c034_3 (mix_q_c034_3 0) resistor r=1G
RINTI_c034_3 (mix_i_c034_3 Icar_c034_3) resistor r=1k
CINTI_c034_3 (Icar_c034_3 0) capacitor c=80p
RINTQ_c034_3 (mix_q_c034_3 Qcar_c034_3) resistor r=1k
CINTQ_c034_3 (Qcar_c034_3 0) capacitor c=80p

// bl035, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c035_0 (bl035 n_cbpf_c035_0) capacitor c=4.052847345694e-13
LBPF_c035_0 (n_cbpf_c035_0 bpf_c035_0) inductor l=1.000000000000e-06
RBPF_c035_0 (bpf_c035_0 0) resistor r=7.853981633974e+01
EMIXI_c035_0_00 (mix_i_src_c035_0_00 0 bpf_c035_0 0) vcvs gain=9.807852804032e-01
SMIXI_c035_0_00 (mix_i_src_c035_0_00 mix_i_c035_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_00 (mix_q_src_c035_0_00 0 bpf_c035_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_0_00 (mix_q_src_c035_0_00 mix_q_c035_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_01 (mix_i_src_c035_0_01 0 bpf_c035_0 0) vcvs gain=8.314696123025e-01
SMIXI_c035_0_01 (mix_i_src_c035_0_01 mix_i_c035_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_01 (mix_q_src_c035_0_01 0 bpf_c035_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_0_01 (mix_q_src_c035_0_01 mix_q_c035_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_02 (mix_i_src_c035_0_02 0 bpf_c035_0 0) vcvs gain=5.555702330196e-01
SMIXI_c035_0_02 (mix_i_src_c035_0_02 mix_i_c035_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_02 (mix_q_src_c035_0_02 0 bpf_c035_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_0_02 (mix_q_src_c035_0_02 mix_q_c035_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_03 (mix_i_src_c035_0_03 0 bpf_c035_0 0) vcvs gain=1.950903220161e-01
SMIXI_c035_0_03 (mix_i_src_c035_0_03 mix_i_c035_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_03 (mix_q_src_c035_0_03 0 bpf_c035_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_0_03 (mix_q_src_c035_0_03 mix_q_c035_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_04 (mix_i_src_c035_0_04 0 bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_0_04 (mix_i_src_c035_0_04 mix_i_c035_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_04 (mix_q_src_c035_0_04 0 bpf_c035_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_0_04 (mix_q_src_c035_0_04 mix_q_c035_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_05 (mix_i_src_c035_0_05 0 bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_0_05 (mix_i_src_c035_0_05 mix_i_c035_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_05 (mix_q_src_c035_0_05 0 bpf_c035_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_0_05 (mix_q_src_c035_0_05 mix_q_c035_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_06 (mix_i_src_c035_0_06 0 bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_0_06 (mix_i_src_c035_0_06 mix_i_c035_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_06 (mix_q_src_c035_0_06 0 bpf_c035_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_0_06 (mix_q_src_c035_0_06 mix_q_c035_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_07 (mix_i_src_c035_0_07 0 bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_0_07 (mix_i_src_c035_0_07 mix_i_c035_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_07 (mix_q_src_c035_0_07 0 bpf_c035_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_0_07 (mix_q_src_c035_0_07 mix_q_c035_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_08 (mix_i_src_c035_0_08 0 bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_0_08 (mix_i_src_c035_0_08 mix_i_c035_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_08 (mix_q_src_c035_0_08 0 bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_0_08 (mix_q_src_c035_0_08 mix_q_c035_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_09 (mix_i_src_c035_0_09 0 bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_0_09 (mix_i_src_c035_0_09 mix_i_c035_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_09 (mix_q_src_c035_0_09 0 bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_0_09 (mix_q_src_c035_0_09 mix_q_c035_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_10 (mix_i_src_c035_0_10 0 bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_0_10 (mix_i_src_c035_0_10 mix_i_c035_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_10 (mix_q_src_c035_0_10 0 bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_0_10 (mix_q_src_c035_0_10 mix_q_c035_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_11 (mix_i_src_c035_0_11 0 bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_0_11 (mix_i_src_c035_0_11 mix_i_c035_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_11 (mix_q_src_c035_0_11 0 bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_0_11 (mix_q_src_c035_0_11 mix_q_c035_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_12 (mix_i_src_c035_0_12 0 bpf_c035_0 0) vcvs gain=1.950903220161e-01
SMIXI_c035_0_12 (mix_i_src_c035_0_12 mix_i_c035_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_12 (mix_q_src_c035_0_12 0 bpf_c035_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_0_12 (mix_q_src_c035_0_12 mix_q_c035_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_13 (mix_i_src_c035_0_13 0 bpf_c035_0 0) vcvs gain=5.555702330196e-01
SMIXI_c035_0_13 (mix_i_src_c035_0_13 mix_i_c035_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_13 (mix_q_src_c035_0_13 0 bpf_c035_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_0_13 (mix_q_src_c035_0_13 mix_q_c035_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_14 (mix_i_src_c035_0_14 0 bpf_c035_0 0) vcvs gain=8.314696123025e-01
SMIXI_c035_0_14 (mix_i_src_c035_0_14 mix_i_c035_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_14 (mix_q_src_c035_0_14 0 bpf_c035_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_0_14 (mix_q_src_c035_0_14 mix_q_c035_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_0_15 (mix_i_src_c035_0_15 0 bpf_c035_0 0) vcvs gain=9.807852804032e-01
SMIXI_c035_0_15 (mix_i_src_c035_0_15 mix_i_c035_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_0_15 (mix_q_src_c035_0_15 0 bpf_c035_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_0_15 (mix_q_src_c035_0_15 mix_q_c035_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c035_0 (mix_i_c035_0 0) resistor r=1G
RMIXQ_c035_0 (mix_q_c035_0 0) resistor r=1G
RINTI_c035_0 (mix_i_c035_0 Icar_c035_0) resistor r=1k
CINTI_c035_0 (Icar_c035_0 0) capacitor c=80p
RINTQ_c035_0 (mix_q_c035_0 Qcar_c035_0) resistor r=1k
CINTQ_c035_0 (Qcar_c035_0 0) capacitor c=80p

// bl035, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c035_1 (bl035 n_cbpf_c035_1) capacitor c=1.013211836423e-13
LBPF_c035_1 (n_cbpf_c035_1 bpf_c035_1) inductor l=1.000000000000e-06
RBPF_c035_1 (bpf_c035_1 0) resistor r=1.570796326795e+02
EMIXI_c035_1_00 (mix_i_src_c035_1_00 0 bpf_c035_1 0) vcvs gain=9.807852804032e-01
SMIXI_c035_1_00 (mix_i_src_c035_1_00 mix_i_c035_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_00 (mix_q_src_c035_1_00 0 bpf_c035_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_1_00 (mix_q_src_c035_1_00 mix_q_c035_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_01 (mix_i_src_c035_1_01 0 bpf_c035_1 0) vcvs gain=8.314696123025e-01
SMIXI_c035_1_01 (mix_i_src_c035_1_01 mix_i_c035_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_01 (mix_q_src_c035_1_01 0 bpf_c035_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_1_01 (mix_q_src_c035_1_01 mix_q_c035_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_02 (mix_i_src_c035_1_02 0 bpf_c035_1 0) vcvs gain=5.555702330196e-01
SMIXI_c035_1_02 (mix_i_src_c035_1_02 mix_i_c035_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_02 (mix_q_src_c035_1_02 0 bpf_c035_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_1_02 (mix_q_src_c035_1_02 mix_q_c035_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_03 (mix_i_src_c035_1_03 0 bpf_c035_1 0) vcvs gain=1.950903220161e-01
SMIXI_c035_1_03 (mix_i_src_c035_1_03 mix_i_c035_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_03 (mix_q_src_c035_1_03 0 bpf_c035_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_1_03 (mix_q_src_c035_1_03 mix_q_c035_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_04 (mix_i_src_c035_1_04 0 bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_1_04 (mix_i_src_c035_1_04 mix_i_c035_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_04 (mix_q_src_c035_1_04 0 bpf_c035_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_1_04 (mix_q_src_c035_1_04 mix_q_c035_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_05 (mix_i_src_c035_1_05 0 bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_1_05 (mix_i_src_c035_1_05 mix_i_c035_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_05 (mix_q_src_c035_1_05 0 bpf_c035_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_1_05 (mix_q_src_c035_1_05 mix_q_c035_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_06 (mix_i_src_c035_1_06 0 bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_1_06 (mix_i_src_c035_1_06 mix_i_c035_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_06 (mix_q_src_c035_1_06 0 bpf_c035_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_1_06 (mix_q_src_c035_1_06 mix_q_c035_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_07 (mix_i_src_c035_1_07 0 bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_1_07 (mix_i_src_c035_1_07 mix_i_c035_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_07 (mix_q_src_c035_1_07 0 bpf_c035_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_1_07 (mix_q_src_c035_1_07 mix_q_c035_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_08 (mix_i_src_c035_1_08 0 bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_1_08 (mix_i_src_c035_1_08 mix_i_c035_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_08 (mix_q_src_c035_1_08 0 bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_1_08 (mix_q_src_c035_1_08 mix_q_c035_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_09 (mix_i_src_c035_1_09 0 bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_1_09 (mix_i_src_c035_1_09 mix_i_c035_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_09 (mix_q_src_c035_1_09 0 bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_1_09 (mix_q_src_c035_1_09 mix_q_c035_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_10 (mix_i_src_c035_1_10 0 bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_1_10 (mix_i_src_c035_1_10 mix_i_c035_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_10 (mix_q_src_c035_1_10 0 bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_1_10 (mix_q_src_c035_1_10 mix_q_c035_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_11 (mix_i_src_c035_1_11 0 bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_1_11 (mix_i_src_c035_1_11 mix_i_c035_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_11 (mix_q_src_c035_1_11 0 bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_1_11 (mix_q_src_c035_1_11 mix_q_c035_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_12 (mix_i_src_c035_1_12 0 bpf_c035_1 0) vcvs gain=1.950903220161e-01
SMIXI_c035_1_12 (mix_i_src_c035_1_12 mix_i_c035_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_12 (mix_q_src_c035_1_12 0 bpf_c035_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_1_12 (mix_q_src_c035_1_12 mix_q_c035_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_13 (mix_i_src_c035_1_13 0 bpf_c035_1 0) vcvs gain=5.555702330196e-01
SMIXI_c035_1_13 (mix_i_src_c035_1_13 mix_i_c035_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_13 (mix_q_src_c035_1_13 0 bpf_c035_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_1_13 (mix_q_src_c035_1_13 mix_q_c035_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_14 (mix_i_src_c035_1_14 0 bpf_c035_1 0) vcvs gain=8.314696123025e-01
SMIXI_c035_1_14 (mix_i_src_c035_1_14 mix_i_c035_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_14 (mix_q_src_c035_1_14 0 bpf_c035_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_1_14 (mix_q_src_c035_1_14 mix_q_c035_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_1_15 (mix_i_src_c035_1_15 0 bpf_c035_1 0) vcvs gain=9.807852804032e-01
SMIXI_c035_1_15 (mix_i_src_c035_1_15 mix_i_c035_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_1_15 (mix_q_src_c035_1_15 0 bpf_c035_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_1_15 (mix_q_src_c035_1_15 mix_q_c035_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c035_1 (mix_i_c035_1 0) resistor r=1G
RMIXQ_c035_1 (mix_q_c035_1 0) resistor r=1G
RINTI_c035_1 (mix_i_c035_1 Icar_c035_1) resistor r=1k
CINTI_c035_1 (Icar_c035_1 0) capacitor c=80p
RINTQ_c035_1 (mix_q_c035_1 Qcar_c035_1) resistor r=1k
CINTQ_c035_1 (Qcar_c035_1 0) capacitor c=80p

// bl035, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c035_2 (bl035 n_cbpf_c035_2) capacitor c=4.503163717437e-14
LBPF_c035_2 (n_cbpf_c035_2 bpf_c035_2) inductor l=1.000000000000e-06
RBPF_c035_2 (bpf_c035_2 0) resistor r=2.356194490192e+02
EMIXI_c035_2_00 (mix_i_src_c035_2_00 0 bpf_c035_2 0) vcvs gain=9.807852804032e-01
SMIXI_c035_2_00 (mix_i_src_c035_2_00 mix_i_c035_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_00 (mix_q_src_c035_2_00 0 bpf_c035_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_2_00 (mix_q_src_c035_2_00 mix_q_c035_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_01 (mix_i_src_c035_2_01 0 bpf_c035_2 0) vcvs gain=8.314696123025e-01
SMIXI_c035_2_01 (mix_i_src_c035_2_01 mix_i_c035_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_01 (mix_q_src_c035_2_01 0 bpf_c035_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_2_01 (mix_q_src_c035_2_01 mix_q_c035_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_02 (mix_i_src_c035_2_02 0 bpf_c035_2 0) vcvs gain=5.555702330196e-01
SMIXI_c035_2_02 (mix_i_src_c035_2_02 mix_i_c035_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_02 (mix_q_src_c035_2_02 0 bpf_c035_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_2_02 (mix_q_src_c035_2_02 mix_q_c035_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_03 (mix_i_src_c035_2_03 0 bpf_c035_2 0) vcvs gain=1.950903220161e-01
SMIXI_c035_2_03 (mix_i_src_c035_2_03 mix_i_c035_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_03 (mix_q_src_c035_2_03 0 bpf_c035_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_2_03 (mix_q_src_c035_2_03 mix_q_c035_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_04 (mix_i_src_c035_2_04 0 bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_2_04 (mix_i_src_c035_2_04 mix_i_c035_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_04 (mix_q_src_c035_2_04 0 bpf_c035_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_2_04 (mix_q_src_c035_2_04 mix_q_c035_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_05 (mix_i_src_c035_2_05 0 bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_2_05 (mix_i_src_c035_2_05 mix_i_c035_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_05 (mix_q_src_c035_2_05 0 bpf_c035_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_2_05 (mix_q_src_c035_2_05 mix_q_c035_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_06 (mix_i_src_c035_2_06 0 bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_2_06 (mix_i_src_c035_2_06 mix_i_c035_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_06 (mix_q_src_c035_2_06 0 bpf_c035_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_2_06 (mix_q_src_c035_2_06 mix_q_c035_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_07 (mix_i_src_c035_2_07 0 bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_2_07 (mix_i_src_c035_2_07 mix_i_c035_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_07 (mix_q_src_c035_2_07 0 bpf_c035_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_2_07 (mix_q_src_c035_2_07 mix_q_c035_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_08 (mix_i_src_c035_2_08 0 bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_2_08 (mix_i_src_c035_2_08 mix_i_c035_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_08 (mix_q_src_c035_2_08 0 bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_2_08 (mix_q_src_c035_2_08 mix_q_c035_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_09 (mix_i_src_c035_2_09 0 bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_2_09 (mix_i_src_c035_2_09 mix_i_c035_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_09 (mix_q_src_c035_2_09 0 bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_2_09 (mix_q_src_c035_2_09 mix_q_c035_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_10 (mix_i_src_c035_2_10 0 bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_2_10 (mix_i_src_c035_2_10 mix_i_c035_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_10 (mix_q_src_c035_2_10 0 bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_2_10 (mix_q_src_c035_2_10 mix_q_c035_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_11 (mix_i_src_c035_2_11 0 bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_2_11 (mix_i_src_c035_2_11 mix_i_c035_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_11 (mix_q_src_c035_2_11 0 bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_2_11 (mix_q_src_c035_2_11 mix_q_c035_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_12 (mix_i_src_c035_2_12 0 bpf_c035_2 0) vcvs gain=1.950903220161e-01
SMIXI_c035_2_12 (mix_i_src_c035_2_12 mix_i_c035_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_12 (mix_q_src_c035_2_12 0 bpf_c035_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_2_12 (mix_q_src_c035_2_12 mix_q_c035_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_13 (mix_i_src_c035_2_13 0 bpf_c035_2 0) vcvs gain=5.555702330196e-01
SMIXI_c035_2_13 (mix_i_src_c035_2_13 mix_i_c035_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_13 (mix_q_src_c035_2_13 0 bpf_c035_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_2_13 (mix_q_src_c035_2_13 mix_q_c035_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_14 (mix_i_src_c035_2_14 0 bpf_c035_2 0) vcvs gain=8.314696123025e-01
SMIXI_c035_2_14 (mix_i_src_c035_2_14 mix_i_c035_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_14 (mix_q_src_c035_2_14 0 bpf_c035_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_2_14 (mix_q_src_c035_2_14 mix_q_c035_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_2_15 (mix_i_src_c035_2_15 0 bpf_c035_2 0) vcvs gain=9.807852804032e-01
SMIXI_c035_2_15 (mix_i_src_c035_2_15 mix_i_c035_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_2_15 (mix_q_src_c035_2_15 0 bpf_c035_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_2_15 (mix_q_src_c035_2_15 mix_q_c035_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c035_2 (mix_i_c035_2 0) resistor r=1G
RMIXQ_c035_2 (mix_q_c035_2 0) resistor r=1G
RINTI_c035_2 (mix_i_c035_2 Icar_c035_2) resistor r=1k
CINTI_c035_2 (Icar_c035_2 0) capacitor c=80p
RINTQ_c035_2 (mix_q_c035_2 Qcar_c035_2) resistor r=1k
CINTQ_c035_2 (Qcar_c035_2 0) capacitor c=80p

// bl035, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c035_3 (bl035 n_cbpf_c035_3) capacitor c=2.533029591058e-14
LBPF_c035_3 (n_cbpf_c035_3 bpf_c035_3) inductor l=1.000000000000e-06
RBPF_c035_3 (bpf_c035_3 0) resistor r=3.141592653590e+02
EMIXI_c035_3_00 (mix_i_src_c035_3_00 0 bpf_c035_3 0) vcvs gain=9.807852804032e-01
SMIXI_c035_3_00 (mix_i_src_c035_3_00 mix_i_c035_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_00 (mix_q_src_c035_3_00 0 bpf_c035_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_3_00 (mix_q_src_c035_3_00 mix_q_c035_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_01 (mix_i_src_c035_3_01 0 bpf_c035_3 0) vcvs gain=8.314696123025e-01
SMIXI_c035_3_01 (mix_i_src_c035_3_01 mix_i_c035_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_01 (mix_q_src_c035_3_01 0 bpf_c035_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_3_01 (mix_q_src_c035_3_01 mix_q_c035_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_02 (mix_i_src_c035_3_02 0 bpf_c035_3 0) vcvs gain=5.555702330196e-01
SMIXI_c035_3_02 (mix_i_src_c035_3_02 mix_i_c035_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_02 (mix_q_src_c035_3_02 0 bpf_c035_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_3_02 (mix_q_src_c035_3_02 mix_q_c035_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_03 (mix_i_src_c035_3_03 0 bpf_c035_3 0) vcvs gain=1.950903220161e-01
SMIXI_c035_3_03 (mix_i_src_c035_3_03 mix_i_c035_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_03 (mix_q_src_c035_3_03 0 bpf_c035_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_3_03 (mix_q_src_c035_3_03 mix_q_c035_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_04 (mix_i_src_c035_3_04 0 bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_3_04 (mix_i_src_c035_3_04 mix_i_c035_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_04 (mix_q_src_c035_3_04 0 bpf_c035_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c035_3_04 (mix_q_src_c035_3_04 mix_q_c035_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_05 (mix_i_src_c035_3_05 0 bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_3_05 (mix_i_src_c035_3_05 mix_i_c035_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_05 (mix_q_src_c035_3_05 0 bpf_c035_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c035_3_05 (mix_q_src_c035_3_05 mix_q_c035_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_06 (mix_i_src_c035_3_06 0 bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_3_06 (mix_i_src_c035_3_06 mix_i_c035_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_06 (mix_q_src_c035_3_06 0 bpf_c035_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c035_3_06 (mix_q_src_c035_3_06 mix_q_c035_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_07 (mix_i_src_c035_3_07 0 bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_3_07 (mix_i_src_c035_3_07 mix_i_c035_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_07 (mix_q_src_c035_3_07 0 bpf_c035_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c035_3_07 (mix_q_src_c035_3_07 mix_q_c035_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_08 (mix_i_src_c035_3_08 0 bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c035_3_08 (mix_i_src_c035_3_08 mix_i_c035_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_08 (mix_q_src_c035_3_08 0 bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_3_08 (mix_q_src_c035_3_08 mix_q_c035_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_09 (mix_i_src_c035_3_09 0 bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c035_3_09 (mix_i_src_c035_3_09 mix_i_c035_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_09 (mix_q_src_c035_3_09 0 bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_3_09 (mix_q_src_c035_3_09 mix_q_c035_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_10 (mix_i_src_c035_3_10 0 bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c035_3_10 (mix_i_src_c035_3_10 mix_i_c035_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_10 (mix_q_src_c035_3_10 0 bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_3_10 (mix_q_src_c035_3_10 mix_q_c035_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_11 (mix_i_src_c035_3_11 0 bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c035_3_11 (mix_i_src_c035_3_11 mix_i_c035_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_11 (mix_q_src_c035_3_11 0 bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_3_11 (mix_q_src_c035_3_11 mix_q_c035_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_12 (mix_i_src_c035_3_12 0 bpf_c035_3 0) vcvs gain=1.950903220161e-01
SMIXI_c035_3_12 (mix_i_src_c035_3_12 mix_i_c035_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_12 (mix_q_src_c035_3_12 0 bpf_c035_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c035_3_12 (mix_q_src_c035_3_12 mix_q_c035_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_13 (mix_i_src_c035_3_13 0 bpf_c035_3 0) vcvs gain=5.555702330196e-01
SMIXI_c035_3_13 (mix_i_src_c035_3_13 mix_i_c035_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_13 (mix_q_src_c035_3_13 0 bpf_c035_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c035_3_13 (mix_q_src_c035_3_13 mix_q_c035_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_14 (mix_i_src_c035_3_14 0 bpf_c035_3 0) vcvs gain=8.314696123025e-01
SMIXI_c035_3_14 (mix_i_src_c035_3_14 mix_i_c035_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_14 (mix_q_src_c035_3_14 0 bpf_c035_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c035_3_14 (mix_q_src_c035_3_14 mix_q_c035_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c035_3_15 (mix_i_src_c035_3_15 0 bpf_c035_3 0) vcvs gain=9.807852804032e-01
SMIXI_c035_3_15 (mix_i_src_c035_3_15 mix_i_c035_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c035_3_15 (mix_q_src_c035_3_15 0 bpf_c035_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c035_3_15 (mix_q_src_c035_3_15 mix_q_c035_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c035_3 (mix_i_c035_3 0) resistor r=1G
RMIXQ_c035_3 (mix_q_c035_3 0) resistor r=1G
RINTI_c035_3 (mix_i_c035_3 Icar_c035_3) resistor r=1k
CINTI_c035_3 (Icar_c035_3 0) capacitor c=80p
RINTQ_c035_3 (mix_q_c035_3 Qcar_c035_3) resistor r=1k
CINTQ_c035_3 (Qcar_c035_3 0) capacitor c=80p

// bl036, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c036_0 (bl036 n_cbpf_c036_0) capacitor c=4.052847345694e-13
LBPF_c036_0 (n_cbpf_c036_0 bpf_c036_0) inductor l=1.000000000000e-06
RBPF_c036_0 (bpf_c036_0 0) resistor r=7.853981633974e+01
EMIXI_c036_0_00 (mix_i_src_c036_0_00 0 bpf_c036_0 0) vcvs gain=9.807852804032e-01
SMIXI_c036_0_00 (mix_i_src_c036_0_00 mix_i_c036_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_00 (mix_q_src_c036_0_00 0 bpf_c036_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_0_00 (mix_q_src_c036_0_00 mix_q_c036_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_01 (mix_i_src_c036_0_01 0 bpf_c036_0 0) vcvs gain=8.314696123025e-01
SMIXI_c036_0_01 (mix_i_src_c036_0_01 mix_i_c036_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_01 (mix_q_src_c036_0_01 0 bpf_c036_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_0_01 (mix_q_src_c036_0_01 mix_q_c036_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_02 (mix_i_src_c036_0_02 0 bpf_c036_0 0) vcvs gain=5.555702330196e-01
SMIXI_c036_0_02 (mix_i_src_c036_0_02 mix_i_c036_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_02 (mix_q_src_c036_0_02 0 bpf_c036_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_0_02 (mix_q_src_c036_0_02 mix_q_c036_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_03 (mix_i_src_c036_0_03 0 bpf_c036_0 0) vcvs gain=1.950903220161e-01
SMIXI_c036_0_03 (mix_i_src_c036_0_03 mix_i_c036_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_03 (mix_q_src_c036_0_03 0 bpf_c036_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_0_03 (mix_q_src_c036_0_03 mix_q_c036_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_04 (mix_i_src_c036_0_04 0 bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_0_04 (mix_i_src_c036_0_04 mix_i_c036_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_04 (mix_q_src_c036_0_04 0 bpf_c036_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_0_04 (mix_q_src_c036_0_04 mix_q_c036_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_05 (mix_i_src_c036_0_05 0 bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_0_05 (mix_i_src_c036_0_05 mix_i_c036_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_05 (mix_q_src_c036_0_05 0 bpf_c036_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_0_05 (mix_q_src_c036_0_05 mix_q_c036_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_06 (mix_i_src_c036_0_06 0 bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_0_06 (mix_i_src_c036_0_06 mix_i_c036_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_06 (mix_q_src_c036_0_06 0 bpf_c036_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_0_06 (mix_q_src_c036_0_06 mix_q_c036_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_07 (mix_i_src_c036_0_07 0 bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_0_07 (mix_i_src_c036_0_07 mix_i_c036_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_07 (mix_q_src_c036_0_07 0 bpf_c036_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_0_07 (mix_q_src_c036_0_07 mix_q_c036_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_08 (mix_i_src_c036_0_08 0 bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_0_08 (mix_i_src_c036_0_08 mix_i_c036_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_08 (mix_q_src_c036_0_08 0 bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_0_08 (mix_q_src_c036_0_08 mix_q_c036_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_09 (mix_i_src_c036_0_09 0 bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_0_09 (mix_i_src_c036_0_09 mix_i_c036_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_09 (mix_q_src_c036_0_09 0 bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_0_09 (mix_q_src_c036_0_09 mix_q_c036_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_10 (mix_i_src_c036_0_10 0 bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_0_10 (mix_i_src_c036_0_10 mix_i_c036_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_10 (mix_q_src_c036_0_10 0 bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_0_10 (mix_q_src_c036_0_10 mix_q_c036_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_11 (mix_i_src_c036_0_11 0 bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_0_11 (mix_i_src_c036_0_11 mix_i_c036_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_11 (mix_q_src_c036_0_11 0 bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_0_11 (mix_q_src_c036_0_11 mix_q_c036_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_12 (mix_i_src_c036_0_12 0 bpf_c036_0 0) vcvs gain=1.950903220161e-01
SMIXI_c036_0_12 (mix_i_src_c036_0_12 mix_i_c036_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_12 (mix_q_src_c036_0_12 0 bpf_c036_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_0_12 (mix_q_src_c036_0_12 mix_q_c036_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_13 (mix_i_src_c036_0_13 0 bpf_c036_0 0) vcvs gain=5.555702330196e-01
SMIXI_c036_0_13 (mix_i_src_c036_0_13 mix_i_c036_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_13 (mix_q_src_c036_0_13 0 bpf_c036_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_0_13 (mix_q_src_c036_0_13 mix_q_c036_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_14 (mix_i_src_c036_0_14 0 bpf_c036_0 0) vcvs gain=8.314696123025e-01
SMIXI_c036_0_14 (mix_i_src_c036_0_14 mix_i_c036_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_14 (mix_q_src_c036_0_14 0 bpf_c036_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_0_14 (mix_q_src_c036_0_14 mix_q_c036_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_0_15 (mix_i_src_c036_0_15 0 bpf_c036_0 0) vcvs gain=9.807852804032e-01
SMIXI_c036_0_15 (mix_i_src_c036_0_15 mix_i_c036_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_0_15 (mix_q_src_c036_0_15 0 bpf_c036_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_0_15 (mix_q_src_c036_0_15 mix_q_c036_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c036_0 (mix_i_c036_0 0) resistor r=1G
RMIXQ_c036_0 (mix_q_c036_0 0) resistor r=1G
RINTI_c036_0 (mix_i_c036_0 Icar_c036_0) resistor r=1k
CINTI_c036_0 (Icar_c036_0 0) capacitor c=80p
RINTQ_c036_0 (mix_q_c036_0 Qcar_c036_0) resistor r=1k
CINTQ_c036_0 (Qcar_c036_0 0) capacitor c=80p

// bl036, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c036_1 (bl036 n_cbpf_c036_1) capacitor c=1.013211836423e-13
LBPF_c036_1 (n_cbpf_c036_1 bpf_c036_1) inductor l=1.000000000000e-06
RBPF_c036_1 (bpf_c036_1 0) resistor r=1.570796326795e+02
EMIXI_c036_1_00 (mix_i_src_c036_1_00 0 bpf_c036_1 0) vcvs gain=9.807852804032e-01
SMIXI_c036_1_00 (mix_i_src_c036_1_00 mix_i_c036_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_00 (mix_q_src_c036_1_00 0 bpf_c036_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_1_00 (mix_q_src_c036_1_00 mix_q_c036_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_01 (mix_i_src_c036_1_01 0 bpf_c036_1 0) vcvs gain=8.314696123025e-01
SMIXI_c036_1_01 (mix_i_src_c036_1_01 mix_i_c036_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_01 (mix_q_src_c036_1_01 0 bpf_c036_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_1_01 (mix_q_src_c036_1_01 mix_q_c036_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_02 (mix_i_src_c036_1_02 0 bpf_c036_1 0) vcvs gain=5.555702330196e-01
SMIXI_c036_1_02 (mix_i_src_c036_1_02 mix_i_c036_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_02 (mix_q_src_c036_1_02 0 bpf_c036_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_1_02 (mix_q_src_c036_1_02 mix_q_c036_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_03 (mix_i_src_c036_1_03 0 bpf_c036_1 0) vcvs gain=1.950903220161e-01
SMIXI_c036_1_03 (mix_i_src_c036_1_03 mix_i_c036_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_03 (mix_q_src_c036_1_03 0 bpf_c036_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_1_03 (mix_q_src_c036_1_03 mix_q_c036_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_04 (mix_i_src_c036_1_04 0 bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_1_04 (mix_i_src_c036_1_04 mix_i_c036_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_04 (mix_q_src_c036_1_04 0 bpf_c036_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_1_04 (mix_q_src_c036_1_04 mix_q_c036_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_05 (mix_i_src_c036_1_05 0 bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_1_05 (mix_i_src_c036_1_05 mix_i_c036_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_05 (mix_q_src_c036_1_05 0 bpf_c036_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_1_05 (mix_q_src_c036_1_05 mix_q_c036_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_06 (mix_i_src_c036_1_06 0 bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_1_06 (mix_i_src_c036_1_06 mix_i_c036_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_06 (mix_q_src_c036_1_06 0 bpf_c036_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_1_06 (mix_q_src_c036_1_06 mix_q_c036_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_07 (mix_i_src_c036_1_07 0 bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_1_07 (mix_i_src_c036_1_07 mix_i_c036_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_07 (mix_q_src_c036_1_07 0 bpf_c036_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_1_07 (mix_q_src_c036_1_07 mix_q_c036_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_08 (mix_i_src_c036_1_08 0 bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_1_08 (mix_i_src_c036_1_08 mix_i_c036_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_08 (mix_q_src_c036_1_08 0 bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_1_08 (mix_q_src_c036_1_08 mix_q_c036_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_09 (mix_i_src_c036_1_09 0 bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_1_09 (mix_i_src_c036_1_09 mix_i_c036_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_09 (mix_q_src_c036_1_09 0 bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_1_09 (mix_q_src_c036_1_09 mix_q_c036_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_10 (mix_i_src_c036_1_10 0 bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_1_10 (mix_i_src_c036_1_10 mix_i_c036_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_10 (mix_q_src_c036_1_10 0 bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_1_10 (mix_q_src_c036_1_10 mix_q_c036_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_11 (mix_i_src_c036_1_11 0 bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_1_11 (mix_i_src_c036_1_11 mix_i_c036_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_11 (mix_q_src_c036_1_11 0 bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_1_11 (mix_q_src_c036_1_11 mix_q_c036_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_12 (mix_i_src_c036_1_12 0 bpf_c036_1 0) vcvs gain=1.950903220161e-01
SMIXI_c036_1_12 (mix_i_src_c036_1_12 mix_i_c036_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_12 (mix_q_src_c036_1_12 0 bpf_c036_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_1_12 (mix_q_src_c036_1_12 mix_q_c036_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_13 (mix_i_src_c036_1_13 0 bpf_c036_1 0) vcvs gain=5.555702330196e-01
SMIXI_c036_1_13 (mix_i_src_c036_1_13 mix_i_c036_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_13 (mix_q_src_c036_1_13 0 bpf_c036_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_1_13 (mix_q_src_c036_1_13 mix_q_c036_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_14 (mix_i_src_c036_1_14 0 bpf_c036_1 0) vcvs gain=8.314696123025e-01
SMIXI_c036_1_14 (mix_i_src_c036_1_14 mix_i_c036_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_14 (mix_q_src_c036_1_14 0 bpf_c036_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_1_14 (mix_q_src_c036_1_14 mix_q_c036_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_1_15 (mix_i_src_c036_1_15 0 bpf_c036_1 0) vcvs gain=9.807852804032e-01
SMIXI_c036_1_15 (mix_i_src_c036_1_15 mix_i_c036_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_1_15 (mix_q_src_c036_1_15 0 bpf_c036_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_1_15 (mix_q_src_c036_1_15 mix_q_c036_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c036_1 (mix_i_c036_1 0) resistor r=1G
RMIXQ_c036_1 (mix_q_c036_1 0) resistor r=1G
RINTI_c036_1 (mix_i_c036_1 Icar_c036_1) resistor r=1k
CINTI_c036_1 (Icar_c036_1 0) capacitor c=80p
RINTQ_c036_1 (mix_q_c036_1 Qcar_c036_1) resistor r=1k
CINTQ_c036_1 (Qcar_c036_1 0) capacitor c=80p

// bl036, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c036_2 (bl036 n_cbpf_c036_2) capacitor c=4.503163717437e-14
LBPF_c036_2 (n_cbpf_c036_2 bpf_c036_2) inductor l=1.000000000000e-06
RBPF_c036_2 (bpf_c036_2 0) resistor r=2.356194490192e+02
EMIXI_c036_2_00 (mix_i_src_c036_2_00 0 bpf_c036_2 0) vcvs gain=9.807852804032e-01
SMIXI_c036_2_00 (mix_i_src_c036_2_00 mix_i_c036_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_00 (mix_q_src_c036_2_00 0 bpf_c036_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_2_00 (mix_q_src_c036_2_00 mix_q_c036_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_01 (mix_i_src_c036_2_01 0 bpf_c036_2 0) vcvs gain=8.314696123025e-01
SMIXI_c036_2_01 (mix_i_src_c036_2_01 mix_i_c036_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_01 (mix_q_src_c036_2_01 0 bpf_c036_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_2_01 (mix_q_src_c036_2_01 mix_q_c036_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_02 (mix_i_src_c036_2_02 0 bpf_c036_2 0) vcvs gain=5.555702330196e-01
SMIXI_c036_2_02 (mix_i_src_c036_2_02 mix_i_c036_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_02 (mix_q_src_c036_2_02 0 bpf_c036_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_2_02 (mix_q_src_c036_2_02 mix_q_c036_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_03 (mix_i_src_c036_2_03 0 bpf_c036_2 0) vcvs gain=1.950903220161e-01
SMIXI_c036_2_03 (mix_i_src_c036_2_03 mix_i_c036_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_03 (mix_q_src_c036_2_03 0 bpf_c036_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_2_03 (mix_q_src_c036_2_03 mix_q_c036_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_04 (mix_i_src_c036_2_04 0 bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_2_04 (mix_i_src_c036_2_04 mix_i_c036_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_04 (mix_q_src_c036_2_04 0 bpf_c036_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_2_04 (mix_q_src_c036_2_04 mix_q_c036_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_05 (mix_i_src_c036_2_05 0 bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_2_05 (mix_i_src_c036_2_05 mix_i_c036_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_05 (mix_q_src_c036_2_05 0 bpf_c036_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_2_05 (mix_q_src_c036_2_05 mix_q_c036_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_06 (mix_i_src_c036_2_06 0 bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_2_06 (mix_i_src_c036_2_06 mix_i_c036_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_06 (mix_q_src_c036_2_06 0 bpf_c036_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_2_06 (mix_q_src_c036_2_06 mix_q_c036_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_07 (mix_i_src_c036_2_07 0 bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_2_07 (mix_i_src_c036_2_07 mix_i_c036_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_07 (mix_q_src_c036_2_07 0 bpf_c036_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_2_07 (mix_q_src_c036_2_07 mix_q_c036_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_08 (mix_i_src_c036_2_08 0 bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_2_08 (mix_i_src_c036_2_08 mix_i_c036_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_08 (mix_q_src_c036_2_08 0 bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_2_08 (mix_q_src_c036_2_08 mix_q_c036_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_09 (mix_i_src_c036_2_09 0 bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_2_09 (mix_i_src_c036_2_09 mix_i_c036_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_09 (mix_q_src_c036_2_09 0 bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_2_09 (mix_q_src_c036_2_09 mix_q_c036_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_10 (mix_i_src_c036_2_10 0 bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_2_10 (mix_i_src_c036_2_10 mix_i_c036_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_10 (mix_q_src_c036_2_10 0 bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_2_10 (mix_q_src_c036_2_10 mix_q_c036_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_11 (mix_i_src_c036_2_11 0 bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_2_11 (mix_i_src_c036_2_11 mix_i_c036_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_11 (mix_q_src_c036_2_11 0 bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_2_11 (mix_q_src_c036_2_11 mix_q_c036_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_12 (mix_i_src_c036_2_12 0 bpf_c036_2 0) vcvs gain=1.950903220161e-01
SMIXI_c036_2_12 (mix_i_src_c036_2_12 mix_i_c036_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_12 (mix_q_src_c036_2_12 0 bpf_c036_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_2_12 (mix_q_src_c036_2_12 mix_q_c036_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_13 (mix_i_src_c036_2_13 0 bpf_c036_2 0) vcvs gain=5.555702330196e-01
SMIXI_c036_2_13 (mix_i_src_c036_2_13 mix_i_c036_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_13 (mix_q_src_c036_2_13 0 bpf_c036_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_2_13 (mix_q_src_c036_2_13 mix_q_c036_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_14 (mix_i_src_c036_2_14 0 bpf_c036_2 0) vcvs gain=8.314696123025e-01
SMIXI_c036_2_14 (mix_i_src_c036_2_14 mix_i_c036_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_14 (mix_q_src_c036_2_14 0 bpf_c036_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_2_14 (mix_q_src_c036_2_14 mix_q_c036_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_2_15 (mix_i_src_c036_2_15 0 bpf_c036_2 0) vcvs gain=9.807852804032e-01
SMIXI_c036_2_15 (mix_i_src_c036_2_15 mix_i_c036_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_2_15 (mix_q_src_c036_2_15 0 bpf_c036_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_2_15 (mix_q_src_c036_2_15 mix_q_c036_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c036_2 (mix_i_c036_2 0) resistor r=1G
RMIXQ_c036_2 (mix_q_c036_2 0) resistor r=1G
RINTI_c036_2 (mix_i_c036_2 Icar_c036_2) resistor r=1k
CINTI_c036_2 (Icar_c036_2 0) capacitor c=80p
RINTQ_c036_2 (mix_q_c036_2 Qcar_c036_2) resistor r=1k
CINTQ_c036_2 (Qcar_c036_2 0) capacitor c=80p

// bl036, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c036_3 (bl036 n_cbpf_c036_3) capacitor c=2.533029591058e-14
LBPF_c036_3 (n_cbpf_c036_3 bpf_c036_3) inductor l=1.000000000000e-06
RBPF_c036_3 (bpf_c036_3 0) resistor r=3.141592653590e+02
EMIXI_c036_3_00 (mix_i_src_c036_3_00 0 bpf_c036_3 0) vcvs gain=9.807852804032e-01
SMIXI_c036_3_00 (mix_i_src_c036_3_00 mix_i_c036_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_00 (mix_q_src_c036_3_00 0 bpf_c036_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_3_00 (mix_q_src_c036_3_00 mix_q_c036_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_01 (mix_i_src_c036_3_01 0 bpf_c036_3 0) vcvs gain=8.314696123025e-01
SMIXI_c036_3_01 (mix_i_src_c036_3_01 mix_i_c036_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_01 (mix_q_src_c036_3_01 0 bpf_c036_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_3_01 (mix_q_src_c036_3_01 mix_q_c036_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_02 (mix_i_src_c036_3_02 0 bpf_c036_3 0) vcvs gain=5.555702330196e-01
SMIXI_c036_3_02 (mix_i_src_c036_3_02 mix_i_c036_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_02 (mix_q_src_c036_3_02 0 bpf_c036_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_3_02 (mix_q_src_c036_3_02 mix_q_c036_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_03 (mix_i_src_c036_3_03 0 bpf_c036_3 0) vcvs gain=1.950903220161e-01
SMIXI_c036_3_03 (mix_i_src_c036_3_03 mix_i_c036_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_03 (mix_q_src_c036_3_03 0 bpf_c036_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_3_03 (mix_q_src_c036_3_03 mix_q_c036_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_04 (mix_i_src_c036_3_04 0 bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_3_04 (mix_i_src_c036_3_04 mix_i_c036_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_04 (mix_q_src_c036_3_04 0 bpf_c036_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c036_3_04 (mix_q_src_c036_3_04 mix_q_c036_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_05 (mix_i_src_c036_3_05 0 bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_3_05 (mix_i_src_c036_3_05 mix_i_c036_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_05 (mix_q_src_c036_3_05 0 bpf_c036_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c036_3_05 (mix_q_src_c036_3_05 mix_q_c036_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_06 (mix_i_src_c036_3_06 0 bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_3_06 (mix_i_src_c036_3_06 mix_i_c036_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_06 (mix_q_src_c036_3_06 0 bpf_c036_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c036_3_06 (mix_q_src_c036_3_06 mix_q_c036_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_07 (mix_i_src_c036_3_07 0 bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_3_07 (mix_i_src_c036_3_07 mix_i_c036_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_07 (mix_q_src_c036_3_07 0 bpf_c036_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c036_3_07 (mix_q_src_c036_3_07 mix_q_c036_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_08 (mix_i_src_c036_3_08 0 bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c036_3_08 (mix_i_src_c036_3_08 mix_i_c036_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_08 (mix_q_src_c036_3_08 0 bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_3_08 (mix_q_src_c036_3_08 mix_q_c036_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_09 (mix_i_src_c036_3_09 0 bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c036_3_09 (mix_i_src_c036_3_09 mix_i_c036_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_09 (mix_q_src_c036_3_09 0 bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_3_09 (mix_q_src_c036_3_09 mix_q_c036_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_10 (mix_i_src_c036_3_10 0 bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c036_3_10 (mix_i_src_c036_3_10 mix_i_c036_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_10 (mix_q_src_c036_3_10 0 bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_3_10 (mix_q_src_c036_3_10 mix_q_c036_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_11 (mix_i_src_c036_3_11 0 bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c036_3_11 (mix_i_src_c036_3_11 mix_i_c036_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_11 (mix_q_src_c036_3_11 0 bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_3_11 (mix_q_src_c036_3_11 mix_q_c036_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_12 (mix_i_src_c036_3_12 0 bpf_c036_3 0) vcvs gain=1.950903220161e-01
SMIXI_c036_3_12 (mix_i_src_c036_3_12 mix_i_c036_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_12 (mix_q_src_c036_3_12 0 bpf_c036_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c036_3_12 (mix_q_src_c036_3_12 mix_q_c036_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_13 (mix_i_src_c036_3_13 0 bpf_c036_3 0) vcvs gain=5.555702330196e-01
SMIXI_c036_3_13 (mix_i_src_c036_3_13 mix_i_c036_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_13 (mix_q_src_c036_3_13 0 bpf_c036_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c036_3_13 (mix_q_src_c036_3_13 mix_q_c036_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_14 (mix_i_src_c036_3_14 0 bpf_c036_3 0) vcvs gain=8.314696123025e-01
SMIXI_c036_3_14 (mix_i_src_c036_3_14 mix_i_c036_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_14 (mix_q_src_c036_3_14 0 bpf_c036_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c036_3_14 (mix_q_src_c036_3_14 mix_q_c036_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c036_3_15 (mix_i_src_c036_3_15 0 bpf_c036_3 0) vcvs gain=9.807852804032e-01
SMIXI_c036_3_15 (mix_i_src_c036_3_15 mix_i_c036_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c036_3_15 (mix_q_src_c036_3_15 0 bpf_c036_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c036_3_15 (mix_q_src_c036_3_15 mix_q_c036_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c036_3 (mix_i_c036_3 0) resistor r=1G
RMIXQ_c036_3 (mix_q_c036_3 0) resistor r=1G
RINTI_c036_3 (mix_i_c036_3 Icar_c036_3) resistor r=1k
CINTI_c036_3 (Icar_c036_3 0) capacitor c=80p
RINTQ_c036_3 (mix_q_c036_3 Qcar_c036_3) resistor r=1k
CINTQ_c036_3 (Qcar_c036_3 0) capacitor c=80p

// bl037, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c037_0 (bl037 n_cbpf_c037_0) capacitor c=4.052847345694e-13
LBPF_c037_0 (n_cbpf_c037_0 bpf_c037_0) inductor l=1.000000000000e-06
RBPF_c037_0 (bpf_c037_0 0) resistor r=7.853981633974e+01
EMIXI_c037_0_00 (mix_i_src_c037_0_00 0 bpf_c037_0 0) vcvs gain=9.807852804032e-01
SMIXI_c037_0_00 (mix_i_src_c037_0_00 mix_i_c037_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_00 (mix_q_src_c037_0_00 0 bpf_c037_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_0_00 (mix_q_src_c037_0_00 mix_q_c037_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_01 (mix_i_src_c037_0_01 0 bpf_c037_0 0) vcvs gain=8.314696123025e-01
SMIXI_c037_0_01 (mix_i_src_c037_0_01 mix_i_c037_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_01 (mix_q_src_c037_0_01 0 bpf_c037_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_0_01 (mix_q_src_c037_0_01 mix_q_c037_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_02 (mix_i_src_c037_0_02 0 bpf_c037_0 0) vcvs gain=5.555702330196e-01
SMIXI_c037_0_02 (mix_i_src_c037_0_02 mix_i_c037_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_02 (mix_q_src_c037_0_02 0 bpf_c037_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_0_02 (mix_q_src_c037_0_02 mix_q_c037_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_03 (mix_i_src_c037_0_03 0 bpf_c037_0 0) vcvs gain=1.950903220161e-01
SMIXI_c037_0_03 (mix_i_src_c037_0_03 mix_i_c037_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_03 (mix_q_src_c037_0_03 0 bpf_c037_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_0_03 (mix_q_src_c037_0_03 mix_q_c037_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_04 (mix_i_src_c037_0_04 0 bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_0_04 (mix_i_src_c037_0_04 mix_i_c037_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_04 (mix_q_src_c037_0_04 0 bpf_c037_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_0_04 (mix_q_src_c037_0_04 mix_q_c037_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_05 (mix_i_src_c037_0_05 0 bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_0_05 (mix_i_src_c037_0_05 mix_i_c037_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_05 (mix_q_src_c037_0_05 0 bpf_c037_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_0_05 (mix_q_src_c037_0_05 mix_q_c037_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_06 (mix_i_src_c037_0_06 0 bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_0_06 (mix_i_src_c037_0_06 mix_i_c037_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_06 (mix_q_src_c037_0_06 0 bpf_c037_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_0_06 (mix_q_src_c037_0_06 mix_q_c037_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_07 (mix_i_src_c037_0_07 0 bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_0_07 (mix_i_src_c037_0_07 mix_i_c037_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_07 (mix_q_src_c037_0_07 0 bpf_c037_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_0_07 (mix_q_src_c037_0_07 mix_q_c037_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_08 (mix_i_src_c037_0_08 0 bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_0_08 (mix_i_src_c037_0_08 mix_i_c037_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_08 (mix_q_src_c037_0_08 0 bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_0_08 (mix_q_src_c037_0_08 mix_q_c037_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_09 (mix_i_src_c037_0_09 0 bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_0_09 (mix_i_src_c037_0_09 mix_i_c037_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_09 (mix_q_src_c037_0_09 0 bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_0_09 (mix_q_src_c037_0_09 mix_q_c037_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_10 (mix_i_src_c037_0_10 0 bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_0_10 (mix_i_src_c037_0_10 mix_i_c037_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_10 (mix_q_src_c037_0_10 0 bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_0_10 (mix_q_src_c037_0_10 mix_q_c037_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_11 (mix_i_src_c037_0_11 0 bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_0_11 (mix_i_src_c037_0_11 mix_i_c037_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_11 (mix_q_src_c037_0_11 0 bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_0_11 (mix_q_src_c037_0_11 mix_q_c037_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_12 (mix_i_src_c037_0_12 0 bpf_c037_0 0) vcvs gain=1.950903220161e-01
SMIXI_c037_0_12 (mix_i_src_c037_0_12 mix_i_c037_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_12 (mix_q_src_c037_0_12 0 bpf_c037_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_0_12 (mix_q_src_c037_0_12 mix_q_c037_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_13 (mix_i_src_c037_0_13 0 bpf_c037_0 0) vcvs gain=5.555702330196e-01
SMIXI_c037_0_13 (mix_i_src_c037_0_13 mix_i_c037_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_13 (mix_q_src_c037_0_13 0 bpf_c037_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_0_13 (mix_q_src_c037_0_13 mix_q_c037_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_14 (mix_i_src_c037_0_14 0 bpf_c037_0 0) vcvs gain=8.314696123025e-01
SMIXI_c037_0_14 (mix_i_src_c037_0_14 mix_i_c037_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_14 (mix_q_src_c037_0_14 0 bpf_c037_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_0_14 (mix_q_src_c037_0_14 mix_q_c037_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_0_15 (mix_i_src_c037_0_15 0 bpf_c037_0 0) vcvs gain=9.807852804032e-01
SMIXI_c037_0_15 (mix_i_src_c037_0_15 mix_i_c037_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_0_15 (mix_q_src_c037_0_15 0 bpf_c037_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_0_15 (mix_q_src_c037_0_15 mix_q_c037_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c037_0 (mix_i_c037_0 0) resistor r=1G
RMIXQ_c037_0 (mix_q_c037_0 0) resistor r=1G
RINTI_c037_0 (mix_i_c037_0 Icar_c037_0) resistor r=1k
CINTI_c037_0 (Icar_c037_0 0) capacitor c=80p
RINTQ_c037_0 (mix_q_c037_0 Qcar_c037_0) resistor r=1k
CINTQ_c037_0 (Qcar_c037_0 0) capacitor c=80p

// bl037, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c037_1 (bl037 n_cbpf_c037_1) capacitor c=1.013211836423e-13
LBPF_c037_1 (n_cbpf_c037_1 bpf_c037_1) inductor l=1.000000000000e-06
RBPF_c037_1 (bpf_c037_1 0) resistor r=1.570796326795e+02
EMIXI_c037_1_00 (mix_i_src_c037_1_00 0 bpf_c037_1 0) vcvs gain=9.807852804032e-01
SMIXI_c037_1_00 (mix_i_src_c037_1_00 mix_i_c037_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_00 (mix_q_src_c037_1_00 0 bpf_c037_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_1_00 (mix_q_src_c037_1_00 mix_q_c037_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_01 (mix_i_src_c037_1_01 0 bpf_c037_1 0) vcvs gain=8.314696123025e-01
SMIXI_c037_1_01 (mix_i_src_c037_1_01 mix_i_c037_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_01 (mix_q_src_c037_1_01 0 bpf_c037_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_1_01 (mix_q_src_c037_1_01 mix_q_c037_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_02 (mix_i_src_c037_1_02 0 bpf_c037_1 0) vcvs gain=5.555702330196e-01
SMIXI_c037_1_02 (mix_i_src_c037_1_02 mix_i_c037_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_02 (mix_q_src_c037_1_02 0 bpf_c037_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_1_02 (mix_q_src_c037_1_02 mix_q_c037_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_03 (mix_i_src_c037_1_03 0 bpf_c037_1 0) vcvs gain=1.950903220161e-01
SMIXI_c037_1_03 (mix_i_src_c037_1_03 mix_i_c037_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_03 (mix_q_src_c037_1_03 0 bpf_c037_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_1_03 (mix_q_src_c037_1_03 mix_q_c037_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_04 (mix_i_src_c037_1_04 0 bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_1_04 (mix_i_src_c037_1_04 mix_i_c037_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_04 (mix_q_src_c037_1_04 0 bpf_c037_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_1_04 (mix_q_src_c037_1_04 mix_q_c037_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_05 (mix_i_src_c037_1_05 0 bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_1_05 (mix_i_src_c037_1_05 mix_i_c037_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_05 (mix_q_src_c037_1_05 0 bpf_c037_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_1_05 (mix_q_src_c037_1_05 mix_q_c037_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_06 (mix_i_src_c037_1_06 0 bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_1_06 (mix_i_src_c037_1_06 mix_i_c037_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_06 (mix_q_src_c037_1_06 0 bpf_c037_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_1_06 (mix_q_src_c037_1_06 mix_q_c037_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_07 (mix_i_src_c037_1_07 0 bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_1_07 (mix_i_src_c037_1_07 mix_i_c037_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_07 (mix_q_src_c037_1_07 0 bpf_c037_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_1_07 (mix_q_src_c037_1_07 mix_q_c037_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_08 (mix_i_src_c037_1_08 0 bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_1_08 (mix_i_src_c037_1_08 mix_i_c037_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_08 (mix_q_src_c037_1_08 0 bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_1_08 (mix_q_src_c037_1_08 mix_q_c037_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_09 (mix_i_src_c037_1_09 0 bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_1_09 (mix_i_src_c037_1_09 mix_i_c037_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_09 (mix_q_src_c037_1_09 0 bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_1_09 (mix_q_src_c037_1_09 mix_q_c037_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_10 (mix_i_src_c037_1_10 0 bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_1_10 (mix_i_src_c037_1_10 mix_i_c037_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_10 (mix_q_src_c037_1_10 0 bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_1_10 (mix_q_src_c037_1_10 mix_q_c037_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_11 (mix_i_src_c037_1_11 0 bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_1_11 (mix_i_src_c037_1_11 mix_i_c037_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_11 (mix_q_src_c037_1_11 0 bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_1_11 (mix_q_src_c037_1_11 mix_q_c037_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_12 (mix_i_src_c037_1_12 0 bpf_c037_1 0) vcvs gain=1.950903220161e-01
SMIXI_c037_1_12 (mix_i_src_c037_1_12 mix_i_c037_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_12 (mix_q_src_c037_1_12 0 bpf_c037_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_1_12 (mix_q_src_c037_1_12 mix_q_c037_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_13 (mix_i_src_c037_1_13 0 bpf_c037_1 0) vcvs gain=5.555702330196e-01
SMIXI_c037_1_13 (mix_i_src_c037_1_13 mix_i_c037_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_13 (mix_q_src_c037_1_13 0 bpf_c037_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_1_13 (mix_q_src_c037_1_13 mix_q_c037_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_14 (mix_i_src_c037_1_14 0 bpf_c037_1 0) vcvs gain=8.314696123025e-01
SMIXI_c037_1_14 (mix_i_src_c037_1_14 mix_i_c037_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_14 (mix_q_src_c037_1_14 0 bpf_c037_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_1_14 (mix_q_src_c037_1_14 mix_q_c037_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_1_15 (mix_i_src_c037_1_15 0 bpf_c037_1 0) vcvs gain=9.807852804032e-01
SMIXI_c037_1_15 (mix_i_src_c037_1_15 mix_i_c037_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_1_15 (mix_q_src_c037_1_15 0 bpf_c037_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_1_15 (mix_q_src_c037_1_15 mix_q_c037_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c037_1 (mix_i_c037_1 0) resistor r=1G
RMIXQ_c037_1 (mix_q_c037_1 0) resistor r=1G
RINTI_c037_1 (mix_i_c037_1 Icar_c037_1) resistor r=1k
CINTI_c037_1 (Icar_c037_1 0) capacitor c=80p
RINTQ_c037_1 (mix_q_c037_1 Qcar_c037_1) resistor r=1k
CINTQ_c037_1 (Qcar_c037_1 0) capacitor c=80p

// bl037, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c037_2 (bl037 n_cbpf_c037_2) capacitor c=4.503163717437e-14
LBPF_c037_2 (n_cbpf_c037_2 bpf_c037_2) inductor l=1.000000000000e-06
RBPF_c037_2 (bpf_c037_2 0) resistor r=2.356194490192e+02
EMIXI_c037_2_00 (mix_i_src_c037_2_00 0 bpf_c037_2 0) vcvs gain=9.807852804032e-01
SMIXI_c037_2_00 (mix_i_src_c037_2_00 mix_i_c037_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_00 (mix_q_src_c037_2_00 0 bpf_c037_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_2_00 (mix_q_src_c037_2_00 mix_q_c037_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_01 (mix_i_src_c037_2_01 0 bpf_c037_2 0) vcvs gain=8.314696123025e-01
SMIXI_c037_2_01 (mix_i_src_c037_2_01 mix_i_c037_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_01 (mix_q_src_c037_2_01 0 bpf_c037_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_2_01 (mix_q_src_c037_2_01 mix_q_c037_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_02 (mix_i_src_c037_2_02 0 bpf_c037_2 0) vcvs gain=5.555702330196e-01
SMIXI_c037_2_02 (mix_i_src_c037_2_02 mix_i_c037_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_02 (mix_q_src_c037_2_02 0 bpf_c037_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_2_02 (mix_q_src_c037_2_02 mix_q_c037_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_03 (mix_i_src_c037_2_03 0 bpf_c037_2 0) vcvs gain=1.950903220161e-01
SMIXI_c037_2_03 (mix_i_src_c037_2_03 mix_i_c037_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_03 (mix_q_src_c037_2_03 0 bpf_c037_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_2_03 (mix_q_src_c037_2_03 mix_q_c037_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_04 (mix_i_src_c037_2_04 0 bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_2_04 (mix_i_src_c037_2_04 mix_i_c037_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_04 (mix_q_src_c037_2_04 0 bpf_c037_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_2_04 (mix_q_src_c037_2_04 mix_q_c037_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_05 (mix_i_src_c037_2_05 0 bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_2_05 (mix_i_src_c037_2_05 mix_i_c037_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_05 (mix_q_src_c037_2_05 0 bpf_c037_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_2_05 (mix_q_src_c037_2_05 mix_q_c037_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_06 (mix_i_src_c037_2_06 0 bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_2_06 (mix_i_src_c037_2_06 mix_i_c037_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_06 (mix_q_src_c037_2_06 0 bpf_c037_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_2_06 (mix_q_src_c037_2_06 mix_q_c037_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_07 (mix_i_src_c037_2_07 0 bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_2_07 (mix_i_src_c037_2_07 mix_i_c037_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_07 (mix_q_src_c037_2_07 0 bpf_c037_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_2_07 (mix_q_src_c037_2_07 mix_q_c037_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_08 (mix_i_src_c037_2_08 0 bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_2_08 (mix_i_src_c037_2_08 mix_i_c037_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_08 (mix_q_src_c037_2_08 0 bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_2_08 (mix_q_src_c037_2_08 mix_q_c037_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_09 (mix_i_src_c037_2_09 0 bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_2_09 (mix_i_src_c037_2_09 mix_i_c037_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_09 (mix_q_src_c037_2_09 0 bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_2_09 (mix_q_src_c037_2_09 mix_q_c037_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_10 (mix_i_src_c037_2_10 0 bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_2_10 (mix_i_src_c037_2_10 mix_i_c037_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_10 (mix_q_src_c037_2_10 0 bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_2_10 (mix_q_src_c037_2_10 mix_q_c037_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_11 (mix_i_src_c037_2_11 0 bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_2_11 (mix_i_src_c037_2_11 mix_i_c037_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_11 (mix_q_src_c037_2_11 0 bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_2_11 (mix_q_src_c037_2_11 mix_q_c037_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_12 (mix_i_src_c037_2_12 0 bpf_c037_2 0) vcvs gain=1.950903220161e-01
SMIXI_c037_2_12 (mix_i_src_c037_2_12 mix_i_c037_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_12 (mix_q_src_c037_2_12 0 bpf_c037_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_2_12 (mix_q_src_c037_2_12 mix_q_c037_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_13 (mix_i_src_c037_2_13 0 bpf_c037_2 0) vcvs gain=5.555702330196e-01
SMIXI_c037_2_13 (mix_i_src_c037_2_13 mix_i_c037_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_13 (mix_q_src_c037_2_13 0 bpf_c037_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_2_13 (mix_q_src_c037_2_13 mix_q_c037_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_14 (mix_i_src_c037_2_14 0 bpf_c037_2 0) vcvs gain=8.314696123025e-01
SMIXI_c037_2_14 (mix_i_src_c037_2_14 mix_i_c037_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_14 (mix_q_src_c037_2_14 0 bpf_c037_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_2_14 (mix_q_src_c037_2_14 mix_q_c037_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_2_15 (mix_i_src_c037_2_15 0 bpf_c037_2 0) vcvs gain=9.807852804032e-01
SMIXI_c037_2_15 (mix_i_src_c037_2_15 mix_i_c037_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_2_15 (mix_q_src_c037_2_15 0 bpf_c037_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_2_15 (mix_q_src_c037_2_15 mix_q_c037_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c037_2 (mix_i_c037_2 0) resistor r=1G
RMIXQ_c037_2 (mix_q_c037_2 0) resistor r=1G
RINTI_c037_2 (mix_i_c037_2 Icar_c037_2) resistor r=1k
CINTI_c037_2 (Icar_c037_2 0) capacitor c=80p
RINTQ_c037_2 (mix_q_c037_2 Qcar_c037_2) resistor r=1k
CINTQ_c037_2 (Qcar_c037_2 0) capacitor c=80p

// bl037, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c037_3 (bl037 n_cbpf_c037_3) capacitor c=2.533029591058e-14
LBPF_c037_3 (n_cbpf_c037_3 bpf_c037_3) inductor l=1.000000000000e-06
RBPF_c037_3 (bpf_c037_3 0) resistor r=3.141592653590e+02
EMIXI_c037_3_00 (mix_i_src_c037_3_00 0 bpf_c037_3 0) vcvs gain=9.807852804032e-01
SMIXI_c037_3_00 (mix_i_src_c037_3_00 mix_i_c037_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_00 (mix_q_src_c037_3_00 0 bpf_c037_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_3_00 (mix_q_src_c037_3_00 mix_q_c037_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_01 (mix_i_src_c037_3_01 0 bpf_c037_3 0) vcvs gain=8.314696123025e-01
SMIXI_c037_3_01 (mix_i_src_c037_3_01 mix_i_c037_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_01 (mix_q_src_c037_3_01 0 bpf_c037_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_3_01 (mix_q_src_c037_3_01 mix_q_c037_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_02 (mix_i_src_c037_3_02 0 bpf_c037_3 0) vcvs gain=5.555702330196e-01
SMIXI_c037_3_02 (mix_i_src_c037_3_02 mix_i_c037_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_02 (mix_q_src_c037_3_02 0 bpf_c037_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_3_02 (mix_q_src_c037_3_02 mix_q_c037_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_03 (mix_i_src_c037_3_03 0 bpf_c037_3 0) vcvs gain=1.950903220161e-01
SMIXI_c037_3_03 (mix_i_src_c037_3_03 mix_i_c037_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_03 (mix_q_src_c037_3_03 0 bpf_c037_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_3_03 (mix_q_src_c037_3_03 mix_q_c037_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_04 (mix_i_src_c037_3_04 0 bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_3_04 (mix_i_src_c037_3_04 mix_i_c037_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_04 (mix_q_src_c037_3_04 0 bpf_c037_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c037_3_04 (mix_q_src_c037_3_04 mix_q_c037_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_05 (mix_i_src_c037_3_05 0 bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_3_05 (mix_i_src_c037_3_05 mix_i_c037_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_05 (mix_q_src_c037_3_05 0 bpf_c037_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c037_3_05 (mix_q_src_c037_3_05 mix_q_c037_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_06 (mix_i_src_c037_3_06 0 bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_3_06 (mix_i_src_c037_3_06 mix_i_c037_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_06 (mix_q_src_c037_3_06 0 bpf_c037_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c037_3_06 (mix_q_src_c037_3_06 mix_q_c037_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_07 (mix_i_src_c037_3_07 0 bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_3_07 (mix_i_src_c037_3_07 mix_i_c037_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_07 (mix_q_src_c037_3_07 0 bpf_c037_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c037_3_07 (mix_q_src_c037_3_07 mix_q_c037_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_08 (mix_i_src_c037_3_08 0 bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c037_3_08 (mix_i_src_c037_3_08 mix_i_c037_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_08 (mix_q_src_c037_3_08 0 bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_3_08 (mix_q_src_c037_3_08 mix_q_c037_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_09 (mix_i_src_c037_3_09 0 bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c037_3_09 (mix_i_src_c037_3_09 mix_i_c037_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_09 (mix_q_src_c037_3_09 0 bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_3_09 (mix_q_src_c037_3_09 mix_q_c037_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_10 (mix_i_src_c037_3_10 0 bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c037_3_10 (mix_i_src_c037_3_10 mix_i_c037_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_10 (mix_q_src_c037_3_10 0 bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_3_10 (mix_q_src_c037_3_10 mix_q_c037_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_11 (mix_i_src_c037_3_11 0 bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c037_3_11 (mix_i_src_c037_3_11 mix_i_c037_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_11 (mix_q_src_c037_3_11 0 bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_3_11 (mix_q_src_c037_3_11 mix_q_c037_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_12 (mix_i_src_c037_3_12 0 bpf_c037_3 0) vcvs gain=1.950903220161e-01
SMIXI_c037_3_12 (mix_i_src_c037_3_12 mix_i_c037_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_12 (mix_q_src_c037_3_12 0 bpf_c037_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c037_3_12 (mix_q_src_c037_3_12 mix_q_c037_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_13 (mix_i_src_c037_3_13 0 bpf_c037_3 0) vcvs gain=5.555702330196e-01
SMIXI_c037_3_13 (mix_i_src_c037_3_13 mix_i_c037_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_13 (mix_q_src_c037_3_13 0 bpf_c037_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c037_3_13 (mix_q_src_c037_3_13 mix_q_c037_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_14 (mix_i_src_c037_3_14 0 bpf_c037_3 0) vcvs gain=8.314696123025e-01
SMIXI_c037_3_14 (mix_i_src_c037_3_14 mix_i_c037_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_14 (mix_q_src_c037_3_14 0 bpf_c037_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c037_3_14 (mix_q_src_c037_3_14 mix_q_c037_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c037_3_15 (mix_i_src_c037_3_15 0 bpf_c037_3 0) vcvs gain=9.807852804032e-01
SMIXI_c037_3_15 (mix_i_src_c037_3_15 mix_i_c037_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c037_3_15 (mix_q_src_c037_3_15 0 bpf_c037_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c037_3_15 (mix_q_src_c037_3_15 mix_q_c037_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c037_3 (mix_i_c037_3 0) resistor r=1G
RMIXQ_c037_3 (mix_q_c037_3 0) resistor r=1G
RINTI_c037_3 (mix_i_c037_3 Icar_c037_3) resistor r=1k
CINTI_c037_3 (Icar_c037_3 0) capacitor c=80p
RINTQ_c037_3 (mix_q_c037_3 Qcar_c037_3) resistor r=1k
CINTQ_c037_3 (Qcar_c037_3 0) capacitor c=80p

// bl038, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c038_0 (bl038 n_cbpf_c038_0) capacitor c=4.052847345694e-13
LBPF_c038_0 (n_cbpf_c038_0 bpf_c038_0) inductor l=1.000000000000e-06
RBPF_c038_0 (bpf_c038_0 0) resistor r=7.853981633974e+01
EMIXI_c038_0_00 (mix_i_src_c038_0_00 0 bpf_c038_0 0) vcvs gain=9.807852804032e-01
SMIXI_c038_0_00 (mix_i_src_c038_0_00 mix_i_c038_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_00 (mix_q_src_c038_0_00 0 bpf_c038_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_0_00 (mix_q_src_c038_0_00 mix_q_c038_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_01 (mix_i_src_c038_0_01 0 bpf_c038_0 0) vcvs gain=8.314696123025e-01
SMIXI_c038_0_01 (mix_i_src_c038_0_01 mix_i_c038_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_01 (mix_q_src_c038_0_01 0 bpf_c038_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_0_01 (mix_q_src_c038_0_01 mix_q_c038_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_02 (mix_i_src_c038_0_02 0 bpf_c038_0 0) vcvs gain=5.555702330196e-01
SMIXI_c038_0_02 (mix_i_src_c038_0_02 mix_i_c038_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_02 (mix_q_src_c038_0_02 0 bpf_c038_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_0_02 (mix_q_src_c038_0_02 mix_q_c038_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_03 (mix_i_src_c038_0_03 0 bpf_c038_0 0) vcvs gain=1.950903220161e-01
SMIXI_c038_0_03 (mix_i_src_c038_0_03 mix_i_c038_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_03 (mix_q_src_c038_0_03 0 bpf_c038_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_0_03 (mix_q_src_c038_0_03 mix_q_c038_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_04 (mix_i_src_c038_0_04 0 bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_0_04 (mix_i_src_c038_0_04 mix_i_c038_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_04 (mix_q_src_c038_0_04 0 bpf_c038_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_0_04 (mix_q_src_c038_0_04 mix_q_c038_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_05 (mix_i_src_c038_0_05 0 bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_0_05 (mix_i_src_c038_0_05 mix_i_c038_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_05 (mix_q_src_c038_0_05 0 bpf_c038_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_0_05 (mix_q_src_c038_0_05 mix_q_c038_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_06 (mix_i_src_c038_0_06 0 bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_0_06 (mix_i_src_c038_0_06 mix_i_c038_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_06 (mix_q_src_c038_0_06 0 bpf_c038_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_0_06 (mix_q_src_c038_0_06 mix_q_c038_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_07 (mix_i_src_c038_0_07 0 bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_0_07 (mix_i_src_c038_0_07 mix_i_c038_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_07 (mix_q_src_c038_0_07 0 bpf_c038_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_0_07 (mix_q_src_c038_0_07 mix_q_c038_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_08 (mix_i_src_c038_0_08 0 bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_0_08 (mix_i_src_c038_0_08 mix_i_c038_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_08 (mix_q_src_c038_0_08 0 bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_0_08 (mix_q_src_c038_0_08 mix_q_c038_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_09 (mix_i_src_c038_0_09 0 bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_0_09 (mix_i_src_c038_0_09 mix_i_c038_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_09 (mix_q_src_c038_0_09 0 bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_0_09 (mix_q_src_c038_0_09 mix_q_c038_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_10 (mix_i_src_c038_0_10 0 bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_0_10 (mix_i_src_c038_0_10 mix_i_c038_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_10 (mix_q_src_c038_0_10 0 bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_0_10 (mix_q_src_c038_0_10 mix_q_c038_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_11 (mix_i_src_c038_0_11 0 bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_0_11 (mix_i_src_c038_0_11 mix_i_c038_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_11 (mix_q_src_c038_0_11 0 bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_0_11 (mix_q_src_c038_0_11 mix_q_c038_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_12 (mix_i_src_c038_0_12 0 bpf_c038_0 0) vcvs gain=1.950903220161e-01
SMIXI_c038_0_12 (mix_i_src_c038_0_12 mix_i_c038_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_12 (mix_q_src_c038_0_12 0 bpf_c038_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_0_12 (mix_q_src_c038_0_12 mix_q_c038_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_13 (mix_i_src_c038_0_13 0 bpf_c038_0 0) vcvs gain=5.555702330196e-01
SMIXI_c038_0_13 (mix_i_src_c038_0_13 mix_i_c038_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_13 (mix_q_src_c038_0_13 0 bpf_c038_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_0_13 (mix_q_src_c038_0_13 mix_q_c038_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_14 (mix_i_src_c038_0_14 0 bpf_c038_0 0) vcvs gain=8.314696123025e-01
SMIXI_c038_0_14 (mix_i_src_c038_0_14 mix_i_c038_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_14 (mix_q_src_c038_0_14 0 bpf_c038_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_0_14 (mix_q_src_c038_0_14 mix_q_c038_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_0_15 (mix_i_src_c038_0_15 0 bpf_c038_0 0) vcvs gain=9.807852804032e-01
SMIXI_c038_0_15 (mix_i_src_c038_0_15 mix_i_c038_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_0_15 (mix_q_src_c038_0_15 0 bpf_c038_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_0_15 (mix_q_src_c038_0_15 mix_q_c038_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c038_0 (mix_i_c038_0 0) resistor r=1G
RMIXQ_c038_0 (mix_q_c038_0 0) resistor r=1G
RINTI_c038_0 (mix_i_c038_0 Icar_c038_0) resistor r=1k
CINTI_c038_0 (Icar_c038_0 0) capacitor c=80p
RINTQ_c038_0 (mix_q_c038_0 Qcar_c038_0) resistor r=1k
CINTQ_c038_0 (Qcar_c038_0 0) capacitor c=80p

// bl038, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c038_1 (bl038 n_cbpf_c038_1) capacitor c=1.013211836423e-13
LBPF_c038_1 (n_cbpf_c038_1 bpf_c038_1) inductor l=1.000000000000e-06
RBPF_c038_1 (bpf_c038_1 0) resistor r=1.570796326795e+02
EMIXI_c038_1_00 (mix_i_src_c038_1_00 0 bpf_c038_1 0) vcvs gain=9.807852804032e-01
SMIXI_c038_1_00 (mix_i_src_c038_1_00 mix_i_c038_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_00 (mix_q_src_c038_1_00 0 bpf_c038_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_1_00 (mix_q_src_c038_1_00 mix_q_c038_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_01 (mix_i_src_c038_1_01 0 bpf_c038_1 0) vcvs gain=8.314696123025e-01
SMIXI_c038_1_01 (mix_i_src_c038_1_01 mix_i_c038_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_01 (mix_q_src_c038_1_01 0 bpf_c038_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_1_01 (mix_q_src_c038_1_01 mix_q_c038_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_02 (mix_i_src_c038_1_02 0 bpf_c038_1 0) vcvs gain=5.555702330196e-01
SMIXI_c038_1_02 (mix_i_src_c038_1_02 mix_i_c038_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_02 (mix_q_src_c038_1_02 0 bpf_c038_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_1_02 (mix_q_src_c038_1_02 mix_q_c038_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_03 (mix_i_src_c038_1_03 0 bpf_c038_1 0) vcvs gain=1.950903220161e-01
SMIXI_c038_1_03 (mix_i_src_c038_1_03 mix_i_c038_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_03 (mix_q_src_c038_1_03 0 bpf_c038_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_1_03 (mix_q_src_c038_1_03 mix_q_c038_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_04 (mix_i_src_c038_1_04 0 bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_1_04 (mix_i_src_c038_1_04 mix_i_c038_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_04 (mix_q_src_c038_1_04 0 bpf_c038_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_1_04 (mix_q_src_c038_1_04 mix_q_c038_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_05 (mix_i_src_c038_1_05 0 bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_1_05 (mix_i_src_c038_1_05 mix_i_c038_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_05 (mix_q_src_c038_1_05 0 bpf_c038_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_1_05 (mix_q_src_c038_1_05 mix_q_c038_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_06 (mix_i_src_c038_1_06 0 bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_1_06 (mix_i_src_c038_1_06 mix_i_c038_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_06 (mix_q_src_c038_1_06 0 bpf_c038_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_1_06 (mix_q_src_c038_1_06 mix_q_c038_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_07 (mix_i_src_c038_1_07 0 bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_1_07 (mix_i_src_c038_1_07 mix_i_c038_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_07 (mix_q_src_c038_1_07 0 bpf_c038_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_1_07 (mix_q_src_c038_1_07 mix_q_c038_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_08 (mix_i_src_c038_1_08 0 bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_1_08 (mix_i_src_c038_1_08 mix_i_c038_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_08 (mix_q_src_c038_1_08 0 bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_1_08 (mix_q_src_c038_1_08 mix_q_c038_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_09 (mix_i_src_c038_1_09 0 bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_1_09 (mix_i_src_c038_1_09 mix_i_c038_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_09 (mix_q_src_c038_1_09 0 bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_1_09 (mix_q_src_c038_1_09 mix_q_c038_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_10 (mix_i_src_c038_1_10 0 bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_1_10 (mix_i_src_c038_1_10 mix_i_c038_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_10 (mix_q_src_c038_1_10 0 bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_1_10 (mix_q_src_c038_1_10 mix_q_c038_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_11 (mix_i_src_c038_1_11 0 bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_1_11 (mix_i_src_c038_1_11 mix_i_c038_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_11 (mix_q_src_c038_1_11 0 bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_1_11 (mix_q_src_c038_1_11 mix_q_c038_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_12 (mix_i_src_c038_1_12 0 bpf_c038_1 0) vcvs gain=1.950903220161e-01
SMIXI_c038_1_12 (mix_i_src_c038_1_12 mix_i_c038_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_12 (mix_q_src_c038_1_12 0 bpf_c038_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_1_12 (mix_q_src_c038_1_12 mix_q_c038_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_13 (mix_i_src_c038_1_13 0 bpf_c038_1 0) vcvs gain=5.555702330196e-01
SMIXI_c038_1_13 (mix_i_src_c038_1_13 mix_i_c038_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_13 (mix_q_src_c038_1_13 0 bpf_c038_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_1_13 (mix_q_src_c038_1_13 mix_q_c038_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_14 (mix_i_src_c038_1_14 0 bpf_c038_1 0) vcvs gain=8.314696123025e-01
SMIXI_c038_1_14 (mix_i_src_c038_1_14 mix_i_c038_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_14 (mix_q_src_c038_1_14 0 bpf_c038_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_1_14 (mix_q_src_c038_1_14 mix_q_c038_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_1_15 (mix_i_src_c038_1_15 0 bpf_c038_1 0) vcvs gain=9.807852804032e-01
SMIXI_c038_1_15 (mix_i_src_c038_1_15 mix_i_c038_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_1_15 (mix_q_src_c038_1_15 0 bpf_c038_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_1_15 (mix_q_src_c038_1_15 mix_q_c038_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c038_1 (mix_i_c038_1 0) resistor r=1G
RMIXQ_c038_1 (mix_q_c038_1 0) resistor r=1G
RINTI_c038_1 (mix_i_c038_1 Icar_c038_1) resistor r=1k
CINTI_c038_1 (Icar_c038_1 0) capacitor c=80p
RINTQ_c038_1 (mix_q_c038_1 Qcar_c038_1) resistor r=1k
CINTQ_c038_1 (Qcar_c038_1 0) capacitor c=80p

// bl038, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c038_2 (bl038 n_cbpf_c038_2) capacitor c=4.503163717437e-14
LBPF_c038_2 (n_cbpf_c038_2 bpf_c038_2) inductor l=1.000000000000e-06
RBPF_c038_2 (bpf_c038_2 0) resistor r=2.356194490192e+02
EMIXI_c038_2_00 (mix_i_src_c038_2_00 0 bpf_c038_2 0) vcvs gain=9.807852804032e-01
SMIXI_c038_2_00 (mix_i_src_c038_2_00 mix_i_c038_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_00 (mix_q_src_c038_2_00 0 bpf_c038_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_2_00 (mix_q_src_c038_2_00 mix_q_c038_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_01 (mix_i_src_c038_2_01 0 bpf_c038_2 0) vcvs gain=8.314696123025e-01
SMIXI_c038_2_01 (mix_i_src_c038_2_01 mix_i_c038_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_01 (mix_q_src_c038_2_01 0 bpf_c038_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_2_01 (mix_q_src_c038_2_01 mix_q_c038_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_02 (mix_i_src_c038_2_02 0 bpf_c038_2 0) vcvs gain=5.555702330196e-01
SMIXI_c038_2_02 (mix_i_src_c038_2_02 mix_i_c038_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_02 (mix_q_src_c038_2_02 0 bpf_c038_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_2_02 (mix_q_src_c038_2_02 mix_q_c038_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_03 (mix_i_src_c038_2_03 0 bpf_c038_2 0) vcvs gain=1.950903220161e-01
SMIXI_c038_2_03 (mix_i_src_c038_2_03 mix_i_c038_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_03 (mix_q_src_c038_2_03 0 bpf_c038_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_2_03 (mix_q_src_c038_2_03 mix_q_c038_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_04 (mix_i_src_c038_2_04 0 bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_2_04 (mix_i_src_c038_2_04 mix_i_c038_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_04 (mix_q_src_c038_2_04 0 bpf_c038_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_2_04 (mix_q_src_c038_2_04 mix_q_c038_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_05 (mix_i_src_c038_2_05 0 bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_2_05 (mix_i_src_c038_2_05 mix_i_c038_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_05 (mix_q_src_c038_2_05 0 bpf_c038_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_2_05 (mix_q_src_c038_2_05 mix_q_c038_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_06 (mix_i_src_c038_2_06 0 bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_2_06 (mix_i_src_c038_2_06 mix_i_c038_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_06 (mix_q_src_c038_2_06 0 bpf_c038_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_2_06 (mix_q_src_c038_2_06 mix_q_c038_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_07 (mix_i_src_c038_2_07 0 bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_2_07 (mix_i_src_c038_2_07 mix_i_c038_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_07 (mix_q_src_c038_2_07 0 bpf_c038_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_2_07 (mix_q_src_c038_2_07 mix_q_c038_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_08 (mix_i_src_c038_2_08 0 bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_2_08 (mix_i_src_c038_2_08 mix_i_c038_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_08 (mix_q_src_c038_2_08 0 bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_2_08 (mix_q_src_c038_2_08 mix_q_c038_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_09 (mix_i_src_c038_2_09 0 bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_2_09 (mix_i_src_c038_2_09 mix_i_c038_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_09 (mix_q_src_c038_2_09 0 bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_2_09 (mix_q_src_c038_2_09 mix_q_c038_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_10 (mix_i_src_c038_2_10 0 bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_2_10 (mix_i_src_c038_2_10 mix_i_c038_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_10 (mix_q_src_c038_2_10 0 bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_2_10 (mix_q_src_c038_2_10 mix_q_c038_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_11 (mix_i_src_c038_2_11 0 bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_2_11 (mix_i_src_c038_2_11 mix_i_c038_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_11 (mix_q_src_c038_2_11 0 bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_2_11 (mix_q_src_c038_2_11 mix_q_c038_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_12 (mix_i_src_c038_2_12 0 bpf_c038_2 0) vcvs gain=1.950903220161e-01
SMIXI_c038_2_12 (mix_i_src_c038_2_12 mix_i_c038_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_12 (mix_q_src_c038_2_12 0 bpf_c038_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_2_12 (mix_q_src_c038_2_12 mix_q_c038_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_13 (mix_i_src_c038_2_13 0 bpf_c038_2 0) vcvs gain=5.555702330196e-01
SMIXI_c038_2_13 (mix_i_src_c038_2_13 mix_i_c038_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_13 (mix_q_src_c038_2_13 0 bpf_c038_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_2_13 (mix_q_src_c038_2_13 mix_q_c038_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_14 (mix_i_src_c038_2_14 0 bpf_c038_2 0) vcvs gain=8.314696123025e-01
SMIXI_c038_2_14 (mix_i_src_c038_2_14 mix_i_c038_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_14 (mix_q_src_c038_2_14 0 bpf_c038_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_2_14 (mix_q_src_c038_2_14 mix_q_c038_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_2_15 (mix_i_src_c038_2_15 0 bpf_c038_2 0) vcvs gain=9.807852804032e-01
SMIXI_c038_2_15 (mix_i_src_c038_2_15 mix_i_c038_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_2_15 (mix_q_src_c038_2_15 0 bpf_c038_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_2_15 (mix_q_src_c038_2_15 mix_q_c038_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c038_2 (mix_i_c038_2 0) resistor r=1G
RMIXQ_c038_2 (mix_q_c038_2 0) resistor r=1G
RINTI_c038_2 (mix_i_c038_2 Icar_c038_2) resistor r=1k
CINTI_c038_2 (Icar_c038_2 0) capacitor c=80p
RINTQ_c038_2 (mix_q_c038_2 Qcar_c038_2) resistor r=1k
CINTQ_c038_2 (Qcar_c038_2 0) capacitor c=80p

// bl038, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c038_3 (bl038 n_cbpf_c038_3) capacitor c=2.533029591058e-14
LBPF_c038_3 (n_cbpf_c038_3 bpf_c038_3) inductor l=1.000000000000e-06
RBPF_c038_3 (bpf_c038_3 0) resistor r=3.141592653590e+02
EMIXI_c038_3_00 (mix_i_src_c038_3_00 0 bpf_c038_3 0) vcvs gain=9.807852804032e-01
SMIXI_c038_3_00 (mix_i_src_c038_3_00 mix_i_c038_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_00 (mix_q_src_c038_3_00 0 bpf_c038_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_3_00 (mix_q_src_c038_3_00 mix_q_c038_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_01 (mix_i_src_c038_3_01 0 bpf_c038_3 0) vcvs gain=8.314696123025e-01
SMIXI_c038_3_01 (mix_i_src_c038_3_01 mix_i_c038_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_01 (mix_q_src_c038_3_01 0 bpf_c038_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_3_01 (mix_q_src_c038_3_01 mix_q_c038_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_02 (mix_i_src_c038_3_02 0 bpf_c038_3 0) vcvs gain=5.555702330196e-01
SMIXI_c038_3_02 (mix_i_src_c038_3_02 mix_i_c038_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_02 (mix_q_src_c038_3_02 0 bpf_c038_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_3_02 (mix_q_src_c038_3_02 mix_q_c038_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_03 (mix_i_src_c038_3_03 0 bpf_c038_3 0) vcvs gain=1.950903220161e-01
SMIXI_c038_3_03 (mix_i_src_c038_3_03 mix_i_c038_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_03 (mix_q_src_c038_3_03 0 bpf_c038_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_3_03 (mix_q_src_c038_3_03 mix_q_c038_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_04 (mix_i_src_c038_3_04 0 bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_3_04 (mix_i_src_c038_3_04 mix_i_c038_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_04 (mix_q_src_c038_3_04 0 bpf_c038_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c038_3_04 (mix_q_src_c038_3_04 mix_q_c038_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_05 (mix_i_src_c038_3_05 0 bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_3_05 (mix_i_src_c038_3_05 mix_i_c038_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_05 (mix_q_src_c038_3_05 0 bpf_c038_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c038_3_05 (mix_q_src_c038_3_05 mix_q_c038_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_06 (mix_i_src_c038_3_06 0 bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_3_06 (mix_i_src_c038_3_06 mix_i_c038_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_06 (mix_q_src_c038_3_06 0 bpf_c038_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c038_3_06 (mix_q_src_c038_3_06 mix_q_c038_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_07 (mix_i_src_c038_3_07 0 bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_3_07 (mix_i_src_c038_3_07 mix_i_c038_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_07 (mix_q_src_c038_3_07 0 bpf_c038_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c038_3_07 (mix_q_src_c038_3_07 mix_q_c038_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_08 (mix_i_src_c038_3_08 0 bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c038_3_08 (mix_i_src_c038_3_08 mix_i_c038_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_08 (mix_q_src_c038_3_08 0 bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_3_08 (mix_q_src_c038_3_08 mix_q_c038_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_09 (mix_i_src_c038_3_09 0 bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c038_3_09 (mix_i_src_c038_3_09 mix_i_c038_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_09 (mix_q_src_c038_3_09 0 bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_3_09 (mix_q_src_c038_3_09 mix_q_c038_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_10 (mix_i_src_c038_3_10 0 bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c038_3_10 (mix_i_src_c038_3_10 mix_i_c038_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_10 (mix_q_src_c038_3_10 0 bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_3_10 (mix_q_src_c038_3_10 mix_q_c038_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_11 (mix_i_src_c038_3_11 0 bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c038_3_11 (mix_i_src_c038_3_11 mix_i_c038_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_11 (mix_q_src_c038_3_11 0 bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_3_11 (mix_q_src_c038_3_11 mix_q_c038_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_12 (mix_i_src_c038_3_12 0 bpf_c038_3 0) vcvs gain=1.950903220161e-01
SMIXI_c038_3_12 (mix_i_src_c038_3_12 mix_i_c038_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_12 (mix_q_src_c038_3_12 0 bpf_c038_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c038_3_12 (mix_q_src_c038_3_12 mix_q_c038_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_13 (mix_i_src_c038_3_13 0 bpf_c038_3 0) vcvs gain=5.555702330196e-01
SMIXI_c038_3_13 (mix_i_src_c038_3_13 mix_i_c038_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_13 (mix_q_src_c038_3_13 0 bpf_c038_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c038_3_13 (mix_q_src_c038_3_13 mix_q_c038_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_14 (mix_i_src_c038_3_14 0 bpf_c038_3 0) vcvs gain=8.314696123025e-01
SMIXI_c038_3_14 (mix_i_src_c038_3_14 mix_i_c038_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_14 (mix_q_src_c038_3_14 0 bpf_c038_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c038_3_14 (mix_q_src_c038_3_14 mix_q_c038_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c038_3_15 (mix_i_src_c038_3_15 0 bpf_c038_3 0) vcvs gain=9.807852804032e-01
SMIXI_c038_3_15 (mix_i_src_c038_3_15 mix_i_c038_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c038_3_15 (mix_q_src_c038_3_15 0 bpf_c038_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c038_3_15 (mix_q_src_c038_3_15 mix_q_c038_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c038_3 (mix_i_c038_3 0) resistor r=1G
RMIXQ_c038_3 (mix_q_c038_3 0) resistor r=1G
RINTI_c038_3 (mix_i_c038_3 Icar_c038_3) resistor r=1k
CINTI_c038_3 (Icar_c038_3 0) capacitor c=80p
RINTQ_c038_3 (mix_q_c038_3 Qcar_c038_3) resistor r=1k
CINTQ_c038_3 (Qcar_c038_3 0) capacitor c=80p

// bl039, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c039_0 (bl039 n_cbpf_c039_0) capacitor c=4.052847345694e-13
LBPF_c039_0 (n_cbpf_c039_0 bpf_c039_0) inductor l=1.000000000000e-06
RBPF_c039_0 (bpf_c039_0 0) resistor r=7.853981633974e+01
EMIXI_c039_0_00 (mix_i_src_c039_0_00 0 bpf_c039_0 0) vcvs gain=9.807852804032e-01
SMIXI_c039_0_00 (mix_i_src_c039_0_00 mix_i_c039_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_00 (mix_q_src_c039_0_00 0 bpf_c039_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_0_00 (mix_q_src_c039_0_00 mix_q_c039_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_01 (mix_i_src_c039_0_01 0 bpf_c039_0 0) vcvs gain=8.314696123025e-01
SMIXI_c039_0_01 (mix_i_src_c039_0_01 mix_i_c039_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_01 (mix_q_src_c039_0_01 0 bpf_c039_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_0_01 (mix_q_src_c039_0_01 mix_q_c039_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_02 (mix_i_src_c039_0_02 0 bpf_c039_0 0) vcvs gain=5.555702330196e-01
SMIXI_c039_0_02 (mix_i_src_c039_0_02 mix_i_c039_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_02 (mix_q_src_c039_0_02 0 bpf_c039_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_0_02 (mix_q_src_c039_0_02 mix_q_c039_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_03 (mix_i_src_c039_0_03 0 bpf_c039_0 0) vcvs gain=1.950903220161e-01
SMIXI_c039_0_03 (mix_i_src_c039_0_03 mix_i_c039_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_03 (mix_q_src_c039_0_03 0 bpf_c039_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_0_03 (mix_q_src_c039_0_03 mix_q_c039_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_04 (mix_i_src_c039_0_04 0 bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_0_04 (mix_i_src_c039_0_04 mix_i_c039_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_04 (mix_q_src_c039_0_04 0 bpf_c039_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_0_04 (mix_q_src_c039_0_04 mix_q_c039_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_05 (mix_i_src_c039_0_05 0 bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_0_05 (mix_i_src_c039_0_05 mix_i_c039_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_05 (mix_q_src_c039_0_05 0 bpf_c039_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_0_05 (mix_q_src_c039_0_05 mix_q_c039_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_06 (mix_i_src_c039_0_06 0 bpf_c039_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_0_06 (mix_i_src_c039_0_06 mix_i_c039_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_06 (mix_q_src_c039_0_06 0 bpf_c039_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_0_06 (mix_q_src_c039_0_06 mix_q_c039_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_07 (mix_i_src_c039_0_07 0 bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_0_07 (mix_i_src_c039_0_07 mix_i_c039_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_07 (mix_q_src_c039_0_07 0 bpf_c039_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_0_07 (mix_q_src_c039_0_07 mix_q_c039_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_08 (mix_i_src_c039_0_08 0 bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_0_08 (mix_i_src_c039_0_08 mix_i_c039_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_08 (mix_q_src_c039_0_08 0 bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_0_08 (mix_q_src_c039_0_08 mix_q_c039_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_09 (mix_i_src_c039_0_09 0 bpf_c039_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_0_09 (mix_i_src_c039_0_09 mix_i_c039_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_09 (mix_q_src_c039_0_09 0 bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_0_09 (mix_q_src_c039_0_09 mix_q_c039_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_10 (mix_i_src_c039_0_10 0 bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_0_10 (mix_i_src_c039_0_10 mix_i_c039_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_10 (mix_q_src_c039_0_10 0 bpf_c039_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_0_10 (mix_q_src_c039_0_10 mix_q_c039_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_11 (mix_i_src_c039_0_11 0 bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_0_11 (mix_i_src_c039_0_11 mix_i_c039_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_11 (mix_q_src_c039_0_11 0 bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_0_11 (mix_q_src_c039_0_11 mix_q_c039_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_12 (mix_i_src_c039_0_12 0 bpf_c039_0 0) vcvs gain=1.950903220161e-01
SMIXI_c039_0_12 (mix_i_src_c039_0_12 mix_i_c039_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_12 (mix_q_src_c039_0_12 0 bpf_c039_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_0_12 (mix_q_src_c039_0_12 mix_q_c039_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_13 (mix_i_src_c039_0_13 0 bpf_c039_0 0) vcvs gain=5.555702330196e-01
SMIXI_c039_0_13 (mix_i_src_c039_0_13 mix_i_c039_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_13 (mix_q_src_c039_0_13 0 bpf_c039_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_0_13 (mix_q_src_c039_0_13 mix_q_c039_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_14 (mix_i_src_c039_0_14 0 bpf_c039_0 0) vcvs gain=8.314696123025e-01
SMIXI_c039_0_14 (mix_i_src_c039_0_14 mix_i_c039_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_14 (mix_q_src_c039_0_14 0 bpf_c039_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_0_14 (mix_q_src_c039_0_14 mix_q_c039_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_0_15 (mix_i_src_c039_0_15 0 bpf_c039_0 0) vcvs gain=9.807852804032e-01
SMIXI_c039_0_15 (mix_i_src_c039_0_15 mix_i_c039_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_0_15 (mix_q_src_c039_0_15 0 bpf_c039_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_0_15 (mix_q_src_c039_0_15 mix_q_c039_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c039_0 (mix_i_c039_0 0) resistor r=1G
RMIXQ_c039_0 (mix_q_c039_0 0) resistor r=1G
RINTI_c039_0 (mix_i_c039_0 Icar_c039_0) resistor r=1k
CINTI_c039_0 (Icar_c039_0 0) capacitor c=80p
RINTQ_c039_0 (mix_q_c039_0 Qcar_c039_0) resistor r=1k
CINTQ_c039_0 (Qcar_c039_0 0) capacitor c=80p

// bl039, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c039_1 (bl039 n_cbpf_c039_1) capacitor c=1.013211836423e-13
LBPF_c039_1 (n_cbpf_c039_1 bpf_c039_1) inductor l=1.000000000000e-06
RBPF_c039_1 (bpf_c039_1 0) resistor r=1.570796326795e+02
EMIXI_c039_1_00 (mix_i_src_c039_1_00 0 bpf_c039_1 0) vcvs gain=9.807852804032e-01
SMIXI_c039_1_00 (mix_i_src_c039_1_00 mix_i_c039_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_00 (mix_q_src_c039_1_00 0 bpf_c039_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_1_00 (mix_q_src_c039_1_00 mix_q_c039_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_01 (mix_i_src_c039_1_01 0 bpf_c039_1 0) vcvs gain=8.314696123025e-01
SMIXI_c039_1_01 (mix_i_src_c039_1_01 mix_i_c039_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_01 (mix_q_src_c039_1_01 0 bpf_c039_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_1_01 (mix_q_src_c039_1_01 mix_q_c039_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_02 (mix_i_src_c039_1_02 0 bpf_c039_1 0) vcvs gain=5.555702330196e-01
SMIXI_c039_1_02 (mix_i_src_c039_1_02 mix_i_c039_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_02 (mix_q_src_c039_1_02 0 bpf_c039_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_1_02 (mix_q_src_c039_1_02 mix_q_c039_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_03 (mix_i_src_c039_1_03 0 bpf_c039_1 0) vcvs gain=1.950903220161e-01
SMIXI_c039_1_03 (mix_i_src_c039_1_03 mix_i_c039_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_03 (mix_q_src_c039_1_03 0 bpf_c039_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_1_03 (mix_q_src_c039_1_03 mix_q_c039_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_04 (mix_i_src_c039_1_04 0 bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_1_04 (mix_i_src_c039_1_04 mix_i_c039_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_04 (mix_q_src_c039_1_04 0 bpf_c039_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_1_04 (mix_q_src_c039_1_04 mix_q_c039_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_05 (mix_i_src_c039_1_05 0 bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_1_05 (mix_i_src_c039_1_05 mix_i_c039_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_05 (mix_q_src_c039_1_05 0 bpf_c039_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_1_05 (mix_q_src_c039_1_05 mix_q_c039_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_06 (mix_i_src_c039_1_06 0 bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_1_06 (mix_i_src_c039_1_06 mix_i_c039_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_06 (mix_q_src_c039_1_06 0 bpf_c039_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_1_06 (mix_q_src_c039_1_06 mix_q_c039_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_07 (mix_i_src_c039_1_07 0 bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_1_07 (mix_i_src_c039_1_07 mix_i_c039_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_07 (mix_q_src_c039_1_07 0 bpf_c039_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_1_07 (mix_q_src_c039_1_07 mix_q_c039_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_08 (mix_i_src_c039_1_08 0 bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_1_08 (mix_i_src_c039_1_08 mix_i_c039_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_08 (mix_q_src_c039_1_08 0 bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_1_08 (mix_q_src_c039_1_08 mix_q_c039_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_09 (mix_i_src_c039_1_09 0 bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_1_09 (mix_i_src_c039_1_09 mix_i_c039_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_09 (mix_q_src_c039_1_09 0 bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_1_09 (mix_q_src_c039_1_09 mix_q_c039_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_10 (mix_i_src_c039_1_10 0 bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_1_10 (mix_i_src_c039_1_10 mix_i_c039_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_10 (mix_q_src_c039_1_10 0 bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_1_10 (mix_q_src_c039_1_10 mix_q_c039_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_11 (mix_i_src_c039_1_11 0 bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_1_11 (mix_i_src_c039_1_11 mix_i_c039_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_11 (mix_q_src_c039_1_11 0 bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_1_11 (mix_q_src_c039_1_11 mix_q_c039_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_12 (mix_i_src_c039_1_12 0 bpf_c039_1 0) vcvs gain=1.950903220161e-01
SMIXI_c039_1_12 (mix_i_src_c039_1_12 mix_i_c039_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_12 (mix_q_src_c039_1_12 0 bpf_c039_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_1_12 (mix_q_src_c039_1_12 mix_q_c039_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_13 (mix_i_src_c039_1_13 0 bpf_c039_1 0) vcvs gain=5.555702330196e-01
SMIXI_c039_1_13 (mix_i_src_c039_1_13 mix_i_c039_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_13 (mix_q_src_c039_1_13 0 bpf_c039_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_1_13 (mix_q_src_c039_1_13 mix_q_c039_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_14 (mix_i_src_c039_1_14 0 bpf_c039_1 0) vcvs gain=8.314696123025e-01
SMIXI_c039_1_14 (mix_i_src_c039_1_14 mix_i_c039_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_14 (mix_q_src_c039_1_14 0 bpf_c039_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_1_14 (mix_q_src_c039_1_14 mix_q_c039_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_1_15 (mix_i_src_c039_1_15 0 bpf_c039_1 0) vcvs gain=9.807852804032e-01
SMIXI_c039_1_15 (mix_i_src_c039_1_15 mix_i_c039_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_1_15 (mix_q_src_c039_1_15 0 bpf_c039_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_1_15 (mix_q_src_c039_1_15 mix_q_c039_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c039_1 (mix_i_c039_1 0) resistor r=1G
RMIXQ_c039_1 (mix_q_c039_1 0) resistor r=1G
RINTI_c039_1 (mix_i_c039_1 Icar_c039_1) resistor r=1k
CINTI_c039_1 (Icar_c039_1 0) capacitor c=80p
RINTQ_c039_1 (mix_q_c039_1 Qcar_c039_1) resistor r=1k
CINTQ_c039_1 (Qcar_c039_1 0) capacitor c=80p

// bl039, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c039_2 (bl039 n_cbpf_c039_2) capacitor c=4.503163717437e-14
LBPF_c039_2 (n_cbpf_c039_2 bpf_c039_2) inductor l=1.000000000000e-06
RBPF_c039_2 (bpf_c039_2 0) resistor r=2.356194490192e+02
EMIXI_c039_2_00 (mix_i_src_c039_2_00 0 bpf_c039_2 0) vcvs gain=9.807852804032e-01
SMIXI_c039_2_00 (mix_i_src_c039_2_00 mix_i_c039_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_00 (mix_q_src_c039_2_00 0 bpf_c039_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_2_00 (mix_q_src_c039_2_00 mix_q_c039_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_01 (mix_i_src_c039_2_01 0 bpf_c039_2 0) vcvs gain=8.314696123025e-01
SMIXI_c039_2_01 (mix_i_src_c039_2_01 mix_i_c039_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_01 (mix_q_src_c039_2_01 0 bpf_c039_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_2_01 (mix_q_src_c039_2_01 mix_q_c039_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_02 (mix_i_src_c039_2_02 0 bpf_c039_2 0) vcvs gain=5.555702330196e-01
SMIXI_c039_2_02 (mix_i_src_c039_2_02 mix_i_c039_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_02 (mix_q_src_c039_2_02 0 bpf_c039_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_2_02 (mix_q_src_c039_2_02 mix_q_c039_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_03 (mix_i_src_c039_2_03 0 bpf_c039_2 0) vcvs gain=1.950903220161e-01
SMIXI_c039_2_03 (mix_i_src_c039_2_03 mix_i_c039_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_03 (mix_q_src_c039_2_03 0 bpf_c039_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_2_03 (mix_q_src_c039_2_03 mix_q_c039_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_04 (mix_i_src_c039_2_04 0 bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_2_04 (mix_i_src_c039_2_04 mix_i_c039_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_04 (mix_q_src_c039_2_04 0 bpf_c039_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_2_04 (mix_q_src_c039_2_04 mix_q_c039_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_05 (mix_i_src_c039_2_05 0 bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_2_05 (mix_i_src_c039_2_05 mix_i_c039_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_05 (mix_q_src_c039_2_05 0 bpf_c039_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_2_05 (mix_q_src_c039_2_05 mix_q_c039_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_06 (mix_i_src_c039_2_06 0 bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_2_06 (mix_i_src_c039_2_06 mix_i_c039_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_06 (mix_q_src_c039_2_06 0 bpf_c039_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_2_06 (mix_q_src_c039_2_06 mix_q_c039_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_07 (mix_i_src_c039_2_07 0 bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_2_07 (mix_i_src_c039_2_07 mix_i_c039_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_07 (mix_q_src_c039_2_07 0 bpf_c039_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_2_07 (mix_q_src_c039_2_07 mix_q_c039_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_08 (mix_i_src_c039_2_08 0 bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_2_08 (mix_i_src_c039_2_08 mix_i_c039_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_08 (mix_q_src_c039_2_08 0 bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_2_08 (mix_q_src_c039_2_08 mix_q_c039_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_09 (mix_i_src_c039_2_09 0 bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_2_09 (mix_i_src_c039_2_09 mix_i_c039_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_09 (mix_q_src_c039_2_09 0 bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_2_09 (mix_q_src_c039_2_09 mix_q_c039_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_10 (mix_i_src_c039_2_10 0 bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_2_10 (mix_i_src_c039_2_10 mix_i_c039_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_10 (mix_q_src_c039_2_10 0 bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_2_10 (mix_q_src_c039_2_10 mix_q_c039_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_11 (mix_i_src_c039_2_11 0 bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_2_11 (mix_i_src_c039_2_11 mix_i_c039_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_11 (mix_q_src_c039_2_11 0 bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_2_11 (mix_q_src_c039_2_11 mix_q_c039_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_12 (mix_i_src_c039_2_12 0 bpf_c039_2 0) vcvs gain=1.950903220161e-01
SMIXI_c039_2_12 (mix_i_src_c039_2_12 mix_i_c039_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_12 (mix_q_src_c039_2_12 0 bpf_c039_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_2_12 (mix_q_src_c039_2_12 mix_q_c039_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_13 (mix_i_src_c039_2_13 0 bpf_c039_2 0) vcvs gain=5.555702330196e-01
SMIXI_c039_2_13 (mix_i_src_c039_2_13 mix_i_c039_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_13 (mix_q_src_c039_2_13 0 bpf_c039_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_2_13 (mix_q_src_c039_2_13 mix_q_c039_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_14 (mix_i_src_c039_2_14 0 bpf_c039_2 0) vcvs gain=8.314696123025e-01
SMIXI_c039_2_14 (mix_i_src_c039_2_14 mix_i_c039_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_14 (mix_q_src_c039_2_14 0 bpf_c039_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_2_14 (mix_q_src_c039_2_14 mix_q_c039_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_2_15 (mix_i_src_c039_2_15 0 bpf_c039_2 0) vcvs gain=9.807852804032e-01
SMIXI_c039_2_15 (mix_i_src_c039_2_15 mix_i_c039_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_2_15 (mix_q_src_c039_2_15 0 bpf_c039_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_2_15 (mix_q_src_c039_2_15 mix_q_c039_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c039_2 (mix_i_c039_2 0) resistor r=1G
RMIXQ_c039_2 (mix_q_c039_2 0) resistor r=1G
RINTI_c039_2 (mix_i_c039_2 Icar_c039_2) resistor r=1k
CINTI_c039_2 (Icar_c039_2 0) capacitor c=80p
RINTQ_c039_2 (mix_q_c039_2 Qcar_c039_2) resistor r=1k
CINTQ_c039_2 (Qcar_c039_2 0) capacitor c=80p

// bl039, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c039_3 (bl039 n_cbpf_c039_3) capacitor c=2.533029591058e-14
LBPF_c039_3 (n_cbpf_c039_3 bpf_c039_3) inductor l=1.000000000000e-06
RBPF_c039_3 (bpf_c039_3 0) resistor r=3.141592653590e+02
EMIXI_c039_3_00 (mix_i_src_c039_3_00 0 bpf_c039_3 0) vcvs gain=9.807852804032e-01
SMIXI_c039_3_00 (mix_i_src_c039_3_00 mix_i_c039_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_00 (mix_q_src_c039_3_00 0 bpf_c039_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_3_00 (mix_q_src_c039_3_00 mix_q_c039_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_01 (mix_i_src_c039_3_01 0 bpf_c039_3 0) vcvs gain=8.314696123025e-01
SMIXI_c039_3_01 (mix_i_src_c039_3_01 mix_i_c039_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_01 (mix_q_src_c039_3_01 0 bpf_c039_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_3_01 (mix_q_src_c039_3_01 mix_q_c039_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_02 (mix_i_src_c039_3_02 0 bpf_c039_3 0) vcvs gain=5.555702330196e-01
SMIXI_c039_3_02 (mix_i_src_c039_3_02 mix_i_c039_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_02 (mix_q_src_c039_3_02 0 bpf_c039_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_3_02 (mix_q_src_c039_3_02 mix_q_c039_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_03 (mix_i_src_c039_3_03 0 bpf_c039_3 0) vcvs gain=1.950903220161e-01
SMIXI_c039_3_03 (mix_i_src_c039_3_03 mix_i_c039_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_03 (mix_q_src_c039_3_03 0 bpf_c039_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_3_03 (mix_q_src_c039_3_03 mix_q_c039_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_04 (mix_i_src_c039_3_04 0 bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_3_04 (mix_i_src_c039_3_04 mix_i_c039_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_04 (mix_q_src_c039_3_04 0 bpf_c039_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c039_3_04 (mix_q_src_c039_3_04 mix_q_c039_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_05 (mix_i_src_c039_3_05 0 bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_3_05 (mix_i_src_c039_3_05 mix_i_c039_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_05 (mix_q_src_c039_3_05 0 bpf_c039_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c039_3_05 (mix_q_src_c039_3_05 mix_q_c039_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_06 (mix_i_src_c039_3_06 0 bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_3_06 (mix_i_src_c039_3_06 mix_i_c039_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_06 (mix_q_src_c039_3_06 0 bpf_c039_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c039_3_06 (mix_q_src_c039_3_06 mix_q_c039_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_07 (mix_i_src_c039_3_07 0 bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_3_07 (mix_i_src_c039_3_07 mix_i_c039_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_07 (mix_q_src_c039_3_07 0 bpf_c039_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c039_3_07 (mix_q_src_c039_3_07 mix_q_c039_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_08 (mix_i_src_c039_3_08 0 bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c039_3_08 (mix_i_src_c039_3_08 mix_i_c039_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_08 (mix_q_src_c039_3_08 0 bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_3_08 (mix_q_src_c039_3_08 mix_q_c039_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_09 (mix_i_src_c039_3_09 0 bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c039_3_09 (mix_i_src_c039_3_09 mix_i_c039_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_09 (mix_q_src_c039_3_09 0 bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_3_09 (mix_q_src_c039_3_09 mix_q_c039_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_10 (mix_i_src_c039_3_10 0 bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c039_3_10 (mix_i_src_c039_3_10 mix_i_c039_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_10 (mix_q_src_c039_3_10 0 bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_3_10 (mix_q_src_c039_3_10 mix_q_c039_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_11 (mix_i_src_c039_3_11 0 bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c039_3_11 (mix_i_src_c039_3_11 mix_i_c039_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_11 (mix_q_src_c039_3_11 0 bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_3_11 (mix_q_src_c039_3_11 mix_q_c039_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_12 (mix_i_src_c039_3_12 0 bpf_c039_3 0) vcvs gain=1.950903220161e-01
SMIXI_c039_3_12 (mix_i_src_c039_3_12 mix_i_c039_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_12 (mix_q_src_c039_3_12 0 bpf_c039_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c039_3_12 (mix_q_src_c039_3_12 mix_q_c039_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_13 (mix_i_src_c039_3_13 0 bpf_c039_3 0) vcvs gain=5.555702330196e-01
SMIXI_c039_3_13 (mix_i_src_c039_3_13 mix_i_c039_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_13 (mix_q_src_c039_3_13 0 bpf_c039_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c039_3_13 (mix_q_src_c039_3_13 mix_q_c039_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_14 (mix_i_src_c039_3_14 0 bpf_c039_3 0) vcvs gain=8.314696123025e-01
SMIXI_c039_3_14 (mix_i_src_c039_3_14 mix_i_c039_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_14 (mix_q_src_c039_3_14 0 bpf_c039_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c039_3_14 (mix_q_src_c039_3_14 mix_q_c039_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c039_3_15 (mix_i_src_c039_3_15 0 bpf_c039_3 0) vcvs gain=9.807852804032e-01
SMIXI_c039_3_15 (mix_i_src_c039_3_15 mix_i_c039_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c039_3_15 (mix_q_src_c039_3_15 0 bpf_c039_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c039_3_15 (mix_q_src_c039_3_15 mix_q_c039_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c039_3 (mix_i_c039_3 0) resistor r=1G
RMIXQ_c039_3 (mix_q_c039_3 0) resistor r=1G
RINTI_c039_3 (mix_i_c039_3 Icar_c039_3) resistor r=1k
CINTI_c039_3 (Icar_c039_3 0) capacitor c=80p
RINTQ_c039_3 (mix_q_c039_3 Qcar_c039_3) resistor r=1k
CINTQ_c039_3 (Qcar_c039_3 0) capacitor c=80p

// bl040, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c040_0 (bl040 n_cbpf_c040_0) capacitor c=4.052847345694e-13
LBPF_c040_0 (n_cbpf_c040_0 bpf_c040_0) inductor l=1.000000000000e-06
RBPF_c040_0 (bpf_c040_0 0) resistor r=7.853981633974e+01
EMIXI_c040_0_00 (mix_i_src_c040_0_00 0 bpf_c040_0 0) vcvs gain=9.807852804032e-01
SMIXI_c040_0_00 (mix_i_src_c040_0_00 mix_i_c040_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_00 (mix_q_src_c040_0_00 0 bpf_c040_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_0_00 (mix_q_src_c040_0_00 mix_q_c040_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_01 (mix_i_src_c040_0_01 0 bpf_c040_0 0) vcvs gain=8.314696123025e-01
SMIXI_c040_0_01 (mix_i_src_c040_0_01 mix_i_c040_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_01 (mix_q_src_c040_0_01 0 bpf_c040_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_0_01 (mix_q_src_c040_0_01 mix_q_c040_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_02 (mix_i_src_c040_0_02 0 bpf_c040_0 0) vcvs gain=5.555702330196e-01
SMIXI_c040_0_02 (mix_i_src_c040_0_02 mix_i_c040_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_02 (mix_q_src_c040_0_02 0 bpf_c040_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_0_02 (mix_q_src_c040_0_02 mix_q_c040_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_03 (mix_i_src_c040_0_03 0 bpf_c040_0 0) vcvs gain=1.950903220161e-01
SMIXI_c040_0_03 (mix_i_src_c040_0_03 mix_i_c040_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_03 (mix_q_src_c040_0_03 0 bpf_c040_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_0_03 (mix_q_src_c040_0_03 mix_q_c040_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_04 (mix_i_src_c040_0_04 0 bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_0_04 (mix_i_src_c040_0_04 mix_i_c040_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_04 (mix_q_src_c040_0_04 0 bpf_c040_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_0_04 (mix_q_src_c040_0_04 mix_q_c040_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_05 (mix_i_src_c040_0_05 0 bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_0_05 (mix_i_src_c040_0_05 mix_i_c040_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_05 (mix_q_src_c040_0_05 0 bpf_c040_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_0_05 (mix_q_src_c040_0_05 mix_q_c040_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_06 (mix_i_src_c040_0_06 0 bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_0_06 (mix_i_src_c040_0_06 mix_i_c040_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_06 (mix_q_src_c040_0_06 0 bpf_c040_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_0_06 (mix_q_src_c040_0_06 mix_q_c040_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_07 (mix_i_src_c040_0_07 0 bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_0_07 (mix_i_src_c040_0_07 mix_i_c040_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_07 (mix_q_src_c040_0_07 0 bpf_c040_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_0_07 (mix_q_src_c040_0_07 mix_q_c040_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_08 (mix_i_src_c040_0_08 0 bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_0_08 (mix_i_src_c040_0_08 mix_i_c040_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_08 (mix_q_src_c040_0_08 0 bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_0_08 (mix_q_src_c040_0_08 mix_q_c040_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_09 (mix_i_src_c040_0_09 0 bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_0_09 (mix_i_src_c040_0_09 mix_i_c040_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_09 (mix_q_src_c040_0_09 0 bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_0_09 (mix_q_src_c040_0_09 mix_q_c040_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_10 (mix_i_src_c040_0_10 0 bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_0_10 (mix_i_src_c040_0_10 mix_i_c040_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_10 (mix_q_src_c040_0_10 0 bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_0_10 (mix_q_src_c040_0_10 mix_q_c040_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_11 (mix_i_src_c040_0_11 0 bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_0_11 (mix_i_src_c040_0_11 mix_i_c040_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_11 (mix_q_src_c040_0_11 0 bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_0_11 (mix_q_src_c040_0_11 mix_q_c040_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_12 (mix_i_src_c040_0_12 0 bpf_c040_0 0) vcvs gain=1.950903220161e-01
SMIXI_c040_0_12 (mix_i_src_c040_0_12 mix_i_c040_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_12 (mix_q_src_c040_0_12 0 bpf_c040_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_0_12 (mix_q_src_c040_0_12 mix_q_c040_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_13 (mix_i_src_c040_0_13 0 bpf_c040_0 0) vcvs gain=5.555702330196e-01
SMIXI_c040_0_13 (mix_i_src_c040_0_13 mix_i_c040_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_13 (mix_q_src_c040_0_13 0 bpf_c040_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_0_13 (mix_q_src_c040_0_13 mix_q_c040_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_14 (mix_i_src_c040_0_14 0 bpf_c040_0 0) vcvs gain=8.314696123025e-01
SMIXI_c040_0_14 (mix_i_src_c040_0_14 mix_i_c040_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_14 (mix_q_src_c040_0_14 0 bpf_c040_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_0_14 (mix_q_src_c040_0_14 mix_q_c040_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_0_15 (mix_i_src_c040_0_15 0 bpf_c040_0 0) vcvs gain=9.807852804032e-01
SMIXI_c040_0_15 (mix_i_src_c040_0_15 mix_i_c040_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_0_15 (mix_q_src_c040_0_15 0 bpf_c040_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_0_15 (mix_q_src_c040_0_15 mix_q_c040_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c040_0 (mix_i_c040_0 0) resistor r=1G
RMIXQ_c040_0 (mix_q_c040_0 0) resistor r=1G
RINTI_c040_0 (mix_i_c040_0 Icar_c040_0) resistor r=1k
CINTI_c040_0 (Icar_c040_0 0) capacitor c=80p
RINTQ_c040_0 (mix_q_c040_0 Qcar_c040_0) resistor r=1k
CINTQ_c040_0 (Qcar_c040_0 0) capacitor c=80p

// bl040, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c040_1 (bl040 n_cbpf_c040_1) capacitor c=1.013211836423e-13
LBPF_c040_1 (n_cbpf_c040_1 bpf_c040_1) inductor l=1.000000000000e-06
RBPF_c040_1 (bpf_c040_1 0) resistor r=1.570796326795e+02
EMIXI_c040_1_00 (mix_i_src_c040_1_00 0 bpf_c040_1 0) vcvs gain=9.807852804032e-01
SMIXI_c040_1_00 (mix_i_src_c040_1_00 mix_i_c040_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_00 (mix_q_src_c040_1_00 0 bpf_c040_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_1_00 (mix_q_src_c040_1_00 mix_q_c040_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_01 (mix_i_src_c040_1_01 0 bpf_c040_1 0) vcvs gain=8.314696123025e-01
SMIXI_c040_1_01 (mix_i_src_c040_1_01 mix_i_c040_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_01 (mix_q_src_c040_1_01 0 bpf_c040_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_1_01 (mix_q_src_c040_1_01 mix_q_c040_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_02 (mix_i_src_c040_1_02 0 bpf_c040_1 0) vcvs gain=5.555702330196e-01
SMIXI_c040_1_02 (mix_i_src_c040_1_02 mix_i_c040_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_02 (mix_q_src_c040_1_02 0 bpf_c040_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_1_02 (mix_q_src_c040_1_02 mix_q_c040_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_03 (mix_i_src_c040_1_03 0 bpf_c040_1 0) vcvs gain=1.950903220161e-01
SMIXI_c040_1_03 (mix_i_src_c040_1_03 mix_i_c040_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_03 (mix_q_src_c040_1_03 0 bpf_c040_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_1_03 (mix_q_src_c040_1_03 mix_q_c040_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_04 (mix_i_src_c040_1_04 0 bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_1_04 (mix_i_src_c040_1_04 mix_i_c040_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_04 (mix_q_src_c040_1_04 0 bpf_c040_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_1_04 (mix_q_src_c040_1_04 mix_q_c040_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_05 (mix_i_src_c040_1_05 0 bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_1_05 (mix_i_src_c040_1_05 mix_i_c040_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_05 (mix_q_src_c040_1_05 0 bpf_c040_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_1_05 (mix_q_src_c040_1_05 mix_q_c040_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_06 (mix_i_src_c040_1_06 0 bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_1_06 (mix_i_src_c040_1_06 mix_i_c040_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_06 (mix_q_src_c040_1_06 0 bpf_c040_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_1_06 (mix_q_src_c040_1_06 mix_q_c040_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_07 (mix_i_src_c040_1_07 0 bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_1_07 (mix_i_src_c040_1_07 mix_i_c040_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_07 (mix_q_src_c040_1_07 0 bpf_c040_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_1_07 (mix_q_src_c040_1_07 mix_q_c040_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_08 (mix_i_src_c040_1_08 0 bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_1_08 (mix_i_src_c040_1_08 mix_i_c040_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_08 (mix_q_src_c040_1_08 0 bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_1_08 (mix_q_src_c040_1_08 mix_q_c040_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_09 (mix_i_src_c040_1_09 0 bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_1_09 (mix_i_src_c040_1_09 mix_i_c040_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_09 (mix_q_src_c040_1_09 0 bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_1_09 (mix_q_src_c040_1_09 mix_q_c040_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_10 (mix_i_src_c040_1_10 0 bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_1_10 (mix_i_src_c040_1_10 mix_i_c040_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_10 (mix_q_src_c040_1_10 0 bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_1_10 (mix_q_src_c040_1_10 mix_q_c040_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_11 (mix_i_src_c040_1_11 0 bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_1_11 (mix_i_src_c040_1_11 mix_i_c040_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_11 (mix_q_src_c040_1_11 0 bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_1_11 (mix_q_src_c040_1_11 mix_q_c040_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_12 (mix_i_src_c040_1_12 0 bpf_c040_1 0) vcvs gain=1.950903220161e-01
SMIXI_c040_1_12 (mix_i_src_c040_1_12 mix_i_c040_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_12 (mix_q_src_c040_1_12 0 bpf_c040_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_1_12 (mix_q_src_c040_1_12 mix_q_c040_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_13 (mix_i_src_c040_1_13 0 bpf_c040_1 0) vcvs gain=5.555702330196e-01
SMIXI_c040_1_13 (mix_i_src_c040_1_13 mix_i_c040_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_13 (mix_q_src_c040_1_13 0 bpf_c040_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_1_13 (mix_q_src_c040_1_13 mix_q_c040_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_14 (mix_i_src_c040_1_14 0 bpf_c040_1 0) vcvs gain=8.314696123025e-01
SMIXI_c040_1_14 (mix_i_src_c040_1_14 mix_i_c040_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_14 (mix_q_src_c040_1_14 0 bpf_c040_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_1_14 (mix_q_src_c040_1_14 mix_q_c040_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_1_15 (mix_i_src_c040_1_15 0 bpf_c040_1 0) vcvs gain=9.807852804032e-01
SMIXI_c040_1_15 (mix_i_src_c040_1_15 mix_i_c040_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_1_15 (mix_q_src_c040_1_15 0 bpf_c040_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_1_15 (mix_q_src_c040_1_15 mix_q_c040_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c040_1 (mix_i_c040_1 0) resistor r=1G
RMIXQ_c040_1 (mix_q_c040_1 0) resistor r=1G
RINTI_c040_1 (mix_i_c040_1 Icar_c040_1) resistor r=1k
CINTI_c040_1 (Icar_c040_1 0) capacitor c=80p
RINTQ_c040_1 (mix_q_c040_1 Qcar_c040_1) resistor r=1k
CINTQ_c040_1 (Qcar_c040_1 0) capacitor c=80p

// bl040, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c040_2 (bl040 n_cbpf_c040_2) capacitor c=4.503163717437e-14
LBPF_c040_2 (n_cbpf_c040_2 bpf_c040_2) inductor l=1.000000000000e-06
RBPF_c040_2 (bpf_c040_2 0) resistor r=2.356194490192e+02
EMIXI_c040_2_00 (mix_i_src_c040_2_00 0 bpf_c040_2 0) vcvs gain=9.807852804032e-01
SMIXI_c040_2_00 (mix_i_src_c040_2_00 mix_i_c040_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_00 (mix_q_src_c040_2_00 0 bpf_c040_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_2_00 (mix_q_src_c040_2_00 mix_q_c040_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_01 (mix_i_src_c040_2_01 0 bpf_c040_2 0) vcvs gain=8.314696123025e-01
SMIXI_c040_2_01 (mix_i_src_c040_2_01 mix_i_c040_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_01 (mix_q_src_c040_2_01 0 bpf_c040_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_2_01 (mix_q_src_c040_2_01 mix_q_c040_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_02 (mix_i_src_c040_2_02 0 bpf_c040_2 0) vcvs gain=5.555702330196e-01
SMIXI_c040_2_02 (mix_i_src_c040_2_02 mix_i_c040_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_02 (mix_q_src_c040_2_02 0 bpf_c040_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_2_02 (mix_q_src_c040_2_02 mix_q_c040_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_03 (mix_i_src_c040_2_03 0 bpf_c040_2 0) vcvs gain=1.950903220161e-01
SMIXI_c040_2_03 (mix_i_src_c040_2_03 mix_i_c040_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_03 (mix_q_src_c040_2_03 0 bpf_c040_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_2_03 (mix_q_src_c040_2_03 mix_q_c040_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_04 (mix_i_src_c040_2_04 0 bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_2_04 (mix_i_src_c040_2_04 mix_i_c040_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_04 (mix_q_src_c040_2_04 0 bpf_c040_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_2_04 (mix_q_src_c040_2_04 mix_q_c040_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_05 (mix_i_src_c040_2_05 0 bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_2_05 (mix_i_src_c040_2_05 mix_i_c040_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_05 (mix_q_src_c040_2_05 0 bpf_c040_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_2_05 (mix_q_src_c040_2_05 mix_q_c040_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_06 (mix_i_src_c040_2_06 0 bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_2_06 (mix_i_src_c040_2_06 mix_i_c040_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_06 (mix_q_src_c040_2_06 0 bpf_c040_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_2_06 (mix_q_src_c040_2_06 mix_q_c040_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_07 (mix_i_src_c040_2_07 0 bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_2_07 (mix_i_src_c040_2_07 mix_i_c040_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_07 (mix_q_src_c040_2_07 0 bpf_c040_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_2_07 (mix_q_src_c040_2_07 mix_q_c040_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_08 (mix_i_src_c040_2_08 0 bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_2_08 (mix_i_src_c040_2_08 mix_i_c040_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_08 (mix_q_src_c040_2_08 0 bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_2_08 (mix_q_src_c040_2_08 mix_q_c040_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_09 (mix_i_src_c040_2_09 0 bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_2_09 (mix_i_src_c040_2_09 mix_i_c040_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_09 (mix_q_src_c040_2_09 0 bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_2_09 (mix_q_src_c040_2_09 mix_q_c040_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_10 (mix_i_src_c040_2_10 0 bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_2_10 (mix_i_src_c040_2_10 mix_i_c040_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_10 (mix_q_src_c040_2_10 0 bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_2_10 (mix_q_src_c040_2_10 mix_q_c040_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_11 (mix_i_src_c040_2_11 0 bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_2_11 (mix_i_src_c040_2_11 mix_i_c040_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_11 (mix_q_src_c040_2_11 0 bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_2_11 (mix_q_src_c040_2_11 mix_q_c040_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_12 (mix_i_src_c040_2_12 0 bpf_c040_2 0) vcvs gain=1.950903220161e-01
SMIXI_c040_2_12 (mix_i_src_c040_2_12 mix_i_c040_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_12 (mix_q_src_c040_2_12 0 bpf_c040_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_2_12 (mix_q_src_c040_2_12 mix_q_c040_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_13 (mix_i_src_c040_2_13 0 bpf_c040_2 0) vcvs gain=5.555702330196e-01
SMIXI_c040_2_13 (mix_i_src_c040_2_13 mix_i_c040_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_13 (mix_q_src_c040_2_13 0 bpf_c040_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_2_13 (mix_q_src_c040_2_13 mix_q_c040_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_14 (mix_i_src_c040_2_14 0 bpf_c040_2 0) vcvs gain=8.314696123025e-01
SMIXI_c040_2_14 (mix_i_src_c040_2_14 mix_i_c040_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_14 (mix_q_src_c040_2_14 0 bpf_c040_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_2_14 (mix_q_src_c040_2_14 mix_q_c040_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_2_15 (mix_i_src_c040_2_15 0 bpf_c040_2 0) vcvs gain=9.807852804032e-01
SMIXI_c040_2_15 (mix_i_src_c040_2_15 mix_i_c040_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_2_15 (mix_q_src_c040_2_15 0 bpf_c040_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_2_15 (mix_q_src_c040_2_15 mix_q_c040_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c040_2 (mix_i_c040_2 0) resistor r=1G
RMIXQ_c040_2 (mix_q_c040_2 0) resistor r=1G
RINTI_c040_2 (mix_i_c040_2 Icar_c040_2) resistor r=1k
CINTI_c040_2 (Icar_c040_2 0) capacitor c=80p
RINTQ_c040_2 (mix_q_c040_2 Qcar_c040_2) resistor r=1k
CINTQ_c040_2 (Qcar_c040_2 0) capacitor c=80p

// bl040, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c040_3 (bl040 n_cbpf_c040_3) capacitor c=2.533029591058e-14
LBPF_c040_3 (n_cbpf_c040_3 bpf_c040_3) inductor l=1.000000000000e-06
RBPF_c040_3 (bpf_c040_3 0) resistor r=3.141592653590e+02
EMIXI_c040_3_00 (mix_i_src_c040_3_00 0 bpf_c040_3 0) vcvs gain=9.807852804032e-01
SMIXI_c040_3_00 (mix_i_src_c040_3_00 mix_i_c040_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_00 (mix_q_src_c040_3_00 0 bpf_c040_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_3_00 (mix_q_src_c040_3_00 mix_q_c040_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_01 (mix_i_src_c040_3_01 0 bpf_c040_3 0) vcvs gain=8.314696123025e-01
SMIXI_c040_3_01 (mix_i_src_c040_3_01 mix_i_c040_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_01 (mix_q_src_c040_3_01 0 bpf_c040_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_3_01 (mix_q_src_c040_3_01 mix_q_c040_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_02 (mix_i_src_c040_3_02 0 bpf_c040_3 0) vcvs gain=5.555702330196e-01
SMIXI_c040_3_02 (mix_i_src_c040_3_02 mix_i_c040_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_02 (mix_q_src_c040_3_02 0 bpf_c040_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_3_02 (mix_q_src_c040_3_02 mix_q_c040_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_03 (mix_i_src_c040_3_03 0 bpf_c040_3 0) vcvs gain=1.950903220161e-01
SMIXI_c040_3_03 (mix_i_src_c040_3_03 mix_i_c040_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_03 (mix_q_src_c040_3_03 0 bpf_c040_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_3_03 (mix_q_src_c040_3_03 mix_q_c040_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_04 (mix_i_src_c040_3_04 0 bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_3_04 (mix_i_src_c040_3_04 mix_i_c040_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_04 (mix_q_src_c040_3_04 0 bpf_c040_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c040_3_04 (mix_q_src_c040_3_04 mix_q_c040_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_05 (mix_i_src_c040_3_05 0 bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_3_05 (mix_i_src_c040_3_05 mix_i_c040_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_05 (mix_q_src_c040_3_05 0 bpf_c040_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c040_3_05 (mix_q_src_c040_3_05 mix_q_c040_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_06 (mix_i_src_c040_3_06 0 bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_3_06 (mix_i_src_c040_3_06 mix_i_c040_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_06 (mix_q_src_c040_3_06 0 bpf_c040_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c040_3_06 (mix_q_src_c040_3_06 mix_q_c040_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_07 (mix_i_src_c040_3_07 0 bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_3_07 (mix_i_src_c040_3_07 mix_i_c040_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_07 (mix_q_src_c040_3_07 0 bpf_c040_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c040_3_07 (mix_q_src_c040_3_07 mix_q_c040_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_08 (mix_i_src_c040_3_08 0 bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c040_3_08 (mix_i_src_c040_3_08 mix_i_c040_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_08 (mix_q_src_c040_3_08 0 bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_3_08 (mix_q_src_c040_3_08 mix_q_c040_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_09 (mix_i_src_c040_3_09 0 bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c040_3_09 (mix_i_src_c040_3_09 mix_i_c040_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_09 (mix_q_src_c040_3_09 0 bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_3_09 (mix_q_src_c040_3_09 mix_q_c040_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_10 (mix_i_src_c040_3_10 0 bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c040_3_10 (mix_i_src_c040_3_10 mix_i_c040_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_10 (mix_q_src_c040_3_10 0 bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_3_10 (mix_q_src_c040_3_10 mix_q_c040_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_11 (mix_i_src_c040_3_11 0 bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c040_3_11 (mix_i_src_c040_3_11 mix_i_c040_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_11 (mix_q_src_c040_3_11 0 bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_3_11 (mix_q_src_c040_3_11 mix_q_c040_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_12 (mix_i_src_c040_3_12 0 bpf_c040_3 0) vcvs gain=1.950903220161e-01
SMIXI_c040_3_12 (mix_i_src_c040_3_12 mix_i_c040_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_12 (mix_q_src_c040_3_12 0 bpf_c040_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c040_3_12 (mix_q_src_c040_3_12 mix_q_c040_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_13 (mix_i_src_c040_3_13 0 bpf_c040_3 0) vcvs gain=5.555702330196e-01
SMIXI_c040_3_13 (mix_i_src_c040_3_13 mix_i_c040_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_13 (mix_q_src_c040_3_13 0 bpf_c040_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c040_3_13 (mix_q_src_c040_3_13 mix_q_c040_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_14 (mix_i_src_c040_3_14 0 bpf_c040_3 0) vcvs gain=8.314696123025e-01
SMIXI_c040_3_14 (mix_i_src_c040_3_14 mix_i_c040_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_14 (mix_q_src_c040_3_14 0 bpf_c040_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c040_3_14 (mix_q_src_c040_3_14 mix_q_c040_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c040_3_15 (mix_i_src_c040_3_15 0 bpf_c040_3 0) vcvs gain=9.807852804032e-01
SMIXI_c040_3_15 (mix_i_src_c040_3_15 mix_i_c040_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c040_3_15 (mix_q_src_c040_3_15 0 bpf_c040_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c040_3_15 (mix_q_src_c040_3_15 mix_q_c040_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c040_3 (mix_i_c040_3 0) resistor r=1G
RMIXQ_c040_3 (mix_q_c040_3 0) resistor r=1G
RINTI_c040_3 (mix_i_c040_3 Icar_c040_3) resistor r=1k
CINTI_c040_3 (Icar_c040_3 0) capacitor c=80p
RINTQ_c040_3 (mix_q_c040_3 Qcar_c040_3) resistor r=1k
CINTQ_c040_3 (Qcar_c040_3 0) capacitor c=80p

// bl041, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c041_0 (bl041 n_cbpf_c041_0) capacitor c=4.052847345694e-13
LBPF_c041_0 (n_cbpf_c041_0 bpf_c041_0) inductor l=1.000000000000e-06
RBPF_c041_0 (bpf_c041_0 0) resistor r=7.853981633974e+01
EMIXI_c041_0_00 (mix_i_src_c041_0_00 0 bpf_c041_0 0) vcvs gain=9.807852804032e-01
SMIXI_c041_0_00 (mix_i_src_c041_0_00 mix_i_c041_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_00 (mix_q_src_c041_0_00 0 bpf_c041_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_0_00 (mix_q_src_c041_0_00 mix_q_c041_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_01 (mix_i_src_c041_0_01 0 bpf_c041_0 0) vcvs gain=8.314696123025e-01
SMIXI_c041_0_01 (mix_i_src_c041_0_01 mix_i_c041_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_01 (mix_q_src_c041_0_01 0 bpf_c041_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_0_01 (mix_q_src_c041_0_01 mix_q_c041_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_02 (mix_i_src_c041_0_02 0 bpf_c041_0 0) vcvs gain=5.555702330196e-01
SMIXI_c041_0_02 (mix_i_src_c041_0_02 mix_i_c041_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_02 (mix_q_src_c041_0_02 0 bpf_c041_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_0_02 (mix_q_src_c041_0_02 mix_q_c041_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_03 (mix_i_src_c041_0_03 0 bpf_c041_0 0) vcvs gain=1.950903220161e-01
SMIXI_c041_0_03 (mix_i_src_c041_0_03 mix_i_c041_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_03 (mix_q_src_c041_0_03 0 bpf_c041_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_0_03 (mix_q_src_c041_0_03 mix_q_c041_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_04 (mix_i_src_c041_0_04 0 bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_0_04 (mix_i_src_c041_0_04 mix_i_c041_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_04 (mix_q_src_c041_0_04 0 bpf_c041_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_0_04 (mix_q_src_c041_0_04 mix_q_c041_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_05 (mix_i_src_c041_0_05 0 bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_0_05 (mix_i_src_c041_0_05 mix_i_c041_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_05 (mix_q_src_c041_0_05 0 bpf_c041_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_0_05 (mix_q_src_c041_0_05 mix_q_c041_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_06 (mix_i_src_c041_0_06 0 bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_0_06 (mix_i_src_c041_0_06 mix_i_c041_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_06 (mix_q_src_c041_0_06 0 bpf_c041_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_0_06 (mix_q_src_c041_0_06 mix_q_c041_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_07 (mix_i_src_c041_0_07 0 bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_0_07 (mix_i_src_c041_0_07 mix_i_c041_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_07 (mix_q_src_c041_0_07 0 bpf_c041_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_0_07 (mix_q_src_c041_0_07 mix_q_c041_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_08 (mix_i_src_c041_0_08 0 bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_0_08 (mix_i_src_c041_0_08 mix_i_c041_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_08 (mix_q_src_c041_0_08 0 bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_0_08 (mix_q_src_c041_0_08 mix_q_c041_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_09 (mix_i_src_c041_0_09 0 bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_0_09 (mix_i_src_c041_0_09 mix_i_c041_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_09 (mix_q_src_c041_0_09 0 bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_0_09 (mix_q_src_c041_0_09 mix_q_c041_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_10 (mix_i_src_c041_0_10 0 bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_0_10 (mix_i_src_c041_0_10 mix_i_c041_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_10 (mix_q_src_c041_0_10 0 bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_0_10 (mix_q_src_c041_0_10 mix_q_c041_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_11 (mix_i_src_c041_0_11 0 bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_0_11 (mix_i_src_c041_0_11 mix_i_c041_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_11 (mix_q_src_c041_0_11 0 bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_0_11 (mix_q_src_c041_0_11 mix_q_c041_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_12 (mix_i_src_c041_0_12 0 bpf_c041_0 0) vcvs gain=1.950903220161e-01
SMIXI_c041_0_12 (mix_i_src_c041_0_12 mix_i_c041_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_12 (mix_q_src_c041_0_12 0 bpf_c041_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_0_12 (mix_q_src_c041_0_12 mix_q_c041_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_13 (mix_i_src_c041_0_13 0 bpf_c041_0 0) vcvs gain=5.555702330196e-01
SMIXI_c041_0_13 (mix_i_src_c041_0_13 mix_i_c041_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_13 (mix_q_src_c041_0_13 0 bpf_c041_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_0_13 (mix_q_src_c041_0_13 mix_q_c041_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_14 (mix_i_src_c041_0_14 0 bpf_c041_0 0) vcvs gain=8.314696123025e-01
SMIXI_c041_0_14 (mix_i_src_c041_0_14 mix_i_c041_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_14 (mix_q_src_c041_0_14 0 bpf_c041_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_0_14 (mix_q_src_c041_0_14 mix_q_c041_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_0_15 (mix_i_src_c041_0_15 0 bpf_c041_0 0) vcvs gain=9.807852804032e-01
SMIXI_c041_0_15 (mix_i_src_c041_0_15 mix_i_c041_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_0_15 (mix_q_src_c041_0_15 0 bpf_c041_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_0_15 (mix_q_src_c041_0_15 mix_q_c041_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c041_0 (mix_i_c041_0 0) resistor r=1G
RMIXQ_c041_0 (mix_q_c041_0 0) resistor r=1G
RINTI_c041_0 (mix_i_c041_0 Icar_c041_0) resistor r=1k
CINTI_c041_0 (Icar_c041_0 0) capacitor c=80p
RINTQ_c041_0 (mix_q_c041_0 Qcar_c041_0) resistor r=1k
CINTQ_c041_0 (Qcar_c041_0 0) capacitor c=80p

// bl041, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c041_1 (bl041 n_cbpf_c041_1) capacitor c=1.013211836423e-13
LBPF_c041_1 (n_cbpf_c041_1 bpf_c041_1) inductor l=1.000000000000e-06
RBPF_c041_1 (bpf_c041_1 0) resistor r=1.570796326795e+02
EMIXI_c041_1_00 (mix_i_src_c041_1_00 0 bpf_c041_1 0) vcvs gain=9.807852804032e-01
SMIXI_c041_1_00 (mix_i_src_c041_1_00 mix_i_c041_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_00 (mix_q_src_c041_1_00 0 bpf_c041_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_1_00 (mix_q_src_c041_1_00 mix_q_c041_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_01 (mix_i_src_c041_1_01 0 bpf_c041_1 0) vcvs gain=8.314696123025e-01
SMIXI_c041_1_01 (mix_i_src_c041_1_01 mix_i_c041_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_01 (mix_q_src_c041_1_01 0 bpf_c041_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_1_01 (mix_q_src_c041_1_01 mix_q_c041_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_02 (mix_i_src_c041_1_02 0 bpf_c041_1 0) vcvs gain=5.555702330196e-01
SMIXI_c041_1_02 (mix_i_src_c041_1_02 mix_i_c041_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_02 (mix_q_src_c041_1_02 0 bpf_c041_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_1_02 (mix_q_src_c041_1_02 mix_q_c041_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_03 (mix_i_src_c041_1_03 0 bpf_c041_1 0) vcvs gain=1.950903220161e-01
SMIXI_c041_1_03 (mix_i_src_c041_1_03 mix_i_c041_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_03 (mix_q_src_c041_1_03 0 bpf_c041_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_1_03 (mix_q_src_c041_1_03 mix_q_c041_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_04 (mix_i_src_c041_1_04 0 bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_1_04 (mix_i_src_c041_1_04 mix_i_c041_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_04 (mix_q_src_c041_1_04 0 bpf_c041_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_1_04 (mix_q_src_c041_1_04 mix_q_c041_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_05 (mix_i_src_c041_1_05 0 bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_1_05 (mix_i_src_c041_1_05 mix_i_c041_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_05 (mix_q_src_c041_1_05 0 bpf_c041_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_1_05 (mix_q_src_c041_1_05 mix_q_c041_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_06 (mix_i_src_c041_1_06 0 bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_1_06 (mix_i_src_c041_1_06 mix_i_c041_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_06 (mix_q_src_c041_1_06 0 bpf_c041_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_1_06 (mix_q_src_c041_1_06 mix_q_c041_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_07 (mix_i_src_c041_1_07 0 bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_1_07 (mix_i_src_c041_1_07 mix_i_c041_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_07 (mix_q_src_c041_1_07 0 bpf_c041_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_1_07 (mix_q_src_c041_1_07 mix_q_c041_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_08 (mix_i_src_c041_1_08 0 bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_1_08 (mix_i_src_c041_1_08 mix_i_c041_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_08 (mix_q_src_c041_1_08 0 bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_1_08 (mix_q_src_c041_1_08 mix_q_c041_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_09 (mix_i_src_c041_1_09 0 bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_1_09 (mix_i_src_c041_1_09 mix_i_c041_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_09 (mix_q_src_c041_1_09 0 bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_1_09 (mix_q_src_c041_1_09 mix_q_c041_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_10 (mix_i_src_c041_1_10 0 bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_1_10 (mix_i_src_c041_1_10 mix_i_c041_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_10 (mix_q_src_c041_1_10 0 bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_1_10 (mix_q_src_c041_1_10 mix_q_c041_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_11 (mix_i_src_c041_1_11 0 bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_1_11 (mix_i_src_c041_1_11 mix_i_c041_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_11 (mix_q_src_c041_1_11 0 bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_1_11 (mix_q_src_c041_1_11 mix_q_c041_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_12 (mix_i_src_c041_1_12 0 bpf_c041_1 0) vcvs gain=1.950903220161e-01
SMIXI_c041_1_12 (mix_i_src_c041_1_12 mix_i_c041_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_12 (mix_q_src_c041_1_12 0 bpf_c041_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_1_12 (mix_q_src_c041_1_12 mix_q_c041_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_13 (mix_i_src_c041_1_13 0 bpf_c041_1 0) vcvs gain=5.555702330196e-01
SMIXI_c041_1_13 (mix_i_src_c041_1_13 mix_i_c041_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_13 (mix_q_src_c041_1_13 0 bpf_c041_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_1_13 (mix_q_src_c041_1_13 mix_q_c041_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_14 (mix_i_src_c041_1_14 0 bpf_c041_1 0) vcvs gain=8.314696123025e-01
SMIXI_c041_1_14 (mix_i_src_c041_1_14 mix_i_c041_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_14 (mix_q_src_c041_1_14 0 bpf_c041_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_1_14 (mix_q_src_c041_1_14 mix_q_c041_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_1_15 (mix_i_src_c041_1_15 0 bpf_c041_1 0) vcvs gain=9.807852804032e-01
SMIXI_c041_1_15 (mix_i_src_c041_1_15 mix_i_c041_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_1_15 (mix_q_src_c041_1_15 0 bpf_c041_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_1_15 (mix_q_src_c041_1_15 mix_q_c041_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c041_1 (mix_i_c041_1 0) resistor r=1G
RMIXQ_c041_1 (mix_q_c041_1 0) resistor r=1G
RINTI_c041_1 (mix_i_c041_1 Icar_c041_1) resistor r=1k
CINTI_c041_1 (Icar_c041_1 0) capacitor c=80p
RINTQ_c041_1 (mix_q_c041_1 Qcar_c041_1) resistor r=1k
CINTQ_c041_1 (Qcar_c041_1 0) capacitor c=80p

// bl041, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c041_2 (bl041 n_cbpf_c041_2) capacitor c=4.503163717437e-14
LBPF_c041_2 (n_cbpf_c041_2 bpf_c041_2) inductor l=1.000000000000e-06
RBPF_c041_2 (bpf_c041_2 0) resistor r=2.356194490192e+02
EMIXI_c041_2_00 (mix_i_src_c041_2_00 0 bpf_c041_2 0) vcvs gain=9.807852804032e-01
SMIXI_c041_2_00 (mix_i_src_c041_2_00 mix_i_c041_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_00 (mix_q_src_c041_2_00 0 bpf_c041_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_2_00 (mix_q_src_c041_2_00 mix_q_c041_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_01 (mix_i_src_c041_2_01 0 bpf_c041_2 0) vcvs gain=8.314696123025e-01
SMIXI_c041_2_01 (mix_i_src_c041_2_01 mix_i_c041_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_01 (mix_q_src_c041_2_01 0 bpf_c041_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_2_01 (mix_q_src_c041_2_01 mix_q_c041_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_02 (mix_i_src_c041_2_02 0 bpf_c041_2 0) vcvs gain=5.555702330196e-01
SMIXI_c041_2_02 (mix_i_src_c041_2_02 mix_i_c041_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_02 (mix_q_src_c041_2_02 0 bpf_c041_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_2_02 (mix_q_src_c041_2_02 mix_q_c041_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_03 (mix_i_src_c041_2_03 0 bpf_c041_2 0) vcvs gain=1.950903220161e-01
SMIXI_c041_2_03 (mix_i_src_c041_2_03 mix_i_c041_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_03 (mix_q_src_c041_2_03 0 bpf_c041_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_2_03 (mix_q_src_c041_2_03 mix_q_c041_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_04 (mix_i_src_c041_2_04 0 bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_2_04 (mix_i_src_c041_2_04 mix_i_c041_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_04 (mix_q_src_c041_2_04 0 bpf_c041_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_2_04 (mix_q_src_c041_2_04 mix_q_c041_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_05 (mix_i_src_c041_2_05 0 bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_2_05 (mix_i_src_c041_2_05 mix_i_c041_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_05 (mix_q_src_c041_2_05 0 bpf_c041_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_2_05 (mix_q_src_c041_2_05 mix_q_c041_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_06 (mix_i_src_c041_2_06 0 bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_2_06 (mix_i_src_c041_2_06 mix_i_c041_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_06 (mix_q_src_c041_2_06 0 bpf_c041_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_2_06 (mix_q_src_c041_2_06 mix_q_c041_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_07 (mix_i_src_c041_2_07 0 bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_2_07 (mix_i_src_c041_2_07 mix_i_c041_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_07 (mix_q_src_c041_2_07 0 bpf_c041_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_2_07 (mix_q_src_c041_2_07 mix_q_c041_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_08 (mix_i_src_c041_2_08 0 bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_2_08 (mix_i_src_c041_2_08 mix_i_c041_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_08 (mix_q_src_c041_2_08 0 bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_2_08 (mix_q_src_c041_2_08 mix_q_c041_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_09 (mix_i_src_c041_2_09 0 bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_2_09 (mix_i_src_c041_2_09 mix_i_c041_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_09 (mix_q_src_c041_2_09 0 bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_2_09 (mix_q_src_c041_2_09 mix_q_c041_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_10 (mix_i_src_c041_2_10 0 bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_2_10 (mix_i_src_c041_2_10 mix_i_c041_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_10 (mix_q_src_c041_2_10 0 bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_2_10 (mix_q_src_c041_2_10 mix_q_c041_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_11 (mix_i_src_c041_2_11 0 bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_2_11 (mix_i_src_c041_2_11 mix_i_c041_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_11 (mix_q_src_c041_2_11 0 bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_2_11 (mix_q_src_c041_2_11 mix_q_c041_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_12 (mix_i_src_c041_2_12 0 bpf_c041_2 0) vcvs gain=1.950903220161e-01
SMIXI_c041_2_12 (mix_i_src_c041_2_12 mix_i_c041_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_12 (mix_q_src_c041_2_12 0 bpf_c041_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_2_12 (mix_q_src_c041_2_12 mix_q_c041_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_13 (mix_i_src_c041_2_13 0 bpf_c041_2 0) vcvs gain=5.555702330196e-01
SMIXI_c041_2_13 (mix_i_src_c041_2_13 mix_i_c041_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_13 (mix_q_src_c041_2_13 0 bpf_c041_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_2_13 (mix_q_src_c041_2_13 mix_q_c041_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_14 (mix_i_src_c041_2_14 0 bpf_c041_2 0) vcvs gain=8.314696123025e-01
SMIXI_c041_2_14 (mix_i_src_c041_2_14 mix_i_c041_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_14 (mix_q_src_c041_2_14 0 bpf_c041_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_2_14 (mix_q_src_c041_2_14 mix_q_c041_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_2_15 (mix_i_src_c041_2_15 0 bpf_c041_2 0) vcvs gain=9.807852804032e-01
SMIXI_c041_2_15 (mix_i_src_c041_2_15 mix_i_c041_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_2_15 (mix_q_src_c041_2_15 0 bpf_c041_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_2_15 (mix_q_src_c041_2_15 mix_q_c041_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c041_2 (mix_i_c041_2 0) resistor r=1G
RMIXQ_c041_2 (mix_q_c041_2 0) resistor r=1G
RINTI_c041_2 (mix_i_c041_2 Icar_c041_2) resistor r=1k
CINTI_c041_2 (Icar_c041_2 0) capacitor c=80p
RINTQ_c041_2 (mix_q_c041_2 Qcar_c041_2) resistor r=1k
CINTQ_c041_2 (Qcar_c041_2 0) capacitor c=80p

// bl041, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c041_3 (bl041 n_cbpf_c041_3) capacitor c=2.533029591058e-14
LBPF_c041_3 (n_cbpf_c041_3 bpf_c041_3) inductor l=1.000000000000e-06
RBPF_c041_3 (bpf_c041_3 0) resistor r=3.141592653590e+02
EMIXI_c041_3_00 (mix_i_src_c041_3_00 0 bpf_c041_3 0) vcvs gain=9.807852804032e-01
SMIXI_c041_3_00 (mix_i_src_c041_3_00 mix_i_c041_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_00 (mix_q_src_c041_3_00 0 bpf_c041_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_3_00 (mix_q_src_c041_3_00 mix_q_c041_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_01 (mix_i_src_c041_3_01 0 bpf_c041_3 0) vcvs gain=8.314696123025e-01
SMIXI_c041_3_01 (mix_i_src_c041_3_01 mix_i_c041_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_01 (mix_q_src_c041_3_01 0 bpf_c041_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_3_01 (mix_q_src_c041_3_01 mix_q_c041_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_02 (mix_i_src_c041_3_02 0 bpf_c041_3 0) vcvs gain=5.555702330196e-01
SMIXI_c041_3_02 (mix_i_src_c041_3_02 mix_i_c041_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_02 (mix_q_src_c041_3_02 0 bpf_c041_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_3_02 (mix_q_src_c041_3_02 mix_q_c041_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_03 (mix_i_src_c041_3_03 0 bpf_c041_3 0) vcvs gain=1.950903220161e-01
SMIXI_c041_3_03 (mix_i_src_c041_3_03 mix_i_c041_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_03 (mix_q_src_c041_3_03 0 bpf_c041_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_3_03 (mix_q_src_c041_3_03 mix_q_c041_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_04 (mix_i_src_c041_3_04 0 bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_3_04 (mix_i_src_c041_3_04 mix_i_c041_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_04 (mix_q_src_c041_3_04 0 bpf_c041_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c041_3_04 (mix_q_src_c041_3_04 mix_q_c041_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_05 (mix_i_src_c041_3_05 0 bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_3_05 (mix_i_src_c041_3_05 mix_i_c041_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_05 (mix_q_src_c041_3_05 0 bpf_c041_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c041_3_05 (mix_q_src_c041_3_05 mix_q_c041_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_06 (mix_i_src_c041_3_06 0 bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_3_06 (mix_i_src_c041_3_06 mix_i_c041_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_06 (mix_q_src_c041_3_06 0 bpf_c041_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c041_3_06 (mix_q_src_c041_3_06 mix_q_c041_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_07 (mix_i_src_c041_3_07 0 bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_3_07 (mix_i_src_c041_3_07 mix_i_c041_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_07 (mix_q_src_c041_3_07 0 bpf_c041_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c041_3_07 (mix_q_src_c041_3_07 mix_q_c041_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_08 (mix_i_src_c041_3_08 0 bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c041_3_08 (mix_i_src_c041_3_08 mix_i_c041_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_08 (mix_q_src_c041_3_08 0 bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_3_08 (mix_q_src_c041_3_08 mix_q_c041_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_09 (mix_i_src_c041_3_09 0 bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c041_3_09 (mix_i_src_c041_3_09 mix_i_c041_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_09 (mix_q_src_c041_3_09 0 bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_3_09 (mix_q_src_c041_3_09 mix_q_c041_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_10 (mix_i_src_c041_3_10 0 bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c041_3_10 (mix_i_src_c041_3_10 mix_i_c041_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_10 (mix_q_src_c041_3_10 0 bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_3_10 (mix_q_src_c041_3_10 mix_q_c041_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_11 (mix_i_src_c041_3_11 0 bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c041_3_11 (mix_i_src_c041_3_11 mix_i_c041_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_11 (mix_q_src_c041_3_11 0 bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_3_11 (mix_q_src_c041_3_11 mix_q_c041_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_12 (mix_i_src_c041_3_12 0 bpf_c041_3 0) vcvs gain=1.950903220161e-01
SMIXI_c041_3_12 (mix_i_src_c041_3_12 mix_i_c041_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_12 (mix_q_src_c041_3_12 0 bpf_c041_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c041_3_12 (mix_q_src_c041_3_12 mix_q_c041_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_13 (mix_i_src_c041_3_13 0 bpf_c041_3 0) vcvs gain=5.555702330196e-01
SMIXI_c041_3_13 (mix_i_src_c041_3_13 mix_i_c041_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_13 (mix_q_src_c041_3_13 0 bpf_c041_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c041_3_13 (mix_q_src_c041_3_13 mix_q_c041_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_14 (mix_i_src_c041_3_14 0 bpf_c041_3 0) vcvs gain=8.314696123025e-01
SMIXI_c041_3_14 (mix_i_src_c041_3_14 mix_i_c041_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_14 (mix_q_src_c041_3_14 0 bpf_c041_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c041_3_14 (mix_q_src_c041_3_14 mix_q_c041_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c041_3_15 (mix_i_src_c041_3_15 0 bpf_c041_3 0) vcvs gain=9.807852804032e-01
SMIXI_c041_3_15 (mix_i_src_c041_3_15 mix_i_c041_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c041_3_15 (mix_q_src_c041_3_15 0 bpf_c041_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c041_3_15 (mix_q_src_c041_3_15 mix_q_c041_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c041_3 (mix_i_c041_3 0) resistor r=1G
RMIXQ_c041_3 (mix_q_c041_3 0) resistor r=1G
RINTI_c041_3 (mix_i_c041_3 Icar_c041_3) resistor r=1k
CINTI_c041_3 (Icar_c041_3 0) capacitor c=80p
RINTQ_c041_3 (mix_q_c041_3 Qcar_c041_3) resistor r=1k
CINTQ_c041_3 (Qcar_c041_3 0) capacitor c=80p

// bl042, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c042_0 (bl042 n_cbpf_c042_0) capacitor c=4.052847345694e-13
LBPF_c042_0 (n_cbpf_c042_0 bpf_c042_0) inductor l=1.000000000000e-06
RBPF_c042_0 (bpf_c042_0 0) resistor r=7.853981633974e+01
EMIXI_c042_0_00 (mix_i_src_c042_0_00 0 bpf_c042_0 0) vcvs gain=9.807852804032e-01
SMIXI_c042_0_00 (mix_i_src_c042_0_00 mix_i_c042_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_00 (mix_q_src_c042_0_00 0 bpf_c042_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_0_00 (mix_q_src_c042_0_00 mix_q_c042_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_01 (mix_i_src_c042_0_01 0 bpf_c042_0 0) vcvs gain=8.314696123025e-01
SMIXI_c042_0_01 (mix_i_src_c042_0_01 mix_i_c042_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_01 (mix_q_src_c042_0_01 0 bpf_c042_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_0_01 (mix_q_src_c042_0_01 mix_q_c042_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_02 (mix_i_src_c042_0_02 0 bpf_c042_0 0) vcvs gain=5.555702330196e-01
SMIXI_c042_0_02 (mix_i_src_c042_0_02 mix_i_c042_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_02 (mix_q_src_c042_0_02 0 bpf_c042_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_0_02 (mix_q_src_c042_0_02 mix_q_c042_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_03 (mix_i_src_c042_0_03 0 bpf_c042_0 0) vcvs gain=1.950903220161e-01
SMIXI_c042_0_03 (mix_i_src_c042_0_03 mix_i_c042_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_03 (mix_q_src_c042_0_03 0 bpf_c042_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_0_03 (mix_q_src_c042_0_03 mix_q_c042_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_04 (mix_i_src_c042_0_04 0 bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_0_04 (mix_i_src_c042_0_04 mix_i_c042_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_04 (mix_q_src_c042_0_04 0 bpf_c042_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_0_04 (mix_q_src_c042_0_04 mix_q_c042_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_05 (mix_i_src_c042_0_05 0 bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c042_0_05 (mix_i_src_c042_0_05 mix_i_c042_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_05 (mix_q_src_c042_0_05 0 bpf_c042_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_0_05 (mix_q_src_c042_0_05 mix_q_c042_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_06 (mix_i_src_c042_0_06 0 bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_0_06 (mix_i_src_c042_0_06 mix_i_c042_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_06 (mix_q_src_c042_0_06 0 bpf_c042_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_0_06 (mix_q_src_c042_0_06 mix_q_c042_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_07 (mix_i_src_c042_0_07 0 bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_0_07 (mix_i_src_c042_0_07 mix_i_c042_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_07 (mix_q_src_c042_0_07 0 bpf_c042_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_0_07 (mix_q_src_c042_0_07 mix_q_c042_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_08 (mix_i_src_c042_0_08 0 bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_0_08 (mix_i_src_c042_0_08 mix_i_c042_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_08 (mix_q_src_c042_0_08 0 bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_0_08 (mix_q_src_c042_0_08 mix_q_c042_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_09 (mix_i_src_c042_0_09 0 bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_0_09 (mix_i_src_c042_0_09 mix_i_c042_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_09 (mix_q_src_c042_0_09 0 bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_0_09 (mix_q_src_c042_0_09 mix_q_c042_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_10 (mix_i_src_c042_0_10 0 bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c042_0_10 (mix_i_src_c042_0_10 mix_i_c042_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_10 (mix_q_src_c042_0_10 0 bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_0_10 (mix_q_src_c042_0_10 mix_q_c042_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_11 (mix_i_src_c042_0_11 0 bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_0_11 (mix_i_src_c042_0_11 mix_i_c042_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_11 (mix_q_src_c042_0_11 0 bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_0_11 (mix_q_src_c042_0_11 mix_q_c042_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_12 (mix_i_src_c042_0_12 0 bpf_c042_0 0) vcvs gain=1.950903220161e-01
SMIXI_c042_0_12 (mix_i_src_c042_0_12 mix_i_c042_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_12 (mix_q_src_c042_0_12 0 bpf_c042_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_0_12 (mix_q_src_c042_0_12 mix_q_c042_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_13 (mix_i_src_c042_0_13 0 bpf_c042_0 0) vcvs gain=5.555702330196e-01
SMIXI_c042_0_13 (mix_i_src_c042_0_13 mix_i_c042_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_13 (mix_q_src_c042_0_13 0 bpf_c042_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_0_13 (mix_q_src_c042_0_13 mix_q_c042_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_14 (mix_i_src_c042_0_14 0 bpf_c042_0 0) vcvs gain=8.314696123025e-01
SMIXI_c042_0_14 (mix_i_src_c042_0_14 mix_i_c042_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_14 (mix_q_src_c042_0_14 0 bpf_c042_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_0_14 (mix_q_src_c042_0_14 mix_q_c042_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_0_15 (mix_i_src_c042_0_15 0 bpf_c042_0 0) vcvs gain=9.807852804032e-01
SMIXI_c042_0_15 (mix_i_src_c042_0_15 mix_i_c042_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_0_15 (mix_q_src_c042_0_15 0 bpf_c042_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_0_15 (mix_q_src_c042_0_15 mix_q_c042_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c042_0 (mix_i_c042_0 0) resistor r=1G
RMIXQ_c042_0 (mix_q_c042_0 0) resistor r=1G
RINTI_c042_0 (mix_i_c042_0 Icar_c042_0) resistor r=1k
CINTI_c042_0 (Icar_c042_0 0) capacitor c=80p
RINTQ_c042_0 (mix_q_c042_0 Qcar_c042_0) resistor r=1k
CINTQ_c042_0 (Qcar_c042_0 0) capacitor c=80p

// bl042, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c042_1 (bl042 n_cbpf_c042_1) capacitor c=1.013211836423e-13
LBPF_c042_1 (n_cbpf_c042_1 bpf_c042_1) inductor l=1.000000000000e-06
RBPF_c042_1 (bpf_c042_1 0) resistor r=1.570796326795e+02
EMIXI_c042_1_00 (mix_i_src_c042_1_00 0 bpf_c042_1 0) vcvs gain=9.807852804032e-01
SMIXI_c042_1_00 (mix_i_src_c042_1_00 mix_i_c042_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_00 (mix_q_src_c042_1_00 0 bpf_c042_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_1_00 (mix_q_src_c042_1_00 mix_q_c042_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_01 (mix_i_src_c042_1_01 0 bpf_c042_1 0) vcvs gain=8.314696123025e-01
SMIXI_c042_1_01 (mix_i_src_c042_1_01 mix_i_c042_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_01 (mix_q_src_c042_1_01 0 bpf_c042_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_1_01 (mix_q_src_c042_1_01 mix_q_c042_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_02 (mix_i_src_c042_1_02 0 bpf_c042_1 0) vcvs gain=5.555702330196e-01
SMIXI_c042_1_02 (mix_i_src_c042_1_02 mix_i_c042_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_02 (mix_q_src_c042_1_02 0 bpf_c042_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_1_02 (mix_q_src_c042_1_02 mix_q_c042_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_03 (mix_i_src_c042_1_03 0 bpf_c042_1 0) vcvs gain=1.950903220161e-01
SMIXI_c042_1_03 (mix_i_src_c042_1_03 mix_i_c042_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_03 (mix_q_src_c042_1_03 0 bpf_c042_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_1_03 (mix_q_src_c042_1_03 mix_q_c042_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_04 (mix_i_src_c042_1_04 0 bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_1_04 (mix_i_src_c042_1_04 mix_i_c042_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_04 (mix_q_src_c042_1_04 0 bpf_c042_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_1_04 (mix_q_src_c042_1_04 mix_q_c042_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_05 (mix_i_src_c042_1_05 0 bpf_c042_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c042_1_05 (mix_i_src_c042_1_05 mix_i_c042_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_05 (mix_q_src_c042_1_05 0 bpf_c042_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_1_05 (mix_q_src_c042_1_05 mix_q_c042_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_06 (mix_i_src_c042_1_06 0 bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_1_06 (mix_i_src_c042_1_06 mix_i_c042_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_06 (mix_q_src_c042_1_06 0 bpf_c042_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_1_06 (mix_q_src_c042_1_06 mix_q_c042_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_07 (mix_i_src_c042_1_07 0 bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_1_07 (mix_i_src_c042_1_07 mix_i_c042_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_07 (mix_q_src_c042_1_07 0 bpf_c042_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_1_07 (mix_q_src_c042_1_07 mix_q_c042_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_08 (mix_i_src_c042_1_08 0 bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_1_08 (mix_i_src_c042_1_08 mix_i_c042_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_08 (mix_q_src_c042_1_08 0 bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_1_08 (mix_q_src_c042_1_08 mix_q_c042_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_09 (mix_i_src_c042_1_09 0 bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_1_09 (mix_i_src_c042_1_09 mix_i_c042_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_09 (mix_q_src_c042_1_09 0 bpf_c042_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_1_09 (mix_q_src_c042_1_09 mix_q_c042_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_10 (mix_i_src_c042_1_10 0 bpf_c042_1 0) vcvs gain=-5.555702330196e-01
