SMIXQ_c113_2_14 (mix_q_src_c113_2_14 mix_q_c113_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_2_15 (mix_i_src_c113_2_15 0 bpf_c113_2 0) vcvs gain=9.807852804032e-01
SMIXI_c113_2_15 (mix_i_src_c113_2_15 mix_i_c113_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_2_15 (mix_q_src_c113_2_15 0 bpf_c113_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_2_15 (mix_q_src_c113_2_15 mix_q_c113_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c113_2 (mix_i_c113_2 0) resistor r=1G
RMIXQ_c113_2 (mix_q_c113_2 0) resistor r=1G
RINTI_c113_2 (mix_i_c113_2 Icar_c113_2) resistor r=1k
CINTI_c113_2 (Icar_c113_2 0) capacitor c=80p
RINTQ_c113_2 (mix_q_c113_2 Qcar_c113_2) resistor r=1k
CINTQ_c113_2 (Qcar_c113_2 0) capacitor c=80p

// bl113, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c113_3 (bl113 n_cbpf_c113_3) capacitor c=2.533029591058e-14
LBPF_c113_3 (n_cbpf_c113_3 bpf_c113_3) inductor l=1.000000000000e-06
RBPF_c113_3 (bpf_c113_3 0) resistor r=3.141592653590e+02
EMIXI_c113_3_00 (mix_i_src_c113_3_00 0 bpf_c113_3 0) vcvs gain=9.807852804032e-01
SMIXI_c113_3_00 (mix_i_src_c113_3_00 mix_i_c113_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_00 (mix_q_src_c113_3_00 0 bpf_c113_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_3_00 (mix_q_src_c113_3_00 mix_q_c113_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_01 (mix_i_src_c113_3_01 0 bpf_c113_3 0) vcvs gain=8.314696123025e-01
SMIXI_c113_3_01 (mix_i_src_c113_3_01 mix_i_c113_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_01 (mix_q_src_c113_3_01 0 bpf_c113_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_3_01 (mix_q_src_c113_3_01 mix_q_c113_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_02 (mix_i_src_c113_3_02 0 bpf_c113_3 0) vcvs gain=5.555702330196e-01
SMIXI_c113_3_02 (mix_i_src_c113_3_02 mix_i_c113_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_02 (mix_q_src_c113_3_02 0 bpf_c113_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_3_02 (mix_q_src_c113_3_02 mix_q_c113_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_03 (mix_i_src_c113_3_03 0 bpf_c113_3 0) vcvs gain=1.950903220161e-01
SMIXI_c113_3_03 (mix_i_src_c113_3_03 mix_i_c113_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_03 (mix_q_src_c113_3_03 0 bpf_c113_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_3_03 (mix_q_src_c113_3_03 mix_q_c113_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_04 (mix_i_src_c113_3_04 0 bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_3_04 (mix_i_src_c113_3_04 mix_i_c113_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_04 (mix_q_src_c113_3_04 0 bpf_c113_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c113_3_04 (mix_q_src_c113_3_04 mix_q_c113_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_05 (mix_i_src_c113_3_05 0 bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_3_05 (mix_i_src_c113_3_05 mix_i_c113_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_05 (mix_q_src_c113_3_05 0 bpf_c113_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c113_3_05 (mix_q_src_c113_3_05 mix_q_c113_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_06 (mix_i_src_c113_3_06 0 bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_3_06 (mix_i_src_c113_3_06 mix_i_c113_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_06 (mix_q_src_c113_3_06 0 bpf_c113_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c113_3_06 (mix_q_src_c113_3_06 mix_q_c113_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_07 (mix_i_src_c113_3_07 0 bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_3_07 (mix_i_src_c113_3_07 mix_i_c113_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_07 (mix_q_src_c113_3_07 0 bpf_c113_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c113_3_07 (mix_q_src_c113_3_07 mix_q_c113_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_08 (mix_i_src_c113_3_08 0 bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c113_3_08 (mix_i_src_c113_3_08 mix_i_c113_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_08 (mix_q_src_c113_3_08 0 bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_3_08 (mix_q_src_c113_3_08 mix_q_c113_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_09 (mix_i_src_c113_3_09 0 bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c113_3_09 (mix_i_src_c113_3_09 mix_i_c113_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_09 (mix_q_src_c113_3_09 0 bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c113_3_09 (mix_q_src_c113_3_09 mix_q_c113_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_10 (mix_i_src_c113_3_10 0 bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c113_3_10 (mix_i_src_c113_3_10 mix_i_c113_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_10 (mix_q_src_c113_3_10 0 bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_3_10 (mix_q_src_c113_3_10 mix_q_c113_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_11 (mix_i_src_c113_3_11 0 bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c113_3_11 (mix_i_src_c113_3_11 mix_i_c113_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_11 (mix_q_src_c113_3_11 0 bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_3_11 (mix_q_src_c113_3_11 mix_q_c113_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_12 (mix_i_src_c113_3_12 0 bpf_c113_3 0) vcvs gain=1.950903220161e-01
SMIXI_c113_3_12 (mix_i_src_c113_3_12 mix_i_c113_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_12 (mix_q_src_c113_3_12 0 bpf_c113_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c113_3_12 (mix_q_src_c113_3_12 mix_q_c113_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_13 (mix_i_src_c113_3_13 0 bpf_c113_3 0) vcvs gain=5.555702330196e-01
SMIXI_c113_3_13 (mix_i_src_c113_3_13 mix_i_c113_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_13 (mix_q_src_c113_3_13 0 bpf_c113_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c113_3_13 (mix_q_src_c113_3_13 mix_q_c113_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_14 (mix_i_src_c113_3_14 0 bpf_c113_3 0) vcvs gain=8.314696123025e-01
SMIXI_c113_3_14 (mix_i_src_c113_3_14 mix_i_c113_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_14 (mix_q_src_c113_3_14 0 bpf_c113_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c113_3_14 (mix_q_src_c113_3_14 mix_q_c113_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c113_3_15 (mix_i_src_c113_3_15 0 bpf_c113_3 0) vcvs gain=9.807852804032e-01
SMIXI_c113_3_15 (mix_i_src_c113_3_15 mix_i_c113_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c113_3_15 (mix_q_src_c113_3_15 0 bpf_c113_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c113_3_15 (mix_q_src_c113_3_15 mix_q_c113_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c113_3 (mix_i_c113_3 0) resistor r=1G
RMIXQ_c113_3 (mix_q_c113_3 0) resistor r=1G
RINTI_c113_3 (mix_i_c113_3 Icar_c113_3) resistor r=1k
CINTI_c113_3 (Icar_c113_3 0) capacitor c=80p
RINTQ_c113_3 (mix_q_c113_3 Qcar_c113_3) resistor r=1k
CINTQ_c113_3 (Qcar_c113_3 0) capacitor c=80p

// bl114, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c114_0 (bl114 n_cbpf_c114_0) capacitor c=4.052847345694e-13
LBPF_c114_0 (n_cbpf_c114_0 bpf_c114_0) inductor l=1.000000000000e-06
RBPF_c114_0 (bpf_c114_0 0) resistor r=7.853981633974e+01
EMIXI_c114_0_00 (mix_i_src_c114_0_00 0 bpf_c114_0 0) vcvs gain=9.807852804032e-01
SMIXI_c114_0_00 (mix_i_src_c114_0_00 mix_i_c114_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_00 (mix_q_src_c114_0_00 0 bpf_c114_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_0_00 (mix_q_src_c114_0_00 mix_q_c114_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_01 (mix_i_src_c114_0_01 0 bpf_c114_0 0) vcvs gain=8.314696123025e-01
SMIXI_c114_0_01 (mix_i_src_c114_0_01 mix_i_c114_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_01 (mix_q_src_c114_0_01 0 bpf_c114_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_0_01 (mix_q_src_c114_0_01 mix_q_c114_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_02 (mix_i_src_c114_0_02 0 bpf_c114_0 0) vcvs gain=5.555702330196e-01
SMIXI_c114_0_02 (mix_i_src_c114_0_02 mix_i_c114_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_02 (mix_q_src_c114_0_02 0 bpf_c114_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_0_02 (mix_q_src_c114_0_02 mix_q_c114_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_03 (mix_i_src_c114_0_03 0 bpf_c114_0 0) vcvs gain=1.950903220161e-01
SMIXI_c114_0_03 (mix_i_src_c114_0_03 mix_i_c114_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_03 (mix_q_src_c114_0_03 0 bpf_c114_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_0_03 (mix_q_src_c114_0_03 mix_q_c114_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_04 (mix_i_src_c114_0_04 0 bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_0_04 (mix_i_src_c114_0_04 mix_i_c114_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_04 (mix_q_src_c114_0_04 0 bpf_c114_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_0_04 (mix_q_src_c114_0_04 mix_q_c114_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_05 (mix_i_src_c114_0_05 0 bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_0_05 (mix_i_src_c114_0_05 mix_i_c114_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_05 (mix_q_src_c114_0_05 0 bpf_c114_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_0_05 (mix_q_src_c114_0_05 mix_q_c114_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_06 (mix_i_src_c114_0_06 0 bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_0_06 (mix_i_src_c114_0_06 mix_i_c114_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_06 (mix_q_src_c114_0_06 0 bpf_c114_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_0_06 (mix_q_src_c114_0_06 mix_q_c114_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_07 (mix_i_src_c114_0_07 0 bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_0_07 (mix_i_src_c114_0_07 mix_i_c114_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_07 (mix_q_src_c114_0_07 0 bpf_c114_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_0_07 (mix_q_src_c114_0_07 mix_q_c114_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_08 (mix_i_src_c114_0_08 0 bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_0_08 (mix_i_src_c114_0_08 mix_i_c114_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_08 (mix_q_src_c114_0_08 0 bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_0_08 (mix_q_src_c114_0_08 mix_q_c114_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_09 (mix_i_src_c114_0_09 0 bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_0_09 (mix_i_src_c114_0_09 mix_i_c114_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_09 (mix_q_src_c114_0_09 0 bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_0_09 (mix_q_src_c114_0_09 mix_q_c114_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_10 (mix_i_src_c114_0_10 0 bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_0_10 (mix_i_src_c114_0_10 mix_i_c114_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_10 (mix_q_src_c114_0_10 0 bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_0_10 (mix_q_src_c114_0_10 mix_q_c114_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_11 (mix_i_src_c114_0_11 0 bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_0_11 (mix_i_src_c114_0_11 mix_i_c114_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_11 (mix_q_src_c114_0_11 0 bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_0_11 (mix_q_src_c114_0_11 mix_q_c114_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_12 (mix_i_src_c114_0_12 0 bpf_c114_0 0) vcvs gain=1.950903220161e-01
SMIXI_c114_0_12 (mix_i_src_c114_0_12 mix_i_c114_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_12 (mix_q_src_c114_0_12 0 bpf_c114_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_0_12 (mix_q_src_c114_0_12 mix_q_c114_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_13 (mix_i_src_c114_0_13 0 bpf_c114_0 0) vcvs gain=5.555702330196e-01
SMIXI_c114_0_13 (mix_i_src_c114_0_13 mix_i_c114_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_13 (mix_q_src_c114_0_13 0 bpf_c114_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_0_13 (mix_q_src_c114_0_13 mix_q_c114_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_14 (mix_i_src_c114_0_14 0 bpf_c114_0 0) vcvs gain=8.314696123025e-01
SMIXI_c114_0_14 (mix_i_src_c114_0_14 mix_i_c114_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_14 (mix_q_src_c114_0_14 0 bpf_c114_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_0_14 (mix_q_src_c114_0_14 mix_q_c114_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_0_15 (mix_i_src_c114_0_15 0 bpf_c114_0 0) vcvs gain=9.807852804032e-01
SMIXI_c114_0_15 (mix_i_src_c114_0_15 mix_i_c114_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_0_15 (mix_q_src_c114_0_15 0 bpf_c114_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_0_15 (mix_q_src_c114_0_15 mix_q_c114_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c114_0 (mix_i_c114_0 0) resistor r=1G
RMIXQ_c114_0 (mix_q_c114_0 0) resistor r=1G
RINTI_c114_0 (mix_i_c114_0 Icar_c114_0) resistor r=1k
CINTI_c114_0 (Icar_c114_0 0) capacitor c=80p
RINTQ_c114_0 (mix_q_c114_0 Qcar_c114_0) resistor r=1k
CINTQ_c114_0 (Qcar_c114_0 0) capacitor c=80p

// bl114, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c114_1 (bl114 n_cbpf_c114_1) capacitor c=1.013211836423e-13
LBPF_c114_1 (n_cbpf_c114_1 bpf_c114_1) inductor l=1.000000000000e-06
RBPF_c114_1 (bpf_c114_1 0) resistor r=1.570796326795e+02
EMIXI_c114_1_00 (mix_i_src_c114_1_00 0 bpf_c114_1 0) vcvs gain=9.807852804032e-01
SMIXI_c114_1_00 (mix_i_src_c114_1_00 mix_i_c114_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_00 (mix_q_src_c114_1_00 0 bpf_c114_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_1_00 (mix_q_src_c114_1_00 mix_q_c114_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_01 (mix_i_src_c114_1_01 0 bpf_c114_1 0) vcvs gain=8.314696123025e-01
SMIXI_c114_1_01 (mix_i_src_c114_1_01 mix_i_c114_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_01 (mix_q_src_c114_1_01 0 bpf_c114_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_1_01 (mix_q_src_c114_1_01 mix_q_c114_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_02 (mix_i_src_c114_1_02 0 bpf_c114_1 0) vcvs gain=5.555702330196e-01
SMIXI_c114_1_02 (mix_i_src_c114_1_02 mix_i_c114_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_02 (mix_q_src_c114_1_02 0 bpf_c114_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_1_02 (mix_q_src_c114_1_02 mix_q_c114_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_03 (mix_i_src_c114_1_03 0 bpf_c114_1 0) vcvs gain=1.950903220161e-01
SMIXI_c114_1_03 (mix_i_src_c114_1_03 mix_i_c114_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_03 (mix_q_src_c114_1_03 0 bpf_c114_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_1_03 (mix_q_src_c114_1_03 mix_q_c114_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_04 (mix_i_src_c114_1_04 0 bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_1_04 (mix_i_src_c114_1_04 mix_i_c114_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_04 (mix_q_src_c114_1_04 0 bpf_c114_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_1_04 (mix_q_src_c114_1_04 mix_q_c114_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_05 (mix_i_src_c114_1_05 0 bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_1_05 (mix_i_src_c114_1_05 mix_i_c114_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_05 (mix_q_src_c114_1_05 0 bpf_c114_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_1_05 (mix_q_src_c114_1_05 mix_q_c114_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_06 (mix_i_src_c114_1_06 0 bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_1_06 (mix_i_src_c114_1_06 mix_i_c114_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_06 (mix_q_src_c114_1_06 0 bpf_c114_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_1_06 (mix_q_src_c114_1_06 mix_q_c114_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_07 (mix_i_src_c114_1_07 0 bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_1_07 (mix_i_src_c114_1_07 mix_i_c114_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_07 (mix_q_src_c114_1_07 0 bpf_c114_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_1_07 (mix_q_src_c114_1_07 mix_q_c114_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_08 (mix_i_src_c114_1_08 0 bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_1_08 (mix_i_src_c114_1_08 mix_i_c114_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_08 (mix_q_src_c114_1_08 0 bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_1_08 (mix_q_src_c114_1_08 mix_q_c114_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_09 (mix_i_src_c114_1_09 0 bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_1_09 (mix_i_src_c114_1_09 mix_i_c114_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_09 (mix_q_src_c114_1_09 0 bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_1_09 (mix_q_src_c114_1_09 mix_q_c114_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_10 (mix_i_src_c114_1_10 0 bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_1_10 (mix_i_src_c114_1_10 mix_i_c114_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_10 (mix_q_src_c114_1_10 0 bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_1_10 (mix_q_src_c114_1_10 mix_q_c114_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_11 (mix_i_src_c114_1_11 0 bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_1_11 (mix_i_src_c114_1_11 mix_i_c114_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_11 (mix_q_src_c114_1_11 0 bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_1_11 (mix_q_src_c114_1_11 mix_q_c114_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_12 (mix_i_src_c114_1_12 0 bpf_c114_1 0) vcvs gain=1.950903220161e-01
SMIXI_c114_1_12 (mix_i_src_c114_1_12 mix_i_c114_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_12 (mix_q_src_c114_1_12 0 bpf_c114_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_1_12 (mix_q_src_c114_1_12 mix_q_c114_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_13 (mix_i_src_c114_1_13 0 bpf_c114_1 0) vcvs gain=5.555702330196e-01
SMIXI_c114_1_13 (mix_i_src_c114_1_13 mix_i_c114_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_13 (mix_q_src_c114_1_13 0 bpf_c114_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_1_13 (mix_q_src_c114_1_13 mix_q_c114_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_14 (mix_i_src_c114_1_14 0 bpf_c114_1 0) vcvs gain=8.314696123025e-01
SMIXI_c114_1_14 (mix_i_src_c114_1_14 mix_i_c114_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_14 (mix_q_src_c114_1_14 0 bpf_c114_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_1_14 (mix_q_src_c114_1_14 mix_q_c114_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_1_15 (mix_i_src_c114_1_15 0 bpf_c114_1 0) vcvs gain=9.807852804032e-01
SMIXI_c114_1_15 (mix_i_src_c114_1_15 mix_i_c114_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_1_15 (mix_q_src_c114_1_15 0 bpf_c114_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_1_15 (mix_q_src_c114_1_15 mix_q_c114_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c114_1 (mix_i_c114_1 0) resistor r=1G
RMIXQ_c114_1 (mix_q_c114_1 0) resistor r=1G
RINTI_c114_1 (mix_i_c114_1 Icar_c114_1) resistor r=1k
CINTI_c114_1 (Icar_c114_1 0) capacitor c=80p
RINTQ_c114_1 (mix_q_c114_1 Qcar_c114_1) resistor r=1k
CINTQ_c114_1 (Qcar_c114_1 0) capacitor c=80p

// bl114, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c114_2 (bl114 n_cbpf_c114_2) capacitor c=4.503163717437e-14
LBPF_c114_2 (n_cbpf_c114_2 bpf_c114_2) inductor l=1.000000000000e-06
RBPF_c114_2 (bpf_c114_2 0) resistor r=2.356194490192e+02
EMIXI_c114_2_00 (mix_i_src_c114_2_00 0 bpf_c114_2 0) vcvs gain=9.807852804032e-01
SMIXI_c114_2_00 (mix_i_src_c114_2_00 mix_i_c114_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_00 (mix_q_src_c114_2_00 0 bpf_c114_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_2_00 (mix_q_src_c114_2_00 mix_q_c114_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_01 (mix_i_src_c114_2_01 0 bpf_c114_2 0) vcvs gain=8.314696123025e-01
SMIXI_c114_2_01 (mix_i_src_c114_2_01 mix_i_c114_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_01 (mix_q_src_c114_2_01 0 bpf_c114_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_2_01 (mix_q_src_c114_2_01 mix_q_c114_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_02 (mix_i_src_c114_2_02 0 bpf_c114_2 0) vcvs gain=5.555702330196e-01
SMIXI_c114_2_02 (mix_i_src_c114_2_02 mix_i_c114_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_02 (mix_q_src_c114_2_02 0 bpf_c114_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_2_02 (mix_q_src_c114_2_02 mix_q_c114_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_03 (mix_i_src_c114_2_03 0 bpf_c114_2 0) vcvs gain=1.950903220161e-01
SMIXI_c114_2_03 (mix_i_src_c114_2_03 mix_i_c114_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_03 (mix_q_src_c114_2_03 0 bpf_c114_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_2_03 (mix_q_src_c114_2_03 mix_q_c114_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_04 (mix_i_src_c114_2_04 0 bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_2_04 (mix_i_src_c114_2_04 mix_i_c114_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_04 (mix_q_src_c114_2_04 0 bpf_c114_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_2_04 (mix_q_src_c114_2_04 mix_q_c114_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_05 (mix_i_src_c114_2_05 0 bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_2_05 (mix_i_src_c114_2_05 mix_i_c114_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_05 (mix_q_src_c114_2_05 0 bpf_c114_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_2_05 (mix_q_src_c114_2_05 mix_q_c114_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_06 (mix_i_src_c114_2_06 0 bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_2_06 (mix_i_src_c114_2_06 mix_i_c114_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_06 (mix_q_src_c114_2_06 0 bpf_c114_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_2_06 (mix_q_src_c114_2_06 mix_q_c114_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_07 (mix_i_src_c114_2_07 0 bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_2_07 (mix_i_src_c114_2_07 mix_i_c114_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_07 (mix_q_src_c114_2_07 0 bpf_c114_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_2_07 (mix_q_src_c114_2_07 mix_q_c114_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_08 (mix_i_src_c114_2_08 0 bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_2_08 (mix_i_src_c114_2_08 mix_i_c114_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_08 (mix_q_src_c114_2_08 0 bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_2_08 (mix_q_src_c114_2_08 mix_q_c114_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_09 (mix_i_src_c114_2_09 0 bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_2_09 (mix_i_src_c114_2_09 mix_i_c114_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_09 (mix_q_src_c114_2_09 0 bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_2_09 (mix_q_src_c114_2_09 mix_q_c114_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_10 (mix_i_src_c114_2_10 0 bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_2_10 (mix_i_src_c114_2_10 mix_i_c114_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_10 (mix_q_src_c114_2_10 0 bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_2_10 (mix_q_src_c114_2_10 mix_q_c114_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_11 (mix_i_src_c114_2_11 0 bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_2_11 (mix_i_src_c114_2_11 mix_i_c114_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_11 (mix_q_src_c114_2_11 0 bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_2_11 (mix_q_src_c114_2_11 mix_q_c114_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_12 (mix_i_src_c114_2_12 0 bpf_c114_2 0) vcvs gain=1.950903220161e-01
SMIXI_c114_2_12 (mix_i_src_c114_2_12 mix_i_c114_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_12 (mix_q_src_c114_2_12 0 bpf_c114_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_2_12 (mix_q_src_c114_2_12 mix_q_c114_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_13 (mix_i_src_c114_2_13 0 bpf_c114_2 0) vcvs gain=5.555702330196e-01
SMIXI_c114_2_13 (mix_i_src_c114_2_13 mix_i_c114_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_13 (mix_q_src_c114_2_13 0 bpf_c114_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_2_13 (mix_q_src_c114_2_13 mix_q_c114_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_14 (mix_i_src_c114_2_14 0 bpf_c114_2 0) vcvs gain=8.314696123025e-01
SMIXI_c114_2_14 (mix_i_src_c114_2_14 mix_i_c114_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_14 (mix_q_src_c114_2_14 0 bpf_c114_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_2_14 (mix_q_src_c114_2_14 mix_q_c114_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_2_15 (mix_i_src_c114_2_15 0 bpf_c114_2 0) vcvs gain=9.807852804032e-01
SMIXI_c114_2_15 (mix_i_src_c114_2_15 mix_i_c114_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_2_15 (mix_q_src_c114_2_15 0 bpf_c114_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_2_15 (mix_q_src_c114_2_15 mix_q_c114_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c114_2 (mix_i_c114_2 0) resistor r=1G
RMIXQ_c114_2 (mix_q_c114_2 0) resistor r=1G
RINTI_c114_2 (mix_i_c114_2 Icar_c114_2) resistor r=1k
CINTI_c114_2 (Icar_c114_2 0) capacitor c=80p
RINTQ_c114_2 (mix_q_c114_2 Qcar_c114_2) resistor r=1k
CINTQ_c114_2 (Qcar_c114_2 0) capacitor c=80p

// bl114, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c114_3 (bl114 n_cbpf_c114_3) capacitor c=2.533029591058e-14
LBPF_c114_3 (n_cbpf_c114_3 bpf_c114_3) inductor l=1.000000000000e-06
RBPF_c114_3 (bpf_c114_3 0) resistor r=3.141592653590e+02
EMIXI_c114_3_00 (mix_i_src_c114_3_00 0 bpf_c114_3 0) vcvs gain=9.807852804032e-01
SMIXI_c114_3_00 (mix_i_src_c114_3_00 mix_i_c114_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_00 (mix_q_src_c114_3_00 0 bpf_c114_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_3_00 (mix_q_src_c114_3_00 mix_q_c114_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_01 (mix_i_src_c114_3_01 0 bpf_c114_3 0) vcvs gain=8.314696123025e-01
SMIXI_c114_3_01 (mix_i_src_c114_3_01 mix_i_c114_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_01 (mix_q_src_c114_3_01 0 bpf_c114_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_3_01 (mix_q_src_c114_3_01 mix_q_c114_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_02 (mix_i_src_c114_3_02 0 bpf_c114_3 0) vcvs gain=5.555702330196e-01
SMIXI_c114_3_02 (mix_i_src_c114_3_02 mix_i_c114_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_02 (mix_q_src_c114_3_02 0 bpf_c114_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_3_02 (mix_q_src_c114_3_02 mix_q_c114_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_03 (mix_i_src_c114_3_03 0 bpf_c114_3 0) vcvs gain=1.950903220161e-01
SMIXI_c114_3_03 (mix_i_src_c114_3_03 mix_i_c114_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_03 (mix_q_src_c114_3_03 0 bpf_c114_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_3_03 (mix_q_src_c114_3_03 mix_q_c114_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_04 (mix_i_src_c114_3_04 0 bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_3_04 (mix_i_src_c114_3_04 mix_i_c114_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_04 (mix_q_src_c114_3_04 0 bpf_c114_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c114_3_04 (mix_q_src_c114_3_04 mix_q_c114_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_05 (mix_i_src_c114_3_05 0 bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_3_05 (mix_i_src_c114_3_05 mix_i_c114_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_05 (mix_q_src_c114_3_05 0 bpf_c114_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c114_3_05 (mix_q_src_c114_3_05 mix_q_c114_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_06 (mix_i_src_c114_3_06 0 bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_3_06 (mix_i_src_c114_3_06 mix_i_c114_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_06 (mix_q_src_c114_3_06 0 bpf_c114_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c114_3_06 (mix_q_src_c114_3_06 mix_q_c114_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_07 (mix_i_src_c114_3_07 0 bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_3_07 (mix_i_src_c114_3_07 mix_i_c114_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_07 (mix_q_src_c114_3_07 0 bpf_c114_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c114_3_07 (mix_q_src_c114_3_07 mix_q_c114_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_08 (mix_i_src_c114_3_08 0 bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c114_3_08 (mix_i_src_c114_3_08 mix_i_c114_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_08 (mix_q_src_c114_3_08 0 bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_3_08 (mix_q_src_c114_3_08 mix_q_c114_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_09 (mix_i_src_c114_3_09 0 bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c114_3_09 (mix_i_src_c114_3_09 mix_i_c114_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_09 (mix_q_src_c114_3_09 0 bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_3_09 (mix_q_src_c114_3_09 mix_q_c114_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_10 (mix_i_src_c114_3_10 0 bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c114_3_10 (mix_i_src_c114_3_10 mix_i_c114_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_10 (mix_q_src_c114_3_10 0 bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_3_10 (mix_q_src_c114_3_10 mix_q_c114_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_11 (mix_i_src_c114_3_11 0 bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c114_3_11 (mix_i_src_c114_3_11 mix_i_c114_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_11 (mix_q_src_c114_3_11 0 bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_3_11 (mix_q_src_c114_3_11 mix_q_c114_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_12 (mix_i_src_c114_3_12 0 bpf_c114_3 0) vcvs gain=1.950903220161e-01
SMIXI_c114_3_12 (mix_i_src_c114_3_12 mix_i_c114_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_12 (mix_q_src_c114_3_12 0 bpf_c114_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c114_3_12 (mix_q_src_c114_3_12 mix_q_c114_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_13 (mix_i_src_c114_3_13 0 bpf_c114_3 0) vcvs gain=5.555702330196e-01
SMIXI_c114_3_13 (mix_i_src_c114_3_13 mix_i_c114_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_13 (mix_q_src_c114_3_13 0 bpf_c114_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c114_3_13 (mix_q_src_c114_3_13 mix_q_c114_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_14 (mix_i_src_c114_3_14 0 bpf_c114_3 0) vcvs gain=8.314696123025e-01
SMIXI_c114_3_14 (mix_i_src_c114_3_14 mix_i_c114_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_14 (mix_q_src_c114_3_14 0 bpf_c114_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c114_3_14 (mix_q_src_c114_3_14 mix_q_c114_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c114_3_15 (mix_i_src_c114_3_15 0 bpf_c114_3 0) vcvs gain=9.807852804032e-01
SMIXI_c114_3_15 (mix_i_src_c114_3_15 mix_i_c114_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c114_3_15 (mix_q_src_c114_3_15 0 bpf_c114_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c114_3_15 (mix_q_src_c114_3_15 mix_q_c114_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c114_3 (mix_i_c114_3 0) resistor r=1G
RMIXQ_c114_3 (mix_q_c114_3 0) resistor r=1G
RINTI_c114_3 (mix_i_c114_3 Icar_c114_3) resistor r=1k
CINTI_c114_3 (Icar_c114_3 0) capacitor c=80p
RINTQ_c114_3 (mix_q_c114_3 Qcar_c114_3) resistor r=1k
CINTQ_c114_3 (Qcar_c114_3 0) capacitor c=80p

// bl115, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c115_0 (bl115 n_cbpf_c115_0) capacitor c=4.052847345694e-13
LBPF_c115_0 (n_cbpf_c115_0 bpf_c115_0) inductor l=1.000000000000e-06
RBPF_c115_0 (bpf_c115_0 0) resistor r=7.853981633974e+01
EMIXI_c115_0_00 (mix_i_src_c115_0_00 0 bpf_c115_0 0) vcvs gain=9.807852804032e-01
SMIXI_c115_0_00 (mix_i_src_c115_0_00 mix_i_c115_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_00 (mix_q_src_c115_0_00 0 bpf_c115_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_0_00 (mix_q_src_c115_0_00 mix_q_c115_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_01 (mix_i_src_c115_0_01 0 bpf_c115_0 0) vcvs gain=8.314696123025e-01
SMIXI_c115_0_01 (mix_i_src_c115_0_01 mix_i_c115_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_01 (mix_q_src_c115_0_01 0 bpf_c115_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_0_01 (mix_q_src_c115_0_01 mix_q_c115_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_02 (mix_i_src_c115_0_02 0 bpf_c115_0 0) vcvs gain=5.555702330196e-01
SMIXI_c115_0_02 (mix_i_src_c115_0_02 mix_i_c115_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_02 (mix_q_src_c115_0_02 0 bpf_c115_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_0_02 (mix_q_src_c115_0_02 mix_q_c115_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_03 (mix_i_src_c115_0_03 0 bpf_c115_0 0) vcvs gain=1.950903220161e-01
SMIXI_c115_0_03 (mix_i_src_c115_0_03 mix_i_c115_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_03 (mix_q_src_c115_0_03 0 bpf_c115_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_0_03 (mix_q_src_c115_0_03 mix_q_c115_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_04 (mix_i_src_c115_0_04 0 bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_0_04 (mix_i_src_c115_0_04 mix_i_c115_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_04 (mix_q_src_c115_0_04 0 bpf_c115_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_0_04 (mix_q_src_c115_0_04 mix_q_c115_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_05 (mix_i_src_c115_0_05 0 bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_0_05 (mix_i_src_c115_0_05 mix_i_c115_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_05 (mix_q_src_c115_0_05 0 bpf_c115_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_0_05 (mix_q_src_c115_0_05 mix_q_c115_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_06 (mix_i_src_c115_0_06 0 bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_0_06 (mix_i_src_c115_0_06 mix_i_c115_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_06 (mix_q_src_c115_0_06 0 bpf_c115_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_0_06 (mix_q_src_c115_0_06 mix_q_c115_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_07 (mix_i_src_c115_0_07 0 bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_0_07 (mix_i_src_c115_0_07 mix_i_c115_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_07 (mix_q_src_c115_0_07 0 bpf_c115_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_0_07 (mix_q_src_c115_0_07 mix_q_c115_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_08 (mix_i_src_c115_0_08 0 bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_0_08 (mix_i_src_c115_0_08 mix_i_c115_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_08 (mix_q_src_c115_0_08 0 bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_0_08 (mix_q_src_c115_0_08 mix_q_c115_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_09 (mix_i_src_c115_0_09 0 bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_0_09 (mix_i_src_c115_0_09 mix_i_c115_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_09 (mix_q_src_c115_0_09 0 bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_0_09 (mix_q_src_c115_0_09 mix_q_c115_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_10 (mix_i_src_c115_0_10 0 bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_0_10 (mix_i_src_c115_0_10 mix_i_c115_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_10 (mix_q_src_c115_0_10 0 bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_0_10 (mix_q_src_c115_0_10 mix_q_c115_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_11 (mix_i_src_c115_0_11 0 bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_0_11 (mix_i_src_c115_0_11 mix_i_c115_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_11 (mix_q_src_c115_0_11 0 bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_0_11 (mix_q_src_c115_0_11 mix_q_c115_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_12 (mix_i_src_c115_0_12 0 bpf_c115_0 0) vcvs gain=1.950903220161e-01
SMIXI_c115_0_12 (mix_i_src_c115_0_12 mix_i_c115_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_12 (mix_q_src_c115_0_12 0 bpf_c115_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_0_12 (mix_q_src_c115_0_12 mix_q_c115_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_13 (mix_i_src_c115_0_13 0 bpf_c115_0 0) vcvs gain=5.555702330196e-01
SMIXI_c115_0_13 (mix_i_src_c115_0_13 mix_i_c115_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_13 (mix_q_src_c115_0_13 0 bpf_c115_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_0_13 (mix_q_src_c115_0_13 mix_q_c115_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_14 (mix_i_src_c115_0_14 0 bpf_c115_0 0) vcvs gain=8.314696123025e-01
SMIXI_c115_0_14 (mix_i_src_c115_0_14 mix_i_c115_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_14 (mix_q_src_c115_0_14 0 bpf_c115_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_0_14 (mix_q_src_c115_0_14 mix_q_c115_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_0_15 (mix_i_src_c115_0_15 0 bpf_c115_0 0) vcvs gain=9.807852804032e-01
SMIXI_c115_0_15 (mix_i_src_c115_0_15 mix_i_c115_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_0_15 (mix_q_src_c115_0_15 0 bpf_c115_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_0_15 (mix_q_src_c115_0_15 mix_q_c115_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c115_0 (mix_i_c115_0 0) resistor r=1G
RMIXQ_c115_0 (mix_q_c115_0 0) resistor r=1G
RINTI_c115_0 (mix_i_c115_0 Icar_c115_0) resistor r=1k
CINTI_c115_0 (Icar_c115_0 0) capacitor c=80p
RINTQ_c115_0 (mix_q_c115_0 Qcar_c115_0) resistor r=1k
CINTQ_c115_0 (Qcar_c115_0 0) capacitor c=80p

// bl115, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c115_1 (bl115 n_cbpf_c115_1) capacitor c=1.013211836423e-13
LBPF_c115_1 (n_cbpf_c115_1 bpf_c115_1) inductor l=1.000000000000e-06
RBPF_c115_1 (bpf_c115_1 0) resistor r=1.570796326795e+02
EMIXI_c115_1_00 (mix_i_src_c115_1_00 0 bpf_c115_1 0) vcvs gain=9.807852804032e-01
SMIXI_c115_1_00 (mix_i_src_c115_1_00 mix_i_c115_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_00 (mix_q_src_c115_1_00 0 bpf_c115_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_1_00 (mix_q_src_c115_1_00 mix_q_c115_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_01 (mix_i_src_c115_1_01 0 bpf_c115_1 0) vcvs gain=8.314696123025e-01
SMIXI_c115_1_01 (mix_i_src_c115_1_01 mix_i_c115_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_01 (mix_q_src_c115_1_01 0 bpf_c115_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_1_01 (mix_q_src_c115_1_01 mix_q_c115_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_02 (mix_i_src_c115_1_02 0 bpf_c115_1 0) vcvs gain=5.555702330196e-01
SMIXI_c115_1_02 (mix_i_src_c115_1_02 mix_i_c115_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_02 (mix_q_src_c115_1_02 0 bpf_c115_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_1_02 (mix_q_src_c115_1_02 mix_q_c115_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_03 (mix_i_src_c115_1_03 0 bpf_c115_1 0) vcvs gain=1.950903220161e-01
SMIXI_c115_1_03 (mix_i_src_c115_1_03 mix_i_c115_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_03 (mix_q_src_c115_1_03 0 bpf_c115_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_1_03 (mix_q_src_c115_1_03 mix_q_c115_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_04 (mix_i_src_c115_1_04 0 bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_1_04 (mix_i_src_c115_1_04 mix_i_c115_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_04 (mix_q_src_c115_1_04 0 bpf_c115_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_1_04 (mix_q_src_c115_1_04 mix_q_c115_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_05 (mix_i_src_c115_1_05 0 bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_1_05 (mix_i_src_c115_1_05 mix_i_c115_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_05 (mix_q_src_c115_1_05 0 bpf_c115_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_1_05 (mix_q_src_c115_1_05 mix_q_c115_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_06 (mix_i_src_c115_1_06 0 bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_1_06 (mix_i_src_c115_1_06 mix_i_c115_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_06 (mix_q_src_c115_1_06 0 bpf_c115_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_1_06 (mix_q_src_c115_1_06 mix_q_c115_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_07 (mix_i_src_c115_1_07 0 bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_1_07 (mix_i_src_c115_1_07 mix_i_c115_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_07 (mix_q_src_c115_1_07 0 bpf_c115_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_1_07 (mix_q_src_c115_1_07 mix_q_c115_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_08 (mix_i_src_c115_1_08 0 bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_1_08 (mix_i_src_c115_1_08 mix_i_c115_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_08 (mix_q_src_c115_1_08 0 bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_1_08 (mix_q_src_c115_1_08 mix_q_c115_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_09 (mix_i_src_c115_1_09 0 bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_1_09 (mix_i_src_c115_1_09 mix_i_c115_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_09 (mix_q_src_c115_1_09 0 bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_1_09 (mix_q_src_c115_1_09 mix_q_c115_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_10 (mix_i_src_c115_1_10 0 bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_1_10 (mix_i_src_c115_1_10 mix_i_c115_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_10 (mix_q_src_c115_1_10 0 bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_1_10 (mix_q_src_c115_1_10 mix_q_c115_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_11 (mix_i_src_c115_1_11 0 bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_1_11 (mix_i_src_c115_1_11 mix_i_c115_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_11 (mix_q_src_c115_1_11 0 bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_1_11 (mix_q_src_c115_1_11 mix_q_c115_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_12 (mix_i_src_c115_1_12 0 bpf_c115_1 0) vcvs gain=1.950903220161e-01
SMIXI_c115_1_12 (mix_i_src_c115_1_12 mix_i_c115_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_12 (mix_q_src_c115_1_12 0 bpf_c115_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_1_12 (mix_q_src_c115_1_12 mix_q_c115_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_13 (mix_i_src_c115_1_13 0 bpf_c115_1 0) vcvs gain=5.555702330196e-01
SMIXI_c115_1_13 (mix_i_src_c115_1_13 mix_i_c115_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_13 (mix_q_src_c115_1_13 0 bpf_c115_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_1_13 (mix_q_src_c115_1_13 mix_q_c115_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_14 (mix_i_src_c115_1_14 0 bpf_c115_1 0) vcvs gain=8.314696123025e-01
SMIXI_c115_1_14 (mix_i_src_c115_1_14 mix_i_c115_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_14 (mix_q_src_c115_1_14 0 bpf_c115_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_1_14 (mix_q_src_c115_1_14 mix_q_c115_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_1_15 (mix_i_src_c115_1_15 0 bpf_c115_1 0) vcvs gain=9.807852804032e-01
SMIXI_c115_1_15 (mix_i_src_c115_1_15 mix_i_c115_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_1_15 (mix_q_src_c115_1_15 0 bpf_c115_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_1_15 (mix_q_src_c115_1_15 mix_q_c115_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c115_1 (mix_i_c115_1 0) resistor r=1G
RMIXQ_c115_1 (mix_q_c115_1 0) resistor r=1G
RINTI_c115_1 (mix_i_c115_1 Icar_c115_1) resistor r=1k
CINTI_c115_1 (Icar_c115_1 0) capacitor c=80p
RINTQ_c115_1 (mix_q_c115_1 Qcar_c115_1) resistor r=1k
CINTQ_c115_1 (Qcar_c115_1 0) capacitor c=80p

// bl115, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c115_2 (bl115 n_cbpf_c115_2) capacitor c=4.503163717437e-14
LBPF_c115_2 (n_cbpf_c115_2 bpf_c115_2) inductor l=1.000000000000e-06
RBPF_c115_2 (bpf_c115_2 0) resistor r=2.356194490192e+02
EMIXI_c115_2_00 (mix_i_src_c115_2_00 0 bpf_c115_2 0) vcvs gain=9.807852804032e-01
SMIXI_c115_2_00 (mix_i_src_c115_2_00 mix_i_c115_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_00 (mix_q_src_c115_2_00 0 bpf_c115_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_2_00 (mix_q_src_c115_2_00 mix_q_c115_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_01 (mix_i_src_c115_2_01 0 bpf_c115_2 0) vcvs gain=8.314696123025e-01
SMIXI_c115_2_01 (mix_i_src_c115_2_01 mix_i_c115_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_01 (mix_q_src_c115_2_01 0 bpf_c115_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_2_01 (mix_q_src_c115_2_01 mix_q_c115_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_02 (mix_i_src_c115_2_02 0 bpf_c115_2 0) vcvs gain=5.555702330196e-01
SMIXI_c115_2_02 (mix_i_src_c115_2_02 mix_i_c115_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_02 (mix_q_src_c115_2_02 0 bpf_c115_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_2_02 (mix_q_src_c115_2_02 mix_q_c115_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_03 (mix_i_src_c115_2_03 0 bpf_c115_2 0) vcvs gain=1.950903220161e-01
SMIXI_c115_2_03 (mix_i_src_c115_2_03 mix_i_c115_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_03 (mix_q_src_c115_2_03 0 bpf_c115_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_2_03 (mix_q_src_c115_2_03 mix_q_c115_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_04 (mix_i_src_c115_2_04 0 bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_2_04 (mix_i_src_c115_2_04 mix_i_c115_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_04 (mix_q_src_c115_2_04 0 bpf_c115_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_2_04 (mix_q_src_c115_2_04 mix_q_c115_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_05 (mix_i_src_c115_2_05 0 bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_2_05 (mix_i_src_c115_2_05 mix_i_c115_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_05 (mix_q_src_c115_2_05 0 bpf_c115_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_2_05 (mix_q_src_c115_2_05 mix_q_c115_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_06 (mix_i_src_c115_2_06 0 bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_2_06 (mix_i_src_c115_2_06 mix_i_c115_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_06 (mix_q_src_c115_2_06 0 bpf_c115_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_2_06 (mix_q_src_c115_2_06 mix_q_c115_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_07 (mix_i_src_c115_2_07 0 bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_2_07 (mix_i_src_c115_2_07 mix_i_c115_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_07 (mix_q_src_c115_2_07 0 bpf_c115_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_2_07 (mix_q_src_c115_2_07 mix_q_c115_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_08 (mix_i_src_c115_2_08 0 bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_2_08 (mix_i_src_c115_2_08 mix_i_c115_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_08 (mix_q_src_c115_2_08 0 bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_2_08 (mix_q_src_c115_2_08 mix_q_c115_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_09 (mix_i_src_c115_2_09 0 bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_2_09 (mix_i_src_c115_2_09 mix_i_c115_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_09 (mix_q_src_c115_2_09 0 bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_2_09 (mix_q_src_c115_2_09 mix_q_c115_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_10 (mix_i_src_c115_2_10 0 bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_2_10 (mix_i_src_c115_2_10 mix_i_c115_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_10 (mix_q_src_c115_2_10 0 bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_2_10 (mix_q_src_c115_2_10 mix_q_c115_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_11 (mix_i_src_c115_2_11 0 bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_2_11 (mix_i_src_c115_2_11 mix_i_c115_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_11 (mix_q_src_c115_2_11 0 bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_2_11 (mix_q_src_c115_2_11 mix_q_c115_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_12 (mix_i_src_c115_2_12 0 bpf_c115_2 0) vcvs gain=1.950903220161e-01
SMIXI_c115_2_12 (mix_i_src_c115_2_12 mix_i_c115_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_12 (mix_q_src_c115_2_12 0 bpf_c115_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_2_12 (mix_q_src_c115_2_12 mix_q_c115_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_13 (mix_i_src_c115_2_13 0 bpf_c115_2 0) vcvs gain=5.555702330196e-01
SMIXI_c115_2_13 (mix_i_src_c115_2_13 mix_i_c115_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_13 (mix_q_src_c115_2_13 0 bpf_c115_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_2_13 (mix_q_src_c115_2_13 mix_q_c115_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_14 (mix_i_src_c115_2_14 0 bpf_c115_2 0) vcvs gain=8.314696123025e-01
SMIXI_c115_2_14 (mix_i_src_c115_2_14 mix_i_c115_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_14 (mix_q_src_c115_2_14 0 bpf_c115_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_2_14 (mix_q_src_c115_2_14 mix_q_c115_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_2_15 (mix_i_src_c115_2_15 0 bpf_c115_2 0) vcvs gain=9.807852804032e-01
SMIXI_c115_2_15 (mix_i_src_c115_2_15 mix_i_c115_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_2_15 (mix_q_src_c115_2_15 0 bpf_c115_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_2_15 (mix_q_src_c115_2_15 mix_q_c115_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c115_2 (mix_i_c115_2 0) resistor r=1G
RMIXQ_c115_2 (mix_q_c115_2 0) resistor r=1G
RINTI_c115_2 (mix_i_c115_2 Icar_c115_2) resistor r=1k
CINTI_c115_2 (Icar_c115_2 0) capacitor c=80p
RINTQ_c115_2 (mix_q_c115_2 Qcar_c115_2) resistor r=1k
CINTQ_c115_2 (Qcar_c115_2 0) capacitor c=80p

// bl115, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c115_3 (bl115 n_cbpf_c115_3) capacitor c=2.533029591058e-14
LBPF_c115_3 (n_cbpf_c115_3 bpf_c115_3) inductor l=1.000000000000e-06
RBPF_c115_3 (bpf_c115_3 0) resistor r=3.141592653590e+02
EMIXI_c115_3_00 (mix_i_src_c115_3_00 0 bpf_c115_3 0) vcvs gain=9.807852804032e-01
SMIXI_c115_3_00 (mix_i_src_c115_3_00 mix_i_c115_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_00 (mix_q_src_c115_3_00 0 bpf_c115_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_3_00 (mix_q_src_c115_3_00 mix_q_c115_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_01 (mix_i_src_c115_3_01 0 bpf_c115_3 0) vcvs gain=8.314696123025e-01
SMIXI_c115_3_01 (mix_i_src_c115_3_01 mix_i_c115_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_01 (mix_q_src_c115_3_01 0 bpf_c115_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_3_01 (mix_q_src_c115_3_01 mix_q_c115_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_02 (mix_i_src_c115_3_02 0 bpf_c115_3 0) vcvs gain=5.555702330196e-01
SMIXI_c115_3_02 (mix_i_src_c115_3_02 mix_i_c115_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_02 (mix_q_src_c115_3_02 0 bpf_c115_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_3_02 (mix_q_src_c115_3_02 mix_q_c115_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_03 (mix_i_src_c115_3_03 0 bpf_c115_3 0) vcvs gain=1.950903220161e-01
SMIXI_c115_3_03 (mix_i_src_c115_3_03 mix_i_c115_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_03 (mix_q_src_c115_3_03 0 bpf_c115_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_3_03 (mix_q_src_c115_3_03 mix_q_c115_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_04 (mix_i_src_c115_3_04 0 bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_3_04 (mix_i_src_c115_3_04 mix_i_c115_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_04 (mix_q_src_c115_3_04 0 bpf_c115_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c115_3_04 (mix_q_src_c115_3_04 mix_q_c115_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_05 (mix_i_src_c115_3_05 0 bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_3_05 (mix_i_src_c115_3_05 mix_i_c115_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_05 (mix_q_src_c115_3_05 0 bpf_c115_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c115_3_05 (mix_q_src_c115_3_05 mix_q_c115_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_06 (mix_i_src_c115_3_06 0 bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_3_06 (mix_i_src_c115_3_06 mix_i_c115_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_06 (mix_q_src_c115_3_06 0 bpf_c115_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c115_3_06 (mix_q_src_c115_3_06 mix_q_c115_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_07 (mix_i_src_c115_3_07 0 bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_3_07 (mix_i_src_c115_3_07 mix_i_c115_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_07 (mix_q_src_c115_3_07 0 bpf_c115_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c115_3_07 (mix_q_src_c115_3_07 mix_q_c115_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_08 (mix_i_src_c115_3_08 0 bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c115_3_08 (mix_i_src_c115_3_08 mix_i_c115_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_08 (mix_q_src_c115_3_08 0 bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_3_08 (mix_q_src_c115_3_08 mix_q_c115_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_09 (mix_i_src_c115_3_09 0 bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c115_3_09 (mix_i_src_c115_3_09 mix_i_c115_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_09 (mix_q_src_c115_3_09 0 bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_3_09 (mix_q_src_c115_3_09 mix_q_c115_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_10 (mix_i_src_c115_3_10 0 bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c115_3_10 (mix_i_src_c115_3_10 mix_i_c115_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_10 (mix_q_src_c115_3_10 0 bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_3_10 (mix_q_src_c115_3_10 mix_q_c115_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_11 (mix_i_src_c115_3_11 0 bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c115_3_11 (mix_i_src_c115_3_11 mix_i_c115_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_11 (mix_q_src_c115_3_11 0 bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_3_11 (mix_q_src_c115_3_11 mix_q_c115_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_12 (mix_i_src_c115_3_12 0 bpf_c115_3 0) vcvs gain=1.950903220161e-01
SMIXI_c115_3_12 (mix_i_src_c115_3_12 mix_i_c115_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_12 (mix_q_src_c115_3_12 0 bpf_c115_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c115_3_12 (mix_q_src_c115_3_12 mix_q_c115_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_13 (mix_i_src_c115_3_13 0 bpf_c115_3 0) vcvs gain=5.555702330196e-01
SMIXI_c115_3_13 (mix_i_src_c115_3_13 mix_i_c115_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_13 (mix_q_src_c115_3_13 0 bpf_c115_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c115_3_13 (mix_q_src_c115_3_13 mix_q_c115_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_14 (mix_i_src_c115_3_14 0 bpf_c115_3 0) vcvs gain=8.314696123025e-01
SMIXI_c115_3_14 (mix_i_src_c115_3_14 mix_i_c115_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_14 (mix_q_src_c115_3_14 0 bpf_c115_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c115_3_14 (mix_q_src_c115_3_14 mix_q_c115_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c115_3_15 (mix_i_src_c115_3_15 0 bpf_c115_3 0) vcvs gain=9.807852804032e-01
SMIXI_c115_3_15 (mix_i_src_c115_3_15 mix_i_c115_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c115_3_15 (mix_q_src_c115_3_15 0 bpf_c115_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c115_3_15 (mix_q_src_c115_3_15 mix_q_c115_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c115_3 (mix_i_c115_3 0) resistor r=1G
RMIXQ_c115_3 (mix_q_c115_3 0) resistor r=1G
RINTI_c115_3 (mix_i_c115_3 Icar_c115_3) resistor r=1k
CINTI_c115_3 (Icar_c115_3 0) capacitor c=80p
RINTQ_c115_3 (mix_q_c115_3 Qcar_c115_3) resistor r=1k
CINTQ_c115_3 (Qcar_c115_3 0) capacitor c=80p

// bl116, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c116_0 (bl116 n_cbpf_c116_0) capacitor c=4.052847345694e-13
LBPF_c116_0 (n_cbpf_c116_0 bpf_c116_0) inductor l=1.000000000000e-06
RBPF_c116_0 (bpf_c116_0 0) resistor r=7.853981633974e+01
EMIXI_c116_0_00 (mix_i_src_c116_0_00 0 bpf_c116_0 0) vcvs gain=9.807852804032e-01
SMIXI_c116_0_00 (mix_i_src_c116_0_00 mix_i_c116_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_00 (mix_q_src_c116_0_00 0 bpf_c116_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_0_00 (mix_q_src_c116_0_00 mix_q_c116_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_01 (mix_i_src_c116_0_01 0 bpf_c116_0 0) vcvs gain=8.314696123025e-01
SMIXI_c116_0_01 (mix_i_src_c116_0_01 mix_i_c116_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_01 (mix_q_src_c116_0_01 0 bpf_c116_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_0_01 (mix_q_src_c116_0_01 mix_q_c116_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_02 (mix_i_src_c116_0_02 0 bpf_c116_0 0) vcvs gain=5.555702330196e-01
SMIXI_c116_0_02 (mix_i_src_c116_0_02 mix_i_c116_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_02 (mix_q_src_c116_0_02 0 bpf_c116_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_0_02 (mix_q_src_c116_0_02 mix_q_c116_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_03 (mix_i_src_c116_0_03 0 bpf_c116_0 0) vcvs gain=1.950903220161e-01
SMIXI_c116_0_03 (mix_i_src_c116_0_03 mix_i_c116_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_03 (mix_q_src_c116_0_03 0 bpf_c116_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_0_03 (mix_q_src_c116_0_03 mix_q_c116_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_04 (mix_i_src_c116_0_04 0 bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_0_04 (mix_i_src_c116_0_04 mix_i_c116_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_04 (mix_q_src_c116_0_04 0 bpf_c116_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_0_04 (mix_q_src_c116_0_04 mix_q_c116_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_05 (mix_i_src_c116_0_05 0 bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_0_05 (mix_i_src_c116_0_05 mix_i_c116_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_05 (mix_q_src_c116_0_05 0 bpf_c116_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_0_05 (mix_q_src_c116_0_05 mix_q_c116_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_06 (mix_i_src_c116_0_06 0 bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_0_06 (mix_i_src_c116_0_06 mix_i_c116_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_06 (mix_q_src_c116_0_06 0 bpf_c116_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_0_06 (mix_q_src_c116_0_06 mix_q_c116_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_07 (mix_i_src_c116_0_07 0 bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_0_07 (mix_i_src_c116_0_07 mix_i_c116_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_07 (mix_q_src_c116_0_07 0 bpf_c116_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_0_07 (mix_q_src_c116_0_07 mix_q_c116_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_08 (mix_i_src_c116_0_08 0 bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_0_08 (mix_i_src_c116_0_08 mix_i_c116_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_08 (mix_q_src_c116_0_08 0 bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_0_08 (mix_q_src_c116_0_08 mix_q_c116_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_09 (mix_i_src_c116_0_09 0 bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_0_09 (mix_i_src_c116_0_09 mix_i_c116_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_09 (mix_q_src_c116_0_09 0 bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_0_09 (mix_q_src_c116_0_09 mix_q_c116_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_10 (mix_i_src_c116_0_10 0 bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_0_10 (mix_i_src_c116_0_10 mix_i_c116_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_10 (mix_q_src_c116_0_10 0 bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_0_10 (mix_q_src_c116_0_10 mix_q_c116_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_11 (mix_i_src_c116_0_11 0 bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_0_11 (mix_i_src_c116_0_11 mix_i_c116_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_11 (mix_q_src_c116_0_11 0 bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_0_11 (mix_q_src_c116_0_11 mix_q_c116_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_12 (mix_i_src_c116_0_12 0 bpf_c116_0 0) vcvs gain=1.950903220161e-01
SMIXI_c116_0_12 (mix_i_src_c116_0_12 mix_i_c116_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_12 (mix_q_src_c116_0_12 0 bpf_c116_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_0_12 (mix_q_src_c116_0_12 mix_q_c116_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_13 (mix_i_src_c116_0_13 0 bpf_c116_0 0) vcvs gain=5.555702330196e-01
SMIXI_c116_0_13 (mix_i_src_c116_0_13 mix_i_c116_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_13 (mix_q_src_c116_0_13 0 bpf_c116_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_0_13 (mix_q_src_c116_0_13 mix_q_c116_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_14 (mix_i_src_c116_0_14 0 bpf_c116_0 0) vcvs gain=8.314696123025e-01
SMIXI_c116_0_14 (mix_i_src_c116_0_14 mix_i_c116_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_14 (mix_q_src_c116_0_14 0 bpf_c116_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_0_14 (mix_q_src_c116_0_14 mix_q_c116_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_0_15 (mix_i_src_c116_0_15 0 bpf_c116_0 0) vcvs gain=9.807852804032e-01
SMIXI_c116_0_15 (mix_i_src_c116_0_15 mix_i_c116_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_0_15 (mix_q_src_c116_0_15 0 bpf_c116_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_0_15 (mix_q_src_c116_0_15 mix_q_c116_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c116_0 (mix_i_c116_0 0) resistor r=1G
RMIXQ_c116_0 (mix_q_c116_0 0) resistor r=1G
RINTI_c116_0 (mix_i_c116_0 Icar_c116_0) resistor r=1k
CINTI_c116_0 (Icar_c116_0 0) capacitor c=80p
RINTQ_c116_0 (mix_q_c116_0 Qcar_c116_0) resistor r=1k
CINTQ_c116_0 (Qcar_c116_0 0) capacitor c=80p

// bl116, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c116_1 (bl116 n_cbpf_c116_1) capacitor c=1.013211836423e-13
LBPF_c116_1 (n_cbpf_c116_1 bpf_c116_1) inductor l=1.000000000000e-06
RBPF_c116_1 (bpf_c116_1 0) resistor r=1.570796326795e+02
EMIXI_c116_1_00 (mix_i_src_c116_1_00 0 bpf_c116_1 0) vcvs gain=9.807852804032e-01
SMIXI_c116_1_00 (mix_i_src_c116_1_00 mix_i_c116_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_00 (mix_q_src_c116_1_00 0 bpf_c116_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_1_00 (mix_q_src_c116_1_00 mix_q_c116_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_01 (mix_i_src_c116_1_01 0 bpf_c116_1 0) vcvs gain=8.314696123025e-01
SMIXI_c116_1_01 (mix_i_src_c116_1_01 mix_i_c116_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_01 (mix_q_src_c116_1_01 0 bpf_c116_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_1_01 (mix_q_src_c116_1_01 mix_q_c116_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_02 (mix_i_src_c116_1_02 0 bpf_c116_1 0) vcvs gain=5.555702330196e-01
SMIXI_c116_1_02 (mix_i_src_c116_1_02 mix_i_c116_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_02 (mix_q_src_c116_1_02 0 bpf_c116_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_1_02 (mix_q_src_c116_1_02 mix_q_c116_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_03 (mix_i_src_c116_1_03 0 bpf_c116_1 0) vcvs gain=1.950903220161e-01
SMIXI_c116_1_03 (mix_i_src_c116_1_03 mix_i_c116_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_03 (mix_q_src_c116_1_03 0 bpf_c116_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_1_03 (mix_q_src_c116_1_03 mix_q_c116_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_04 (mix_i_src_c116_1_04 0 bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_1_04 (mix_i_src_c116_1_04 mix_i_c116_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_04 (mix_q_src_c116_1_04 0 bpf_c116_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_1_04 (mix_q_src_c116_1_04 mix_q_c116_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_05 (mix_i_src_c116_1_05 0 bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_1_05 (mix_i_src_c116_1_05 mix_i_c116_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_05 (mix_q_src_c116_1_05 0 bpf_c116_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_1_05 (mix_q_src_c116_1_05 mix_q_c116_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_06 (mix_i_src_c116_1_06 0 bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_1_06 (mix_i_src_c116_1_06 mix_i_c116_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_06 (mix_q_src_c116_1_06 0 bpf_c116_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_1_06 (mix_q_src_c116_1_06 mix_q_c116_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_07 (mix_i_src_c116_1_07 0 bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_1_07 (mix_i_src_c116_1_07 mix_i_c116_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_07 (mix_q_src_c116_1_07 0 bpf_c116_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_1_07 (mix_q_src_c116_1_07 mix_q_c116_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_08 (mix_i_src_c116_1_08 0 bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_1_08 (mix_i_src_c116_1_08 mix_i_c116_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_08 (mix_q_src_c116_1_08 0 bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_1_08 (mix_q_src_c116_1_08 mix_q_c116_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_09 (mix_i_src_c116_1_09 0 bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_1_09 (mix_i_src_c116_1_09 mix_i_c116_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_09 (mix_q_src_c116_1_09 0 bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_1_09 (mix_q_src_c116_1_09 mix_q_c116_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_10 (mix_i_src_c116_1_10 0 bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_1_10 (mix_i_src_c116_1_10 mix_i_c116_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_10 (mix_q_src_c116_1_10 0 bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_1_10 (mix_q_src_c116_1_10 mix_q_c116_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_11 (mix_i_src_c116_1_11 0 bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_1_11 (mix_i_src_c116_1_11 mix_i_c116_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_11 (mix_q_src_c116_1_11 0 bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_1_11 (mix_q_src_c116_1_11 mix_q_c116_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_12 (mix_i_src_c116_1_12 0 bpf_c116_1 0) vcvs gain=1.950903220161e-01
SMIXI_c116_1_12 (mix_i_src_c116_1_12 mix_i_c116_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_12 (mix_q_src_c116_1_12 0 bpf_c116_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_1_12 (mix_q_src_c116_1_12 mix_q_c116_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_13 (mix_i_src_c116_1_13 0 bpf_c116_1 0) vcvs gain=5.555702330196e-01
SMIXI_c116_1_13 (mix_i_src_c116_1_13 mix_i_c116_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_13 (mix_q_src_c116_1_13 0 bpf_c116_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_1_13 (mix_q_src_c116_1_13 mix_q_c116_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_14 (mix_i_src_c116_1_14 0 bpf_c116_1 0) vcvs gain=8.314696123025e-01
SMIXI_c116_1_14 (mix_i_src_c116_1_14 mix_i_c116_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_14 (mix_q_src_c116_1_14 0 bpf_c116_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_1_14 (mix_q_src_c116_1_14 mix_q_c116_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_1_15 (mix_i_src_c116_1_15 0 bpf_c116_1 0) vcvs gain=9.807852804032e-01
SMIXI_c116_1_15 (mix_i_src_c116_1_15 mix_i_c116_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_1_15 (mix_q_src_c116_1_15 0 bpf_c116_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_1_15 (mix_q_src_c116_1_15 mix_q_c116_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c116_1 (mix_i_c116_1 0) resistor r=1G
RMIXQ_c116_1 (mix_q_c116_1 0) resistor r=1G
RINTI_c116_1 (mix_i_c116_1 Icar_c116_1) resistor r=1k
CINTI_c116_1 (Icar_c116_1 0) capacitor c=80p
RINTQ_c116_1 (mix_q_c116_1 Qcar_c116_1) resistor r=1k
CINTQ_c116_1 (Qcar_c116_1 0) capacitor c=80p

// bl116, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c116_2 (bl116 n_cbpf_c116_2) capacitor c=4.503163717437e-14
LBPF_c116_2 (n_cbpf_c116_2 bpf_c116_2) inductor l=1.000000000000e-06
RBPF_c116_2 (bpf_c116_2 0) resistor r=2.356194490192e+02
EMIXI_c116_2_00 (mix_i_src_c116_2_00 0 bpf_c116_2 0) vcvs gain=9.807852804032e-01
SMIXI_c116_2_00 (mix_i_src_c116_2_00 mix_i_c116_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_00 (mix_q_src_c116_2_00 0 bpf_c116_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_2_00 (mix_q_src_c116_2_00 mix_q_c116_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_01 (mix_i_src_c116_2_01 0 bpf_c116_2 0) vcvs gain=8.314696123025e-01
SMIXI_c116_2_01 (mix_i_src_c116_2_01 mix_i_c116_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_01 (mix_q_src_c116_2_01 0 bpf_c116_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_2_01 (mix_q_src_c116_2_01 mix_q_c116_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_02 (mix_i_src_c116_2_02 0 bpf_c116_2 0) vcvs gain=5.555702330196e-01
SMIXI_c116_2_02 (mix_i_src_c116_2_02 mix_i_c116_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_02 (mix_q_src_c116_2_02 0 bpf_c116_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_2_02 (mix_q_src_c116_2_02 mix_q_c116_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_03 (mix_i_src_c116_2_03 0 bpf_c116_2 0) vcvs gain=1.950903220161e-01
SMIXI_c116_2_03 (mix_i_src_c116_2_03 mix_i_c116_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_03 (mix_q_src_c116_2_03 0 bpf_c116_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_2_03 (mix_q_src_c116_2_03 mix_q_c116_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_04 (mix_i_src_c116_2_04 0 bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_2_04 (mix_i_src_c116_2_04 mix_i_c116_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_04 (mix_q_src_c116_2_04 0 bpf_c116_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_2_04 (mix_q_src_c116_2_04 mix_q_c116_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_05 (mix_i_src_c116_2_05 0 bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_2_05 (mix_i_src_c116_2_05 mix_i_c116_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_05 (mix_q_src_c116_2_05 0 bpf_c116_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_2_05 (mix_q_src_c116_2_05 mix_q_c116_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_06 (mix_i_src_c116_2_06 0 bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_2_06 (mix_i_src_c116_2_06 mix_i_c116_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_06 (mix_q_src_c116_2_06 0 bpf_c116_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_2_06 (mix_q_src_c116_2_06 mix_q_c116_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_07 (mix_i_src_c116_2_07 0 bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_2_07 (mix_i_src_c116_2_07 mix_i_c116_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_07 (mix_q_src_c116_2_07 0 bpf_c116_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_2_07 (mix_q_src_c116_2_07 mix_q_c116_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_08 (mix_i_src_c116_2_08 0 bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_2_08 (mix_i_src_c116_2_08 mix_i_c116_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_08 (mix_q_src_c116_2_08 0 bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_2_08 (mix_q_src_c116_2_08 mix_q_c116_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_09 (mix_i_src_c116_2_09 0 bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_2_09 (mix_i_src_c116_2_09 mix_i_c116_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_09 (mix_q_src_c116_2_09 0 bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_2_09 (mix_q_src_c116_2_09 mix_q_c116_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_10 (mix_i_src_c116_2_10 0 bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_2_10 (mix_i_src_c116_2_10 mix_i_c116_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_10 (mix_q_src_c116_2_10 0 bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_2_10 (mix_q_src_c116_2_10 mix_q_c116_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_11 (mix_i_src_c116_2_11 0 bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_2_11 (mix_i_src_c116_2_11 mix_i_c116_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_11 (mix_q_src_c116_2_11 0 bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_2_11 (mix_q_src_c116_2_11 mix_q_c116_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_12 (mix_i_src_c116_2_12 0 bpf_c116_2 0) vcvs gain=1.950903220161e-01
SMIXI_c116_2_12 (mix_i_src_c116_2_12 mix_i_c116_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_12 (mix_q_src_c116_2_12 0 bpf_c116_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_2_12 (mix_q_src_c116_2_12 mix_q_c116_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_13 (mix_i_src_c116_2_13 0 bpf_c116_2 0) vcvs gain=5.555702330196e-01
SMIXI_c116_2_13 (mix_i_src_c116_2_13 mix_i_c116_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_13 (mix_q_src_c116_2_13 0 bpf_c116_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_2_13 (mix_q_src_c116_2_13 mix_q_c116_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_14 (mix_i_src_c116_2_14 0 bpf_c116_2 0) vcvs gain=8.314696123025e-01
SMIXI_c116_2_14 (mix_i_src_c116_2_14 mix_i_c116_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_14 (mix_q_src_c116_2_14 0 bpf_c116_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_2_14 (mix_q_src_c116_2_14 mix_q_c116_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_2_15 (mix_i_src_c116_2_15 0 bpf_c116_2 0) vcvs gain=9.807852804032e-01
SMIXI_c116_2_15 (mix_i_src_c116_2_15 mix_i_c116_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_2_15 (mix_q_src_c116_2_15 0 bpf_c116_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_2_15 (mix_q_src_c116_2_15 mix_q_c116_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c116_2 (mix_i_c116_2 0) resistor r=1G
RMIXQ_c116_2 (mix_q_c116_2 0) resistor r=1G
RINTI_c116_2 (mix_i_c116_2 Icar_c116_2) resistor r=1k
CINTI_c116_2 (Icar_c116_2 0) capacitor c=80p
RINTQ_c116_2 (mix_q_c116_2 Qcar_c116_2) resistor r=1k
CINTQ_c116_2 (Qcar_c116_2 0) capacitor c=80p

// bl116, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c116_3 (bl116 n_cbpf_c116_3) capacitor c=2.533029591058e-14
LBPF_c116_3 (n_cbpf_c116_3 bpf_c116_3) inductor l=1.000000000000e-06
RBPF_c116_3 (bpf_c116_3 0) resistor r=3.141592653590e+02
EMIXI_c116_3_00 (mix_i_src_c116_3_00 0 bpf_c116_3 0) vcvs gain=9.807852804032e-01
SMIXI_c116_3_00 (mix_i_src_c116_3_00 mix_i_c116_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_00 (mix_q_src_c116_3_00 0 bpf_c116_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_3_00 (mix_q_src_c116_3_00 mix_q_c116_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_01 (mix_i_src_c116_3_01 0 bpf_c116_3 0) vcvs gain=8.314696123025e-01
SMIXI_c116_3_01 (mix_i_src_c116_3_01 mix_i_c116_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_01 (mix_q_src_c116_3_01 0 bpf_c116_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_3_01 (mix_q_src_c116_3_01 mix_q_c116_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_02 (mix_i_src_c116_3_02 0 bpf_c116_3 0) vcvs gain=5.555702330196e-01
SMIXI_c116_3_02 (mix_i_src_c116_3_02 mix_i_c116_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_02 (mix_q_src_c116_3_02 0 bpf_c116_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_3_02 (mix_q_src_c116_3_02 mix_q_c116_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_03 (mix_i_src_c116_3_03 0 bpf_c116_3 0) vcvs gain=1.950903220161e-01
SMIXI_c116_3_03 (mix_i_src_c116_3_03 mix_i_c116_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_03 (mix_q_src_c116_3_03 0 bpf_c116_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_3_03 (mix_q_src_c116_3_03 mix_q_c116_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_04 (mix_i_src_c116_3_04 0 bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_3_04 (mix_i_src_c116_3_04 mix_i_c116_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_04 (mix_q_src_c116_3_04 0 bpf_c116_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c116_3_04 (mix_q_src_c116_3_04 mix_q_c116_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_05 (mix_i_src_c116_3_05 0 bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_3_05 (mix_i_src_c116_3_05 mix_i_c116_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_05 (mix_q_src_c116_3_05 0 bpf_c116_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c116_3_05 (mix_q_src_c116_3_05 mix_q_c116_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_06 (mix_i_src_c116_3_06 0 bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_3_06 (mix_i_src_c116_3_06 mix_i_c116_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_06 (mix_q_src_c116_3_06 0 bpf_c116_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c116_3_06 (mix_q_src_c116_3_06 mix_q_c116_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_07 (mix_i_src_c116_3_07 0 bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_3_07 (mix_i_src_c116_3_07 mix_i_c116_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_07 (mix_q_src_c116_3_07 0 bpf_c116_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c116_3_07 (mix_q_src_c116_3_07 mix_q_c116_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_08 (mix_i_src_c116_3_08 0 bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c116_3_08 (mix_i_src_c116_3_08 mix_i_c116_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_08 (mix_q_src_c116_3_08 0 bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_3_08 (mix_q_src_c116_3_08 mix_q_c116_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_09 (mix_i_src_c116_3_09 0 bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c116_3_09 (mix_i_src_c116_3_09 mix_i_c116_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_09 (mix_q_src_c116_3_09 0 bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_3_09 (mix_q_src_c116_3_09 mix_q_c116_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_10 (mix_i_src_c116_3_10 0 bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c116_3_10 (mix_i_src_c116_3_10 mix_i_c116_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_10 (mix_q_src_c116_3_10 0 bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_3_10 (mix_q_src_c116_3_10 mix_q_c116_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_11 (mix_i_src_c116_3_11 0 bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c116_3_11 (mix_i_src_c116_3_11 mix_i_c116_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_11 (mix_q_src_c116_3_11 0 bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_3_11 (mix_q_src_c116_3_11 mix_q_c116_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_12 (mix_i_src_c116_3_12 0 bpf_c116_3 0) vcvs gain=1.950903220161e-01
SMIXI_c116_3_12 (mix_i_src_c116_3_12 mix_i_c116_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_12 (mix_q_src_c116_3_12 0 bpf_c116_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c116_3_12 (mix_q_src_c116_3_12 mix_q_c116_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_13 (mix_i_src_c116_3_13 0 bpf_c116_3 0) vcvs gain=5.555702330196e-01
SMIXI_c116_3_13 (mix_i_src_c116_3_13 mix_i_c116_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_13 (mix_q_src_c116_3_13 0 bpf_c116_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c116_3_13 (mix_q_src_c116_3_13 mix_q_c116_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_14 (mix_i_src_c116_3_14 0 bpf_c116_3 0) vcvs gain=8.314696123025e-01
SMIXI_c116_3_14 (mix_i_src_c116_3_14 mix_i_c116_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_14 (mix_q_src_c116_3_14 0 bpf_c116_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c116_3_14 (mix_q_src_c116_3_14 mix_q_c116_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c116_3_15 (mix_i_src_c116_3_15 0 bpf_c116_3 0) vcvs gain=9.807852804032e-01
SMIXI_c116_3_15 (mix_i_src_c116_3_15 mix_i_c116_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c116_3_15 (mix_q_src_c116_3_15 0 bpf_c116_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c116_3_15 (mix_q_src_c116_3_15 mix_q_c116_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c116_3 (mix_i_c116_3 0) resistor r=1G
RMIXQ_c116_3 (mix_q_c116_3 0) resistor r=1G
RINTI_c116_3 (mix_i_c116_3 Icar_c116_3) resistor r=1k
CINTI_c116_3 (Icar_c116_3 0) capacitor c=80p
RINTQ_c116_3 (mix_q_c116_3 Qcar_c116_3) resistor r=1k
CINTQ_c116_3 (Qcar_c116_3 0) capacitor c=80p

// bl117, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c117_0 (bl117 n_cbpf_c117_0) capacitor c=4.052847345694e-13
LBPF_c117_0 (n_cbpf_c117_0 bpf_c117_0) inductor l=1.000000000000e-06
RBPF_c117_0 (bpf_c117_0 0) resistor r=7.853981633974e+01
EMIXI_c117_0_00 (mix_i_src_c117_0_00 0 bpf_c117_0 0) vcvs gain=9.807852804032e-01
SMIXI_c117_0_00 (mix_i_src_c117_0_00 mix_i_c117_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_00 (mix_q_src_c117_0_00 0 bpf_c117_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_0_00 (mix_q_src_c117_0_00 mix_q_c117_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_01 (mix_i_src_c117_0_01 0 bpf_c117_0 0) vcvs gain=8.314696123025e-01
SMIXI_c117_0_01 (mix_i_src_c117_0_01 mix_i_c117_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_01 (mix_q_src_c117_0_01 0 bpf_c117_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_0_01 (mix_q_src_c117_0_01 mix_q_c117_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_02 (mix_i_src_c117_0_02 0 bpf_c117_0 0) vcvs gain=5.555702330196e-01
SMIXI_c117_0_02 (mix_i_src_c117_0_02 mix_i_c117_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_02 (mix_q_src_c117_0_02 0 bpf_c117_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_0_02 (mix_q_src_c117_0_02 mix_q_c117_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_03 (mix_i_src_c117_0_03 0 bpf_c117_0 0) vcvs gain=1.950903220161e-01
SMIXI_c117_0_03 (mix_i_src_c117_0_03 mix_i_c117_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_03 (mix_q_src_c117_0_03 0 bpf_c117_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_0_03 (mix_q_src_c117_0_03 mix_q_c117_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_04 (mix_i_src_c117_0_04 0 bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_0_04 (mix_i_src_c117_0_04 mix_i_c117_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_04 (mix_q_src_c117_0_04 0 bpf_c117_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_0_04 (mix_q_src_c117_0_04 mix_q_c117_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_05 (mix_i_src_c117_0_05 0 bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_0_05 (mix_i_src_c117_0_05 mix_i_c117_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_05 (mix_q_src_c117_0_05 0 bpf_c117_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_0_05 (mix_q_src_c117_0_05 mix_q_c117_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_06 (mix_i_src_c117_0_06 0 bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_0_06 (mix_i_src_c117_0_06 mix_i_c117_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_06 (mix_q_src_c117_0_06 0 bpf_c117_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_0_06 (mix_q_src_c117_0_06 mix_q_c117_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_07 (mix_i_src_c117_0_07 0 bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_0_07 (mix_i_src_c117_0_07 mix_i_c117_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_07 (mix_q_src_c117_0_07 0 bpf_c117_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_0_07 (mix_q_src_c117_0_07 mix_q_c117_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_08 (mix_i_src_c117_0_08 0 bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_0_08 (mix_i_src_c117_0_08 mix_i_c117_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_08 (mix_q_src_c117_0_08 0 bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_0_08 (mix_q_src_c117_0_08 mix_q_c117_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_09 (mix_i_src_c117_0_09 0 bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_0_09 (mix_i_src_c117_0_09 mix_i_c117_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_09 (mix_q_src_c117_0_09 0 bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_0_09 (mix_q_src_c117_0_09 mix_q_c117_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_10 (mix_i_src_c117_0_10 0 bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_0_10 (mix_i_src_c117_0_10 mix_i_c117_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_10 (mix_q_src_c117_0_10 0 bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_0_10 (mix_q_src_c117_0_10 mix_q_c117_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_11 (mix_i_src_c117_0_11 0 bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_0_11 (mix_i_src_c117_0_11 mix_i_c117_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_11 (mix_q_src_c117_0_11 0 bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_0_11 (mix_q_src_c117_0_11 mix_q_c117_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_12 (mix_i_src_c117_0_12 0 bpf_c117_0 0) vcvs gain=1.950903220161e-01
SMIXI_c117_0_12 (mix_i_src_c117_0_12 mix_i_c117_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_12 (mix_q_src_c117_0_12 0 bpf_c117_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_0_12 (mix_q_src_c117_0_12 mix_q_c117_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_13 (mix_i_src_c117_0_13 0 bpf_c117_0 0) vcvs gain=5.555702330196e-01
SMIXI_c117_0_13 (mix_i_src_c117_0_13 mix_i_c117_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_13 (mix_q_src_c117_0_13 0 bpf_c117_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_0_13 (mix_q_src_c117_0_13 mix_q_c117_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_14 (mix_i_src_c117_0_14 0 bpf_c117_0 0) vcvs gain=8.314696123025e-01
SMIXI_c117_0_14 (mix_i_src_c117_0_14 mix_i_c117_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_14 (mix_q_src_c117_0_14 0 bpf_c117_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_0_14 (mix_q_src_c117_0_14 mix_q_c117_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_0_15 (mix_i_src_c117_0_15 0 bpf_c117_0 0) vcvs gain=9.807852804032e-01
SMIXI_c117_0_15 (mix_i_src_c117_0_15 mix_i_c117_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_0_15 (mix_q_src_c117_0_15 0 bpf_c117_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_0_15 (mix_q_src_c117_0_15 mix_q_c117_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c117_0 (mix_i_c117_0 0) resistor r=1G
RMIXQ_c117_0 (mix_q_c117_0 0) resistor r=1G
RINTI_c117_0 (mix_i_c117_0 Icar_c117_0) resistor r=1k
CINTI_c117_0 (Icar_c117_0 0) capacitor c=80p
RINTQ_c117_0 (mix_q_c117_0 Qcar_c117_0) resistor r=1k
CINTQ_c117_0 (Qcar_c117_0 0) capacitor c=80p

// bl117, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c117_1 (bl117 n_cbpf_c117_1) capacitor c=1.013211836423e-13
LBPF_c117_1 (n_cbpf_c117_1 bpf_c117_1) inductor l=1.000000000000e-06
RBPF_c117_1 (bpf_c117_1 0) resistor r=1.570796326795e+02
EMIXI_c117_1_00 (mix_i_src_c117_1_00 0 bpf_c117_1 0) vcvs gain=9.807852804032e-01
SMIXI_c117_1_00 (mix_i_src_c117_1_00 mix_i_c117_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_00 (mix_q_src_c117_1_00 0 bpf_c117_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_1_00 (mix_q_src_c117_1_00 mix_q_c117_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_01 (mix_i_src_c117_1_01 0 bpf_c117_1 0) vcvs gain=8.314696123025e-01
SMIXI_c117_1_01 (mix_i_src_c117_1_01 mix_i_c117_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_01 (mix_q_src_c117_1_01 0 bpf_c117_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_1_01 (mix_q_src_c117_1_01 mix_q_c117_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_02 (mix_i_src_c117_1_02 0 bpf_c117_1 0) vcvs gain=5.555702330196e-01
SMIXI_c117_1_02 (mix_i_src_c117_1_02 mix_i_c117_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_02 (mix_q_src_c117_1_02 0 bpf_c117_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_1_02 (mix_q_src_c117_1_02 mix_q_c117_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_03 (mix_i_src_c117_1_03 0 bpf_c117_1 0) vcvs gain=1.950903220161e-01
SMIXI_c117_1_03 (mix_i_src_c117_1_03 mix_i_c117_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_03 (mix_q_src_c117_1_03 0 bpf_c117_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_1_03 (mix_q_src_c117_1_03 mix_q_c117_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_04 (mix_i_src_c117_1_04 0 bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_1_04 (mix_i_src_c117_1_04 mix_i_c117_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_04 (mix_q_src_c117_1_04 0 bpf_c117_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_1_04 (mix_q_src_c117_1_04 mix_q_c117_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_05 (mix_i_src_c117_1_05 0 bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_1_05 (mix_i_src_c117_1_05 mix_i_c117_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_05 (mix_q_src_c117_1_05 0 bpf_c117_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_1_05 (mix_q_src_c117_1_05 mix_q_c117_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_06 (mix_i_src_c117_1_06 0 bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_1_06 (mix_i_src_c117_1_06 mix_i_c117_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_06 (mix_q_src_c117_1_06 0 bpf_c117_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_1_06 (mix_q_src_c117_1_06 mix_q_c117_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_07 (mix_i_src_c117_1_07 0 bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_1_07 (mix_i_src_c117_1_07 mix_i_c117_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_07 (mix_q_src_c117_1_07 0 bpf_c117_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_1_07 (mix_q_src_c117_1_07 mix_q_c117_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_08 (mix_i_src_c117_1_08 0 bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_1_08 (mix_i_src_c117_1_08 mix_i_c117_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_08 (mix_q_src_c117_1_08 0 bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_1_08 (mix_q_src_c117_1_08 mix_q_c117_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_09 (mix_i_src_c117_1_09 0 bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_1_09 (mix_i_src_c117_1_09 mix_i_c117_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_09 (mix_q_src_c117_1_09 0 bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_1_09 (mix_q_src_c117_1_09 mix_q_c117_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_10 (mix_i_src_c117_1_10 0 bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_1_10 (mix_i_src_c117_1_10 mix_i_c117_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_10 (mix_q_src_c117_1_10 0 bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_1_10 (mix_q_src_c117_1_10 mix_q_c117_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_11 (mix_i_src_c117_1_11 0 bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_1_11 (mix_i_src_c117_1_11 mix_i_c117_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_11 (mix_q_src_c117_1_11 0 bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_1_11 (mix_q_src_c117_1_11 mix_q_c117_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_12 (mix_i_src_c117_1_12 0 bpf_c117_1 0) vcvs gain=1.950903220161e-01
SMIXI_c117_1_12 (mix_i_src_c117_1_12 mix_i_c117_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_12 (mix_q_src_c117_1_12 0 bpf_c117_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_1_12 (mix_q_src_c117_1_12 mix_q_c117_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_13 (mix_i_src_c117_1_13 0 bpf_c117_1 0) vcvs gain=5.555702330196e-01
SMIXI_c117_1_13 (mix_i_src_c117_1_13 mix_i_c117_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_13 (mix_q_src_c117_1_13 0 bpf_c117_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_1_13 (mix_q_src_c117_1_13 mix_q_c117_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_14 (mix_i_src_c117_1_14 0 bpf_c117_1 0) vcvs gain=8.314696123025e-01
SMIXI_c117_1_14 (mix_i_src_c117_1_14 mix_i_c117_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_14 (mix_q_src_c117_1_14 0 bpf_c117_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_1_14 (mix_q_src_c117_1_14 mix_q_c117_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_1_15 (mix_i_src_c117_1_15 0 bpf_c117_1 0) vcvs gain=9.807852804032e-01
SMIXI_c117_1_15 (mix_i_src_c117_1_15 mix_i_c117_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_1_15 (mix_q_src_c117_1_15 0 bpf_c117_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_1_15 (mix_q_src_c117_1_15 mix_q_c117_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c117_1 (mix_i_c117_1 0) resistor r=1G
RMIXQ_c117_1 (mix_q_c117_1 0) resistor r=1G
RINTI_c117_1 (mix_i_c117_1 Icar_c117_1) resistor r=1k
CINTI_c117_1 (Icar_c117_1 0) capacitor c=80p
RINTQ_c117_1 (mix_q_c117_1 Qcar_c117_1) resistor r=1k
CINTQ_c117_1 (Qcar_c117_1 0) capacitor c=80p

// bl117, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c117_2 (bl117 n_cbpf_c117_2) capacitor c=4.503163717437e-14
LBPF_c117_2 (n_cbpf_c117_2 bpf_c117_2) inductor l=1.000000000000e-06
RBPF_c117_2 (bpf_c117_2 0) resistor r=2.356194490192e+02
EMIXI_c117_2_00 (mix_i_src_c117_2_00 0 bpf_c117_2 0) vcvs gain=9.807852804032e-01
SMIXI_c117_2_00 (mix_i_src_c117_2_00 mix_i_c117_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_00 (mix_q_src_c117_2_00 0 bpf_c117_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_2_00 (mix_q_src_c117_2_00 mix_q_c117_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_01 (mix_i_src_c117_2_01 0 bpf_c117_2 0) vcvs gain=8.314696123025e-01
SMIXI_c117_2_01 (mix_i_src_c117_2_01 mix_i_c117_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_01 (mix_q_src_c117_2_01 0 bpf_c117_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_2_01 (mix_q_src_c117_2_01 mix_q_c117_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_02 (mix_i_src_c117_2_02 0 bpf_c117_2 0) vcvs gain=5.555702330196e-01
SMIXI_c117_2_02 (mix_i_src_c117_2_02 mix_i_c117_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_02 (mix_q_src_c117_2_02 0 bpf_c117_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_2_02 (mix_q_src_c117_2_02 mix_q_c117_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_03 (mix_i_src_c117_2_03 0 bpf_c117_2 0) vcvs gain=1.950903220161e-01
SMIXI_c117_2_03 (mix_i_src_c117_2_03 mix_i_c117_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_03 (mix_q_src_c117_2_03 0 bpf_c117_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_2_03 (mix_q_src_c117_2_03 mix_q_c117_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_04 (mix_i_src_c117_2_04 0 bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_2_04 (mix_i_src_c117_2_04 mix_i_c117_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_04 (mix_q_src_c117_2_04 0 bpf_c117_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_2_04 (mix_q_src_c117_2_04 mix_q_c117_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_05 (mix_i_src_c117_2_05 0 bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_2_05 (mix_i_src_c117_2_05 mix_i_c117_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_05 (mix_q_src_c117_2_05 0 bpf_c117_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_2_05 (mix_q_src_c117_2_05 mix_q_c117_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_06 (mix_i_src_c117_2_06 0 bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_2_06 (mix_i_src_c117_2_06 mix_i_c117_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_06 (mix_q_src_c117_2_06 0 bpf_c117_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_2_06 (mix_q_src_c117_2_06 mix_q_c117_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_07 (mix_i_src_c117_2_07 0 bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_2_07 (mix_i_src_c117_2_07 mix_i_c117_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_07 (mix_q_src_c117_2_07 0 bpf_c117_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_2_07 (mix_q_src_c117_2_07 mix_q_c117_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_08 (mix_i_src_c117_2_08 0 bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_2_08 (mix_i_src_c117_2_08 mix_i_c117_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_08 (mix_q_src_c117_2_08 0 bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_2_08 (mix_q_src_c117_2_08 mix_q_c117_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_09 (mix_i_src_c117_2_09 0 bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_2_09 (mix_i_src_c117_2_09 mix_i_c117_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_09 (mix_q_src_c117_2_09 0 bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_2_09 (mix_q_src_c117_2_09 mix_q_c117_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_10 (mix_i_src_c117_2_10 0 bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_2_10 (mix_i_src_c117_2_10 mix_i_c117_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_10 (mix_q_src_c117_2_10 0 bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_2_10 (mix_q_src_c117_2_10 mix_q_c117_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_11 (mix_i_src_c117_2_11 0 bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_2_11 (mix_i_src_c117_2_11 mix_i_c117_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_11 (mix_q_src_c117_2_11 0 bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_2_11 (mix_q_src_c117_2_11 mix_q_c117_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_12 (mix_i_src_c117_2_12 0 bpf_c117_2 0) vcvs gain=1.950903220161e-01
SMIXI_c117_2_12 (mix_i_src_c117_2_12 mix_i_c117_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_12 (mix_q_src_c117_2_12 0 bpf_c117_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_2_12 (mix_q_src_c117_2_12 mix_q_c117_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_13 (mix_i_src_c117_2_13 0 bpf_c117_2 0) vcvs gain=5.555702330196e-01
SMIXI_c117_2_13 (mix_i_src_c117_2_13 mix_i_c117_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_13 (mix_q_src_c117_2_13 0 bpf_c117_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_2_13 (mix_q_src_c117_2_13 mix_q_c117_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_14 (mix_i_src_c117_2_14 0 bpf_c117_2 0) vcvs gain=8.314696123025e-01
SMIXI_c117_2_14 (mix_i_src_c117_2_14 mix_i_c117_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_14 (mix_q_src_c117_2_14 0 bpf_c117_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_2_14 (mix_q_src_c117_2_14 mix_q_c117_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_2_15 (mix_i_src_c117_2_15 0 bpf_c117_2 0) vcvs gain=9.807852804032e-01
SMIXI_c117_2_15 (mix_i_src_c117_2_15 mix_i_c117_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_2_15 (mix_q_src_c117_2_15 0 bpf_c117_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_2_15 (mix_q_src_c117_2_15 mix_q_c117_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c117_2 (mix_i_c117_2 0) resistor r=1G
RMIXQ_c117_2 (mix_q_c117_2 0) resistor r=1G
RINTI_c117_2 (mix_i_c117_2 Icar_c117_2) resistor r=1k
CINTI_c117_2 (Icar_c117_2 0) capacitor c=80p
RINTQ_c117_2 (mix_q_c117_2 Qcar_c117_2) resistor r=1k
CINTQ_c117_2 (Qcar_c117_2 0) capacitor c=80p

// bl117, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c117_3 (bl117 n_cbpf_c117_3) capacitor c=2.533029591058e-14
LBPF_c117_3 (n_cbpf_c117_3 bpf_c117_3) inductor l=1.000000000000e-06
RBPF_c117_3 (bpf_c117_3 0) resistor r=3.141592653590e+02
EMIXI_c117_3_00 (mix_i_src_c117_3_00 0 bpf_c117_3 0) vcvs gain=9.807852804032e-01
SMIXI_c117_3_00 (mix_i_src_c117_3_00 mix_i_c117_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_00 (mix_q_src_c117_3_00 0 bpf_c117_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_3_00 (mix_q_src_c117_3_00 mix_q_c117_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_01 (mix_i_src_c117_3_01 0 bpf_c117_3 0) vcvs gain=8.314696123025e-01
SMIXI_c117_3_01 (mix_i_src_c117_3_01 mix_i_c117_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_01 (mix_q_src_c117_3_01 0 bpf_c117_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_3_01 (mix_q_src_c117_3_01 mix_q_c117_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_02 (mix_i_src_c117_3_02 0 bpf_c117_3 0) vcvs gain=5.555702330196e-01
SMIXI_c117_3_02 (mix_i_src_c117_3_02 mix_i_c117_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_02 (mix_q_src_c117_3_02 0 bpf_c117_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_3_02 (mix_q_src_c117_3_02 mix_q_c117_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_03 (mix_i_src_c117_3_03 0 bpf_c117_3 0) vcvs gain=1.950903220161e-01
SMIXI_c117_3_03 (mix_i_src_c117_3_03 mix_i_c117_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_03 (mix_q_src_c117_3_03 0 bpf_c117_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_3_03 (mix_q_src_c117_3_03 mix_q_c117_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_04 (mix_i_src_c117_3_04 0 bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_3_04 (mix_i_src_c117_3_04 mix_i_c117_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_04 (mix_q_src_c117_3_04 0 bpf_c117_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c117_3_04 (mix_q_src_c117_3_04 mix_q_c117_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_05 (mix_i_src_c117_3_05 0 bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_3_05 (mix_i_src_c117_3_05 mix_i_c117_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_05 (mix_q_src_c117_3_05 0 bpf_c117_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c117_3_05 (mix_q_src_c117_3_05 mix_q_c117_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_06 (mix_i_src_c117_3_06 0 bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_3_06 (mix_i_src_c117_3_06 mix_i_c117_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_06 (mix_q_src_c117_3_06 0 bpf_c117_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c117_3_06 (mix_q_src_c117_3_06 mix_q_c117_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_07 (mix_i_src_c117_3_07 0 bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_3_07 (mix_i_src_c117_3_07 mix_i_c117_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_07 (mix_q_src_c117_3_07 0 bpf_c117_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c117_3_07 (mix_q_src_c117_3_07 mix_q_c117_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_08 (mix_i_src_c117_3_08 0 bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c117_3_08 (mix_i_src_c117_3_08 mix_i_c117_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_08 (mix_q_src_c117_3_08 0 bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_3_08 (mix_q_src_c117_3_08 mix_q_c117_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_09 (mix_i_src_c117_3_09 0 bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c117_3_09 (mix_i_src_c117_3_09 mix_i_c117_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_09 (mix_q_src_c117_3_09 0 bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_3_09 (mix_q_src_c117_3_09 mix_q_c117_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_10 (mix_i_src_c117_3_10 0 bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c117_3_10 (mix_i_src_c117_3_10 mix_i_c117_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_10 (mix_q_src_c117_3_10 0 bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_3_10 (mix_q_src_c117_3_10 mix_q_c117_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_11 (mix_i_src_c117_3_11 0 bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c117_3_11 (mix_i_src_c117_3_11 mix_i_c117_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_11 (mix_q_src_c117_3_11 0 bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_3_11 (mix_q_src_c117_3_11 mix_q_c117_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_12 (mix_i_src_c117_3_12 0 bpf_c117_3 0) vcvs gain=1.950903220161e-01
SMIXI_c117_3_12 (mix_i_src_c117_3_12 mix_i_c117_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_12 (mix_q_src_c117_3_12 0 bpf_c117_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c117_3_12 (mix_q_src_c117_3_12 mix_q_c117_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_13 (mix_i_src_c117_3_13 0 bpf_c117_3 0) vcvs gain=5.555702330196e-01
SMIXI_c117_3_13 (mix_i_src_c117_3_13 mix_i_c117_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_13 (mix_q_src_c117_3_13 0 bpf_c117_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c117_3_13 (mix_q_src_c117_3_13 mix_q_c117_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_14 (mix_i_src_c117_3_14 0 bpf_c117_3 0) vcvs gain=8.314696123025e-01
SMIXI_c117_3_14 (mix_i_src_c117_3_14 mix_i_c117_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_14 (mix_q_src_c117_3_14 0 bpf_c117_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c117_3_14 (mix_q_src_c117_3_14 mix_q_c117_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c117_3_15 (mix_i_src_c117_3_15 0 bpf_c117_3 0) vcvs gain=9.807852804032e-01
SMIXI_c117_3_15 (mix_i_src_c117_3_15 mix_i_c117_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c117_3_15 (mix_q_src_c117_3_15 0 bpf_c117_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c117_3_15 (mix_q_src_c117_3_15 mix_q_c117_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c117_3 (mix_i_c117_3 0) resistor r=1G
RMIXQ_c117_3 (mix_q_c117_3 0) resistor r=1G
RINTI_c117_3 (mix_i_c117_3 Icar_c117_3) resistor r=1k
CINTI_c117_3 (Icar_c117_3 0) capacitor c=80p
RINTQ_c117_3 (mix_q_c117_3 Qcar_c117_3) resistor r=1k
CINTQ_c117_3 (Qcar_c117_3 0) capacitor c=80p

// bl118, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c118_0 (bl118 n_cbpf_c118_0) capacitor c=4.052847345694e-13
LBPF_c118_0 (n_cbpf_c118_0 bpf_c118_0) inductor l=1.000000000000e-06
RBPF_c118_0 (bpf_c118_0 0) resistor r=7.853981633974e+01
EMIXI_c118_0_00 (mix_i_src_c118_0_00 0 bpf_c118_0 0) vcvs gain=9.807852804032e-01
SMIXI_c118_0_00 (mix_i_src_c118_0_00 mix_i_c118_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_00 (mix_q_src_c118_0_00 0 bpf_c118_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_0_00 (mix_q_src_c118_0_00 mix_q_c118_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_01 (mix_i_src_c118_0_01 0 bpf_c118_0 0) vcvs gain=8.314696123025e-01
SMIXI_c118_0_01 (mix_i_src_c118_0_01 mix_i_c118_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_01 (mix_q_src_c118_0_01 0 bpf_c118_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_0_01 (mix_q_src_c118_0_01 mix_q_c118_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_02 (mix_i_src_c118_0_02 0 bpf_c118_0 0) vcvs gain=5.555702330196e-01
SMIXI_c118_0_02 (mix_i_src_c118_0_02 mix_i_c118_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_02 (mix_q_src_c118_0_02 0 bpf_c118_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_0_02 (mix_q_src_c118_0_02 mix_q_c118_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_03 (mix_i_src_c118_0_03 0 bpf_c118_0 0) vcvs gain=1.950903220161e-01
SMIXI_c118_0_03 (mix_i_src_c118_0_03 mix_i_c118_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_03 (mix_q_src_c118_0_03 0 bpf_c118_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_0_03 (mix_q_src_c118_0_03 mix_q_c118_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_04 (mix_i_src_c118_0_04 0 bpf_c118_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_0_04 (mix_i_src_c118_0_04 mix_i_c118_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_04 (mix_q_src_c118_0_04 0 bpf_c118_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_0_04 (mix_q_src_c118_0_04 mix_q_c118_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_05 (mix_i_src_c118_0_05 0 bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_0_05 (mix_i_src_c118_0_05 mix_i_c118_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_05 (mix_q_src_c118_0_05 0 bpf_c118_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_0_05 (mix_q_src_c118_0_05 mix_q_c118_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_06 (mix_i_src_c118_0_06 0 bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_0_06 (mix_i_src_c118_0_06 mix_i_c118_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_06 (mix_q_src_c118_0_06 0 bpf_c118_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_0_06 (mix_q_src_c118_0_06 mix_q_c118_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_07 (mix_i_src_c118_0_07 0 bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_0_07 (mix_i_src_c118_0_07 mix_i_c118_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_07 (mix_q_src_c118_0_07 0 bpf_c118_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_0_07 (mix_q_src_c118_0_07 mix_q_c118_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_08 (mix_i_src_c118_0_08 0 bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_0_08 (mix_i_src_c118_0_08 mix_i_c118_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_08 (mix_q_src_c118_0_08 0 bpf_c118_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_0_08 (mix_q_src_c118_0_08 mix_q_c118_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_09 (mix_i_src_c118_0_09 0 bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_0_09 (mix_i_src_c118_0_09 mix_i_c118_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_09 (mix_q_src_c118_0_09 0 bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_0_09 (mix_q_src_c118_0_09 mix_q_c118_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_10 (mix_i_src_c118_0_10 0 bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_0_10 (mix_i_src_c118_0_10 mix_i_c118_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_10 (mix_q_src_c118_0_10 0 bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_0_10 (mix_q_src_c118_0_10 mix_q_c118_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_11 (mix_i_src_c118_0_11 0 bpf_c118_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_0_11 (mix_i_src_c118_0_11 mix_i_c118_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_11 (mix_q_src_c118_0_11 0 bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_0_11 (mix_q_src_c118_0_11 mix_q_c118_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_12 (mix_i_src_c118_0_12 0 bpf_c118_0 0) vcvs gain=1.950903220161e-01
SMIXI_c118_0_12 (mix_i_src_c118_0_12 mix_i_c118_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_12 (mix_q_src_c118_0_12 0 bpf_c118_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_0_12 (mix_q_src_c118_0_12 mix_q_c118_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_13 (mix_i_src_c118_0_13 0 bpf_c118_0 0) vcvs gain=5.555702330196e-01
SMIXI_c118_0_13 (mix_i_src_c118_0_13 mix_i_c118_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_13 (mix_q_src_c118_0_13 0 bpf_c118_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_0_13 (mix_q_src_c118_0_13 mix_q_c118_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_14 (mix_i_src_c118_0_14 0 bpf_c118_0 0) vcvs gain=8.314696123025e-01
SMIXI_c118_0_14 (mix_i_src_c118_0_14 mix_i_c118_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_14 (mix_q_src_c118_0_14 0 bpf_c118_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_0_14 (mix_q_src_c118_0_14 mix_q_c118_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_0_15 (mix_i_src_c118_0_15 0 bpf_c118_0 0) vcvs gain=9.807852804032e-01
SMIXI_c118_0_15 (mix_i_src_c118_0_15 mix_i_c118_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_0_15 (mix_q_src_c118_0_15 0 bpf_c118_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_0_15 (mix_q_src_c118_0_15 mix_q_c118_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c118_0 (mix_i_c118_0 0) resistor r=1G
RMIXQ_c118_0 (mix_q_c118_0 0) resistor r=1G
RINTI_c118_0 (mix_i_c118_0 Icar_c118_0) resistor r=1k
CINTI_c118_0 (Icar_c118_0 0) capacitor c=80p
RINTQ_c118_0 (mix_q_c118_0 Qcar_c118_0) resistor r=1k
CINTQ_c118_0 (Qcar_c118_0 0) capacitor c=80p

// bl118, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c118_1 (bl118 n_cbpf_c118_1) capacitor c=1.013211836423e-13
LBPF_c118_1 (n_cbpf_c118_1 bpf_c118_1) inductor l=1.000000000000e-06
RBPF_c118_1 (bpf_c118_1 0) resistor r=1.570796326795e+02
EMIXI_c118_1_00 (mix_i_src_c118_1_00 0 bpf_c118_1 0) vcvs gain=9.807852804032e-01
SMIXI_c118_1_00 (mix_i_src_c118_1_00 mix_i_c118_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_00 (mix_q_src_c118_1_00 0 bpf_c118_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_1_00 (mix_q_src_c118_1_00 mix_q_c118_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_01 (mix_i_src_c118_1_01 0 bpf_c118_1 0) vcvs gain=8.314696123025e-01
SMIXI_c118_1_01 (mix_i_src_c118_1_01 mix_i_c118_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_01 (mix_q_src_c118_1_01 0 bpf_c118_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_1_01 (mix_q_src_c118_1_01 mix_q_c118_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_02 (mix_i_src_c118_1_02 0 bpf_c118_1 0) vcvs gain=5.555702330196e-01
SMIXI_c118_1_02 (mix_i_src_c118_1_02 mix_i_c118_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_02 (mix_q_src_c118_1_02 0 bpf_c118_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_1_02 (mix_q_src_c118_1_02 mix_q_c118_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_03 (mix_i_src_c118_1_03 0 bpf_c118_1 0) vcvs gain=1.950903220161e-01
SMIXI_c118_1_03 (mix_i_src_c118_1_03 mix_i_c118_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_03 (mix_q_src_c118_1_03 0 bpf_c118_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_1_03 (mix_q_src_c118_1_03 mix_q_c118_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_04 (mix_i_src_c118_1_04 0 bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_1_04 (mix_i_src_c118_1_04 mix_i_c118_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_04 (mix_q_src_c118_1_04 0 bpf_c118_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_1_04 (mix_q_src_c118_1_04 mix_q_c118_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_05 (mix_i_src_c118_1_05 0 bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_1_05 (mix_i_src_c118_1_05 mix_i_c118_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_05 (mix_q_src_c118_1_05 0 bpf_c118_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_1_05 (mix_q_src_c118_1_05 mix_q_c118_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_06 (mix_i_src_c118_1_06 0 bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_1_06 (mix_i_src_c118_1_06 mix_i_c118_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_06 (mix_q_src_c118_1_06 0 bpf_c118_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_1_06 (mix_q_src_c118_1_06 mix_q_c118_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_07 (mix_i_src_c118_1_07 0 bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_1_07 (mix_i_src_c118_1_07 mix_i_c118_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_07 (mix_q_src_c118_1_07 0 bpf_c118_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_1_07 (mix_q_src_c118_1_07 mix_q_c118_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_08 (mix_i_src_c118_1_08 0 bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_1_08 (mix_i_src_c118_1_08 mix_i_c118_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_08 (mix_q_src_c118_1_08 0 bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_1_08 (mix_q_src_c118_1_08 mix_q_c118_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_09 (mix_i_src_c118_1_09 0 bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_1_09 (mix_i_src_c118_1_09 mix_i_c118_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_09 (mix_q_src_c118_1_09 0 bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_1_09 (mix_q_src_c118_1_09 mix_q_c118_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_10 (mix_i_src_c118_1_10 0 bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_1_10 (mix_i_src_c118_1_10 mix_i_c118_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_10 (mix_q_src_c118_1_10 0 bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_1_10 (mix_q_src_c118_1_10 mix_q_c118_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_11 (mix_i_src_c118_1_11 0 bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_1_11 (mix_i_src_c118_1_11 mix_i_c118_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_11 (mix_q_src_c118_1_11 0 bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_1_11 (mix_q_src_c118_1_11 mix_q_c118_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_12 (mix_i_src_c118_1_12 0 bpf_c118_1 0) vcvs gain=1.950903220161e-01
SMIXI_c118_1_12 (mix_i_src_c118_1_12 mix_i_c118_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_12 (mix_q_src_c118_1_12 0 bpf_c118_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_1_12 (mix_q_src_c118_1_12 mix_q_c118_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_13 (mix_i_src_c118_1_13 0 bpf_c118_1 0) vcvs gain=5.555702330196e-01
SMIXI_c118_1_13 (mix_i_src_c118_1_13 mix_i_c118_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_13 (mix_q_src_c118_1_13 0 bpf_c118_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_1_13 (mix_q_src_c118_1_13 mix_q_c118_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_14 (mix_i_src_c118_1_14 0 bpf_c118_1 0) vcvs gain=8.314696123025e-01
SMIXI_c118_1_14 (mix_i_src_c118_1_14 mix_i_c118_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_14 (mix_q_src_c118_1_14 0 bpf_c118_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_1_14 (mix_q_src_c118_1_14 mix_q_c118_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_1_15 (mix_i_src_c118_1_15 0 bpf_c118_1 0) vcvs gain=9.807852804032e-01
SMIXI_c118_1_15 (mix_i_src_c118_1_15 mix_i_c118_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_1_15 (mix_q_src_c118_1_15 0 bpf_c118_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_1_15 (mix_q_src_c118_1_15 mix_q_c118_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c118_1 (mix_i_c118_1 0) resistor r=1G
RMIXQ_c118_1 (mix_q_c118_1 0) resistor r=1G
RINTI_c118_1 (mix_i_c118_1 Icar_c118_1) resistor r=1k
CINTI_c118_1 (Icar_c118_1 0) capacitor c=80p
RINTQ_c118_1 (mix_q_c118_1 Qcar_c118_1) resistor r=1k
CINTQ_c118_1 (Qcar_c118_1 0) capacitor c=80p

// bl118, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c118_2 (bl118 n_cbpf_c118_2) capacitor c=4.503163717437e-14
LBPF_c118_2 (n_cbpf_c118_2 bpf_c118_2) inductor l=1.000000000000e-06
RBPF_c118_2 (bpf_c118_2 0) resistor r=2.356194490192e+02
EMIXI_c118_2_00 (mix_i_src_c118_2_00 0 bpf_c118_2 0) vcvs gain=9.807852804032e-01
SMIXI_c118_2_00 (mix_i_src_c118_2_00 mix_i_c118_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_00 (mix_q_src_c118_2_00 0 bpf_c118_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_2_00 (mix_q_src_c118_2_00 mix_q_c118_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_01 (mix_i_src_c118_2_01 0 bpf_c118_2 0) vcvs gain=8.314696123025e-01
SMIXI_c118_2_01 (mix_i_src_c118_2_01 mix_i_c118_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_01 (mix_q_src_c118_2_01 0 bpf_c118_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_2_01 (mix_q_src_c118_2_01 mix_q_c118_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_02 (mix_i_src_c118_2_02 0 bpf_c118_2 0) vcvs gain=5.555702330196e-01
SMIXI_c118_2_02 (mix_i_src_c118_2_02 mix_i_c118_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_02 (mix_q_src_c118_2_02 0 bpf_c118_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_2_02 (mix_q_src_c118_2_02 mix_q_c118_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_03 (mix_i_src_c118_2_03 0 bpf_c118_2 0) vcvs gain=1.950903220161e-01
SMIXI_c118_2_03 (mix_i_src_c118_2_03 mix_i_c118_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_03 (mix_q_src_c118_2_03 0 bpf_c118_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_2_03 (mix_q_src_c118_2_03 mix_q_c118_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_04 (mix_i_src_c118_2_04 0 bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_2_04 (mix_i_src_c118_2_04 mix_i_c118_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_04 (mix_q_src_c118_2_04 0 bpf_c118_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_2_04 (mix_q_src_c118_2_04 mix_q_c118_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_05 (mix_i_src_c118_2_05 0 bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_2_05 (mix_i_src_c118_2_05 mix_i_c118_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_05 (mix_q_src_c118_2_05 0 bpf_c118_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_2_05 (mix_q_src_c118_2_05 mix_q_c118_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_06 (mix_i_src_c118_2_06 0 bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_2_06 (mix_i_src_c118_2_06 mix_i_c118_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_06 (mix_q_src_c118_2_06 0 bpf_c118_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_2_06 (mix_q_src_c118_2_06 mix_q_c118_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_07 (mix_i_src_c118_2_07 0 bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_2_07 (mix_i_src_c118_2_07 mix_i_c118_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_07 (mix_q_src_c118_2_07 0 bpf_c118_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_2_07 (mix_q_src_c118_2_07 mix_q_c118_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_08 (mix_i_src_c118_2_08 0 bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_2_08 (mix_i_src_c118_2_08 mix_i_c118_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_08 (mix_q_src_c118_2_08 0 bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_2_08 (mix_q_src_c118_2_08 mix_q_c118_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_09 (mix_i_src_c118_2_09 0 bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_2_09 (mix_i_src_c118_2_09 mix_i_c118_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_09 (mix_q_src_c118_2_09 0 bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_2_09 (mix_q_src_c118_2_09 mix_q_c118_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_10 (mix_i_src_c118_2_10 0 bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_2_10 (mix_i_src_c118_2_10 mix_i_c118_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_10 (mix_q_src_c118_2_10 0 bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_2_10 (mix_q_src_c118_2_10 mix_q_c118_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_11 (mix_i_src_c118_2_11 0 bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_2_11 (mix_i_src_c118_2_11 mix_i_c118_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_11 (mix_q_src_c118_2_11 0 bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_2_11 (mix_q_src_c118_2_11 mix_q_c118_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_12 (mix_i_src_c118_2_12 0 bpf_c118_2 0) vcvs gain=1.950903220161e-01
SMIXI_c118_2_12 (mix_i_src_c118_2_12 mix_i_c118_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_12 (mix_q_src_c118_2_12 0 bpf_c118_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_2_12 (mix_q_src_c118_2_12 mix_q_c118_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_13 (mix_i_src_c118_2_13 0 bpf_c118_2 0) vcvs gain=5.555702330196e-01
SMIXI_c118_2_13 (mix_i_src_c118_2_13 mix_i_c118_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_13 (mix_q_src_c118_2_13 0 bpf_c118_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_2_13 (mix_q_src_c118_2_13 mix_q_c118_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_14 (mix_i_src_c118_2_14 0 bpf_c118_2 0) vcvs gain=8.314696123025e-01
SMIXI_c118_2_14 (mix_i_src_c118_2_14 mix_i_c118_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_14 (mix_q_src_c118_2_14 0 bpf_c118_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_2_14 (mix_q_src_c118_2_14 mix_q_c118_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_2_15 (mix_i_src_c118_2_15 0 bpf_c118_2 0) vcvs gain=9.807852804032e-01
SMIXI_c118_2_15 (mix_i_src_c118_2_15 mix_i_c118_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_2_15 (mix_q_src_c118_2_15 0 bpf_c118_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_2_15 (mix_q_src_c118_2_15 mix_q_c118_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c118_2 (mix_i_c118_2 0) resistor r=1G
RMIXQ_c118_2 (mix_q_c118_2 0) resistor r=1G
RINTI_c118_2 (mix_i_c118_2 Icar_c118_2) resistor r=1k
CINTI_c118_2 (Icar_c118_2 0) capacitor c=80p
RINTQ_c118_2 (mix_q_c118_2 Qcar_c118_2) resistor r=1k
CINTQ_c118_2 (Qcar_c118_2 0) capacitor c=80p

// bl118, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c118_3 (bl118 n_cbpf_c118_3) capacitor c=2.533029591058e-14
LBPF_c118_3 (n_cbpf_c118_3 bpf_c118_3) inductor l=1.000000000000e-06
RBPF_c118_3 (bpf_c118_3 0) resistor r=3.141592653590e+02
EMIXI_c118_3_00 (mix_i_src_c118_3_00 0 bpf_c118_3 0) vcvs gain=9.807852804032e-01
SMIXI_c118_3_00 (mix_i_src_c118_3_00 mix_i_c118_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_00 (mix_q_src_c118_3_00 0 bpf_c118_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_3_00 (mix_q_src_c118_3_00 mix_q_c118_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_01 (mix_i_src_c118_3_01 0 bpf_c118_3 0) vcvs gain=8.314696123025e-01
SMIXI_c118_3_01 (mix_i_src_c118_3_01 mix_i_c118_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_01 (mix_q_src_c118_3_01 0 bpf_c118_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_3_01 (mix_q_src_c118_3_01 mix_q_c118_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_02 (mix_i_src_c118_3_02 0 bpf_c118_3 0) vcvs gain=5.555702330196e-01
SMIXI_c118_3_02 (mix_i_src_c118_3_02 mix_i_c118_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_02 (mix_q_src_c118_3_02 0 bpf_c118_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_3_02 (mix_q_src_c118_3_02 mix_q_c118_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_03 (mix_i_src_c118_3_03 0 bpf_c118_3 0) vcvs gain=1.950903220161e-01
SMIXI_c118_3_03 (mix_i_src_c118_3_03 mix_i_c118_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_03 (mix_q_src_c118_3_03 0 bpf_c118_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_3_03 (mix_q_src_c118_3_03 mix_q_c118_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_04 (mix_i_src_c118_3_04 0 bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_3_04 (mix_i_src_c118_3_04 mix_i_c118_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_04 (mix_q_src_c118_3_04 0 bpf_c118_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c118_3_04 (mix_q_src_c118_3_04 mix_q_c118_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_05 (mix_i_src_c118_3_05 0 bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_3_05 (mix_i_src_c118_3_05 mix_i_c118_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_05 (mix_q_src_c118_3_05 0 bpf_c118_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c118_3_05 (mix_q_src_c118_3_05 mix_q_c118_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_06 (mix_i_src_c118_3_06 0 bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_3_06 (mix_i_src_c118_3_06 mix_i_c118_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_06 (mix_q_src_c118_3_06 0 bpf_c118_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c118_3_06 (mix_q_src_c118_3_06 mix_q_c118_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_07 (mix_i_src_c118_3_07 0 bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_3_07 (mix_i_src_c118_3_07 mix_i_c118_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_07 (mix_q_src_c118_3_07 0 bpf_c118_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c118_3_07 (mix_q_src_c118_3_07 mix_q_c118_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_08 (mix_i_src_c118_3_08 0 bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c118_3_08 (mix_i_src_c118_3_08 mix_i_c118_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_08 (mix_q_src_c118_3_08 0 bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_3_08 (mix_q_src_c118_3_08 mix_q_c118_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_09 (mix_i_src_c118_3_09 0 bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c118_3_09 (mix_i_src_c118_3_09 mix_i_c118_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_09 (mix_q_src_c118_3_09 0 bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_3_09 (mix_q_src_c118_3_09 mix_q_c118_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_10 (mix_i_src_c118_3_10 0 bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c118_3_10 (mix_i_src_c118_3_10 mix_i_c118_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_10 (mix_q_src_c118_3_10 0 bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_3_10 (mix_q_src_c118_3_10 mix_q_c118_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_11 (mix_i_src_c118_3_11 0 bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c118_3_11 (mix_i_src_c118_3_11 mix_i_c118_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_11 (mix_q_src_c118_3_11 0 bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_3_11 (mix_q_src_c118_3_11 mix_q_c118_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_12 (mix_i_src_c118_3_12 0 bpf_c118_3 0) vcvs gain=1.950903220161e-01
SMIXI_c118_3_12 (mix_i_src_c118_3_12 mix_i_c118_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_12 (mix_q_src_c118_3_12 0 bpf_c118_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c118_3_12 (mix_q_src_c118_3_12 mix_q_c118_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_13 (mix_i_src_c118_3_13 0 bpf_c118_3 0) vcvs gain=5.555702330196e-01
SMIXI_c118_3_13 (mix_i_src_c118_3_13 mix_i_c118_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_13 (mix_q_src_c118_3_13 0 bpf_c118_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c118_3_13 (mix_q_src_c118_3_13 mix_q_c118_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_14 (mix_i_src_c118_3_14 0 bpf_c118_3 0) vcvs gain=8.314696123025e-01
SMIXI_c118_3_14 (mix_i_src_c118_3_14 mix_i_c118_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_14 (mix_q_src_c118_3_14 0 bpf_c118_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c118_3_14 (mix_q_src_c118_3_14 mix_q_c118_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c118_3_15 (mix_i_src_c118_3_15 0 bpf_c118_3 0) vcvs gain=9.807852804032e-01
SMIXI_c118_3_15 (mix_i_src_c118_3_15 mix_i_c118_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c118_3_15 (mix_q_src_c118_3_15 0 bpf_c118_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c118_3_15 (mix_q_src_c118_3_15 mix_q_c118_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c118_3 (mix_i_c118_3 0) resistor r=1G
RMIXQ_c118_3 (mix_q_c118_3 0) resistor r=1G
RINTI_c118_3 (mix_i_c118_3 Icar_c118_3) resistor r=1k
CINTI_c118_3 (Icar_c118_3 0) capacitor c=80p
RINTQ_c118_3 (mix_q_c118_3 Qcar_c118_3) resistor r=1k
CINTQ_c118_3 (Qcar_c118_3 0) capacitor c=80p

// bl119, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c119_0 (bl119 n_cbpf_c119_0) capacitor c=4.052847345694e-13
LBPF_c119_0 (n_cbpf_c119_0 bpf_c119_0) inductor l=1.000000000000e-06
RBPF_c119_0 (bpf_c119_0 0) resistor r=7.853981633974e+01
EMIXI_c119_0_00 (mix_i_src_c119_0_00 0 bpf_c119_0 0) vcvs gain=9.807852804032e-01
SMIXI_c119_0_00 (mix_i_src_c119_0_00 mix_i_c119_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_00 (mix_q_src_c119_0_00 0 bpf_c119_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_0_00 (mix_q_src_c119_0_00 mix_q_c119_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_01 (mix_i_src_c119_0_01 0 bpf_c119_0 0) vcvs gain=8.314696123025e-01
SMIXI_c119_0_01 (mix_i_src_c119_0_01 mix_i_c119_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_01 (mix_q_src_c119_0_01 0 bpf_c119_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_0_01 (mix_q_src_c119_0_01 mix_q_c119_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_02 (mix_i_src_c119_0_02 0 bpf_c119_0 0) vcvs gain=5.555702330196e-01
SMIXI_c119_0_02 (mix_i_src_c119_0_02 mix_i_c119_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_02 (mix_q_src_c119_0_02 0 bpf_c119_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_0_02 (mix_q_src_c119_0_02 mix_q_c119_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_03 (mix_i_src_c119_0_03 0 bpf_c119_0 0) vcvs gain=1.950903220161e-01
SMIXI_c119_0_03 (mix_i_src_c119_0_03 mix_i_c119_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_03 (mix_q_src_c119_0_03 0 bpf_c119_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_0_03 (mix_q_src_c119_0_03 mix_q_c119_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_04 (mix_i_src_c119_0_04 0 bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_0_04 (mix_i_src_c119_0_04 mix_i_c119_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_04 (mix_q_src_c119_0_04 0 bpf_c119_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_0_04 (mix_q_src_c119_0_04 mix_q_c119_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_05 (mix_i_src_c119_0_05 0 bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_0_05 (mix_i_src_c119_0_05 mix_i_c119_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_05 (mix_q_src_c119_0_05 0 bpf_c119_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_0_05 (mix_q_src_c119_0_05 mix_q_c119_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_06 (mix_i_src_c119_0_06 0 bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_0_06 (mix_i_src_c119_0_06 mix_i_c119_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_06 (mix_q_src_c119_0_06 0 bpf_c119_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_0_06 (mix_q_src_c119_0_06 mix_q_c119_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_07 (mix_i_src_c119_0_07 0 bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_0_07 (mix_i_src_c119_0_07 mix_i_c119_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_07 (mix_q_src_c119_0_07 0 bpf_c119_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_0_07 (mix_q_src_c119_0_07 mix_q_c119_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_08 (mix_i_src_c119_0_08 0 bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_0_08 (mix_i_src_c119_0_08 mix_i_c119_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_08 (mix_q_src_c119_0_08 0 bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_0_08 (mix_q_src_c119_0_08 mix_q_c119_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_09 (mix_i_src_c119_0_09 0 bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_0_09 (mix_i_src_c119_0_09 mix_i_c119_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_09 (mix_q_src_c119_0_09 0 bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_0_09 (mix_q_src_c119_0_09 mix_q_c119_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_10 (mix_i_src_c119_0_10 0 bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_0_10 (mix_i_src_c119_0_10 mix_i_c119_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_10 (mix_q_src_c119_0_10 0 bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_0_10 (mix_q_src_c119_0_10 mix_q_c119_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_11 (mix_i_src_c119_0_11 0 bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_0_11 (mix_i_src_c119_0_11 mix_i_c119_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_11 (mix_q_src_c119_0_11 0 bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_0_11 (mix_q_src_c119_0_11 mix_q_c119_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_12 (mix_i_src_c119_0_12 0 bpf_c119_0 0) vcvs gain=1.950903220161e-01
SMIXI_c119_0_12 (mix_i_src_c119_0_12 mix_i_c119_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_12 (mix_q_src_c119_0_12 0 bpf_c119_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_0_12 (mix_q_src_c119_0_12 mix_q_c119_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_13 (mix_i_src_c119_0_13 0 bpf_c119_0 0) vcvs gain=5.555702330196e-01
SMIXI_c119_0_13 (mix_i_src_c119_0_13 mix_i_c119_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_13 (mix_q_src_c119_0_13 0 bpf_c119_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_0_13 (mix_q_src_c119_0_13 mix_q_c119_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_14 (mix_i_src_c119_0_14 0 bpf_c119_0 0) vcvs gain=8.314696123025e-01
SMIXI_c119_0_14 (mix_i_src_c119_0_14 mix_i_c119_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_14 (mix_q_src_c119_0_14 0 bpf_c119_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_0_14 (mix_q_src_c119_0_14 mix_q_c119_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_0_15 (mix_i_src_c119_0_15 0 bpf_c119_0 0) vcvs gain=9.807852804032e-01
SMIXI_c119_0_15 (mix_i_src_c119_0_15 mix_i_c119_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_0_15 (mix_q_src_c119_0_15 0 bpf_c119_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_0_15 (mix_q_src_c119_0_15 mix_q_c119_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c119_0 (mix_i_c119_0 0) resistor r=1G
RMIXQ_c119_0 (mix_q_c119_0 0) resistor r=1G
RINTI_c119_0 (mix_i_c119_0 Icar_c119_0) resistor r=1k
CINTI_c119_0 (Icar_c119_0 0) capacitor c=80p
RINTQ_c119_0 (mix_q_c119_0 Qcar_c119_0) resistor r=1k
CINTQ_c119_0 (Qcar_c119_0 0) capacitor c=80p

// bl119, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c119_1 (bl119 n_cbpf_c119_1) capacitor c=1.013211836423e-13
LBPF_c119_1 (n_cbpf_c119_1 bpf_c119_1) inductor l=1.000000000000e-06
RBPF_c119_1 (bpf_c119_1 0) resistor r=1.570796326795e+02
EMIXI_c119_1_00 (mix_i_src_c119_1_00 0 bpf_c119_1 0) vcvs gain=9.807852804032e-01
SMIXI_c119_1_00 (mix_i_src_c119_1_00 mix_i_c119_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_00 (mix_q_src_c119_1_00 0 bpf_c119_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_1_00 (mix_q_src_c119_1_00 mix_q_c119_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_01 (mix_i_src_c119_1_01 0 bpf_c119_1 0) vcvs gain=8.314696123025e-01
SMIXI_c119_1_01 (mix_i_src_c119_1_01 mix_i_c119_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_01 (mix_q_src_c119_1_01 0 bpf_c119_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_1_01 (mix_q_src_c119_1_01 mix_q_c119_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_02 (mix_i_src_c119_1_02 0 bpf_c119_1 0) vcvs gain=5.555702330196e-01
SMIXI_c119_1_02 (mix_i_src_c119_1_02 mix_i_c119_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_02 (mix_q_src_c119_1_02 0 bpf_c119_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_1_02 (mix_q_src_c119_1_02 mix_q_c119_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_03 (mix_i_src_c119_1_03 0 bpf_c119_1 0) vcvs gain=1.950903220161e-01
SMIXI_c119_1_03 (mix_i_src_c119_1_03 mix_i_c119_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_03 (mix_q_src_c119_1_03 0 bpf_c119_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_1_03 (mix_q_src_c119_1_03 mix_q_c119_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_04 (mix_i_src_c119_1_04 0 bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_1_04 (mix_i_src_c119_1_04 mix_i_c119_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_04 (mix_q_src_c119_1_04 0 bpf_c119_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_1_04 (mix_q_src_c119_1_04 mix_q_c119_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_05 (mix_i_src_c119_1_05 0 bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_1_05 (mix_i_src_c119_1_05 mix_i_c119_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_05 (mix_q_src_c119_1_05 0 bpf_c119_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_1_05 (mix_q_src_c119_1_05 mix_q_c119_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_06 (mix_i_src_c119_1_06 0 bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_1_06 (mix_i_src_c119_1_06 mix_i_c119_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_06 (mix_q_src_c119_1_06 0 bpf_c119_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_1_06 (mix_q_src_c119_1_06 mix_q_c119_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_07 (mix_i_src_c119_1_07 0 bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_1_07 (mix_i_src_c119_1_07 mix_i_c119_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_07 (mix_q_src_c119_1_07 0 bpf_c119_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_1_07 (mix_q_src_c119_1_07 mix_q_c119_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_08 (mix_i_src_c119_1_08 0 bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_1_08 (mix_i_src_c119_1_08 mix_i_c119_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_08 (mix_q_src_c119_1_08 0 bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_1_08 (mix_q_src_c119_1_08 mix_q_c119_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_09 (mix_i_src_c119_1_09 0 bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_1_09 (mix_i_src_c119_1_09 mix_i_c119_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_09 (mix_q_src_c119_1_09 0 bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_1_09 (mix_q_src_c119_1_09 mix_q_c119_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_10 (mix_i_src_c119_1_10 0 bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_1_10 (mix_i_src_c119_1_10 mix_i_c119_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_10 (mix_q_src_c119_1_10 0 bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_1_10 (mix_q_src_c119_1_10 mix_q_c119_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_11 (mix_i_src_c119_1_11 0 bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_1_11 (mix_i_src_c119_1_11 mix_i_c119_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_11 (mix_q_src_c119_1_11 0 bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_1_11 (mix_q_src_c119_1_11 mix_q_c119_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_12 (mix_i_src_c119_1_12 0 bpf_c119_1 0) vcvs gain=1.950903220161e-01
SMIXI_c119_1_12 (mix_i_src_c119_1_12 mix_i_c119_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_12 (mix_q_src_c119_1_12 0 bpf_c119_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_1_12 (mix_q_src_c119_1_12 mix_q_c119_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_13 (mix_i_src_c119_1_13 0 bpf_c119_1 0) vcvs gain=5.555702330196e-01
SMIXI_c119_1_13 (mix_i_src_c119_1_13 mix_i_c119_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_13 (mix_q_src_c119_1_13 0 bpf_c119_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_1_13 (mix_q_src_c119_1_13 mix_q_c119_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_14 (mix_i_src_c119_1_14 0 bpf_c119_1 0) vcvs gain=8.314696123025e-01
SMIXI_c119_1_14 (mix_i_src_c119_1_14 mix_i_c119_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_14 (mix_q_src_c119_1_14 0 bpf_c119_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_1_14 (mix_q_src_c119_1_14 mix_q_c119_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_1_15 (mix_i_src_c119_1_15 0 bpf_c119_1 0) vcvs gain=9.807852804032e-01
SMIXI_c119_1_15 (mix_i_src_c119_1_15 mix_i_c119_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_1_15 (mix_q_src_c119_1_15 0 bpf_c119_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_1_15 (mix_q_src_c119_1_15 mix_q_c119_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c119_1 (mix_i_c119_1 0) resistor r=1G
RMIXQ_c119_1 (mix_q_c119_1 0) resistor r=1G
RINTI_c119_1 (mix_i_c119_1 Icar_c119_1) resistor r=1k
CINTI_c119_1 (Icar_c119_1 0) capacitor c=80p
RINTQ_c119_1 (mix_q_c119_1 Qcar_c119_1) resistor r=1k
CINTQ_c119_1 (Qcar_c119_1 0) capacitor c=80p

// bl119, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c119_2 (bl119 n_cbpf_c119_2) capacitor c=4.503163717437e-14
LBPF_c119_2 (n_cbpf_c119_2 bpf_c119_2) inductor l=1.000000000000e-06
RBPF_c119_2 (bpf_c119_2 0) resistor r=2.356194490192e+02
EMIXI_c119_2_00 (mix_i_src_c119_2_00 0 bpf_c119_2 0) vcvs gain=9.807852804032e-01
SMIXI_c119_2_00 (mix_i_src_c119_2_00 mix_i_c119_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_00 (mix_q_src_c119_2_00 0 bpf_c119_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_2_00 (mix_q_src_c119_2_00 mix_q_c119_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_01 (mix_i_src_c119_2_01 0 bpf_c119_2 0) vcvs gain=8.314696123025e-01
SMIXI_c119_2_01 (mix_i_src_c119_2_01 mix_i_c119_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_01 (mix_q_src_c119_2_01 0 bpf_c119_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_2_01 (mix_q_src_c119_2_01 mix_q_c119_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_02 (mix_i_src_c119_2_02 0 bpf_c119_2 0) vcvs gain=5.555702330196e-01
SMIXI_c119_2_02 (mix_i_src_c119_2_02 mix_i_c119_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_02 (mix_q_src_c119_2_02 0 bpf_c119_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_2_02 (mix_q_src_c119_2_02 mix_q_c119_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_03 (mix_i_src_c119_2_03 0 bpf_c119_2 0) vcvs gain=1.950903220161e-01
SMIXI_c119_2_03 (mix_i_src_c119_2_03 mix_i_c119_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_03 (mix_q_src_c119_2_03 0 bpf_c119_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_2_03 (mix_q_src_c119_2_03 mix_q_c119_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_04 (mix_i_src_c119_2_04 0 bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_2_04 (mix_i_src_c119_2_04 mix_i_c119_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_04 (mix_q_src_c119_2_04 0 bpf_c119_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_2_04 (mix_q_src_c119_2_04 mix_q_c119_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_05 (mix_i_src_c119_2_05 0 bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_2_05 (mix_i_src_c119_2_05 mix_i_c119_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_05 (mix_q_src_c119_2_05 0 bpf_c119_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_2_05 (mix_q_src_c119_2_05 mix_q_c119_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_06 (mix_i_src_c119_2_06 0 bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_2_06 (mix_i_src_c119_2_06 mix_i_c119_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_06 (mix_q_src_c119_2_06 0 bpf_c119_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_2_06 (mix_q_src_c119_2_06 mix_q_c119_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_07 (mix_i_src_c119_2_07 0 bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_2_07 (mix_i_src_c119_2_07 mix_i_c119_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_07 (mix_q_src_c119_2_07 0 bpf_c119_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_2_07 (mix_q_src_c119_2_07 mix_q_c119_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_08 (mix_i_src_c119_2_08 0 bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_2_08 (mix_i_src_c119_2_08 mix_i_c119_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_08 (mix_q_src_c119_2_08 0 bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_2_08 (mix_q_src_c119_2_08 mix_q_c119_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_09 (mix_i_src_c119_2_09 0 bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_2_09 (mix_i_src_c119_2_09 mix_i_c119_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_09 (mix_q_src_c119_2_09 0 bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_2_09 (mix_q_src_c119_2_09 mix_q_c119_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_10 (mix_i_src_c119_2_10 0 bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_2_10 (mix_i_src_c119_2_10 mix_i_c119_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_10 (mix_q_src_c119_2_10 0 bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_2_10 (mix_q_src_c119_2_10 mix_q_c119_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_11 (mix_i_src_c119_2_11 0 bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_2_11 (mix_i_src_c119_2_11 mix_i_c119_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_11 (mix_q_src_c119_2_11 0 bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_2_11 (mix_q_src_c119_2_11 mix_q_c119_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_12 (mix_i_src_c119_2_12 0 bpf_c119_2 0) vcvs gain=1.950903220161e-01
SMIXI_c119_2_12 (mix_i_src_c119_2_12 mix_i_c119_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_12 (mix_q_src_c119_2_12 0 bpf_c119_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_2_12 (mix_q_src_c119_2_12 mix_q_c119_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_13 (mix_i_src_c119_2_13 0 bpf_c119_2 0) vcvs gain=5.555702330196e-01
SMIXI_c119_2_13 (mix_i_src_c119_2_13 mix_i_c119_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_13 (mix_q_src_c119_2_13 0 bpf_c119_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_2_13 (mix_q_src_c119_2_13 mix_q_c119_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_14 (mix_i_src_c119_2_14 0 bpf_c119_2 0) vcvs gain=8.314696123025e-01
SMIXI_c119_2_14 (mix_i_src_c119_2_14 mix_i_c119_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_14 (mix_q_src_c119_2_14 0 bpf_c119_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_2_14 (mix_q_src_c119_2_14 mix_q_c119_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_2_15 (mix_i_src_c119_2_15 0 bpf_c119_2 0) vcvs gain=9.807852804032e-01
SMIXI_c119_2_15 (mix_i_src_c119_2_15 mix_i_c119_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_2_15 (mix_q_src_c119_2_15 0 bpf_c119_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_2_15 (mix_q_src_c119_2_15 mix_q_c119_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c119_2 (mix_i_c119_2 0) resistor r=1G
RMIXQ_c119_2 (mix_q_c119_2 0) resistor r=1G
RINTI_c119_2 (mix_i_c119_2 Icar_c119_2) resistor r=1k
CINTI_c119_2 (Icar_c119_2 0) capacitor c=80p
RINTQ_c119_2 (mix_q_c119_2 Qcar_c119_2) resistor r=1k
CINTQ_c119_2 (Qcar_c119_2 0) capacitor c=80p

// bl119, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c119_3 (bl119 n_cbpf_c119_3) capacitor c=2.533029591058e-14
LBPF_c119_3 (n_cbpf_c119_3 bpf_c119_3) inductor l=1.000000000000e-06
RBPF_c119_3 (bpf_c119_3 0) resistor r=3.141592653590e+02
EMIXI_c119_3_00 (mix_i_src_c119_3_00 0 bpf_c119_3 0) vcvs gain=9.807852804032e-01
SMIXI_c119_3_00 (mix_i_src_c119_3_00 mix_i_c119_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_00 (mix_q_src_c119_3_00 0 bpf_c119_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_3_00 (mix_q_src_c119_3_00 mix_q_c119_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_01 (mix_i_src_c119_3_01 0 bpf_c119_3 0) vcvs gain=8.314696123025e-01
SMIXI_c119_3_01 (mix_i_src_c119_3_01 mix_i_c119_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_01 (mix_q_src_c119_3_01 0 bpf_c119_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_3_01 (mix_q_src_c119_3_01 mix_q_c119_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_02 (mix_i_src_c119_3_02 0 bpf_c119_3 0) vcvs gain=5.555702330196e-01
SMIXI_c119_3_02 (mix_i_src_c119_3_02 mix_i_c119_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_02 (mix_q_src_c119_3_02 0 bpf_c119_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_3_02 (mix_q_src_c119_3_02 mix_q_c119_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_03 (mix_i_src_c119_3_03 0 bpf_c119_3 0) vcvs gain=1.950903220161e-01
SMIXI_c119_3_03 (mix_i_src_c119_3_03 mix_i_c119_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_03 (mix_q_src_c119_3_03 0 bpf_c119_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_3_03 (mix_q_src_c119_3_03 mix_q_c119_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_04 (mix_i_src_c119_3_04 0 bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_3_04 (mix_i_src_c119_3_04 mix_i_c119_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_04 (mix_q_src_c119_3_04 0 bpf_c119_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c119_3_04 (mix_q_src_c119_3_04 mix_q_c119_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_05 (mix_i_src_c119_3_05 0 bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_3_05 (mix_i_src_c119_3_05 mix_i_c119_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_05 (mix_q_src_c119_3_05 0 bpf_c119_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c119_3_05 (mix_q_src_c119_3_05 mix_q_c119_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_06 (mix_i_src_c119_3_06 0 bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_3_06 (mix_i_src_c119_3_06 mix_i_c119_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_06 (mix_q_src_c119_3_06 0 bpf_c119_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c119_3_06 (mix_q_src_c119_3_06 mix_q_c119_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_07 (mix_i_src_c119_3_07 0 bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_3_07 (mix_i_src_c119_3_07 mix_i_c119_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_07 (mix_q_src_c119_3_07 0 bpf_c119_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c119_3_07 (mix_q_src_c119_3_07 mix_q_c119_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_08 (mix_i_src_c119_3_08 0 bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c119_3_08 (mix_i_src_c119_3_08 mix_i_c119_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_08 (mix_q_src_c119_3_08 0 bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_3_08 (mix_q_src_c119_3_08 mix_q_c119_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_09 (mix_i_src_c119_3_09 0 bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c119_3_09 (mix_i_src_c119_3_09 mix_i_c119_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_09 (mix_q_src_c119_3_09 0 bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_3_09 (mix_q_src_c119_3_09 mix_q_c119_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_10 (mix_i_src_c119_3_10 0 bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c119_3_10 (mix_i_src_c119_3_10 mix_i_c119_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_10 (mix_q_src_c119_3_10 0 bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_3_10 (mix_q_src_c119_3_10 mix_q_c119_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_11 (mix_i_src_c119_3_11 0 bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c119_3_11 (mix_i_src_c119_3_11 mix_i_c119_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_11 (mix_q_src_c119_3_11 0 bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_3_11 (mix_q_src_c119_3_11 mix_q_c119_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_12 (mix_i_src_c119_3_12 0 bpf_c119_3 0) vcvs gain=1.950903220161e-01
SMIXI_c119_3_12 (mix_i_src_c119_3_12 mix_i_c119_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_12 (mix_q_src_c119_3_12 0 bpf_c119_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c119_3_12 (mix_q_src_c119_3_12 mix_q_c119_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_13 (mix_i_src_c119_3_13 0 bpf_c119_3 0) vcvs gain=5.555702330196e-01
SMIXI_c119_3_13 (mix_i_src_c119_3_13 mix_i_c119_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_13 (mix_q_src_c119_3_13 0 bpf_c119_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c119_3_13 (mix_q_src_c119_3_13 mix_q_c119_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_14 (mix_i_src_c119_3_14 0 bpf_c119_3 0) vcvs gain=8.314696123025e-01
SMIXI_c119_3_14 (mix_i_src_c119_3_14 mix_i_c119_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_14 (mix_q_src_c119_3_14 0 bpf_c119_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c119_3_14 (mix_q_src_c119_3_14 mix_q_c119_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c119_3_15 (mix_i_src_c119_3_15 0 bpf_c119_3 0) vcvs gain=9.807852804032e-01
SMIXI_c119_3_15 (mix_i_src_c119_3_15 mix_i_c119_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c119_3_15 (mix_q_src_c119_3_15 0 bpf_c119_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c119_3_15 (mix_q_src_c119_3_15 mix_q_c119_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c119_3 (mix_i_c119_3 0) resistor r=1G
RMIXQ_c119_3 (mix_q_c119_3 0) resistor r=1G
RINTI_c119_3 (mix_i_c119_3 Icar_c119_3) resistor r=1k
CINTI_c119_3 (Icar_c119_3 0) capacitor c=80p
RINTQ_c119_3 (mix_q_c119_3 Qcar_c119_3) resistor r=1k
CINTQ_c119_3 (Qcar_c119_3 0) capacitor c=80p

// bl120, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c120_0 (bl120 n_cbpf_c120_0) capacitor c=4.052847345694e-13
LBPF_c120_0 (n_cbpf_c120_0 bpf_c120_0) inductor l=1.000000000000e-06
RBPF_c120_0 (bpf_c120_0 0) resistor r=7.853981633974e+01
EMIXI_c120_0_00 (mix_i_src_c120_0_00 0 bpf_c120_0 0) vcvs gain=9.807852804032e-01
SMIXI_c120_0_00 (mix_i_src_c120_0_00 mix_i_c120_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_00 (mix_q_src_c120_0_00 0 bpf_c120_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_0_00 (mix_q_src_c120_0_00 mix_q_c120_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_01 (mix_i_src_c120_0_01 0 bpf_c120_0 0) vcvs gain=8.314696123025e-01
SMIXI_c120_0_01 (mix_i_src_c120_0_01 mix_i_c120_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_01 (mix_q_src_c120_0_01 0 bpf_c120_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_0_01 (mix_q_src_c120_0_01 mix_q_c120_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_02 (mix_i_src_c120_0_02 0 bpf_c120_0 0) vcvs gain=5.555702330196e-01
SMIXI_c120_0_02 (mix_i_src_c120_0_02 mix_i_c120_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_02 (mix_q_src_c120_0_02 0 bpf_c120_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_0_02 (mix_q_src_c120_0_02 mix_q_c120_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_03 (mix_i_src_c120_0_03 0 bpf_c120_0 0) vcvs gain=1.950903220161e-01
SMIXI_c120_0_03 (mix_i_src_c120_0_03 mix_i_c120_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_03 (mix_q_src_c120_0_03 0 bpf_c120_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_0_03 (mix_q_src_c120_0_03 mix_q_c120_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_04 (mix_i_src_c120_0_04 0 bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_0_04 (mix_i_src_c120_0_04 mix_i_c120_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_04 (mix_q_src_c120_0_04 0 bpf_c120_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_0_04 (mix_q_src_c120_0_04 mix_q_c120_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_05 (mix_i_src_c120_0_05 0 bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_0_05 (mix_i_src_c120_0_05 mix_i_c120_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_05 (mix_q_src_c120_0_05 0 bpf_c120_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_0_05 (mix_q_src_c120_0_05 mix_q_c120_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_06 (mix_i_src_c120_0_06 0 bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_0_06 (mix_i_src_c120_0_06 mix_i_c120_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_06 (mix_q_src_c120_0_06 0 bpf_c120_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_0_06 (mix_q_src_c120_0_06 mix_q_c120_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_07 (mix_i_src_c120_0_07 0 bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_0_07 (mix_i_src_c120_0_07 mix_i_c120_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_07 (mix_q_src_c120_0_07 0 bpf_c120_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_0_07 (mix_q_src_c120_0_07 mix_q_c120_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_08 (mix_i_src_c120_0_08 0 bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_0_08 (mix_i_src_c120_0_08 mix_i_c120_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_08 (mix_q_src_c120_0_08 0 bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_0_08 (mix_q_src_c120_0_08 mix_q_c120_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_09 (mix_i_src_c120_0_09 0 bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_0_09 (mix_i_src_c120_0_09 mix_i_c120_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_09 (mix_q_src_c120_0_09 0 bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_0_09 (mix_q_src_c120_0_09 mix_q_c120_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_10 (mix_i_src_c120_0_10 0 bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_0_10 (mix_i_src_c120_0_10 mix_i_c120_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_10 (mix_q_src_c120_0_10 0 bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_0_10 (mix_q_src_c120_0_10 mix_q_c120_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_11 (mix_i_src_c120_0_11 0 bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_0_11 (mix_i_src_c120_0_11 mix_i_c120_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_11 (mix_q_src_c120_0_11 0 bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_0_11 (mix_q_src_c120_0_11 mix_q_c120_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_12 (mix_i_src_c120_0_12 0 bpf_c120_0 0) vcvs gain=1.950903220161e-01
SMIXI_c120_0_12 (mix_i_src_c120_0_12 mix_i_c120_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_12 (mix_q_src_c120_0_12 0 bpf_c120_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_0_12 (mix_q_src_c120_0_12 mix_q_c120_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_13 (mix_i_src_c120_0_13 0 bpf_c120_0 0) vcvs gain=5.555702330196e-01
SMIXI_c120_0_13 (mix_i_src_c120_0_13 mix_i_c120_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_13 (mix_q_src_c120_0_13 0 bpf_c120_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_0_13 (mix_q_src_c120_0_13 mix_q_c120_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_14 (mix_i_src_c120_0_14 0 bpf_c120_0 0) vcvs gain=8.314696123025e-01
SMIXI_c120_0_14 (mix_i_src_c120_0_14 mix_i_c120_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_14 (mix_q_src_c120_0_14 0 bpf_c120_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_0_14 (mix_q_src_c120_0_14 mix_q_c120_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_0_15 (mix_i_src_c120_0_15 0 bpf_c120_0 0) vcvs gain=9.807852804032e-01
SMIXI_c120_0_15 (mix_i_src_c120_0_15 mix_i_c120_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_0_15 (mix_q_src_c120_0_15 0 bpf_c120_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_0_15 (mix_q_src_c120_0_15 mix_q_c120_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c120_0 (mix_i_c120_0 0) resistor r=1G
RMIXQ_c120_0 (mix_q_c120_0 0) resistor r=1G
RINTI_c120_0 (mix_i_c120_0 Icar_c120_0) resistor r=1k
CINTI_c120_0 (Icar_c120_0 0) capacitor c=80p
RINTQ_c120_0 (mix_q_c120_0 Qcar_c120_0) resistor r=1k
CINTQ_c120_0 (Qcar_c120_0 0) capacitor c=80p

// bl120, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c120_1 (bl120 n_cbpf_c120_1) capacitor c=1.013211836423e-13
LBPF_c120_1 (n_cbpf_c120_1 bpf_c120_1) inductor l=1.000000000000e-06
RBPF_c120_1 (bpf_c120_1 0) resistor r=1.570796326795e+02
EMIXI_c120_1_00 (mix_i_src_c120_1_00 0 bpf_c120_1 0) vcvs gain=9.807852804032e-01
SMIXI_c120_1_00 (mix_i_src_c120_1_00 mix_i_c120_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_00 (mix_q_src_c120_1_00 0 bpf_c120_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_1_00 (mix_q_src_c120_1_00 mix_q_c120_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_01 (mix_i_src_c120_1_01 0 bpf_c120_1 0) vcvs gain=8.314696123025e-01
SMIXI_c120_1_01 (mix_i_src_c120_1_01 mix_i_c120_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_01 (mix_q_src_c120_1_01 0 bpf_c120_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_1_01 (mix_q_src_c120_1_01 mix_q_c120_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_02 (mix_i_src_c120_1_02 0 bpf_c120_1 0) vcvs gain=5.555702330196e-01
SMIXI_c120_1_02 (mix_i_src_c120_1_02 mix_i_c120_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_02 (mix_q_src_c120_1_02 0 bpf_c120_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_1_02 (mix_q_src_c120_1_02 mix_q_c120_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_03 (mix_i_src_c120_1_03 0 bpf_c120_1 0) vcvs gain=1.950903220161e-01
SMIXI_c120_1_03 (mix_i_src_c120_1_03 mix_i_c120_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_03 (mix_q_src_c120_1_03 0 bpf_c120_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_1_03 (mix_q_src_c120_1_03 mix_q_c120_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_04 (mix_i_src_c120_1_04 0 bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_1_04 (mix_i_src_c120_1_04 mix_i_c120_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_04 (mix_q_src_c120_1_04 0 bpf_c120_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_1_04 (mix_q_src_c120_1_04 mix_q_c120_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_05 (mix_i_src_c120_1_05 0 bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_1_05 (mix_i_src_c120_1_05 mix_i_c120_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_05 (mix_q_src_c120_1_05 0 bpf_c120_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_1_05 (mix_q_src_c120_1_05 mix_q_c120_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_06 (mix_i_src_c120_1_06 0 bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_1_06 (mix_i_src_c120_1_06 mix_i_c120_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_06 (mix_q_src_c120_1_06 0 bpf_c120_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_1_06 (mix_q_src_c120_1_06 mix_q_c120_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_07 (mix_i_src_c120_1_07 0 bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_1_07 (mix_i_src_c120_1_07 mix_i_c120_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_07 (mix_q_src_c120_1_07 0 bpf_c120_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_1_07 (mix_q_src_c120_1_07 mix_q_c120_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_08 (mix_i_src_c120_1_08 0 bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_1_08 (mix_i_src_c120_1_08 mix_i_c120_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_08 (mix_q_src_c120_1_08 0 bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_1_08 (mix_q_src_c120_1_08 mix_q_c120_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_09 (mix_i_src_c120_1_09 0 bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_1_09 (mix_i_src_c120_1_09 mix_i_c120_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_09 (mix_q_src_c120_1_09 0 bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_1_09 (mix_q_src_c120_1_09 mix_q_c120_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_10 (mix_i_src_c120_1_10 0 bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_1_10 (mix_i_src_c120_1_10 mix_i_c120_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_10 (mix_q_src_c120_1_10 0 bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_1_10 (mix_q_src_c120_1_10 mix_q_c120_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_11 (mix_i_src_c120_1_11 0 bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_1_11 (mix_i_src_c120_1_11 mix_i_c120_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_11 (mix_q_src_c120_1_11 0 bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_1_11 (mix_q_src_c120_1_11 mix_q_c120_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_12 (mix_i_src_c120_1_12 0 bpf_c120_1 0) vcvs gain=1.950903220161e-01
SMIXI_c120_1_12 (mix_i_src_c120_1_12 mix_i_c120_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_12 (mix_q_src_c120_1_12 0 bpf_c120_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_1_12 (mix_q_src_c120_1_12 mix_q_c120_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_13 (mix_i_src_c120_1_13 0 bpf_c120_1 0) vcvs gain=5.555702330196e-01
SMIXI_c120_1_13 (mix_i_src_c120_1_13 mix_i_c120_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_13 (mix_q_src_c120_1_13 0 bpf_c120_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_1_13 (mix_q_src_c120_1_13 mix_q_c120_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_14 (mix_i_src_c120_1_14 0 bpf_c120_1 0) vcvs gain=8.314696123025e-01
SMIXI_c120_1_14 (mix_i_src_c120_1_14 mix_i_c120_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_14 (mix_q_src_c120_1_14 0 bpf_c120_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_1_14 (mix_q_src_c120_1_14 mix_q_c120_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_1_15 (mix_i_src_c120_1_15 0 bpf_c120_1 0) vcvs gain=9.807852804032e-01
SMIXI_c120_1_15 (mix_i_src_c120_1_15 mix_i_c120_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_1_15 (mix_q_src_c120_1_15 0 bpf_c120_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_1_15 (mix_q_src_c120_1_15 mix_q_c120_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c120_1 (mix_i_c120_1 0) resistor r=1G
RMIXQ_c120_1 (mix_q_c120_1 0) resistor r=1G
RINTI_c120_1 (mix_i_c120_1 Icar_c120_1) resistor r=1k
CINTI_c120_1 (Icar_c120_1 0) capacitor c=80p
RINTQ_c120_1 (mix_q_c120_1 Qcar_c120_1) resistor r=1k
CINTQ_c120_1 (Qcar_c120_1 0) capacitor c=80p

// bl120, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c120_2 (bl120 n_cbpf_c120_2) capacitor c=4.503163717437e-14
LBPF_c120_2 (n_cbpf_c120_2 bpf_c120_2) inductor l=1.000000000000e-06
RBPF_c120_2 (bpf_c120_2 0) resistor r=2.356194490192e+02
EMIXI_c120_2_00 (mix_i_src_c120_2_00 0 bpf_c120_2 0) vcvs gain=9.807852804032e-01
SMIXI_c120_2_00 (mix_i_src_c120_2_00 mix_i_c120_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_00 (mix_q_src_c120_2_00 0 bpf_c120_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_2_00 (mix_q_src_c120_2_00 mix_q_c120_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_01 (mix_i_src_c120_2_01 0 bpf_c120_2 0) vcvs gain=8.314696123025e-01
SMIXI_c120_2_01 (mix_i_src_c120_2_01 mix_i_c120_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_01 (mix_q_src_c120_2_01 0 bpf_c120_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_2_01 (mix_q_src_c120_2_01 mix_q_c120_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_02 (mix_i_src_c120_2_02 0 bpf_c120_2 0) vcvs gain=5.555702330196e-01
SMIXI_c120_2_02 (mix_i_src_c120_2_02 mix_i_c120_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_02 (mix_q_src_c120_2_02 0 bpf_c120_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_2_02 (mix_q_src_c120_2_02 mix_q_c120_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_03 (mix_i_src_c120_2_03 0 bpf_c120_2 0) vcvs gain=1.950903220161e-01
SMIXI_c120_2_03 (mix_i_src_c120_2_03 mix_i_c120_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_03 (mix_q_src_c120_2_03 0 bpf_c120_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_2_03 (mix_q_src_c120_2_03 mix_q_c120_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_04 (mix_i_src_c120_2_04 0 bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_2_04 (mix_i_src_c120_2_04 mix_i_c120_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_04 (mix_q_src_c120_2_04 0 bpf_c120_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_2_04 (mix_q_src_c120_2_04 mix_q_c120_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_05 (mix_i_src_c120_2_05 0 bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_2_05 (mix_i_src_c120_2_05 mix_i_c120_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_05 (mix_q_src_c120_2_05 0 bpf_c120_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_2_05 (mix_q_src_c120_2_05 mix_q_c120_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_06 (mix_i_src_c120_2_06 0 bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_2_06 (mix_i_src_c120_2_06 mix_i_c120_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_06 (mix_q_src_c120_2_06 0 bpf_c120_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_2_06 (mix_q_src_c120_2_06 mix_q_c120_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_07 (mix_i_src_c120_2_07 0 bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_2_07 (mix_i_src_c120_2_07 mix_i_c120_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_07 (mix_q_src_c120_2_07 0 bpf_c120_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_2_07 (mix_q_src_c120_2_07 mix_q_c120_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_08 (mix_i_src_c120_2_08 0 bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_2_08 (mix_i_src_c120_2_08 mix_i_c120_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_08 (mix_q_src_c120_2_08 0 bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_2_08 (mix_q_src_c120_2_08 mix_q_c120_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_09 (mix_i_src_c120_2_09 0 bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_2_09 (mix_i_src_c120_2_09 mix_i_c120_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_09 (mix_q_src_c120_2_09 0 bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_2_09 (mix_q_src_c120_2_09 mix_q_c120_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_10 (mix_i_src_c120_2_10 0 bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_2_10 (mix_i_src_c120_2_10 mix_i_c120_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_10 (mix_q_src_c120_2_10 0 bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_2_10 (mix_q_src_c120_2_10 mix_q_c120_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_11 (mix_i_src_c120_2_11 0 bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_2_11 (mix_i_src_c120_2_11 mix_i_c120_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_11 (mix_q_src_c120_2_11 0 bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_2_11 (mix_q_src_c120_2_11 mix_q_c120_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_12 (mix_i_src_c120_2_12 0 bpf_c120_2 0) vcvs gain=1.950903220161e-01
SMIXI_c120_2_12 (mix_i_src_c120_2_12 mix_i_c120_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_12 (mix_q_src_c120_2_12 0 bpf_c120_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_2_12 (mix_q_src_c120_2_12 mix_q_c120_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_13 (mix_i_src_c120_2_13 0 bpf_c120_2 0) vcvs gain=5.555702330196e-01
SMIXI_c120_2_13 (mix_i_src_c120_2_13 mix_i_c120_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_13 (mix_q_src_c120_2_13 0 bpf_c120_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_2_13 (mix_q_src_c120_2_13 mix_q_c120_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_14 (mix_i_src_c120_2_14 0 bpf_c120_2 0) vcvs gain=8.314696123025e-01
SMIXI_c120_2_14 (mix_i_src_c120_2_14 mix_i_c120_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_14 (mix_q_src_c120_2_14 0 bpf_c120_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_2_14 (mix_q_src_c120_2_14 mix_q_c120_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_2_15 (mix_i_src_c120_2_15 0 bpf_c120_2 0) vcvs gain=9.807852804032e-01
SMIXI_c120_2_15 (mix_i_src_c120_2_15 mix_i_c120_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_2_15 (mix_q_src_c120_2_15 0 bpf_c120_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_2_15 (mix_q_src_c120_2_15 mix_q_c120_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c120_2 (mix_i_c120_2 0) resistor r=1G
RMIXQ_c120_2 (mix_q_c120_2 0) resistor r=1G
RINTI_c120_2 (mix_i_c120_2 Icar_c120_2) resistor r=1k
CINTI_c120_2 (Icar_c120_2 0) capacitor c=80p
RINTQ_c120_2 (mix_q_c120_2 Qcar_c120_2) resistor r=1k
CINTQ_c120_2 (Qcar_c120_2 0) capacitor c=80p

// bl120, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c120_3 (bl120 n_cbpf_c120_3) capacitor c=2.533029591058e-14
LBPF_c120_3 (n_cbpf_c120_3 bpf_c120_3) inductor l=1.000000000000e-06
RBPF_c120_3 (bpf_c120_3 0) resistor r=3.141592653590e+02
EMIXI_c120_3_00 (mix_i_src_c120_3_00 0 bpf_c120_3 0) vcvs gain=9.807852804032e-01
SMIXI_c120_3_00 (mix_i_src_c120_3_00 mix_i_c120_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_00 (mix_q_src_c120_3_00 0 bpf_c120_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_3_00 (mix_q_src_c120_3_00 mix_q_c120_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_01 (mix_i_src_c120_3_01 0 bpf_c120_3 0) vcvs gain=8.314696123025e-01
SMIXI_c120_3_01 (mix_i_src_c120_3_01 mix_i_c120_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_01 (mix_q_src_c120_3_01 0 bpf_c120_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_3_01 (mix_q_src_c120_3_01 mix_q_c120_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_02 (mix_i_src_c120_3_02 0 bpf_c120_3 0) vcvs gain=5.555702330196e-01
SMIXI_c120_3_02 (mix_i_src_c120_3_02 mix_i_c120_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_02 (mix_q_src_c120_3_02 0 bpf_c120_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_3_02 (mix_q_src_c120_3_02 mix_q_c120_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_03 (mix_i_src_c120_3_03 0 bpf_c120_3 0) vcvs gain=1.950903220161e-01
SMIXI_c120_3_03 (mix_i_src_c120_3_03 mix_i_c120_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_03 (mix_q_src_c120_3_03 0 bpf_c120_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_3_03 (mix_q_src_c120_3_03 mix_q_c120_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_04 (mix_i_src_c120_3_04 0 bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_3_04 (mix_i_src_c120_3_04 mix_i_c120_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_04 (mix_q_src_c120_3_04 0 bpf_c120_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c120_3_04 (mix_q_src_c120_3_04 mix_q_c120_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_05 (mix_i_src_c120_3_05 0 bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_3_05 (mix_i_src_c120_3_05 mix_i_c120_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_05 (mix_q_src_c120_3_05 0 bpf_c120_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c120_3_05 (mix_q_src_c120_3_05 mix_q_c120_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_06 (mix_i_src_c120_3_06 0 bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_3_06 (mix_i_src_c120_3_06 mix_i_c120_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_06 (mix_q_src_c120_3_06 0 bpf_c120_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c120_3_06 (mix_q_src_c120_3_06 mix_q_c120_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_07 (mix_i_src_c120_3_07 0 bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_3_07 (mix_i_src_c120_3_07 mix_i_c120_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_07 (mix_q_src_c120_3_07 0 bpf_c120_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c120_3_07 (mix_q_src_c120_3_07 mix_q_c120_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_08 (mix_i_src_c120_3_08 0 bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c120_3_08 (mix_i_src_c120_3_08 mix_i_c120_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_08 (mix_q_src_c120_3_08 0 bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_3_08 (mix_q_src_c120_3_08 mix_q_c120_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_09 (mix_i_src_c120_3_09 0 bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c120_3_09 (mix_i_src_c120_3_09 mix_i_c120_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_09 (mix_q_src_c120_3_09 0 bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_3_09 (mix_q_src_c120_3_09 mix_q_c120_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_10 (mix_i_src_c120_3_10 0 bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c120_3_10 (mix_i_src_c120_3_10 mix_i_c120_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_10 (mix_q_src_c120_3_10 0 bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_3_10 (mix_q_src_c120_3_10 mix_q_c120_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_11 (mix_i_src_c120_3_11 0 bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c120_3_11 (mix_i_src_c120_3_11 mix_i_c120_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_11 (mix_q_src_c120_3_11 0 bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_3_11 (mix_q_src_c120_3_11 mix_q_c120_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_12 (mix_i_src_c120_3_12 0 bpf_c120_3 0) vcvs gain=1.950903220161e-01
SMIXI_c120_3_12 (mix_i_src_c120_3_12 mix_i_c120_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_12 (mix_q_src_c120_3_12 0 bpf_c120_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c120_3_12 (mix_q_src_c120_3_12 mix_q_c120_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_13 (mix_i_src_c120_3_13 0 bpf_c120_3 0) vcvs gain=5.555702330196e-01
SMIXI_c120_3_13 (mix_i_src_c120_3_13 mix_i_c120_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_13 (mix_q_src_c120_3_13 0 bpf_c120_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c120_3_13 (mix_q_src_c120_3_13 mix_q_c120_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_14 (mix_i_src_c120_3_14 0 bpf_c120_3 0) vcvs gain=8.314696123025e-01
SMIXI_c120_3_14 (mix_i_src_c120_3_14 mix_i_c120_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_14 (mix_q_src_c120_3_14 0 bpf_c120_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c120_3_14 (mix_q_src_c120_3_14 mix_q_c120_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c120_3_15 (mix_i_src_c120_3_15 0 bpf_c120_3 0) vcvs gain=9.807852804032e-01
SMIXI_c120_3_15 (mix_i_src_c120_3_15 mix_i_c120_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c120_3_15 (mix_q_src_c120_3_15 0 bpf_c120_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c120_3_15 (mix_q_src_c120_3_15 mix_q_c120_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c120_3 (mix_i_c120_3 0) resistor r=1G
RMIXQ_c120_3 (mix_q_c120_3 0) resistor r=1G
RINTI_c120_3 (mix_i_c120_3 Icar_c120_3) resistor r=1k
CINTI_c120_3 (Icar_c120_3 0) capacitor c=80p
RINTQ_c120_3 (mix_q_c120_3 Qcar_c120_3) resistor r=1k
CINTQ_c120_3 (Qcar_c120_3 0) capacitor c=80p

// bl121, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c121_0 (bl121 n_cbpf_c121_0) capacitor c=4.052847345694e-13
LBPF_c121_0 (n_cbpf_c121_0 bpf_c121_0) inductor l=1.000000000000e-06
RBPF_c121_0 (bpf_c121_0 0) resistor r=7.853981633974e+01
EMIXI_c121_0_00 (mix_i_src_c121_0_00 0 bpf_c121_0 0) vcvs gain=9.807852804032e-01
SMIXI_c121_0_00 (mix_i_src_c121_0_00 mix_i_c121_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_00 (mix_q_src_c121_0_00 0 bpf_c121_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_0_00 (mix_q_src_c121_0_00 mix_q_c121_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_01 (mix_i_src_c121_0_01 0 bpf_c121_0 0) vcvs gain=8.314696123025e-01
SMIXI_c121_0_01 (mix_i_src_c121_0_01 mix_i_c121_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_01 (mix_q_src_c121_0_01 0 bpf_c121_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_0_01 (mix_q_src_c121_0_01 mix_q_c121_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_02 (mix_i_src_c121_0_02 0 bpf_c121_0 0) vcvs gain=5.555702330196e-01
SMIXI_c121_0_02 (mix_i_src_c121_0_02 mix_i_c121_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_02 (mix_q_src_c121_0_02 0 bpf_c121_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_0_02 (mix_q_src_c121_0_02 mix_q_c121_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_03 (mix_i_src_c121_0_03 0 bpf_c121_0 0) vcvs gain=1.950903220161e-01
SMIXI_c121_0_03 (mix_i_src_c121_0_03 mix_i_c121_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_03 (mix_q_src_c121_0_03 0 bpf_c121_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_0_03 (mix_q_src_c121_0_03 mix_q_c121_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_04 (mix_i_src_c121_0_04 0 bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_0_04 (mix_i_src_c121_0_04 mix_i_c121_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_04 (mix_q_src_c121_0_04 0 bpf_c121_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_0_04 (mix_q_src_c121_0_04 mix_q_c121_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_05 (mix_i_src_c121_0_05 0 bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_0_05 (mix_i_src_c121_0_05 mix_i_c121_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_05 (mix_q_src_c121_0_05 0 bpf_c121_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_0_05 (mix_q_src_c121_0_05 mix_q_c121_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_06 (mix_i_src_c121_0_06 0 bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_0_06 (mix_i_src_c121_0_06 mix_i_c121_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_06 (mix_q_src_c121_0_06 0 bpf_c121_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_0_06 (mix_q_src_c121_0_06 mix_q_c121_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_07 (mix_i_src_c121_0_07 0 bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_0_07 (mix_i_src_c121_0_07 mix_i_c121_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_07 (mix_q_src_c121_0_07 0 bpf_c121_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_0_07 (mix_q_src_c121_0_07 mix_q_c121_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_08 (mix_i_src_c121_0_08 0 bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_0_08 (mix_i_src_c121_0_08 mix_i_c121_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_08 (mix_q_src_c121_0_08 0 bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_0_08 (mix_q_src_c121_0_08 mix_q_c121_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_09 (mix_i_src_c121_0_09 0 bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_0_09 (mix_i_src_c121_0_09 mix_i_c121_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_09 (mix_q_src_c121_0_09 0 bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_0_09 (mix_q_src_c121_0_09 mix_q_c121_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_10 (mix_i_src_c121_0_10 0 bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_0_10 (mix_i_src_c121_0_10 mix_i_c121_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_10 (mix_q_src_c121_0_10 0 bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_0_10 (mix_q_src_c121_0_10 mix_q_c121_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_11 (mix_i_src_c121_0_11 0 bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_0_11 (mix_i_src_c121_0_11 mix_i_c121_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_11 (mix_q_src_c121_0_11 0 bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_0_11 (mix_q_src_c121_0_11 mix_q_c121_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_12 (mix_i_src_c121_0_12 0 bpf_c121_0 0) vcvs gain=1.950903220161e-01
SMIXI_c121_0_12 (mix_i_src_c121_0_12 mix_i_c121_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_12 (mix_q_src_c121_0_12 0 bpf_c121_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_0_12 (mix_q_src_c121_0_12 mix_q_c121_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_13 (mix_i_src_c121_0_13 0 bpf_c121_0 0) vcvs gain=5.555702330196e-01
SMIXI_c121_0_13 (mix_i_src_c121_0_13 mix_i_c121_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_13 (mix_q_src_c121_0_13 0 bpf_c121_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_0_13 (mix_q_src_c121_0_13 mix_q_c121_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_14 (mix_i_src_c121_0_14 0 bpf_c121_0 0) vcvs gain=8.314696123025e-01
SMIXI_c121_0_14 (mix_i_src_c121_0_14 mix_i_c121_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_14 (mix_q_src_c121_0_14 0 bpf_c121_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_0_14 (mix_q_src_c121_0_14 mix_q_c121_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_0_15 (mix_i_src_c121_0_15 0 bpf_c121_0 0) vcvs gain=9.807852804032e-01
SMIXI_c121_0_15 (mix_i_src_c121_0_15 mix_i_c121_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_0_15 (mix_q_src_c121_0_15 0 bpf_c121_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_0_15 (mix_q_src_c121_0_15 mix_q_c121_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c121_0 (mix_i_c121_0 0) resistor r=1G
RMIXQ_c121_0 (mix_q_c121_0 0) resistor r=1G
RINTI_c121_0 (mix_i_c121_0 Icar_c121_0) resistor r=1k
CINTI_c121_0 (Icar_c121_0 0) capacitor c=80p
RINTQ_c121_0 (mix_q_c121_0 Qcar_c121_0) resistor r=1k
CINTQ_c121_0 (Qcar_c121_0 0) capacitor c=80p

// bl121, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c121_1 (bl121 n_cbpf_c121_1) capacitor c=1.013211836423e-13
LBPF_c121_1 (n_cbpf_c121_1 bpf_c121_1) inductor l=1.000000000000e-06
RBPF_c121_1 (bpf_c121_1 0) resistor r=1.570796326795e+02
EMIXI_c121_1_00 (mix_i_src_c121_1_00 0 bpf_c121_1 0) vcvs gain=9.807852804032e-01
SMIXI_c121_1_00 (mix_i_src_c121_1_00 mix_i_c121_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_00 (mix_q_src_c121_1_00 0 bpf_c121_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_1_00 (mix_q_src_c121_1_00 mix_q_c121_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_01 (mix_i_src_c121_1_01 0 bpf_c121_1 0) vcvs gain=8.314696123025e-01
SMIXI_c121_1_01 (mix_i_src_c121_1_01 mix_i_c121_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_01 (mix_q_src_c121_1_01 0 bpf_c121_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_1_01 (mix_q_src_c121_1_01 mix_q_c121_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_02 (mix_i_src_c121_1_02 0 bpf_c121_1 0) vcvs gain=5.555702330196e-01
SMIXI_c121_1_02 (mix_i_src_c121_1_02 mix_i_c121_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_02 (mix_q_src_c121_1_02 0 bpf_c121_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_1_02 (mix_q_src_c121_1_02 mix_q_c121_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_03 (mix_i_src_c121_1_03 0 bpf_c121_1 0) vcvs gain=1.950903220161e-01
SMIXI_c121_1_03 (mix_i_src_c121_1_03 mix_i_c121_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_03 (mix_q_src_c121_1_03 0 bpf_c121_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_1_03 (mix_q_src_c121_1_03 mix_q_c121_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_04 (mix_i_src_c121_1_04 0 bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_1_04 (mix_i_src_c121_1_04 mix_i_c121_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_04 (mix_q_src_c121_1_04 0 bpf_c121_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_1_04 (mix_q_src_c121_1_04 mix_q_c121_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_05 (mix_i_src_c121_1_05 0 bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_1_05 (mix_i_src_c121_1_05 mix_i_c121_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_05 (mix_q_src_c121_1_05 0 bpf_c121_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_1_05 (mix_q_src_c121_1_05 mix_q_c121_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_06 (mix_i_src_c121_1_06 0 bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_1_06 (mix_i_src_c121_1_06 mix_i_c121_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_06 (mix_q_src_c121_1_06 0 bpf_c121_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_1_06 (mix_q_src_c121_1_06 mix_q_c121_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_07 (mix_i_src_c121_1_07 0 bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_1_07 (mix_i_src_c121_1_07 mix_i_c121_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_07 (mix_q_src_c121_1_07 0 bpf_c121_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_1_07 (mix_q_src_c121_1_07 mix_q_c121_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_08 (mix_i_src_c121_1_08 0 bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_1_08 (mix_i_src_c121_1_08 mix_i_c121_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_08 (mix_q_src_c121_1_08 0 bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_1_08 (mix_q_src_c121_1_08 mix_q_c121_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_09 (mix_i_src_c121_1_09 0 bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_1_09 (mix_i_src_c121_1_09 mix_i_c121_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_09 (mix_q_src_c121_1_09 0 bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_1_09 (mix_q_src_c121_1_09 mix_q_c121_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_10 (mix_i_src_c121_1_10 0 bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_1_10 (mix_i_src_c121_1_10 mix_i_c121_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_10 (mix_q_src_c121_1_10 0 bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_1_10 (mix_q_src_c121_1_10 mix_q_c121_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_11 (mix_i_src_c121_1_11 0 bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_1_11 (mix_i_src_c121_1_11 mix_i_c121_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_11 (mix_q_src_c121_1_11 0 bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_1_11 (mix_q_src_c121_1_11 mix_q_c121_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_12 (mix_i_src_c121_1_12 0 bpf_c121_1 0) vcvs gain=1.950903220161e-01
SMIXI_c121_1_12 (mix_i_src_c121_1_12 mix_i_c121_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_12 (mix_q_src_c121_1_12 0 bpf_c121_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_1_12 (mix_q_src_c121_1_12 mix_q_c121_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_13 (mix_i_src_c121_1_13 0 bpf_c121_1 0) vcvs gain=5.555702330196e-01
SMIXI_c121_1_13 (mix_i_src_c121_1_13 mix_i_c121_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_13 (mix_q_src_c121_1_13 0 bpf_c121_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_1_13 (mix_q_src_c121_1_13 mix_q_c121_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_14 (mix_i_src_c121_1_14 0 bpf_c121_1 0) vcvs gain=8.314696123025e-01
SMIXI_c121_1_14 (mix_i_src_c121_1_14 mix_i_c121_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_14 (mix_q_src_c121_1_14 0 bpf_c121_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_1_14 (mix_q_src_c121_1_14 mix_q_c121_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_1_15 (mix_i_src_c121_1_15 0 bpf_c121_1 0) vcvs gain=9.807852804032e-01
SMIXI_c121_1_15 (mix_i_src_c121_1_15 mix_i_c121_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_1_15 (mix_q_src_c121_1_15 0 bpf_c121_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_1_15 (mix_q_src_c121_1_15 mix_q_c121_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c121_1 (mix_i_c121_1 0) resistor r=1G
RMIXQ_c121_1 (mix_q_c121_1 0) resistor r=1G
RINTI_c121_1 (mix_i_c121_1 Icar_c121_1) resistor r=1k
CINTI_c121_1 (Icar_c121_1 0) capacitor c=80p
RINTQ_c121_1 (mix_q_c121_1 Qcar_c121_1) resistor r=1k
CINTQ_c121_1 (Qcar_c121_1 0) capacitor c=80p

// bl121, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c121_2 (bl121 n_cbpf_c121_2) capacitor c=4.503163717437e-14
LBPF_c121_2 (n_cbpf_c121_2 bpf_c121_2) inductor l=1.000000000000e-06
RBPF_c121_2 (bpf_c121_2 0) resistor r=2.356194490192e+02
EMIXI_c121_2_00 (mix_i_src_c121_2_00 0 bpf_c121_2 0) vcvs gain=9.807852804032e-01
SMIXI_c121_2_00 (mix_i_src_c121_2_00 mix_i_c121_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_00 (mix_q_src_c121_2_00 0 bpf_c121_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_2_00 (mix_q_src_c121_2_00 mix_q_c121_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_01 (mix_i_src_c121_2_01 0 bpf_c121_2 0) vcvs gain=8.314696123025e-01
SMIXI_c121_2_01 (mix_i_src_c121_2_01 mix_i_c121_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_01 (mix_q_src_c121_2_01 0 bpf_c121_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_2_01 (mix_q_src_c121_2_01 mix_q_c121_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_02 (mix_i_src_c121_2_02 0 bpf_c121_2 0) vcvs gain=5.555702330196e-01
SMIXI_c121_2_02 (mix_i_src_c121_2_02 mix_i_c121_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_02 (mix_q_src_c121_2_02 0 bpf_c121_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_2_02 (mix_q_src_c121_2_02 mix_q_c121_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_03 (mix_i_src_c121_2_03 0 bpf_c121_2 0) vcvs gain=1.950903220161e-01
SMIXI_c121_2_03 (mix_i_src_c121_2_03 mix_i_c121_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_03 (mix_q_src_c121_2_03 0 bpf_c121_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_2_03 (mix_q_src_c121_2_03 mix_q_c121_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_04 (mix_i_src_c121_2_04 0 bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_2_04 (mix_i_src_c121_2_04 mix_i_c121_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_04 (mix_q_src_c121_2_04 0 bpf_c121_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_2_04 (mix_q_src_c121_2_04 mix_q_c121_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_05 (mix_i_src_c121_2_05 0 bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_2_05 (mix_i_src_c121_2_05 mix_i_c121_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_05 (mix_q_src_c121_2_05 0 bpf_c121_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_2_05 (mix_q_src_c121_2_05 mix_q_c121_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_06 (mix_i_src_c121_2_06 0 bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_2_06 (mix_i_src_c121_2_06 mix_i_c121_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_06 (mix_q_src_c121_2_06 0 bpf_c121_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_2_06 (mix_q_src_c121_2_06 mix_q_c121_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_07 (mix_i_src_c121_2_07 0 bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_2_07 (mix_i_src_c121_2_07 mix_i_c121_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_07 (mix_q_src_c121_2_07 0 bpf_c121_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_2_07 (mix_q_src_c121_2_07 mix_q_c121_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_08 (mix_i_src_c121_2_08 0 bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_2_08 (mix_i_src_c121_2_08 mix_i_c121_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_08 (mix_q_src_c121_2_08 0 bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_2_08 (mix_q_src_c121_2_08 mix_q_c121_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_09 (mix_i_src_c121_2_09 0 bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_2_09 (mix_i_src_c121_2_09 mix_i_c121_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_09 (mix_q_src_c121_2_09 0 bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_2_09 (mix_q_src_c121_2_09 mix_q_c121_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_10 (mix_i_src_c121_2_10 0 bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_2_10 (mix_i_src_c121_2_10 mix_i_c121_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_10 (mix_q_src_c121_2_10 0 bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_2_10 (mix_q_src_c121_2_10 mix_q_c121_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_11 (mix_i_src_c121_2_11 0 bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_2_11 (mix_i_src_c121_2_11 mix_i_c121_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_11 (mix_q_src_c121_2_11 0 bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_2_11 (mix_q_src_c121_2_11 mix_q_c121_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_12 (mix_i_src_c121_2_12 0 bpf_c121_2 0) vcvs gain=1.950903220161e-01
SMIXI_c121_2_12 (mix_i_src_c121_2_12 mix_i_c121_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_12 (mix_q_src_c121_2_12 0 bpf_c121_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_2_12 (mix_q_src_c121_2_12 mix_q_c121_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_13 (mix_i_src_c121_2_13 0 bpf_c121_2 0) vcvs gain=5.555702330196e-01
SMIXI_c121_2_13 (mix_i_src_c121_2_13 mix_i_c121_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_13 (mix_q_src_c121_2_13 0 bpf_c121_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_2_13 (mix_q_src_c121_2_13 mix_q_c121_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_14 (mix_i_src_c121_2_14 0 bpf_c121_2 0) vcvs gain=8.314696123025e-01
SMIXI_c121_2_14 (mix_i_src_c121_2_14 mix_i_c121_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_14 (mix_q_src_c121_2_14 0 bpf_c121_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_2_14 (mix_q_src_c121_2_14 mix_q_c121_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_2_15 (mix_i_src_c121_2_15 0 bpf_c121_2 0) vcvs gain=9.807852804032e-01
SMIXI_c121_2_15 (mix_i_src_c121_2_15 mix_i_c121_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_2_15 (mix_q_src_c121_2_15 0 bpf_c121_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_2_15 (mix_q_src_c121_2_15 mix_q_c121_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c121_2 (mix_i_c121_2 0) resistor r=1G
RMIXQ_c121_2 (mix_q_c121_2 0) resistor r=1G
RINTI_c121_2 (mix_i_c121_2 Icar_c121_2) resistor r=1k
CINTI_c121_2 (Icar_c121_2 0) capacitor c=80p
RINTQ_c121_2 (mix_q_c121_2 Qcar_c121_2) resistor r=1k
CINTQ_c121_2 (Qcar_c121_2 0) capacitor c=80p

// bl121, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c121_3 (bl121 n_cbpf_c121_3) capacitor c=2.533029591058e-14
LBPF_c121_3 (n_cbpf_c121_3 bpf_c121_3) inductor l=1.000000000000e-06
RBPF_c121_3 (bpf_c121_3 0) resistor r=3.141592653590e+02
EMIXI_c121_3_00 (mix_i_src_c121_3_00 0 bpf_c121_3 0) vcvs gain=9.807852804032e-01
SMIXI_c121_3_00 (mix_i_src_c121_3_00 mix_i_c121_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_00 (mix_q_src_c121_3_00 0 bpf_c121_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_3_00 (mix_q_src_c121_3_00 mix_q_c121_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_01 (mix_i_src_c121_3_01 0 bpf_c121_3 0) vcvs gain=8.314696123025e-01
SMIXI_c121_3_01 (mix_i_src_c121_3_01 mix_i_c121_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_01 (mix_q_src_c121_3_01 0 bpf_c121_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_3_01 (mix_q_src_c121_3_01 mix_q_c121_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_02 (mix_i_src_c121_3_02 0 bpf_c121_3 0) vcvs gain=5.555702330196e-01
SMIXI_c121_3_02 (mix_i_src_c121_3_02 mix_i_c121_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_02 (mix_q_src_c121_3_02 0 bpf_c121_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_3_02 (mix_q_src_c121_3_02 mix_q_c121_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_03 (mix_i_src_c121_3_03 0 bpf_c121_3 0) vcvs gain=1.950903220161e-01
SMIXI_c121_3_03 (mix_i_src_c121_3_03 mix_i_c121_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_03 (mix_q_src_c121_3_03 0 bpf_c121_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_3_03 (mix_q_src_c121_3_03 mix_q_c121_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_04 (mix_i_src_c121_3_04 0 bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_3_04 (mix_i_src_c121_3_04 mix_i_c121_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_04 (mix_q_src_c121_3_04 0 bpf_c121_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c121_3_04 (mix_q_src_c121_3_04 mix_q_c121_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_05 (mix_i_src_c121_3_05 0 bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_3_05 (mix_i_src_c121_3_05 mix_i_c121_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_05 (mix_q_src_c121_3_05 0 bpf_c121_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c121_3_05 (mix_q_src_c121_3_05 mix_q_c121_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_06 (mix_i_src_c121_3_06 0 bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_3_06 (mix_i_src_c121_3_06 mix_i_c121_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_06 (mix_q_src_c121_3_06 0 bpf_c121_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c121_3_06 (mix_q_src_c121_3_06 mix_q_c121_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_07 (mix_i_src_c121_3_07 0 bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_3_07 (mix_i_src_c121_3_07 mix_i_c121_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_07 (mix_q_src_c121_3_07 0 bpf_c121_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c121_3_07 (mix_q_src_c121_3_07 mix_q_c121_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_08 (mix_i_src_c121_3_08 0 bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c121_3_08 (mix_i_src_c121_3_08 mix_i_c121_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_08 (mix_q_src_c121_3_08 0 bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_3_08 (mix_q_src_c121_3_08 mix_q_c121_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_09 (mix_i_src_c121_3_09 0 bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c121_3_09 (mix_i_src_c121_3_09 mix_i_c121_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_09 (mix_q_src_c121_3_09 0 bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_3_09 (mix_q_src_c121_3_09 mix_q_c121_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_10 (mix_i_src_c121_3_10 0 bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c121_3_10 (mix_i_src_c121_3_10 mix_i_c121_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_10 (mix_q_src_c121_3_10 0 bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_3_10 (mix_q_src_c121_3_10 mix_q_c121_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_11 (mix_i_src_c121_3_11 0 bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c121_3_11 (mix_i_src_c121_3_11 mix_i_c121_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_11 (mix_q_src_c121_3_11 0 bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_3_11 (mix_q_src_c121_3_11 mix_q_c121_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_12 (mix_i_src_c121_3_12 0 bpf_c121_3 0) vcvs gain=1.950903220161e-01
SMIXI_c121_3_12 (mix_i_src_c121_3_12 mix_i_c121_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_12 (mix_q_src_c121_3_12 0 bpf_c121_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c121_3_12 (mix_q_src_c121_3_12 mix_q_c121_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_13 (mix_i_src_c121_3_13 0 bpf_c121_3 0) vcvs gain=5.555702330196e-01
SMIXI_c121_3_13 (mix_i_src_c121_3_13 mix_i_c121_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_13 (mix_q_src_c121_3_13 0 bpf_c121_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c121_3_13 (mix_q_src_c121_3_13 mix_q_c121_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_14 (mix_i_src_c121_3_14 0 bpf_c121_3 0) vcvs gain=8.314696123025e-01
SMIXI_c121_3_14 (mix_i_src_c121_3_14 mix_i_c121_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_14 (mix_q_src_c121_3_14 0 bpf_c121_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c121_3_14 (mix_q_src_c121_3_14 mix_q_c121_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c121_3_15 (mix_i_src_c121_3_15 0 bpf_c121_3 0) vcvs gain=9.807852804032e-01
SMIXI_c121_3_15 (mix_i_src_c121_3_15 mix_i_c121_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c121_3_15 (mix_q_src_c121_3_15 0 bpf_c121_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c121_3_15 (mix_q_src_c121_3_15 mix_q_c121_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c121_3 (mix_i_c121_3 0) resistor r=1G
RMIXQ_c121_3 (mix_q_c121_3 0) resistor r=1G
RINTI_c121_3 (mix_i_c121_3 Icar_c121_3) resistor r=1k
CINTI_c121_3 (Icar_c121_3 0) capacitor c=80p
RINTQ_c121_3 (mix_q_c121_3 Qcar_c121_3) resistor r=1k
CINTQ_c121_3 (Qcar_c121_3 0) capacitor c=80p

// bl122, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c122_0 (bl122 n_cbpf_c122_0) capacitor c=4.052847345694e-13
LBPF_c122_0 (n_cbpf_c122_0 bpf_c122_0) inductor l=1.000000000000e-06
RBPF_c122_0 (bpf_c122_0 0) resistor r=7.853981633974e+01
EMIXI_c122_0_00 (mix_i_src_c122_0_00 0 bpf_c122_0 0) vcvs gain=9.807852804032e-01
SMIXI_c122_0_00 (mix_i_src_c122_0_00 mix_i_c122_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_00 (mix_q_src_c122_0_00 0 bpf_c122_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_0_00 (mix_q_src_c122_0_00 mix_q_c122_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_01 (mix_i_src_c122_0_01 0 bpf_c122_0 0) vcvs gain=8.314696123025e-01
SMIXI_c122_0_01 (mix_i_src_c122_0_01 mix_i_c122_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_01 (mix_q_src_c122_0_01 0 bpf_c122_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_0_01 (mix_q_src_c122_0_01 mix_q_c122_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_02 (mix_i_src_c122_0_02 0 bpf_c122_0 0) vcvs gain=5.555702330196e-01
SMIXI_c122_0_02 (mix_i_src_c122_0_02 mix_i_c122_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_02 (mix_q_src_c122_0_02 0 bpf_c122_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_0_02 (mix_q_src_c122_0_02 mix_q_c122_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_03 (mix_i_src_c122_0_03 0 bpf_c122_0 0) vcvs gain=1.950903220161e-01
SMIXI_c122_0_03 (mix_i_src_c122_0_03 mix_i_c122_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_03 (mix_q_src_c122_0_03 0 bpf_c122_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_0_03 (mix_q_src_c122_0_03 mix_q_c122_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_04 (mix_i_src_c122_0_04 0 bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_0_04 (mix_i_src_c122_0_04 mix_i_c122_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_04 (mix_q_src_c122_0_04 0 bpf_c122_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_0_04 (mix_q_src_c122_0_04 mix_q_c122_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_05 (mix_i_src_c122_0_05 0 bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_0_05 (mix_i_src_c122_0_05 mix_i_c122_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_05 (mix_q_src_c122_0_05 0 bpf_c122_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_0_05 (mix_q_src_c122_0_05 mix_q_c122_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_06 (mix_i_src_c122_0_06 0 bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_0_06 (mix_i_src_c122_0_06 mix_i_c122_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_06 (mix_q_src_c122_0_06 0 bpf_c122_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_0_06 (mix_q_src_c122_0_06 mix_q_c122_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_07 (mix_i_src_c122_0_07 0 bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_0_07 (mix_i_src_c122_0_07 mix_i_c122_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_07 (mix_q_src_c122_0_07 0 bpf_c122_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_0_07 (mix_q_src_c122_0_07 mix_q_c122_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_08 (mix_i_src_c122_0_08 0 bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_0_08 (mix_i_src_c122_0_08 mix_i_c122_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_08 (mix_q_src_c122_0_08 0 bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_0_08 (mix_q_src_c122_0_08 mix_q_c122_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_09 (mix_i_src_c122_0_09 0 bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_0_09 (mix_i_src_c122_0_09 mix_i_c122_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_09 (mix_q_src_c122_0_09 0 bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_0_09 (mix_q_src_c122_0_09 mix_q_c122_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_10 (mix_i_src_c122_0_10 0 bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_0_10 (mix_i_src_c122_0_10 mix_i_c122_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_10 (mix_q_src_c122_0_10 0 bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_0_10 (mix_q_src_c122_0_10 mix_q_c122_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_11 (mix_i_src_c122_0_11 0 bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_0_11 (mix_i_src_c122_0_11 mix_i_c122_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_11 (mix_q_src_c122_0_11 0 bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_0_11 (mix_q_src_c122_0_11 mix_q_c122_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_12 (mix_i_src_c122_0_12 0 bpf_c122_0 0) vcvs gain=1.950903220161e-01
SMIXI_c122_0_12 (mix_i_src_c122_0_12 mix_i_c122_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_12 (mix_q_src_c122_0_12 0 bpf_c122_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_0_12 (mix_q_src_c122_0_12 mix_q_c122_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_13 (mix_i_src_c122_0_13 0 bpf_c122_0 0) vcvs gain=5.555702330196e-01
SMIXI_c122_0_13 (mix_i_src_c122_0_13 mix_i_c122_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_13 (mix_q_src_c122_0_13 0 bpf_c122_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_0_13 (mix_q_src_c122_0_13 mix_q_c122_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_14 (mix_i_src_c122_0_14 0 bpf_c122_0 0) vcvs gain=8.314696123025e-01
SMIXI_c122_0_14 (mix_i_src_c122_0_14 mix_i_c122_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_14 (mix_q_src_c122_0_14 0 bpf_c122_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_0_14 (mix_q_src_c122_0_14 mix_q_c122_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_0_15 (mix_i_src_c122_0_15 0 bpf_c122_0 0) vcvs gain=9.807852804032e-01
SMIXI_c122_0_15 (mix_i_src_c122_0_15 mix_i_c122_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_0_15 (mix_q_src_c122_0_15 0 bpf_c122_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_0_15 (mix_q_src_c122_0_15 mix_q_c122_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c122_0 (mix_i_c122_0 0) resistor r=1G
RMIXQ_c122_0 (mix_q_c122_0 0) resistor r=1G
RINTI_c122_0 (mix_i_c122_0 Icar_c122_0) resistor r=1k
CINTI_c122_0 (Icar_c122_0 0) capacitor c=80p
RINTQ_c122_0 (mix_q_c122_0 Qcar_c122_0) resistor r=1k
CINTQ_c122_0 (Qcar_c122_0 0) capacitor c=80p

// bl122, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c122_1 (bl122 n_cbpf_c122_1) capacitor c=1.013211836423e-13
LBPF_c122_1 (n_cbpf_c122_1 bpf_c122_1) inductor l=1.000000000000e-06
RBPF_c122_1 (bpf_c122_1 0) resistor r=1.570796326795e+02
EMIXI_c122_1_00 (mix_i_src_c122_1_00 0 bpf_c122_1 0) vcvs gain=9.807852804032e-01
SMIXI_c122_1_00 (mix_i_src_c122_1_00 mix_i_c122_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_00 (mix_q_src_c122_1_00 0 bpf_c122_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_1_00 (mix_q_src_c122_1_00 mix_q_c122_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_01 (mix_i_src_c122_1_01 0 bpf_c122_1 0) vcvs gain=8.314696123025e-01
SMIXI_c122_1_01 (mix_i_src_c122_1_01 mix_i_c122_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_01 (mix_q_src_c122_1_01 0 bpf_c122_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_1_01 (mix_q_src_c122_1_01 mix_q_c122_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_02 (mix_i_src_c122_1_02 0 bpf_c122_1 0) vcvs gain=5.555702330196e-01
SMIXI_c122_1_02 (mix_i_src_c122_1_02 mix_i_c122_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_02 (mix_q_src_c122_1_02 0 bpf_c122_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_1_02 (mix_q_src_c122_1_02 mix_q_c122_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_03 (mix_i_src_c122_1_03 0 bpf_c122_1 0) vcvs gain=1.950903220161e-01
SMIXI_c122_1_03 (mix_i_src_c122_1_03 mix_i_c122_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_03 (mix_q_src_c122_1_03 0 bpf_c122_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_1_03 (mix_q_src_c122_1_03 mix_q_c122_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_04 (mix_i_src_c122_1_04 0 bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_1_04 (mix_i_src_c122_1_04 mix_i_c122_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_04 (mix_q_src_c122_1_04 0 bpf_c122_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_1_04 (mix_q_src_c122_1_04 mix_q_c122_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_05 (mix_i_src_c122_1_05 0 bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_1_05 (mix_i_src_c122_1_05 mix_i_c122_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_05 (mix_q_src_c122_1_05 0 bpf_c122_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_1_05 (mix_q_src_c122_1_05 mix_q_c122_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_06 (mix_i_src_c122_1_06 0 bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_1_06 (mix_i_src_c122_1_06 mix_i_c122_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_06 (mix_q_src_c122_1_06 0 bpf_c122_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_1_06 (mix_q_src_c122_1_06 mix_q_c122_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_07 (mix_i_src_c122_1_07 0 bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_1_07 (mix_i_src_c122_1_07 mix_i_c122_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_07 (mix_q_src_c122_1_07 0 bpf_c122_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_1_07 (mix_q_src_c122_1_07 mix_q_c122_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_08 (mix_i_src_c122_1_08 0 bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_1_08 (mix_i_src_c122_1_08 mix_i_c122_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_08 (mix_q_src_c122_1_08 0 bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_1_08 (mix_q_src_c122_1_08 mix_q_c122_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_09 (mix_i_src_c122_1_09 0 bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_1_09 (mix_i_src_c122_1_09 mix_i_c122_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_09 (mix_q_src_c122_1_09 0 bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_1_09 (mix_q_src_c122_1_09 mix_q_c122_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_10 (mix_i_src_c122_1_10 0 bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_1_10 (mix_i_src_c122_1_10 mix_i_c122_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_10 (mix_q_src_c122_1_10 0 bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_1_10 (mix_q_src_c122_1_10 mix_q_c122_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_11 (mix_i_src_c122_1_11 0 bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_1_11 (mix_i_src_c122_1_11 mix_i_c122_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_11 (mix_q_src_c122_1_11 0 bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_1_11 (mix_q_src_c122_1_11 mix_q_c122_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_12 (mix_i_src_c122_1_12 0 bpf_c122_1 0) vcvs gain=1.950903220161e-01
SMIXI_c122_1_12 (mix_i_src_c122_1_12 mix_i_c122_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_12 (mix_q_src_c122_1_12 0 bpf_c122_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_1_12 (mix_q_src_c122_1_12 mix_q_c122_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_13 (mix_i_src_c122_1_13 0 bpf_c122_1 0) vcvs gain=5.555702330196e-01
SMIXI_c122_1_13 (mix_i_src_c122_1_13 mix_i_c122_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_13 (mix_q_src_c122_1_13 0 bpf_c122_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_1_13 (mix_q_src_c122_1_13 mix_q_c122_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_14 (mix_i_src_c122_1_14 0 bpf_c122_1 0) vcvs gain=8.314696123025e-01
SMIXI_c122_1_14 (mix_i_src_c122_1_14 mix_i_c122_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_14 (mix_q_src_c122_1_14 0 bpf_c122_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_1_14 (mix_q_src_c122_1_14 mix_q_c122_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_1_15 (mix_i_src_c122_1_15 0 bpf_c122_1 0) vcvs gain=9.807852804032e-01
SMIXI_c122_1_15 (mix_i_src_c122_1_15 mix_i_c122_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_1_15 (mix_q_src_c122_1_15 0 bpf_c122_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_1_15 (mix_q_src_c122_1_15 mix_q_c122_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c122_1 (mix_i_c122_1 0) resistor r=1G
RMIXQ_c122_1 (mix_q_c122_1 0) resistor r=1G
RINTI_c122_1 (mix_i_c122_1 Icar_c122_1) resistor r=1k
CINTI_c122_1 (Icar_c122_1 0) capacitor c=80p
RINTQ_c122_1 (mix_q_c122_1 Qcar_c122_1) resistor r=1k
CINTQ_c122_1 (Qcar_c122_1 0) capacitor c=80p

// bl122, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c122_2 (bl122 n_cbpf_c122_2) capacitor c=4.503163717437e-14
LBPF_c122_2 (n_cbpf_c122_2 bpf_c122_2) inductor l=1.000000000000e-06
RBPF_c122_2 (bpf_c122_2 0) resistor r=2.356194490192e+02
EMIXI_c122_2_00 (mix_i_src_c122_2_00 0 bpf_c122_2 0) vcvs gain=9.807852804032e-01
SMIXI_c122_2_00 (mix_i_src_c122_2_00 mix_i_c122_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_00 (mix_q_src_c122_2_00 0 bpf_c122_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_2_00 (mix_q_src_c122_2_00 mix_q_c122_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_01 (mix_i_src_c122_2_01 0 bpf_c122_2 0) vcvs gain=8.314696123025e-01
SMIXI_c122_2_01 (mix_i_src_c122_2_01 mix_i_c122_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_01 (mix_q_src_c122_2_01 0 bpf_c122_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_2_01 (mix_q_src_c122_2_01 mix_q_c122_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_02 (mix_i_src_c122_2_02 0 bpf_c122_2 0) vcvs gain=5.555702330196e-01
SMIXI_c122_2_02 (mix_i_src_c122_2_02 mix_i_c122_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_02 (mix_q_src_c122_2_02 0 bpf_c122_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_2_02 (mix_q_src_c122_2_02 mix_q_c122_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_03 (mix_i_src_c122_2_03 0 bpf_c122_2 0) vcvs gain=1.950903220161e-01
SMIXI_c122_2_03 (mix_i_src_c122_2_03 mix_i_c122_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_03 (mix_q_src_c122_2_03 0 bpf_c122_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_2_03 (mix_q_src_c122_2_03 mix_q_c122_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_04 (mix_i_src_c122_2_04 0 bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_2_04 (mix_i_src_c122_2_04 mix_i_c122_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_04 (mix_q_src_c122_2_04 0 bpf_c122_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_2_04 (mix_q_src_c122_2_04 mix_q_c122_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_05 (mix_i_src_c122_2_05 0 bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_2_05 (mix_i_src_c122_2_05 mix_i_c122_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_05 (mix_q_src_c122_2_05 0 bpf_c122_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_2_05 (mix_q_src_c122_2_05 mix_q_c122_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_06 (mix_i_src_c122_2_06 0 bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_2_06 (mix_i_src_c122_2_06 mix_i_c122_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_06 (mix_q_src_c122_2_06 0 bpf_c122_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_2_06 (mix_q_src_c122_2_06 mix_q_c122_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_07 (mix_i_src_c122_2_07 0 bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_2_07 (mix_i_src_c122_2_07 mix_i_c122_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_07 (mix_q_src_c122_2_07 0 bpf_c122_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_2_07 (mix_q_src_c122_2_07 mix_q_c122_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_08 (mix_i_src_c122_2_08 0 bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_2_08 (mix_i_src_c122_2_08 mix_i_c122_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_08 (mix_q_src_c122_2_08 0 bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_2_08 (mix_q_src_c122_2_08 mix_q_c122_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_09 (mix_i_src_c122_2_09 0 bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_2_09 (mix_i_src_c122_2_09 mix_i_c122_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_09 (mix_q_src_c122_2_09 0 bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_2_09 (mix_q_src_c122_2_09 mix_q_c122_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_10 (mix_i_src_c122_2_10 0 bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_2_10 (mix_i_src_c122_2_10 mix_i_c122_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_10 (mix_q_src_c122_2_10 0 bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_2_10 (mix_q_src_c122_2_10 mix_q_c122_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_11 (mix_i_src_c122_2_11 0 bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_2_11 (mix_i_src_c122_2_11 mix_i_c122_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_11 (mix_q_src_c122_2_11 0 bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_2_11 (mix_q_src_c122_2_11 mix_q_c122_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_12 (mix_i_src_c122_2_12 0 bpf_c122_2 0) vcvs gain=1.950903220161e-01
SMIXI_c122_2_12 (mix_i_src_c122_2_12 mix_i_c122_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_12 (mix_q_src_c122_2_12 0 bpf_c122_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_2_12 (mix_q_src_c122_2_12 mix_q_c122_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_13 (mix_i_src_c122_2_13 0 bpf_c122_2 0) vcvs gain=5.555702330196e-01
SMIXI_c122_2_13 (mix_i_src_c122_2_13 mix_i_c122_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_13 (mix_q_src_c122_2_13 0 bpf_c122_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_2_13 (mix_q_src_c122_2_13 mix_q_c122_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_14 (mix_i_src_c122_2_14 0 bpf_c122_2 0) vcvs gain=8.314696123025e-01
SMIXI_c122_2_14 (mix_i_src_c122_2_14 mix_i_c122_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_14 (mix_q_src_c122_2_14 0 bpf_c122_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_2_14 (mix_q_src_c122_2_14 mix_q_c122_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_2_15 (mix_i_src_c122_2_15 0 bpf_c122_2 0) vcvs gain=9.807852804032e-01
SMIXI_c122_2_15 (mix_i_src_c122_2_15 mix_i_c122_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_2_15 (mix_q_src_c122_2_15 0 bpf_c122_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_2_15 (mix_q_src_c122_2_15 mix_q_c122_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c122_2 (mix_i_c122_2 0) resistor r=1G
RMIXQ_c122_2 (mix_q_c122_2 0) resistor r=1G
RINTI_c122_2 (mix_i_c122_2 Icar_c122_2) resistor r=1k
CINTI_c122_2 (Icar_c122_2 0) capacitor c=80p
RINTQ_c122_2 (mix_q_c122_2 Qcar_c122_2) resistor r=1k
CINTQ_c122_2 (Qcar_c122_2 0) capacitor c=80p

// bl122, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c122_3 (bl122 n_cbpf_c122_3) capacitor c=2.533029591058e-14
LBPF_c122_3 (n_cbpf_c122_3 bpf_c122_3) inductor l=1.000000000000e-06
RBPF_c122_3 (bpf_c122_3 0) resistor r=3.141592653590e+02
EMIXI_c122_3_00 (mix_i_src_c122_3_00 0 bpf_c122_3 0) vcvs gain=9.807852804032e-01
SMIXI_c122_3_00 (mix_i_src_c122_3_00 mix_i_c122_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_00 (mix_q_src_c122_3_00 0 bpf_c122_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_3_00 (mix_q_src_c122_3_00 mix_q_c122_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_01 (mix_i_src_c122_3_01 0 bpf_c122_3 0) vcvs gain=8.314696123025e-01
SMIXI_c122_3_01 (mix_i_src_c122_3_01 mix_i_c122_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_01 (mix_q_src_c122_3_01 0 bpf_c122_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_3_01 (mix_q_src_c122_3_01 mix_q_c122_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_02 (mix_i_src_c122_3_02 0 bpf_c122_3 0) vcvs gain=5.555702330196e-01
SMIXI_c122_3_02 (mix_i_src_c122_3_02 mix_i_c122_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_02 (mix_q_src_c122_3_02 0 bpf_c122_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_3_02 (mix_q_src_c122_3_02 mix_q_c122_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_03 (mix_i_src_c122_3_03 0 bpf_c122_3 0) vcvs gain=1.950903220161e-01
SMIXI_c122_3_03 (mix_i_src_c122_3_03 mix_i_c122_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_03 (mix_q_src_c122_3_03 0 bpf_c122_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_3_03 (mix_q_src_c122_3_03 mix_q_c122_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_04 (mix_i_src_c122_3_04 0 bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_3_04 (mix_i_src_c122_3_04 mix_i_c122_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_04 (mix_q_src_c122_3_04 0 bpf_c122_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c122_3_04 (mix_q_src_c122_3_04 mix_q_c122_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_05 (mix_i_src_c122_3_05 0 bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_3_05 (mix_i_src_c122_3_05 mix_i_c122_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_05 (mix_q_src_c122_3_05 0 bpf_c122_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c122_3_05 (mix_q_src_c122_3_05 mix_q_c122_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_06 (mix_i_src_c122_3_06 0 bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_3_06 (mix_i_src_c122_3_06 mix_i_c122_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_06 (mix_q_src_c122_3_06 0 bpf_c122_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c122_3_06 (mix_q_src_c122_3_06 mix_q_c122_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_07 (mix_i_src_c122_3_07 0 bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_3_07 (mix_i_src_c122_3_07 mix_i_c122_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_07 (mix_q_src_c122_3_07 0 bpf_c122_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c122_3_07 (mix_q_src_c122_3_07 mix_q_c122_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_08 (mix_i_src_c122_3_08 0 bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c122_3_08 (mix_i_src_c122_3_08 mix_i_c122_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_08 (mix_q_src_c122_3_08 0 bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_3_08 (mix_q_src_c122_3_08 mix_q_c122_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_09 (mix_i_src_c122_3_09 0 bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c122_3_09 (mix_i_src_c122_3_09 mix_i_c122_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_09 (mix_q_src_c122_3_09 0 bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_3_09 (mix_q_src_c122_3_09 mix_q_c122_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_10 (mix_i_src_c122_3_10 0 bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c122_3_10 (mix_i_src_c122_3_10 mix_i_c122_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_10 (mix_q_src_c122_3_10 0 bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_3_10 (mix_q_src_c122_3_10 mix_q_c122_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_11 (mix_i_src_c122_3_11 0 bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c122_3_11 (mix_i_src_c122_3_11 mix_i_c122_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_11 (mix_q_src_c122_3_11 0 bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_3_11 (mix_q_src_c122_3_11 mix_q_c122_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_12 (mix_i_src_c122_3_12 0 bpf_c122_3 0) vcvs gain=1.950903220161e-01
SMIXI_c122_3_12 (mix_i_src_c122_3_12 mix_i_c122_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_12 (mix_q_src_c122_3_12 0 bpf_c122_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c122_3_12 (mix_q_src_c122_3_12 mix_q_c122_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_13 (mix_i_src_c122_3_13 0 bpf_c122_3 0) vcvs gain=5.555702330196e-01
SMIXI_c122_3_13 (mix_i_src_c122_3_13 mix_i_c122_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_13 (mix_q_src_c122_3_13 0 bpf_c122_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c122_3_13 (mix_q_src_c122_3_13 mix_q_c122_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_14 (mix_i_src_c122_3_14 0 bpf_c122_3 0) vcvs gain=8.314696123025e-01
SMIXI_c122_3_14 (mix_i_src_c122_3_14 mix_i_c122_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_14 (mix_q_src_c122_3_14 0 bpf_c122_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c122_3_14 (mix_q_src_c122_3_14 mix_q_c122_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c122_3_15 (mix_i_src_c122_3_15 0 bpf_c122_3 0) vcvs gain=9.807852804032e-01
SMIXI_c122_3_15 (mix_i_src_c122_3_15 mix_i_c122_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c122_3_15 (mix_q_src_c122_3_15 0 bpf_c122_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c122_3_15 (mix_q_src_c122_3_15 mix_q_c122_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c122_3 (mix_i_c122_3 0) resistor r=1G
RMIXQ_c122_3 (mix_q_c122_3 0) resistor r=1G
RINTI_c122_3 (mix_i_c122_3 Icar_c122_3) resistor r=1k
CINTI_c122_3 (Icar_c122_3 0) capacitor c=80p
RINTQ_c122_3 (mix_q_c122_3 Qcar_c122_3) resistor r=1k
CINTQ_c122_3 (Qcar_c122_3 0) capacitor c=80p

// bl123, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c123_0 (bl123 n_cbpf_c123_0) capacitor c=4.052847345694e-13
LBPF_c123_0 (n_cbpf_c123_0 bpf_c123_0) inductor l=1.000000000000e-06
RBPF_c123_0 (bpf_c123_0 0) resistor r=7.853981633974e+01
EMIXI_c123_0_00 (mix_i_src_c123_0_00 0 bpf_c123_0 0) vcvs gain=9.807852804032e-01
SMIXI_c123_0_00 (mix_i_src_c123_0_00 mix_i_c123_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_00 (mix_q_src_c123_0_00 0 bpf_c123_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_0_00 (mix_q_src_c123_0_00 mix_q_c123_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_01 (mix_i_src_c123_0_01 0 bpf_c123_0 0) vcvs gain=8.314696123025e-01
SMIXI_c123_0_01 (mix_i_src_c123_0_01 mix_i_c123_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_01 (mix_q_src_c123_0_01 0 bpf_c123_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_0_01 (mix_q_src_c123_0_01 mix_q_c123_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_02 (mix_i_src_c123_0_02 0 bpf_c123_0 0) vcvs gain=5.555702330196e-01
SMIXI_c123_0_02 (mix_i_src_c123_0_02 mix_i_c123_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_02 (mix_q_src_c123_0_02 0 bpf_c123_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_0_02 (mix_q_src_c123_0_02 mix_q_c123_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_03 (mix_i_src_c123_0_03 0 bpf_c123_0 0) vcvs gain=1.950903220161e-01
SMIXI_c123_0_03 (mix_i_src_c123_0_03 mix_i_c123_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_03 (mix_q_src_c123_0_03 0 bpf_c123_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_0_03 (mix_q_src_c123_0_03 mix_q_c123_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_04 (mix_i_src_c123_0_04 0 bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_0_04 (mix_i_src_c123_0_04 mix_i_c123_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_04 (mix_q_src_c123_0_04 0 bpf_c123_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_0_04 (mix_q_src_c123_0_04 mix_q_c123_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_05 (mix_i_src_c123_0_05 0 bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_0_05 (mix_i_src_c123_0_05 mix_i_c123_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_05 (mix_q_src_c123_0_05 0 bpf_c123_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_0_05 (mix_q_src_c123_0_05 mix_q_c123_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_06 (mix_i_src_c123_0_06 0 bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_0_06 (mix_i_src_c123_0_06 mix_i_c123_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_06 (mix_q_src_c123_0_06 0 bpf_c123_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_0_06 (mix_q_src_c123_0_06 mix_q_c123_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_07 (mix_i_src_c123_0_07 0 bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_0_07 (mix_i_src_c123_0_07 mix_i_c123_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_07 (mix_q_src_c123_0_07 0 bpf_c123_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_0_07 (mix_q_src_c123_0_07 mix_q_c123_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_08 (mix_i_src_c123_0_08 0 bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_0_08 (mix_i_src_c123_0_08 mix_i_c123_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_08 (mix_q_src_c123_0_08 0 bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_0_08 (mix_q_src_c123_0_08 mix_q_c123_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_09 (mix_i_src_c123_0_09 0 bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_0_09 (mix_i_src_c123_0_09 mix_i_c123_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_09 (mix_q_src_c123_0_09 0 bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_0_09 (mix_q_src_c123_0_09 mix_q_c123_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_10 (mix_i_src_c123_0_10 0 bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_0_10 (mix_i_src_c123_0_10 mix_i_c123_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_10 (mix_q_src_c123_0_10 0 bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_0_10 (mix_q_src_c123_0_10 mix_q_c123_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_11 (mix_i_src_c123_0_11 0 bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_0_11 (mix_i_src_c123_0_11 mix_i_c123_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_11 (mix_q_src_c123_0_11 0 bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_0_11 (mix_q_src_c123_0_11 mix_q_c123_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_12 (mix_i_src_c123_0_12 0 bpf_c123_0 0) vcvs gain=1.950903220161e-01
SMIXI_c123_0_12 (mix_i_src_c123_0_12 mix_i_c123_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_12 (mix_q_src_c123_0_12 0 bpf_c123_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_0_12 (mix_q_src_c123_0_12 mix_q_c123_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_13 (mix_i_src_c123_0_13 0 bpf_c123_0 0) vcvs gain=5.555702330196e-01
SMIXI_c123_0_13 (mix_i_src_c123_0_13 mix_i_c123_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_13 (mix_q_src_c123_0_13 0 bpf_c123_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_0_13 (mix_q_src_c123_0_13 mix_q_c123_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_14 (mix_i_src_c123_0_14 0 bpf_c123_0 0) vcvs gain=8.314696123025e-01
SMIXI_c123_0_14 (mix_i_src_c123_0_14 mix_i_c123_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_14 (mix_q_src_c123_0_14 0 bpf_c123_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_0_14 (mix_q_src_c123_0_14 mix_q_c123_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_0_15 (mix_i_src_c123_0_15 0 bpf_c123_0 0) vcvs gain=9.807852804032e-01
SMIXI_c123_0_15 (mix_i_src_c123_0_15 mix_i_c123_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_0_15 (mix_q_src_c123_0_15 0 bpf_c123_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_0_15 (mix_q_src_c123_0_15 mix_q_c123_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c123_0 (mix_i_c123_0 0) resistor r=1G
RMIXQ_c123_0 (mix_q_c123_0 0) resistor r=1G
RINTI_c123_0 (mix_i_c123_0 Icar_c123_0) resistor r=1k
CINTI_c123_0 (Icar_c123_0 0) capacitor c=80p
RINTQ_c123_0 (mix_q_c123_0 Qcar_c123_0) resistor r=1k
CINTQ_c123_0 (Qcar_c123_0 0) capacitor c=80p

// bl123, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c123_1 (bl123 n_cbpf_c123_1) capacitor c=1.013211836423e-13
LBPF_c123_1 (n_cbpf_c123_1 bpf_c123_1) inductor l=1.000000000000e-06
RBPF_c123_1 (bpf_c123_1 0) resistor r=1.570796326795e+02
EMIXI_c123_1_00 (mix_i_src_c123_1_00 0 bpf_c123_1 0) vcvs gain=9.807852804032e-01
SMIXI_c123_1_00 (mix_i_src_c123_1_00 mix_i_c123_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_00 (mix_q_src_c123_1_00 0 bpf_c123_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_1_00 (mix_q_src_c123_1_00 mix_q_c123_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_01 (mix_i_src_c123_1_01 0 bpf_c123_1 0) vcvs gain=8.314696123025e-01
SMIXI_c123_1_01 (mix_i_src_c123_1_01 mix_i_c123_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_01 (mix_q_src_c123_1_01 0 bpf_c123_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_1_01 (mix_q_src_c123_1_01 mix_q_c123_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_02 (mix_i_src_c123_1_02 0 bpf_c123_1 0) vcvs gain=5.555702330196e-01
SMIXI_c123_1_02 (mix_i_src_c123_1_02 mix_i_c123_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_02 (mix_q_src_c123_1_02 0 bpf_c123_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_1_02 (mix_q_src_c123_1_02 mix_q_c123_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_03 (mix_i_src_c123_1_03 0 bpf_c123_1 0) vcvs gain=1.950903220161e-01
SMIXI_c123_1_03 (mix_i_src_c123_1_03 mix_i_c123_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_03 (mix_q_src_c123_1_03 0 bpf_c123_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_1_03 (mix_q_src_c123_1_03 mix_q_c123_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_04 (mix_i_src_c123_1_04 0 bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_1_04 (mix_i_src_c123_1_04 mix_i_c123_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_04 (mix_q_src_c123_1_04 0 bpf_c123_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_1_04 (mix_q_src_c123_1_04 mix_q_c123_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_05 (mix_i_src_c123_1_05 0 bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_1_05 (mix_i_src_c123_1_05 mix_i_c123_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_05 (mix_q_src_c123_1_05 0 bpf_c123_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_1_05 (mix_q_src_c123_1_05 mix_q_c123_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_06 (mix_i_src_c123_1_06 0 bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_1_06 (mix_i_src_c123_1_06 mix_i_c123_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_06 (mix_q_src_c123_1_06 0 bpf_c123_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_1_06 (mix_q_src_c123_1_06 mix_q_c123_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_07 (mix_i_src_c123_1_07 0 bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_1_07 (mix_i_src_c123_1_07 mix_i_c123_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_07 (mix_q_src_c123_1_07 0 bpf_c123_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_1_07 (mix_q_src_c123_1_07 mix_q_c123_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_08 (mix_i_src_c123_1_08 0 bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_1_08 (mix_i_src_c123_1_08 mix_i_c123_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_08 (mix_q_src_c123_1_08 0 bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_1_08 (mix_q_src_c123_1_08 mix_q_c123_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_09 (mix_i_src_c123_1_09 0 bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_1_09 (mix_i_src_c123_1_09 mix_i_c123_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_09 (mix_q_src_c123_1_09 0 bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_1_09 (mix_q_src_c123_1_09 mix_q_c123_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_10 (mix_i_src_c123_1_10 0 bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_1_10 (mix_i_src_c123_1_10 mix_i_c123_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_10 (mix_q_src_c123_1_10 0 bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_1_10 (mix_q_src_c123_1_10 mix_q_c123_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_11 (mix_i_src_c123_1_11 0 bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_1_11 (mix_i_src_c123_1_11 mix_i_c123_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_11 (mix_q_src_c123_1_11 0 bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_1_11 (mix_q_src_c123_1_11 mix_q_c123_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_12 (mix_i_src_c123_1_12 0 bpf_c123_1 0) vcvs gain=1.950903220161e-01
SMIXI_c123_1_12 (mix_i_src_c123_1_12 mix_i_c123_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_12 (mix_q_src_c123_1_12 0 bpf_c123_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_1_12 (mix_q_src_c123_1_12 mix_q_c123_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_13 (mix_i_src_c123_1_13 0 bpf_c123_1 0) vcvs gain=5.555702330196e-01
SMIXI_c123_1_13 (mix_i_src_c123_1_13 mix_i_c123_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_13 (mix_q_src_c123_1_13 0 bpf_c123_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_1_13 (mix_q_src_c123_1_13 mix_q_c123_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_14 (mix_i_src_c123_1_14 0 bpf_c123_1 0) vcvs gain=8.314696123025e-01
SMIXI_c123_1_14 (mix_i_src_c123_1_14 mix_i_c123_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_14 (mix_q_src_c123_1_14 0 bpf_c123_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_1_14 (mix_q_src_c123_1_14 mix_q_c123_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_1_15 (mix_i_src_c123_1_15 0 bpf_c123_1 0) vcvs gain=9.807852804032e-01
SMIXI_c123_1_15 (mix_i_src_c123_1_15 mix_i_c123_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_1_15 (mix_q_src_c123_1_15 0 bpf_c123_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_1_15 (mix_q_src_c123_1_15 mix_q_c123_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c123_1 (mix_i_c123_1 0) resistor r=1G
RMIXQ_c123_1 (mix_q_c123_1 0) resistor r=1G
RINTI_c123_1 (mix_i_c123_1 Icar_c123_1) resistor r=1k
CINTI_c123_1 (Icar_c123_1 0) capacitor c=80p
RINTQ_c123_1 (mix_q_c123_1 Qcar_c123_1) resistor r=1k
CINTQ_c123_1 (Qcar_c123_1 0) capacitor c=80p

// bl123, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c123_2 (bl123 n_cbpf_c123_2) capacitor c=4.503163717437e-14
LBPF_c123_2 (n_cbpf_c123_2 bpf_c123_2) inductor l=1.000000000000e-06
RBPF_c123_2 (bpf_c123_2 0) resistor r=2.356194490192e+02
EMIXI_c123_2_00 (mix_i_src_c123_2_00 0 bpf_c123_2 0) vcvs gain=9.807852804032e-01
SMIXI_c123_2_00 (mix_i_src_c123_2_00 mix_i_c123_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_00 (mix_q_src_c123_2_00 0 bpf_c123_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_2_00 (mix_q_src_c123_2_00 mix_q_c123_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_01 (mix_i_src_c123_2_01 0 bpf_c123_2 0) vcvs gain=8.314696123025e-01
SMIXI_c123_2_01 (mix_i_src_c123_2_01 mix_i_c123_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_01 (mix_q_src_c123_2_01 0 bpf_c123_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_2_01 (mix_q_src_c123_2_01 mix_q_c123_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_02 (mix_i_src_c123_2_02 0 bpf_c123_2 0) vcvs gain=5.555702330196e-01
SMIXI_c123_2_02 (mix_i_src_c123_2_02 mix_i_c123_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_02 (mix_q_src_c123_2_02 0 bpf_c123_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_2_02 (mix_q_src_c123_2_02 mix_q_c123_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_03 (mix_i_src_c123_2_03 0 bpf_c123_2 0) vcvs gain=1.950903220161e-01
SMIXI_c123_2_03 (mix_i_src_c123_2_03 mix_i_c123_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_03 (mix_q_src_c123_2_03 0 bpf_c123_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_2_03 (mix_q_src_c123_2_03 mix_q_c123_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_04 (mix_i_src_c123_2_04 0 bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_2_04 (mix_i_src_c123_2_04 mix_i_c123_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_04 (mix_q_src_c123_2_04 0 bpf_c123_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_2_04 (mix_q_src_c123_2_04 mix_q_c123_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_05 (mix_i_src_c123_2_05 0 bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_2_05 (mix_i_src_c123_2_05 mix_i_c123_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_05 (mix_q_src_c123_2_05 0 bpf_c123_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_2_05 (mix_q_src_c123_2_05 mix_q_c123_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_06 (mix_i_src_c123_2_06 0 bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_2_06 (mix_i_src_c123_2_06 mix_i_c123_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_06 (mix_q_src_c123_2_06 0 bpf_c123_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_2_06 (mix_q_src_c123_2_06 mix_q_c123_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_07 (mix_i_src_c123_2_07 0 bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_2_07 (mix_i_src_c123_2_07 mix_i_c123_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_07 (mix_q_src_c123_2_07 0 bpf_c123_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_2_07 (mix_q_src_c123_2_07 mix_q_c123_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_08 (mix_i_src_c123_2_08 0 bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_2_08 (mix_i_src_c123_2_08 mix_i_c123_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_08 (mix_q_src_c123_2_08 0 bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_2_08 (mix_q_src_c123_2_08 mix_q_c123_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_09 (mix_i_src_c123_2_09 0 bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_2_09 (mix_i_src_c123_2_09 mix_i_c123_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_09 (mix_q_src_c123_2_09 0 bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_2_09 (mix_q_src_c123_2_09 mix_q_c123_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_10 (mix_i_src_c123_2_10 0 bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_2_10 (mix_i_src_c123_2_10 mix_i_c123_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_10 (mix_q_src_c123_2_10 0 bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_2_10 (mix_q_src_c123_2_10 mix_q_c123_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_11 (mix_i_src_c123_2_11 0 bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_2_11 (mix_i_src_c123_2_11 mix_i_c123_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_11 (mix_q_src_c123_2_11 0 bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_2_11 (mix_q_src_c123_2_11 mix_q_c123_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_12 (mix_i_src_c123_2_12 0 bpf_c123_2 0) vcvs gain=1.950903220161e-01
SMIXI_c123_2_12 (mix_i_src_c123_2_12 mix_i_c123_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_12 (mix_q_src_c123_2_12 0 bpf_c123_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_2_12 (mix_q_src_c123_2_12 mix_q_c123_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_13 (mix_i_src_c123_2_13 0 bpf_c123_2 0) vcvs gain=5.555702330196e-01
SMIXI_c123_2_13 (mix_i_src_c123_2_13 mix_i_c123_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_13 (mix_q_src_c123_2_13 0 bpf_c123_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_2_13 (mix_q_src_c123_2_13 mix_q_c123_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_14 (mix_i_src_c123_2_14 0 bpf_c123_2 0) vcvs gain=8.314696123025e-01
SMIXI_c123_2_14 (mix_i_src_c123_2_14 mix_i_c123_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_14 (mix_q_src_c123_2_14 0 bpf_c123_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_2_14 (mix_q_src_c123_2_14 mix_q_c123_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_2_15 (mix_i_src_c123_2_15 0 bpf_c123_2 0) vcvs gain=9.807852804032e-01
SMIXI_c123_2_15 (mix_i_src_c123_2_15 mix_i_c123_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_2_15 (mix_q_src_c123_2_15 0 bpf_c123_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_2_15 (mix_q_src_c123_2_15 mix_q_c123_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c123_2 (mix_i_c123_2 0) resistor r=1G
RMIXQ_c123_2 (mix_q_c123_2 0) resistor r=1G
RINTI_c123_2 (mix_i_c123_2 Icar_c123_2) resistor r=1k
CINTI_c123_2 (Icar_c123_2 0) capacitor c=80p
RINTQ_c123_2 (mix_q_c123_2 Qcar_c123_2) resistor r=1k
CINTQ_c123_2 (Qcar_c123_2 0) capacitor c=80p

// bl123, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c123_3 (bl123 n_cbpf_c123_3) capacitor c=2.533029591058e-14
LBPF_c123_3 (n_cbpf_c123_3 bpf_c123_3) inductor l=1.000000000000e-06
RBPF_c123_3 (bpf_c123_3 0) resistor r=3.141592653590e+02
EMIXI_c123_3_00 (mix_i_src_c123_3_00 0 bpf_c123_3 0) vcvs gain=9.807852804032e-01
SMIXI_c123_3_00 (mix_i_src_c123_3_00 mix_i_c123_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_00 (mix_q_src_c123_3_00 0 bpf_c123_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_3_00 (mix_q_src_c123_3_00 mix_q_c123_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_01 (mix_i_src_c123_3_01 0 bpf_c123_3 0) vcvs gain=8.314696123025e-01
SMIXI_c123_3_01 (mix_i_src_c123_3_01 mix_i_c123_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_01 (mix_q_src_c123_3_01 0 bpf_c123_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_3_01 (mix_q_src_c123_3_01 mix_q_c123_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_02 (mix_i_src_c123_3_02 0 bpf_c123_3 0) vcvs gain=5.555702330196e-01
SMIXI_c123_3_02 (mix_i_src_c123_3_02 mix_i_c123_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_02 (mix_q_src_c123_3_02 0 bpf_c123_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_3_02 (mix_q_src_c123_3_02 mix_q_c123_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_03 (mix_i_src_c123_3_03 0 bpf_c123_3 0) vcvs gain=1.950903220161e-01
SMIXI_c123_3_03 (mix_i_src_c123_3_03 mix_i_c123_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_03 (mix_q_src_c123_3_03 0 bpf_c123_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_3_03 (mix_q_src_c123_3_03 mix_q_c123_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_04 (mix_i_src_c123_3_04 0 bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_3_04 (mix_i_src_c123_3_04 mix_i_c123_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_04 (mix_q_src_c123_3_04 0 bpf_c123_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c123_3_04 (mix_q_src_c123_3_04 mix_q_c123_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_05 (mix_i_src_c123_3_05 0 bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_3_05 (mix_i_src_c123_3_05 mix_i_c123_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_05 (mix_q_src_c123_3_05 0 bpf_c123_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c123_3_05 (mix_q_src_c123_3_05 mix_q_c123_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_06 (mix_i_src_c123_3_06 0 bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_3_06 (mix_i_src_c123_3_06 mix_i_c123_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_06 (mix_q_src_c123_3_06 0 bpf_c123_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c123_3_06 (mix_q_src_c123_3_06 mix_q_c123_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_07 (mix_i_src_c123_3_07 0 bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_3_07 (mix_i_src_c123_3_07 mix_i_c123_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_07 (mix_q_src_c123_3_07 0 bpf_c123_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c123_3_07 (mix_q_src_c123_3_07 mix_q_c123_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_08 (mix_i_src_c123_3_08 0 bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c123_3_08 (mix_i_src_c123_3_08 mix_i_c123_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_08 (mix_q_src_c123_3_08 0 bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_3_08 (mix_q_src_c123_3_08 mix_q_c123_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_09 (mix_i_src_c123_3_09 0 bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c123_3_09 (mix_i_src_c123_3_09 mix_i_c123_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_09 (mix_q_src_c123_3_09 0 bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_3_09 (mix_q_src_c123_3_09 mix_q_c123_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_10 (mix_i_src_c123_3_10 0 bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c123_3_10 (mix_i_src_c123_3_10 mix_i_c123_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_10 (mix_q_src_c123_3_10 0 bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_3_10 (mix_q_src_c123_3_10 mix_q_c123_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_11 (mix_i_src_c123_3_11 0 bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c123_3_11 (mix_i_src_c123_3_11 mix_i_c123_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_11 (mix_q_src_c123_3_11 0 bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_3_11 (mix_q_src_c123_3_11 mix_q_c123_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_12 (mix_i_src_c123_3_12 0 bpf_c123_3 0) vcvs gain=1.950903220161e-01
SMIXI_c123_3_12 (mix_i_src_c123_3_12 mix_i_c123_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_12 (mix_q_src_c123_3_12 0 bpf_c123_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c123_3_12 (mix_q_src_c123_3_12 mix_q_c123_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_13 (mix_i_src_c123_3_13 0 bpf_c123_3 0) vcvs gain=5.555702330196e-01
SMIXI_c123_3_13 (mix_i_src_c123_3_13 mix_i_c123_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_13 (mix_q_src_c123_3_13 0 bpf_c123_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c123_3_13 (mix_q_src_c123_3_13 mix_q_c123_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_14 (mix_i_src_c123_3_14 0 bpf_c123_3 0) vcvs gain=8.314696123025e-01
SMIXI_c123_3_14 (mix_i_src_c123_3_14 mix_i_c123_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_14 (mix_q_src_c123_3_14 0 bpf_c123_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c123_3_14 (mix_q_src_c123_3_14 mix_q_c123_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c123_3_15 (mix_i_src_c123_3_15 0 bpf_c123_3 0) vcvs gain=9.807852804032e-01
SMIXI_c123_3_15 (mix_i_src_c123_3_15 mix_i_c123_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c123_3_15 (mix_q_src_c123_3_15 0 bpf_c123_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c123_3_15 (mix_q_src_c123_3_15 mix_q_c123_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c123_3 (mix_i_c123_3 0) resistor r=1G
RMIXQ_c123_3 (mix_q_c123_3 0) resistor r=1G
RINTI_c123_3 (mix_i_c123_3 Icar_c123_3) resistor r=1k
CINTI_c123_3 (Icar_c123_3 0) capacitor c=80p
RINTQ_c123_3 (mix_q_c123_3 Qcar_c123_3) resistor r=1k
CINTQ_c123_3 (Qcar_c123_3 0) capacitor c=80p

// bl124, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c124_0 (bl124 n_cbpf_c124_0) capacitor c=4.052847345694e-13
LBPF_c124_0 (n_cbpf_c124_0 bpf_c124_0) inductor l=1.000000000000e-06
RBPF_c124_0 (bpf_c124_0 0) resistor r=7.853981633974e+01
EMIXI_c124_0_00 (mix_i_src_c124_0_00 0 bpf_c124_0 0) vcvs gain=9.807852804032e-01
SMIXI_c124_0_00 (mix_i_src_c124_0_00 mix_i_c124_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_00 (mix_q_src_c124_0_00 0 bpf_c124_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_0_00 (mix_q_src_c124_0_00 mix_q_c124_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_01 (mix_i_src_c124_0_01 0 bpf_c124_0 0) vcvs gain=8.314696123025e-01
SMIXI_c124_0_01 (mix_i_src_c124_0_01 mix_i_c124_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_01 (mix_q_src_c124_0_01 0 bpf_c124_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_0_01 (mix_q_src_c124_0_01 mix_q_c124_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_02 (mix_i_src_c124_0_02 0 bpf_c124_0 0) vcvs gain=5.555702330196e-01
SMIXI_c124_0_02 (mix_i_src_c124_0_02 mix_i_c124_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_02 (mix_q_src_c124_0_02 0 bpf_c124_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_0_02 (mix_q_src_c124_0_02 mix_q_c124_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_03 (mix_i_src_c124_0_03 0 bpf_c124_0 0) vcvs gain=1.950903220161e-01
SMIXI_c124_0_03 (mix_i_src_c124_0_03 mix_i_c124_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_03 (mix_q_src_c124_0_03 0 bpf_c124_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_0_03 (mix_q_src_c124_0_03 mix_q_c124_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_04 (mix_i_src_c124_0_04 0 bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_0_04 (mix_i_src_c124_0_04 mix_i_c124_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_04 (mix_q_src_c124_0_04 0 bpf_c124_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_0_04 (mix_q_src_c124_0_04 mix_q_c124_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_05 (mix_i_src_c124_0_05 0 bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_0_05 (mix_i_src_c124_0_05 mix_i_c124_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_05 (mix_q_src_c124_0_05 0 bpf_c124_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_0_05 (mix_q_src_c124_0_05 mix_q_c124_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_06 (mix_i_src_c124_0_06 0 bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_0_06 (mix_i_src_c124_0_06 mix_i_c124_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_06 (mix_q_src_c124_0_06 0 bpf_c124_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_0_06 (mix_q_src_c124_0_06 mix_q_c124_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_07 (mix_i_src_c124_0_07 0 bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_0_07 (mix_i_src_c124_0_07 mix_i_c124_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_07 (mix_q_src_c124_0_07 0 bpf_c124_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_0_07 (mix_q_src_c124_0_07 mix_q_c124_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_08 (mix_i_src_c124_0_08 0 bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_0_08 (mix_i_src_c124_0_08 mix_i_c124_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_08 (mix_q_src_c124_0_08 0 bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_0_08 (mix_q_src_c124_0_08 mix_q_c124_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_09 (mix_i_src_c124_0_09 0 bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_0_09 (mix_i_src_c124_0_09 mix_i_c124_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_09 (mix_q_src_c124_0_09 0 bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_0_09 (mix_q_src_c124_0_09 mix_q_c124_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_10 (mix_i_src_c124_0_10 0 bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_0_10 (mix_i_src_c124_0_10 mix_i_c124_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_10 (mix_q_src_c124_0_10 0 bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_0_10 (mix_q_src_c124_0_10 mix_q_c124_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_11 (mix_i_src_c124_0_11 0 bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_0_11 (mix_i_src_c124_0_11 mix_i_c124_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_11 (mix_q_src_c124_0_11 0 bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_0_11 (mix_q_src_c124_0_11 mix_q_c124_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_12 (mix_i_src_c124_0_12 0 bpf_c124_0 0) vcvs gain=1.950903220161e-01
SMIXI_c124_0_12 (mix_i_src_c124_0_12 mix_i_c124_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_12 (mix_q_src_c124_0_12 0 bpf_c124_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_0_12 (mix_q_src_c124_0_12 mix_q_c124_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_13 (mix_i_src_c124_0_13 0 bpf_c124_0 0) vcvs gain=5.555702330196e-01
SMIXI_c124_0_13 (mix_i_src_c124_0_13 mix_i_c124_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_13 (mix_q_src_c124_0_13 0 bpf_c124_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_0_13 (mix_q_src_c124_0_13 mix_q_c124_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_14 (mix_i_src_c124_0_14 0 bpf_c124_0 0) vcvs gain=8.314696123025e-01
SMIXI_c124_0_14 (mix_i_src_c124_0_14 mix_i_c124_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_14 (mix_q_src_c124_0_14 0 bpf_c124_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_0_14 (mix_q_src_c124_0_14 mix_q_c124_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_0_15 (mix_i_src_c124_0_15 0 bpf_c124_0 0) vcvs gain=9.807852804032e-01
SMIXI_c124_0_15 (mix_i_src_c124_0_15 mix_i_c124_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_0_15 (mix_q_src_c124_0_15 0 bpf_c124_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_0_15 (mix_q_src_c124_0_15 mix_q_c124_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c124_0 (mix_i_c124_0 0) resistor r=1G
RMIXQ_c124_0 (mix_q_c124_0 0) resistor r=1G
RINTI_c124_0 (mix_i_c124_0 Icar_c124_0) resistor r=1k
CINTI_c124_0 (Icar_c124_0 0) capacitor c=80p
RINTQ_c124_0 (mix_q_c124_0 Qcar_c124_0) resistor r=1k
CINTQ_c124_0 (Qcar_c124_0 0) capacitor c=80p

// bl124, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c124_1 (bl124 n_cbpf_c124_1) capacitor c=1.013211836423e-13
LBPF_c124_1 (n_cbpf_c124_1 bpf_c124_1) inductor l=1.000000000000e-06
RBPF_c124_1 (bpf_c124_1 0) resistor r=1.570796326795e+02
EMIXI_c124_1_00 (mix_i_src_c124_1_00 0 bpf_c124_1 0) vcvs gain=9.807852804032e-01
SMIXI_c124_1_00 (mix_i_src_c124_1_00 mix_i_c124_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_00 (mix_q_src_c124_1_00 0 bpf_c124_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_1_00 (mix_q_src_c124_1_00 mix_q_c124_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_01 (mix_i_src_c124_1_01 0 bpf_c124_1 0) vcvs gain=8.314696123025e-01
SMIXI_c124_1_01 (mix_i_src_c124_1_01 mix_i_c124_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_01 (mix_q_src_c124_1_01 0 bpf_c124_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_1_01 (mix_q_src_c124_1_01 mix_q_c124_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_02 (mix_i_src_c124_1_02 0 bpf_c124_1 0) vcvs gain=5.555702330196e-01
SMIXI_c124_1_02 (mix_i_src_c124_1_02 mix_i_c124_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_02 (mix_q_src_c124_1_02 0 bpf_c124_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_1_02 (mix_q_src_c124_1_02 mix_q_c124_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_03 (mix_i_src_c124_1_03 0 bpf_c124_1 0) vcvs gain=1.950903220161e-01
SMIXI_c124_1_03 (mix_i_src_c124_1_03 mix_i_c124_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_03 (mix_q_src_c124_1_03 0 bpf_c124_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_1_03 (mix_q_src_c124_1_03 mix_q_c124_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_04 (mix_i_src_c124_1_04 0 bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_1_04 (mix_i_src_c124_1_04 mix_i_c124_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_04 (mix_q_src_c124_1_04 0 bpf_c124_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_1_04 (mix_q_src_c124_1_04 mix_q_c124_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_05 (mix_i_src_c124_1_05 0 bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_1_05 (mix_i_src_c124_1_05 mix_i_c124_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_05 (mix_q_src_c124_1_05 0 bpf_c124_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_1_05 (mix_q_src_c124_1_05 mix_q_c124_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_06 (mix_i_src_c124_1_06 0 bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_1_06 (mix_i_src_c124_1_06 mix_i_c124_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_06 (mix_q_src_c124_1_06 0 bpf_c124_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_1_06 (mix_q_src_c124_1_06 mix_q_c124_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_07 (mix_i_src_c124_1_07 0 bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_1_07 (mix_i_src_c124_1_07 mix_i_c124_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_07 (mix_q_src_c124_1_07 0 bpf_c124_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_1_07 (mix_q_src_c124_1_07 mix_q_c124_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_08 (mix_i_src_c124_1_08 0 bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_1_08 (mix_i_src_c124_1_08 mix_i_c124_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_08 (mix_q_src_c124_1_08 0 bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_1_08 (mix_q_src_c124_1_08 mix_q_c124_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_09 (mix_i_src_c124_1_09 0 bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_1_09 (mix_i_src_c124_1_09 mix_i_c124_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_09 (mix_q_src_c124_1_09 0 bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_1_09 (mix_q_src_c124_1_09 mix_q_c124_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_10 (mix_i_src_c124_1_10 0 bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_1_10 (mix_i_src_c124_1_10 mix_i_c124_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_10 (mix_q_src_c124_1_10 0 bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_1_10 (mix_q_src_c124_1_10 mix_q_c124_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_11 (mix_i_src_c124_1_11 0 bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_1_11 (mix_i_src_c124_1_11 mix_i_c124_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_11 (mix_q_src_c124_1_11 0 bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_1_11 (mix_q_src_c124_1_11 mix_q_c124_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_12 (mix_i_src_c124_1_12 0 bpf_c124_1 0) vcvs gain=1.950903220161e-01
SMIXI_c124_1_12 (mix_i_src_c124_1_12 mix_i_c124_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_12 (mix_q_src_c124_1_12 0 bpf_c124_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_1_12 (mix_q_src_c124_1_12 mix_q_c124_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_13 (mix_i_src_c124_1_13 0 bpf_c124_1 0) vcvs gain=5.555702330196e-01
SMIXI_c124_1_13 (mix_i_src_c124_1_13 mix_i_c124_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_13 (mix_q_src_c124_1_13 0 bpf_c124_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_1_13 (mix_q_src_c124_1_13 mix_q_c124_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_14 (mix_i_src_c124_1_14 0 bpf_c124_1 0) vcvs gain=8.314696123025e-01
SMIXI_c124_1_14 (mix_i_src_c124_1_14 mix_i_c124_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_14 (mix_q_src_c124_1_14 0 bpf_c124_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_1_14 (mix_q_src_c124_1_14 mix_q_c124_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_1_15 (mix_i_src_c124_1_15 0 bpf_c124_1 0) vcvs gain=9.807852804032e-01
SMIXI_c124_1_15 (mix_i_src_c124_1_15 mix_i_c124_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_1_15 (mix_q_src_c124_1_15 0 bpf_c124_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_1_15 (mix_q_src_c124_1_15 mix_q_c124_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c124_1 (mix_i_c124_1 0) resistor r=1G
RMIXQ_c124_1 (mix_q_c124_1 0) resistor r=1G
RINTI_c124_1 (mix_i_c124_1 Icar_c124_1) resistor r=1k
CINTI_c124_1 (Icar_c124_1 0) capacitor c=80p
RINTQ_c124_1 (mix_q_c124_1 Qcar_c124_1) resistor r=1k
CINTQ_c124_1 (Qcar_c124_1 0) capacitor c=80p

// bl124, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c124_2 (bl124 n_cbpf_c124_2) capacitor c=4.503163717437e-14
LBPF_c124_2 (n_cbpf_c124_2 bpf_c124_2) inductor l=1.000000000000e-06
RBPF_c124_2 (bpf_c124_2 0) resistor r=2.356194490192e+02
EMIXI_c124_2_00 (mix_i_src_c124_2_00 0 bpf_c124_2 0) vcvs gain=9.807852804032e-01
SMIXI_c124_2_00 (mix_i_src_c124_2_00 mix_i_c124_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_00 (mix_q_src_c124_2_00 0 bpf_c124_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_2_00 (mix_q_src_c124_2_00 mix_q_c124_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_01 (mix_i_src_c124_2_01 0 bpf_c124_2 0) vcvs gain=8.314696123025e-01
SMIXI_c124_2_01 (mix_i_src_c124_2_01 mix_i_c124_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_01 (mix_q_src_c124_2_01 0 bpf_c124_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_2_01 (mix_q_src_c124_2_01 mix_q_c124_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_02 (mix_i_src_c124_2_02 0 bpf_c124_2 0) vcvs gain=5.555702330196e-01
SMIXI_c124_2_02 (mix_i_src_c124_2_02 mix_i_c124_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_02 (mix_q_src_c124_2_02 0 bpf_c124_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_2_02 (mix_q_src_c124_2_02 mix_q_c124_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_03 (mix_i_src_c124_2_03 0 bpf_c124_2 0) vcvs gain=1.950903220161e-01
SMIXI_c124_2_03 (mix_i_src_c124_2_03 mix_i_c124_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_03 (mix_q_src_c124_2_03 0 bpf_c124_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_2_03 (mix_q_src_c124_2_03 mix_q_c124_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_04 (mix_i_src_c124_2_04 0 bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_2_04 (mix_i_src_c124_2_04 mix_i_c124_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_04 (mix_q_src_c124_2_04 0 bpf_c124_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_2_04 (mix_q_src_c124_2_04 mix_q_c124_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_05 (mix_i_src_c124_2_05 0 bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_2_05 (mix_i_src_c124_2_05 mix_i_c124_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_05 (mix_q_src_c124_2_05 0 bpf_c124_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_2_05 (mix_q_src_c124_2_05 mix_q_c124_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_06 (mix_i_src_c124_2_06 0 bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_2_06 (mix_i_src_c124_2_06 mix_i_c124_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_06 (mix_q_src_c124_2_06 0 bpf_c124_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_2_06 (mix_q_src_c124_2_06 mix_q_c124_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_07 (mix_i_src_c124_2_07 0 bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_2_07 (mix_i_src_c124_2_07 mix_i_c124_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_07 (mix_q_src_c124_2_07 0 bpf_c124_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_2_07 (mix_q_src_c124_2_07 mix_q_c124_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_08 (mix_i_src_c124_2_08 0 bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_2_08 (mix_i_src_c124_2_08 mix_i_c124_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_08 (mix_q_src_c124_2_08 0 bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_2_08 (mix_q_src_c124_2_08 mix_q_c124_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_09 (mix_i_src_c124_2_09 0 bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_2_09 (mix_i_src_c124_2_09 mix_i_c124_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_09 (mix_q_src_c124_2_09 0 bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_2_09 (mix_q_src_c124_2_09 mix_q_c124_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_10 (mix_i_src_c124_2_10 0 bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_2_10 (mix_i_src_c124_2_10 mix_i_c124_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_10 (mix_q_src_c124_2_10 0 bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_2_10 (mix_q_src_c124_2_10 mix_q_c124_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_11 (mix_i_src_c124_2_11 0 bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_2_11 (mix_i_src_c124_2_11 mix_i_c124_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_11 (mix_q_src_c124_2_11 0 bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_2_11 (mix_q_src_c124_2_11 mix_q_c124_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_12 (mix_i_src_c124_2_12 0 bpf_c124_2 0) vcvs gain=1.950903220161e-01
SMIXI_c124_2_12 (mix_i_src_c124_2_12 mix_i_c124_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_12 (mix_q_src_c124_2_12 0 bpf_c124_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_2_12 (mix_q_src_c124_2_12 mix_q_c124_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_13 (mix_i_src_c124_2_13 0 bpf_c124_2 0) vcvs gain=5.555702330196e-01
SMIXI_c124_2_13 (mix_i_src_c124_2_13 mix_i_c124_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_13 (mix_q_src_c124_2_13 0 bpf_c124_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_2_13 (mix_q_src_c124_2_13 mix_q_c124_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_14 (mix_i_src_c124_2_14 0 bpf_c124_2 0) vcvs gain=8.314696123025e-01
SMIXI_c124_2_14 (mix_i_src_c124_2_14 mix_i_c124_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_14 (mix_q_src_c124_2_14 0 bpf_c124_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_2_14 (mix_q_src_c124_2_14 mix_q_c124_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_2_15 (mix_i_src_c124_2_15 0 bpf_c124_2 0) vcvs gain=9.807852804032e-01
SMIXI_c124_2_15 (mix_i_src_c124_2_15 mix_i_c124_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_2_15 (mix_q_src_c124_2_15 0 bpf_c124_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_2_15 (mix_q_src_c124_2_15 mix_q_c124_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c124_2 (mix_i_c124_2 0) resistor r=1G
RMIXQ_c124_2 (mix_q_c124_2 0) resistor r=1G
RINTI_c124_2 (mix_i_c124_2 Icar_c124_2) resistor r=1k
CINTI_c124_2 (Icar_c124_2 0) capacitor c=80p
RINTQ_c124_2 (mix_q_c124_2 Qcar_c124_2) resistor r=1k
CINTQ_c124_2 (Qcar_c124_2 0) capacitor c=80p

// bl124, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c124_3 (bl124 n_cbpf_c124_3) capacitor c=2.533029591058e-14
LBPF_c124_3 (n_cbpf_c124_3 bpf_c124_3) inductor l=1.000000000000e-06
RBPF_c124_3 (bpf_c124_3 0) resistor r=3.141592653590e+02
EMIXI_c124_3_00 (mix_i_src_c124_3_00 0 bpf_c124_3 0) vcvs gain=9.807852804032e-01
SMIXI_c124_3_00 (mix_i_src_c124_3_00 mix_i_c124_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_00 (mix_q_src_c124_3_00 0 bpf_c124_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_3_00 (mix_q_src_c124_3_00 mix_q_c124_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_01 (mix_i_src_c124_3_01 0 bpf_c124_3 0) vcvs gain=8.314696123025e-01
SMIXI_c124_3_01 (mix_i_src_c124_3_01 mix_i_c124_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_01 (mix_q_src_c124_3_01 0 bpf_c124_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_3_01 (mix_q_src_c124_3_01 mix_q_c124_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_02 (mix_i_src_c124_3_02 0 bpf_c124_3 0) vcvs gain=5.555702330196e-01
SMIXI_c124_3_02 (mix_i_src_c124_3_02 mix_i_c124_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_02 (mix_q_src_c124_3_02 0 bpf_c124_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_3_02 (mix_q_src_c124_3_02 mix_q_c124_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_03 (mix_i_src_c124_3_03 0 bpf_c124_3 0) vcvs gain=1.950903220161e-01
SMIXI_c124_3_03 (mix_i_src_c124_3_03 mix_i_c124_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_03 (mix_q_src_c124_3_03 0 bpf_c124_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_3_03 (mix_q_src_c124_3_03 mix_q_c124_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_04 (mix_i_src_c124_3_04 0 bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_3_04 (mix_i_src_c124_3_04 mix_i_c124_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_04 (mix_q_src_c124_3_04 0 bpf_c124_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c124_3_04 (mix_q_src_c124_3_04 mix_q_c124_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_05 (mix_i_src_c124_3_05 0 bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_3_05 (mix_i_src_c124_3_05 mix_i_c124_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_05 (mix_q_src_c124_3_05 0 bpf_c124_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c124_3_05 (mix_q_src_c124_3_05 mix_q_c124_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_06 (mix_i_src_c124_3_06 0 bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_3_06 (mix_i_src_c124_3_06 mix_i_c124_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_06 (mix_q_src_c124_3_06 0 bpf_c124_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c124_3_06 (mix_q_src_c124_3_06 mix_q_c124_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_07 (mix_i_src_c124_3_07 0 bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_3_07 (mix_i_src_c124_3_07 mix_i_c124_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_07 (mix_q_src_c124_3_07 0 bpf_c124_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c124_3_07 (mix_q_src_c124_3_07 mix_q_c124_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_08 (mix_i_src_c124_3_08 0 bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c124_3_08 (mix_i_src_c124_3_08 mix_i_c124_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_08 (mix_q_src_c124_3_08 0 bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_3_08 (mix_q_src_c124_3_08 mix_q_c124_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_09 (mix_i_src_c124_3_09 0 bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c124_3_09 (mix_i_src_c124_3_09 mix_i_c124_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_09 (mix_q_src_c124_3_09 0 bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_3_09 (mix_q_src_c124_3_09 mix_q_c124_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_10 (mix_i_src_c124_3_10 0 bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c124_3_10 (mix_i_src_c124_3_10 mix_i_c124_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_10 (mix_q_src_c124_3_10 0 bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_3_10 (mix_q_src_c124_3_10 mix_q_c124_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_11 (mix_i_src_c124_3_11 0 bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c124_3_11 (mix_i_src_c124_3_11 mix_i_c124_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_11 (mix_q_src_c124_3_11 0 bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_3_11 (mix_q_src_c124_3_11 mix_q_c124_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_12 (mix_i_src_c124_3_12 0 bpf_c124_3 0) vcvs gain=1.950903220161e-01
SMIXI_c124_3_12 (mix_i_src_c124_3_12 mix_i_c124_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_12 (mix_q_src_c124_3_12 0 bpf_c124_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c124_3_12 (mix_q_src_c124_3_12 mix_q_c124_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_13 (mix_i_src_c124_3_13 0 bpf_c124_3 0) vcvs gain=5.555702330196e-01
SMIXI_c124_3_13 (mix_i_src_c124_3_13 mix_i_c124_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_13 (mix_q_src_c124_3_13 0 bpf_c124_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c124_3_13 (mix_q_src_c124_3_13 mix_q_c124_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_14 (mix_i_src_c124_3_14 0 bpf_c124_3 0) vcvs gain=8.314696123025e-01
SMIXI_c124_3_14 (mix_i_src_c124_3_14 mix_i_c124_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_14 (mix_q_src_c124_3_14 0 bpf_c124_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c124_3_14 (mix_q_src_c124_3_14 mix_q_c124_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c124_3_15 (mix_i_src_c124_3_15 0 bpf_c124_3 0) vcvs gain=9.807852804032e-01
SMIXI_c124_3_15 (mix_i_src_c124_3_15 mix_i_c124_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c124_3_15 (mix_q_src_c124_3_15 0 bpf_c124_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c124_3_15 (mix_q_src_c124_3_15 mix_q_c124_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c124_3 (mix_i_c124_3 0) resistor r=1G
RMIXQ_c124_3 (mix_q_c124_3 0) resistor r=1G
RINTI_c124_3 (mix_i_c124_3 Icar_c124_3) resistor r=1k
CINTI_c124_3 (Icar_c124_3 0) capacitor c=80p
RINTQ_c124_3 (mix_q_c124_3 Qcar_c124_3) resistor r=1k
CINTQ_c124_3 (Qcar_c124_3 0) capacitor c=80p

// bl125, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c125_0 (bl125 n_cbpf_c125_0) capacitor c=4.052847345694e-13
LBPF_c125_0 (n_cbpf_c125_0 bpf_c125_0) inductor l=1.000000000000e-06
RBPF_c125_0 (bpf_c125_0 0) resistor r=7.853981633974e+01
EMIXI_c125_0_00 (mix_i_src_c125_0_00 0 bpf_c125_0 0) vcvs gain=9.807852804032e-01
SMIXI_c125_0_00 (mix_i_src_c125_0_00 mix_i_c125_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_00 (mix_q_src_c125_0_00 0 bpf_c125_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_0_00 (mix_q_src_c125_0_00 mix_q_c125_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_01 (mix_i_src_c125_0_01 0 bpf_c125_0 0) vcvs gain=8.314696123025e-01
SMIXI_c125_0_01 (mix_i_src_c125_0_01 mix_i_c125_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_01 (mix_q_src_c125_0_01 0 bpf_c125_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_0_01 (mix_q_src_c125_0_01 mix_q_c125_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_02 (mix_i_src_c125_0_02 0 bpf_c125_0 0) vcvs gain=5.555702330196e-01
SMIXI_c125_0_02 (mix_i_src_c125_0_02 mix_i_c125_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_02 (mix_q_src_c125_0_02 0 bpf_c125_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_0_02 (mix_q_src_c125_0_02 mix_q_c125_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_03 (mix_i_src_c125_0_03 0 bpf_c125_0 0) vcvs gain=1.950903220161e-01
SMIXI_c125_0_03 (mix_i_src_c125_0_03 mix_i_c125_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_03 (mix_q_src_c125_0_03 0 bpf_c125_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_0_03 (mix_q_src_c125_0_03 mix_q_c125_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_04 (mix_i_src_c125_0_04 0 bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_0_04 (mix_i_src_c125_0_04 mix_i_c125_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_04 (mix_q_src_c125_0_04 0 bpf_c125_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_0_04 (mix_q_src_c125_0_04 mix_q_c125_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_05 (mix_i_src_c125_0_05 0 bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_0_05 (mix_i_src_c125_0_05 mix_i_c125_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_05 (mix_q_src_c125_0_05 0 bpf_c125_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_0_05 (mix_q_src_c125_0_05 mix_q_c125_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_06 (mix_i_src_c125_0_06 0 bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_0_06 (mix_i_src_c125_0_06 mix_i_c125_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_06 (mix_q_src_c125_0_06 0 bpf_c125_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_0_06 (mix_q_src_c125_0_06 mix_q_c125_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_07 (mix_i_src_c125_0_07 0 bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_0_07 (mix_i_src_c125_0_07 mix_i_c125_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_07 (mix_q_src_c125_0_07 0 bpf_c125_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_0_07 (mix_q_src_c125_0_07 mix_q_c125_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_08 (mix_i_src_c125_0_08 0 bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_0_08 (mix_i_src_c125_0_08 mix_i_c125_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_08 (mix_q_src_c125_0_08 0 bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_0_08 (mix_q_src_c125_0_08 mix_q_c125_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_09 (mix_i_src_c125_0_09 0 bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_0_09 (mix_i_src_c125_0_09 mix_i_c125_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_09 (mix_q_src_c125_0_09 0 bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_0_09 (mix_q_src_c125_0_09 mix_q_c125_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_10 (mix_i_src_c125_0_10 0 bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_0_10 (mix_i_src_c125_0_10 mix_i_c125_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_10 (mix_q_src_c125_0_10 0 bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_0_10 (mix_q_src_c125_0_10 mix_q_c125_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_11 (mix_i_src_c125_0_11 0 bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_0_11 (mix_i_src_c125_0_11 mix_i_c125_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_11 (mix_q_src_c125_0_11 0 bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_0_11 (mix_q_src_c125_0_11 mix_q_c125_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_12 (mix_i_src_c125_0_12 0 bpf_c125_0 0) vcvs gain=1.950903220161e-01
SMIXI_c125_0_12 (mix_i_src_c125_0_12 mix_i_c125_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_12 (mix_q_src_c125_0_12 0 bpf_c125_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_0_12 (mix_q_src_c125_0_12 mix_q_c125_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_13 (mix_i_src_c125_0_13 0 bpf_c125_0 0) vcvs gain=5.555702330196e-01
SMIXI_c125_0_13 (mix_i_src_c125_0_13 mix_i_c125_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_13 (mix_q_src_c125_0_13 0 bpf_c125_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_0_13 (mix_q_src_c125_0_13 mix_q_c125_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_14 (mix_i_src_c125_0_14 0 bpf_c125_0 0) vcvs gain=8.314696123025e-01
SMIXI_c125_0_14 (mix_i_src_c125_0_14 mix_i_c125_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_14 (mix_q_src_c125_0_14 0 bpf_c125_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_0_14 (mix_q_src_c125_0_14 mix_q_c125_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_0_15 (mix_i_src_c125_0_15 0 bpf_c125_0 0) vcvs gain=9.807852804032e-01
SMIXI_c125_0_15 (mix_i_src_c125_0_15 mix_i_c125_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_0_15 (mix_q_src_c125_0_15 0 bpf_c125_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_0_15 (mix_q_src_c125_0_15 mix_q_c125_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c125_0 (mix_i_c125_0 0) resistor r=1G
RMIXQ_c125_0 (mix_q_c125_0 0) resistor r=1G
RINTI_c125_0 (mix_i_c125_0 Icar_c125_0) resistor r=1k
CINTI_c125_0 (Icar_c125_0 0) capacitor c=80p
RINTQ_c125_0 (mix_q_c125_0 Qcar_c125_0) resistor r=1k
CINTQ_c125_0 (Qcar_c125_0 0) capacitor c=80p

// bl125, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c125_1 (bl125 n_cbpf_c125_1) capacitor c=1.013211836423e-13
LBPF_c125_1 (n_cbpf_c125_1 bpf_c125_1) inductor l=1.000000000000e-06
RBPF_c125_1 (bpf_c125_1 0) resistor r=1.570796326795e+02
EMIXI_c125_1_00 (mix_i_src_c125_1_00 0 bpf_c125_1 0) vcvs gain=9.807852804032e-01
SMIXI_c125_1_00 (mix_i_src_c125_1_00 mix_i_c125_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_00 (mix_q_src_c125_1_00 0 bpf_c125_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_1_00 (mix_q_src_c125_1_00 mix_q_c125_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_01 (mix_i_src_c125_1_01 0 bpf_c125_1 0) vcvs gain=8.314696123025e-01
SMIXI_c125_1_01 (mix_i_src_c125_1_01 mix_i_c125_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_01 (mix_q_src_c125_1_01 0 bpf_c125_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_1_01 (mix_q_src_c125_1_01 mix_q_c125_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_02 (mix_i_src_c125_1_02 0 bpf_c125_1 0) vcvs gain=5.555702330196e-01
SMIXI_c125_1_02 (mix_i_src_c125_1_02 mix_i_c125_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_02 (mix_q_src_c125_1_02 0 bpf_c125_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_1_02 (mix_q_src_c125_1_02 mix_q_c125_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_03 (mix_i_src_c125_1_03 0 bpf_c125_1 0) vcvs gain=1.950903220161e-01
SMIXI_c125_1_03 (mix_i_src_c125_1_03 mix_i_c125_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_03 (mix_q_src_c125_1_03 0 bpf_c125_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_1_03 (mix_q_src_c125_1_03 mix_q_c125_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_04 (mix_i_src_c125_1_04 0 bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_1_04 (mix_i_src_c125_1_04 mix_i_c125_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_04 (mix_q_src_c125_1_04 0 bpf_c125_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_1_04 (mix_q_src_c125_1_04 mix_q_c125_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_05 (mix_i_src_c125_1_05 0 bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_1_05 (mix_i_src_c125_1_05 mix_i_c125_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_05 (mix_q_src_c125_1_05 0 bpf_c125_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_1_05 (mix_q_src_c125_1_05 mix_q_c125_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_06 (mix_i_src_c125_1_06 0 bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_1_06 (mix_i_src_c125_1_06 mix_i_c125_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_06 (mix_q_src_c125_1_06 0 bpf_c125_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_1_06 (mix_q_src_c125_1_06 mix_q_c125_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_07 (mix_i_src_c125_1_07 0 bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_1_07 (mix_i_src_c125_1_07 mix_i_c125_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_07 (mix_q_src_c125_1_07 0 bpf_c125_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_1_07 (mix_q_src_c125_1_07 mix_q_c125_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_08 (mix_i_src_c125_1_08 0 bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_1_08 (mix_i_src_c125_1_08 mix_i_c125_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_08 (mix_q_src_c125_1_08 0 bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_1_08 (mix_q_src_c125_1_08 mix_q_c125_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_09 (mix_i_src_c125_1_09 0 bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_1_09 (mix_i_src_c125_1_09 mix_i_c125_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_09 (mix_q_src_c125_1_09 0 bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_1_09 (mix_q_src_c125_1_09 mix_q_c125_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_10 (mix_i_src_c125_1_10 0 bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_1_10 (mix_i_src_c125_1_10 mix_i_c125_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_10 (mix_q_src_c125_1_10 0 bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_1_10 (mix_q_src_c125_1_10 mix_q_c125_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_11 (mix_i_src_c125_1_11 0 bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_1_11 (mix_i_src_c125_1_11 mix_i_c125_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_11 (mix_q_src_c125_1_11 0 bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_1_11 (mix_q_src_c125_1_11 mix_q_c125_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_12 (mix_i_src_c125_1_12 0 bpf_c125_1 0) vcvs gain=1.950903220161e-01
SMIXI_c125_1_12 (mix_i_src_c125_1_12 mix_i_c125_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_12 (mix_q_src_c125_1_12 0 bpf_c125_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_1_12 (mix_q_src_c125_1_12 mix_q_c125_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_13 (mix_i_src_c125_1_13 0 bpf_c125_1 0) vcvs gain=5.555702330196e-01
SMIXI_c125_1_13 (mix_i_src_c125_1_13 mix_i_c125_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_13 (mix_q_src_c125_1_13 0 bpf_c125_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_1_13 (mix_q_src_c125_1_13 mix_q_c125_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_14 (mix_i_src_c125_1_14 0 bpf_c125_1 0) vcvs gain=8.314696123025e-01
SMIXI_c125_1_14 (mix_i_src_c125_1_14 mix_i_c125_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_14 (mix_q_src_c125_1_14 0 bpf_c125_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_1_14 (mix_q_src_c125_1_14 mix_q_c125_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_1_15 (mix_i_src_c125_1_15 0 bpf_c125_1 0) vcvs gain=9.807852804032e-01
SMIXI_c125_1_15 (mix_i_src_c125_1_15 mix_i_c125_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_1_15 (mix_q_src_c125_1_15 0 bpf_c125_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_1_15 (mix_q_src_c125_1_15 mix_q_c125_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c125_1 (mix_i_c125_1 0) resistor r=1G
RMIXQ_c125_1 (mix_q_c125_1 0) resistor r=1G
RINTI_c125_1 (mix_i_c125_1 Icar_c125_1) resistor r=1k
CINTI_c125_1 (Icar_c125_1 0) capacitor c=80p
RINTQ_c125_1 (mix_q_c125_1 Qcar_c125_1) resistor r=1k
CINTQ_c125_1 (Qcar_c125_1 0) capacitor c=80p

// bl125, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c125_2 (bl125 n_cbpf_c125_2) capacitor c=4.503163717437e-14
LBPF_c125_2 (n_cbpf_c125_2 bpf_c125_2) inductor l=1.000000000000e-06
RBPF_c125_2 (bpf_c125_2 0) resistor r=2.356194490192e+02
EMIXI_c125_2_00 (mix_i_src_c125_2_00 0 bpf_c125_2 0) vcvs gain=9.807852804032e-01
SMIXI_c125_2_00 (mix_i_src_c125_2_00 mix_i_c125_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_00 (mix_q_src_c125_2_00 0 bpf_c125_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_2_00 (mix_q_src_c125_2_00 mix_q_c125_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_01 (mix_i_src_c125_2_01 0 bpf_c125_2 0) vcvs gain=8.314696123025e-01
SMIXI_c125_2_01 (mix_i_src_c125_2_01 mix_i_c125_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_01 (mix_q_src_c125_2_01 0 bpf_c125_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_2_01 (mix_q_src_c125_2_01 mix_q_c125_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_02 (mix_i_src_c125_2_02 0 bpf_c125_2 0) vcvs gain=5.555702330196e-01
SMIXI_c125_2_02 (mix_i_src_c125_2_02 mix_i_c125_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_02 (mix_q_src_c125_2_02 0 bpf_c125_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_2_02 (mix_q_src_c125_2_02 mix_q_c125_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_03 (mix_i_src_c125_2_03 0 bpf_c125_2 0) vcvs gain=1.950903220161e-01
SMIXI_c125_2_03 (mix_i_src_c125_2_03 mix_i_c125_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_03 (mix_q_src_c125_2_03 0 bpf_c125_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_2_03 (mix_q_src_c125_2_03 mix_q_c125_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_04 (mix_i_src_c125_2_04 0 bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_2_04 (mix_i_src_c125_2_04 mix_i_c125_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_04 (mix_q_src_c125_2_04 0 bpf_c125_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_2_04 (mix_q_src_c125_2_04 mix_q_c125_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_05 (mix_i_src_c125_2_05 0 bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_2_05 (mix_i_src_c125_2_05 mix_i_c125_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_05 (mix_q_src_c125_2_05 0 bpf_c125_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_2_05 (mix_q_src_c125_2_05 mix_q_c125_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_06 (mix_i_src_c125_2_06 0 bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_2_06 (mix_i_src_c125_2_06 mix_i_c125_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_06 (mix_q_src_c125_2_06 0 bpf_c125_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_2_06 (mix_q_src_c125_2_06 mix_q_c125_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_07 (mix_i_src_c125_2_07 0 bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_2_07 (mix_i_src_c125_2_07 mix_i_c125_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_07 (mix_q_src_c125_2_07 0 bpf_c125_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_2_07 (mix_q_src_c125_2_07 mix_q_c125_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_08 (mix_i_src_c125_2_08 0 bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_2_08 (mix_i_src_c125_2_08 mix_i_c125_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_08 (mix_q_src_c125_2_08 0 bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_2_08 (mix_q_src_c125_2_08 mix_q_c125_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_09 (mix_i_src_c125_2_09 0 bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_2_09 (mix_i_src_c125_2_09 mix_i_c125_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_09 (mix_q_src_c125_2_09 0 bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_2_09 (mix_q_src_c125_2_09 mix_q_c125_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_10 (mix_i_src_c125_2_10 0 bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_2_10 (mix_i_src_c125_2_10 mix_i_c125_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_10 (mix_q_src_c125_2_10 0 bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_2_10 (mix_q_src_c125_2_10 mix_q_c125_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_11 (mix_i_src_c125_2_11 0 bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_2_11 (mix_i_src_c125_2_11 mix_i_c125_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_11 (mix_q_src_c125_2_11 0 bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_2_11 (mix_q_src_c125_2_11 mix_q_c125_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_12 (mix_i_src_c125_2_12 0 bpf_c125_2 0) vcvs gain=1.950903220161e-01
SMIXI_c125_2_12 (mix_i_src_c125_2_12 mix_i_c125_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_12 (mix_q_src_c125_2_12 0 bpf_c125_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_2_12 (mix_q_src_c125_2_12 mix_q_c125_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_13 (mix_i_src_c125_2_13 0 bpf_c125_2 0) vcvs gain=5.555702330196e-01
SMIXI_c125_2_13 (mix_i_src_c125_2_13 mix_i_c125_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_13 (mix_q_src_c125_2_13 0 bpf_c125_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_2_13 (mix_q_src_c125_2_13 mix_q_c125_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_14 (mix_i_src_c125_2_14 0 bpf_c125_2 0) vcvs gain=8.314696123025e-01
SMIXI_c125_2_14 (mix_i_src_c125_2_14 mix_i_c125_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_14 (mix_q_src_c125_2_14 0 bpf_c125_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_2_14 (mix_q_src_c125_2_14 mix_q_c125_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_2_15 (mix_i_src_c125_2_15 0 bpf_c125_2 0) vcvs gain=9.807852804032e-01
SMIXI_c125_2_15 (mix_i_src_c125_2_15 mix_i_c125_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_2_15 (mix_q_src_c125_2_15 0 bpf_c125_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_2_15 (mix_q_src_c125_2_15 mix_q_c125_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c125_2 (mix_i_c125_2 0) resistor r=1G
RMIXQ_c125_2 (mix_q_c125_2 0) resistor r=1G
RINTI_c125_2 (mix_i_c125_2 Icar_c125_2) resistor r=1k
CINTI_c125_2 (Icar_c125_2 0) capacitor c=80p
RINTQ_c125_2 (mix_q_c125_2 Qcar_c125_2) resistor r=1k
CINTQ_c125_2 (Qcar_c125_2 0) capacitor c=80p

// bl125, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c125_3 (bl125 n_cbpf_c125_3) capacitor c=2.533029591058e-14
LBPF_c125_3 (n_cbpf_c125_3 bpf_c125_3) inductor l=1.000000000000e-06
RBPF_c125_3 (bpf_c125_3 0) resistor r=3.141592653590e+02
EMIXI_c125_3_00 (mix_i_src_c125_3_00 0 bpf_c125_3 0) vcvs gain=9.807852804032e-01
SMIXI_c125_3_00 (mix_i_src_c125_3_00 mix_i_c125_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_00 (mix_q_src_c125_3_00 0 bpf_c125_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_3_00 (mix_q_src_c125_3_00 mix_q_c125_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_01 (mix_i_src_c125_3_01 0 bpf_c125_3 0) vcvs gain=8.314696123025e-01
SMIXI_c125_3_01 (mix_i_src_c125_3_01 mix_i_c125_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_01 (mix_q_src_c125_3_01 0 bpf_c125_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_3_01 (mix_q_src_c125_3_01 mix_q_c125_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_02 (mix_i_src_c125_3_02 0 bpf_c125_3 0) vcvs gain=5.555702330196e-01
SMIXI_c125_3_02 (mix_i_src_c125_3_02 mix_i_c125_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_02 (mix_q_src_c125_3_02 0 bpf_c125_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_3_02 (mix_q_src_c125_3_02 mix_q_c125_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_03 (mix_i_src_c125_3_03 0 bpf_c125_3 0) vcvs gain=1.950903220161e-01
SMIXI_c125_3_03 (mix_i_src_c125_3_03 mix_i_c125_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_03 (mix_q_src_c125_3_03 0 bpf_c125_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_3_03 (mix_q_src_c125_3_03 mix_q_c125_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_04 (mix_i_src_c125_3_04 0 bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_3_04 (mix_i_src_c125_3_04 mix_i_c125_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_04 (mix_q_src_c125_3_04 0 bpf_c125_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c125_3_04 (mix_q_src_c125_3_04 mix_q_c125_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_05 (mix_i_src_c125_3_05 0 bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_3_05 (mix_i_src_c125_3_05 mix_i_c125_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_05 (mix_q_src_c125_3_05 0 bpf_c125_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c125_3_05 (mix_q_src_c125_3_05 mix_q_c125_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_06 (mix_i_src_c125_3_06 0 bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_3_06 (mix_i_src_c125_3_06 mix_i_c125_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_06 (mix_q_src_c125_3_06 0 bpf_c125_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c125_3_06 (mix_q_src_c125_3_06 mix_q_c125_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_07 (mix_i_src_c125_3_07 0 bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_3_07 (mix_i_src_c125_3_07 mix_i_c125_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_07 (mix_q_src_c125_3_07 0 bpf_c125_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c125_3_07 (mix_q_src_c125_3_07 mix_q_c125_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_08 (mix_i_src_c125_3_08 0 bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c125_3_08 (mix_i_src_c125_3_08 mix_i_c125_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_08 (mix_q_src_c125_3_08 0 bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_3_08 (mix_q_src_c125_3_08 mix_q_c125_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_09 (mix_i_src_c125_3_09 0 bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c125_3_09 (mix_i_src_c125_3_09 mix_i_c125_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_09 (mix_q_src_c125_3_09 0 bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_3_09 (mix_q_src_c125_3_09 mix_q_c125_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_10 (mix_i_src_c125_3_10 0 bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c125_3_10 (mix_i_src_c125_3_10 mix_i_c125_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_10 (mix_q_src_c125_3_10 0 bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_3_10 (mix_q_src_c125_3_10 mix_q_c125_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_11 (mix_i_src_c125_3_11 0 bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c125_3_11 (mix_i_src_c125_3_11 mix_i_c125_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_11 (mix_q_src_c125_3_11 0 bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_3_11 (mix_q_src_c125_3_11 mix_q_c125_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_12 (mix_i_src_c125_3_12 0 bpf_c125_3 0) vcvs gain=1.950903220161e-01
SMIXI_c125_3_12 (mix_i_src_c125_3_12 mix_i_c125_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_12 (mix_q_src_c125_3_12 0 bpf_c125_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c125_3_12 (mix_q_src_c125_3_12 mix_q_c125_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_13 (mix_i_src_c125_3_13 0 bpf_c125_3 0) vcvs gain=5.555702330196e-01
SMIXI_c125_3_13 (mix_i_src_c125_3_13 mix_i_c125_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_13 (mix_q_src_c125_3_13 0 bpf_c125_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c125_3_13 (mix_q_src_c125_3_13 mix_q_c125_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_14 (mix_i_src_c125_3_14 0 bpf_c125_3 0) vcvs gain=8.314696123025e-01
SMIXI_c125_3_14 (mix_i_src_c125_3_14 mix_i_c125_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_14 (mix_q_src_c125_3_14 0 bpf_c125_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c125_3_14 (mix_q_src_c125_3_14 mix_q_c125_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c125_3_15 (mix_i_src_c125_3_15 0 bpf_c125_3 0) vcvs gain=9.807852804032e-01
SMIXI_c125_3_15 (mix_i_src_c125_3_15 mix_i_c125_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c125_3_15 (mix_q_src_c125_3_15 0 bpf_c125_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c125_3_15 (mix_q_src_c125_3_15 mix_q_c125_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c125_3 (mix_i_c125_3 0) resistor r=1G
RMIXQ_c125_3 (mix_q_c125_3 0) resistor r=1G
RINTI_c125_3 (mix_i_c125_3 Icar_c125_3) resistor r=1k
CINTI_c125_3 (Icar_c125_3 0) capacitor c=80p
RINTQ_c125_3 (mix_q_c125_3 Qcar_c125_3) resistor r=1k
CINTQ_c125_3 (Qcar_c125_3 0) capacitor c=80p

// bl126, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c126_0 (bl126 n_cbpf_c126_0) capacitor c=4.052847345694e-13
LBPF_c126_0 (n_cbpf_c126_0 bpf_c126_0) inductor l=1.000000000000e-06
RBPF_c126_0 (bpf_c126_0 0) resistor r=7.853981633974e+01
EMIXI_c126_0_00 (mix_i_src_c126_0_00 0 bpf_c126_0 0) vcvs gain=9.807852804032e-01
SMIXI_c126_0_00 (mix_i_src_c126_0_00 mix_i_c126_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_00 (mix_q_src_c126_0_00 0 bpf_c126_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_0_00 (mix_q_src_c126_0_00 mix_q_c126_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_01 (mix_i_src_c126_0_01 0 bpf_c126_0 0) vcvs gain=8.314696123025e-01
SMIXI_c126_0_01 (mix_i_src_c126_0_01 mix_i_c126_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_01 (mix_q_src_c126_0_01 0 bpf_c126_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_0_01 (mix_q_src_c126_0_01 mix_q_c126_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_02 (mix_i_src_c126_0_02 0 bpf_c126_0 0) vcvs gain=5.555702330196e-01
SMIXI_c126_0_02 (mix_i_src_c126_0_02 mix_i_c126_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_02 (mix_q_src_c126_0_02 0 bpf_c126_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_0_02 (mix_q_src_c126_0_02 mix_q_c126_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_03 (mix_i_src_c126_0_03 0 bpf_c126_0 0) vcvs gain=1.950903220161e-01
SMIXI_c126_0_03 (mix_i_src_c126_0_03 mix_i_c126_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_03 (mix_q_src_c126_0_03 0 bpf_c126_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_0_03 (mix_q_src_c126_0_03 mix_q_c126_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_04 (mix_i_src_c126_0_04 0 bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_0_04 (mix_i_src_c126_0_04 mix_i_c126_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_04 (mix_q_src_c126_0_04 0 bpf_c126_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_0_04 (mix_q_src_c126_0_04 mix_q_c126_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_05 (mix_i_src_c126_0_05 0 bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_0_05 (mix_i_src_c126_0_05 mix_i_c126_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_05 (mix_q_src_c126_0_05 0 bpf_c126_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_0_05 (mix_q_src_c126_0_05 mix_q_c126_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_06 (mix_i_src_c126_0_06 0 bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_0_06 (mix_i_src_c126_0_06 mix_i_c126_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_06 (mix_q_src_c126_0_06 0 bpf_c126_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_0_06 (mix_q_src_c126_0_06 mix_q_c126_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_07 (mix_i_src_c126_0_07 0 bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_0_07 (mix_i_src_c126_0_07 mix_i_c126_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_07 (mix_q_src_c126_0_07 0 bpf_c126_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_0_07 (mix_q_src_c126_0_07 mix_q_c126_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_08 (mix_i_src_c126_0_08 0 bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_0_08 (mix_i_src_c126_0_08 mix_i_c126_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_08 (mix_q_src_c126_0_08 0 bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_0_08 (mix_q_src_c126_0_08 mix_q_c126_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_09 (mix_i_src_c126_0_09 0 bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_0_09 (mix_i_src_c126_0_09 mix_i_c126_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_09 (mix_q_src_c126_0_09 0 bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_0_09 (mix_q_src_c126_0_09 mix_q_c126_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_10 (mix_i_src_c126_0_10 0 bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_0_10 (mix_i_src_c126_0_10 mix_i_c126_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_10 (mix_q_src_c126_0_10 0 bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_0_10 (mix_q_src_c126_0_10 mix_q_c126_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_11 (mix_i_src_c126_0_11 0 bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_0_11 (mix_i_src_c126_0_11 mix_i_c126_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_11 (mix_q_src_c126_0_11 0 bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_0_11 (mix_q_src_c126_0_11 mix_q_c126_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_12 (mix_i_src_c126_0_12 0 bpf_c126_0 0) vcvs gain=1.950903220161e-01
SMIXI_c126_0_12 (mix_i_src_c126_0_12 mix_i_c126_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_12 (mix_q_src_c126_0_12 0 bpf_c126_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_0_12 (mix_q_src_c126_0_12 mix_q_c126_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_13 (mix_i_src_c126_0_13 0 bpf_c126_0 0) vcvs gain=5.555702330196e-01
SMIXI_c126_0_13 (mix_i_src_c126_0_13 mix_i_c126_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_13 (mix_q_src_c126_0_13 0 bpf_c126_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_0_13 (mix_q_src_c126_0_13 mix_q_c126_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_14 (mix_i_src_c126_0_14 0 bpf_c126_0 0) vcvs gain=8.314696123025e-01
SMIXI_c126_0_14 (mix_i_src_c126_0_14 mix_i_c126_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_14 (mix_q_src_c126_0_14 0 bpf_c126_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_0_14 (mix_q_src_c126_0_14 mix_q_c126_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_0_15 (mix_i_src_c126_0_15 0 bpf_c126_0 0) vcvs gain=9.807852804032e-01
SMIXI_c126_0_15 (mix_i_src_c126_0_15 mix_i_c126_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_0_15 (mix_q_src_c126_0_15 0 bpf_c126_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_0_15 (mix_q_src_c126_0_15 mix_q_c126_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c126_0 (mix_i_c126_0 0) resistor r=1G
RMIXQ_c126_0 (mix_q_c126_0 0) resistor r=1G
RINTI_c126_0 (mix_i_c126_0 Icar_c126_0) resistor r=1k
CINTI_c126_0 (Icar_c126_0 0) capacitor c=80p
RINTQ_c126_0 (mix_q_c126_0 Qcar_c126_0) resistor r=1k
CINTQ_c126_0 (Qcar_c126_0 0) capacitor c=80p

// bl126, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c126_1 (bl126 n_cbpf_c126_1) capacitor c=1.013211836423e-13
LBPF_c126_1 (n_cbpf_c126_1 bpf_c126_1) inductor l=1.000000000000e-06
RBPF_c126_1 (bpf_c126_1 0) resistor r=1.570796326795e+02
EMIXI_c126_1_00 (mix_i_src_c126_1_00 0 bpf_c126_1 0) vcvs gain=9.807852804032e-01
SMIXI_c126_1_00 (mix_i_src_c126_1_00 mix_i_c126_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_00 (mix_q_src_c126_1_00 0 bpf_c126_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_1_00 (mix_q_src_c126_1_00 mix_q_c126_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_01 (mix_i_src_c126_1_01 0 bpf_c126_1 0) vcvs gain=8.314696123025e-01
SMIXI_c126_1_01 (mix_i_src_c126_1_01 mix_i_c126_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_01 (mix_q_src_c126_1_01 0 bpf_c126_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_1_01 (mix_q_src_c126_1_01 mix_q_c126_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_02 (mix_i_src_c126_1_02 0 bpf_c126_1 0) vcvs gain=5.555702330196e-01
SMIXI_c126_1_02 (mix_i_src_c126_1_02 mix_i_c126_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_02 (mix_q_src_c126_1_02 0 bpf_c126_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_1_02 (mix_q_src_c126_1_02 mix_q_c126_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_03 (mix_i_src_c126_1_03 0 bpf_c126_1 0) vcvs gain=1.950903220161e-01
SMIXI_c126_1_03 (mix_i_src_c126_1_03 mix_i_c126_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_03 (mix_q_src_c126_1_03 0 bpf_c126_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_1_03 (mix_q_src_c126_1_03 mix_q_c126_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_04 (mix_i_src_c126_1_04 0 bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_1_04 (mix_i_src_c126_1_04 mix_i_c126_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_04 (mix_q_src_c126_1_04 0 bpf_c126_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_1_04 (mix_q_src_c126_1_04 mix_q_c126_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_05 (mix_i_src_c126_1_05 0 bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_1_05 (mix_i_src_c126_1_05 mix_i_c126_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_05 (mix_q_src_c126_1_05 0 bpf_c126_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_1_05 (mix_q_src_c126_1_05 mix_q_c126_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_06 (mix_i_src_c126_1_06 0 bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_1_06 (mix_i_src_c126_1_06 mix_i_c126_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_06 (mix_q_src_c126_1_06 0 bpf_c126_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_1_06 (mix_q_src_c126_1_06 mix_q_c126_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_07 (mix_i_src_c126_1_07 0 bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_1_07 (mix_i_src_c126_1_07 mix_i_c126_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_07 (mix_q_src_c126_1_07 0 bpf_c126_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_1_07 (mix_q_src_c126_1_07 mix_q_c126_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_08 (mix_i_src_c126_1_08 0 bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_1_08 (mix_i_src_c126_1_08 mix_i_c126_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_08 (mix_q_src_c126_1_08 0 bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_1_08 (mix_q_src_c126_1_08 mix_q_c126_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_09 (mix_i_src_c126_1_09 0 bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_1_09 (mix_i_src_c126_1_09 mix_i_c126_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_09 (mix_q_src_c126_1_09 0 bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_1_09 (mix_q_src_c126_1_09 mix_q_c126_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_10 (mix_i_src_c126_1_10 0 bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_1_10 (mix_i_src_c126_1_10 mix_i_c126_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_10 (mix_q_src_c126_1_10 0 bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_1_10 (mix_q_src_c126_1_10 mix_q_c126_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_11 (mix_i_src_c126_1_11 0 bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_1_11 (mix_i_src_c126_1_11 mix_i_c126_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_11 (mix_q_src_c126_1_11 0 bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_1_11 (mix_q_src_c126_1_11 mix_q_c126_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_12 (mix_i_src_c126_1_12 0 bpf_c126_1 0) vcvs gain=1.950903220161e-01
SMIXI_c126_1_12 (mix_i_src_c126_1_12 mix_i_c126_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_12 (mix_q_src_c126_1_12 0 bpf_c126_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_1_12 (mix_q_src_c126_1_12 mix_q_c126_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_13 (mix_i_src_c126_1_13 0 bpf_c126_1 0) vcvs gain=5.555702330196e-01
SMIXI_c126_1_13 (mix_i_src_c126_1_13 mix_i_c126_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_13 (mix_q_src_c126_1_13 0 bpf_c126_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_1_13 (mix_q_src_c126_1_13 mix_q_c126_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_14 (mix_i_src_c126_1_14 0 bpf_c126_1 0) vcvs gain=8.314696123025e-01
SMIXI_c126_1_14 (mix_i_src_c126_1_14 mix_i_c126_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_14 (mix_q_src_c126_1_14 0 bpf_c126_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_1_14 (mix_q_src_c126_1_14 mix_q_c126_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_1_15 (mix_i_src_c126_1_15 0 bpf_c126_1 0) vcvs gain=9.807852804032e-01
SMIXI_c126_1_15 (mix_i_src_c126_1_15 mix_i_c126_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_1_15 (mix_q_src_c126_1_15 0 bpf_c126_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_1_15 (mix_q_src_c126_1_15 mix_q_c126_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c126_1 (mix_i_c126_1 0) resistor r=1G
RMIXQ_c126_1 (mix_q_c126_1 0) resistor r=1G
RINTI_c126_1 (mix_i_c126_1 Icar_c126_1) resistor r=1k
CINTI_c126_1 (Icar_c126_1 0) capacitor c=80p
RINTQ_c126_1 (mix_q_c126_1 Qcar_c126_1) resistor r=1k
CINTQ_c126_1 (Qcar_c126_1 0) capacitor c=80p

// bl126, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c126_2 (bl126 n_cbpf_c126_2) capacitor c=4.503163717437e-14
LBPF_c126_2 (n_cbpf_c126_2 bpf_c126_2) inductor l=1.000000000000e-06
RBPF_c126_2 (bpf_c126_2 0) resistor r=2.356194490192e+02
EMIXI_c126_2_00 (mix_i_src_c126_2_00 0 bpf_c126_2 0) vcvs gain=9.807852804032e-01
SMIXI_c126_2_00 (mix_i_src_c126_2_00 mix_i_c126_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_00 (mix_q_src_c126_2_00 0 bpf_c126_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_2_00 (mix_q_src_c126_2_00 mix_q_c126_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_01 (mix_i_src_c126_2_01 0 bpf_c126_2 0) vcvs gain=8.314696123025e-01
SMIXI_c126_2_01 (mix_i_src_c126_2_01 mix_i_c126_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_01 (mix_q_src_c126_2_01 0 bpf_c126_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_2_01 (mix_q_src_c126_2_01 mix_q_c126_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_02 (mix_i_src_c126_2_02 0 bpf_c126_2 0) vcvs gain=5.555702330196e-01
SMIXI_c126_2_02 (mix_i_src_c126_2_02 mix_i_c126_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_02 (mix_q_src_c126_2_02 0 bpf_c126_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_2_02 (mix_q_src_c126_2_02 mix_q_c126_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_03 (mix_i_src_c126_2_03 0 bpf_c126_2 0) vcvs gain=1.950903220161e-01
SMIXI_c126_2_03 (mix_i_src_c126_2_03 mix_i_c126_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_03 (mix_q_src_c126_2_03 0 bpf_c126_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_2_03 (mix_q_src_c126_2_03 mix_q_c126_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_04 (mix_i_src_c126_2_04 0 bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_2_04 (mix_i_src_c126_2_04 mix_i_c126_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_04 (mix_q_src_c126_2_04 0 bpf_c126_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_2_04 (mix_q_src_c126_2_04 mix_q_c126_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_05 (mix_i_src_c126_2_05 0 bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_2_05 (mix_i_src_c126_2_05 mix_i_c126_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_05 (mix_q_src_c126_2_05 0 bpf_c126_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_2_05 (mix_q_src_c126_2_05 mix_q_c126_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_06 (mix_i_src_c126_2_06 0 bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_2_06 (mix_i_src_c126_2_06 mix_i_c126_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_06 (mix_q_src_c126_2_06 0 bpf_c126_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_2_06 (mix_q_src_c126_2_06 mix_q_c126_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_07 (mix_i_src_c126_2_07 0 bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_2_07 (mix_i_src_c126_2_07 mix_i_c126_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_07 (mix_q_src_c126_2_07 0 bpf_c126_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_2_07 (mix_q_src_c126_2_07 mix_q_c126_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_08 (mix_i_src_c126_2_08 0 bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_2_08 (mix_i_src_c126_2_08 mix_i_c126_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_08 (mix_q_src_c126_2_08 0 bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_2_08 (mix_q_src_c126_2_08 mix_q_c126_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_09 (mix_i_src_c126_2_09 0 bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_2_09 (mix_i_src_c126_2_09 mix_i_c126_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_09 (mix_q_src_c126_2_09 0 bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_2_09 (mix_q_src_c126_2_09 mix_q_c126_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_10 (mix_i_src_c126_2_10 0 bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_2_10 (mix_i_src_c126_2_10 mix_i_c126_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_10 (mix_q_src_c126_2_10 0 bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_2_10 (mix_q_src_c126_2_10 mix_q_c126_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_11 (mix_i_src_c126_2_11 0 bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_2_11 (mix_i_src_c126_2_11 mix_i_c126_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_11 (mix_q_src_c126_2_11 0 bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_2_11 (mix_q_src_c126_2_11 mix_q_c126_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_12 (mix_i_src_c126_2_12 0 bpf_c126_2 0) vcvs gain=1.950903220161e-01
SMIXI_c126_2_12 (mix_i_src_c126_2_12 mix_i_c126_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_12 (mix_q_src_c126_2_12 0 bpf_c126_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_2_12 (mix_q_src_c126_2_12 mix_q_c126_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_13 (mix_i_src_c126_2_13 0 bpf_c126_2 0) vcvs gain=5.555702330196e-01
SMIXI_c126_2_13 (mix_i_src_c126_2_13 mix_i_c126_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_13 (mix_q_src_c126_2_13 0 bpf_c126_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_2_13 (mix_q_src_c126_2_13 mix_q_c126_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_14 (mix_i_src_c126_2_14 0 bpf_c126_2 0) vcvs gain=8.314696123025e-01
SMIXI_c126_2_14 (mix_i_src_c126_2_14 mix_i_c126_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_14 (mix_q_src_c126_2_14 0 bpf_c126_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_2_14 (mix_q_src_c126_2_14 mix_q_c126_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_2_15 (mix_i_src_c126_2_15 0 bpf_c126_2 0) vcvs gain=9.807852804032e-01
SMIXI_c126_2_15 (mix_i_src_c126_2_15 mix_i_c126_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_2_15 (mix_q_src_c126_2_15 0 bpf_c126_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_2_15 (mix_q_src_c126_2_15 mix_q_c126_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c126_2 (mix_i_c126_2 0) resistor r=1G
RMIXQ_c126_2 (mix_q_c126_2 0) resistor r=1G
RINTI_c126_2 (mix_i_c126_2 Icar_c126_2) resistor r=1k
CINTI_c126_2 (Icar_c126_2 0) capacitor c=80p
RINTQ_c126_2 (mix_q_c126_2 Qcar_c126_2) resistor r=1k
CINTQ_c126_2 (Qcar_c126_2 0) capacitor c=80p

// bl126, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c126_3 (bl126 n_cbpf_c126_3) capacitor c=2.533029591058e-14
LBPF_c126_3 (n_cbpf_c126_3 bpf_c126_3) inductor l=1.000000000000e-06
RBPF_c126_3 (bpf_c126_3 0) resistor r=3.141592653590e+02
EMIXI_c126_3_00 (mix_i_src_c126_3_00 0 bpf_c126_3 0) vcvs gain=9.807852804032e-01
SMIXI_c126_3_00 (mix_i_src_c126_3_00 mix_i_c126_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_00 (mix_q_src_c126_3_00 0 bpf_c126_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_3_00 (mix_q_src_c126_3_00 mix_q_c126_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_01 (mix_i_src_c126_3_01 0 bpf_c126_3 0) vcvs gain=8.314696123025e-01
SMIXI_c126_3_01 (mix_i_src_c126_3_01 mix_i_c126_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_01 (mix_q_src_c126_3_01 0 bpf_c126_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_3_01 (mix_q_src_c126_3_01 mix_q_c126_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_02 (mix_i_src_c126_3_02 0 bpf_c126_3 0) vcvs gain=5.555702330196e-01
SMIXI_c126_3_02 (mix_i_src_c126_3_02 mix_i_c126_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_02 (mix_q_src_c126_3_02 0 bpf_c126_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_3_02 (mix_q_src_c126_3_02 mix_q_c126_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_03 (mix_i_src_c126_3_03 0 bpf_c126_3 0) vcvs gain=1.950903220161e-01
SMIXI_c126_3_03 (mix_i_src_c126_3_03 mix_i_c126_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_03 (mix_q_src_c126_3_03 0 bpf_c126_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_3_03 (mix_q_src_c126_3_03 mix_q_c126_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_04 (mix_i_src_c126_3_04 0 bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_3_04 (mix_i_src_c126_3_04 mix_i_c126_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_04 (mix_q_src_c126_3_04 0 bpf_c126_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c126_3_04 (mix_q_src_c126_3_04 mix_q_c126_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_05 (mix_i_src_c126_3_05 0 bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_3_05 (mix_i_src_c126_3_05 mix_i_c126_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_05 (mix_q_src_c126_3_05 0 bpf_c126_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c126_3_05 (mix_q_src_c126_3_05 mix_q_c126_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_06 (mix_i_src_c126_3_06 0 bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_3_06 (mix_i_src_c126_3_06 mix_i_c126_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_06 (mix_q_src_c126_3_06 0 bpf_c126_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c126_3_06 (mix_q_src_c126_3_06 mix_q_c126_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_07 (mix_i_src_c126_3_07 0 bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_3_07 (mix_i_src_c126_3_07 mix_i_c126_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_07 (mix_q_src_c126_3_07 0 bpf_c126_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c126_3_07 (mix_q_src_c126_3_07 mix_q_c126_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_08 (mix_i_src_c126_3_08 0 bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c126_3_08 (mix_i_src_c126_3_08 mix_i_c126_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_08 (mix_q_src_c126_3_08 0 bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_3_08 (mix_q_src_c126_3_08 mix_q_c126_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_09 (mix_i_src_c126_3_09 0 bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c126_3_09 (mix_i_src_c126_3_09 mix_i_c126_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_09 (mix_q_src_c126_3_09 0 bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_3_09 (mix_q_src_c126_3_09 mix_q_c126_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_10 (mix_i_src_c126_3_10 0 bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c126_3_10 (mix_i_src_c126_3_10 mix_i_c126_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_10 (mix_q_src_c126_3_10 0 bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_3_10 (mix_q_src_c126_3_10 mix_q_c126_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_11 (mix_i_src_c126_3_11 0 bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c126_3_11 (mix_i_src_c126_3_11 mix_i_c126_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_11 (mix_q_src_c126_3_11 0 bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_3_11 (mix_q_src_c126_3_11 mix_q_c126_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_12 (mix_i_src_c126_3_12 0 bpf_c126_3 0) vcvs gain=1.950903220161e-01
SMIXI_c126_3_12 (mix_i_src_c126_3_12 mix_i_c126_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_12 (mix_q_src_c126_3_12 0 bpf_c126_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c126_3_12 (mix_q_src_c126_3_12 mix_q_c126_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_13 (mix_i_src_c126_3_13 0 bpf_c126_3 0) vcvs gain=5.555702330196e-01
SMIXI_c126_3_13 (mix_i_src_c126_3_13 mix_i_c126_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_13 (mix_q_src_c126_3_13 0 bpf_c126_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c126_3_13 (mix_q_src_c126_3_13 mix_q_c126_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_14 (mix_i_src_c126_3_14 0 bpf_c126_3 0) vcvs gain=8.314696123025e-01
SMIXI_c126_3_14 (mix_i_src_c126_3_14 mix_i_c126_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_14 (mix_q_src_c126_3_14 0 bpf_c126_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c126_3_14 (mix_q_src_c126_3_14 mix_q_c126_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c126_3_15 (mix_i_src_c126_3_15 0 bpf_c126_3 0) vcvs gain=9.807852804032e-01
SMIXI_c126_3_15 (mix_i_src_c126_3_15 mix_i_c126_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c126_3_15 (mix_q_src_c126_3_15 0 bpf_c126_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c126_3_15 (mix_q_src_c126_3_15 mix_q_c126_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c126_3 (mix_i_c126_3 0) resistor r=1G
RMIXQ_c126_3 (mix_q_c126_3 0) resistor r=1G
RINTI_c126_3 (mix_i_c126_3 Icar_c126_3) resistor r=1k
CINTI_c126_3 (Icar_c126_3 0) capacitor c=80p
RINTQ_c126_3 (mix_q_c126_3 Qcar_c126_3) resistor r=1k
CINTQ_c126_3 (Qcar_c126_3 0) capacitor c=80p

// bl127, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c127_0 (bl127 n_cbpf_c127_0) capacitor c=4.052847345694e-13
LBPF_c127_0 (n_cbpf_c127_0 bpf_c127_0) inductor l=1.000000000000e-06
RBPF_c127_0 (bpf_c127_0 0) resistor r=7.853981633974e+01
EMIXI_c127_0_00 (mix_i_src_c127_0_00 0 bpf_c127_0 0) vcvs gain=9.807852804032e-01
SMIXI_c127_0_00 (mix_i_src_c127_0_00 mix_i_c127_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_00 (mix_q_src_c127_0_00 0 bpf_c127_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_0_00 (mix_q_src_c127_0_00 mix_q_c127_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_01 (mix_i_src_c127_0_01 0 bpf_c127_0 0) vcvs gain=8.314696123025e-01
SMIXI_c127_0_01 (mix_i_src_c127_0_01 mix_i_c127_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_01 (mix_q_src_c127_0_01 0 bpf_c127_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_0_01 (mix_q_src_c127_0_01 mix_q_c127_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_02 (mix_i_src_c127_0_02 0 bpf_c127_0 0) vcvs gain=5.555702330196e-01
SMIXI_c127_0_02 (mix_i_src_c127_0_02 mix_i_c127_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_02 (mix_q_src_c127_0_02 0 bpf_c127_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_0_02 (mix_q_src_c127_0_02 mix_q_c127_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_03 (mix_i_src_c127_0_03 0 bpf_c127_0 0) vcvs gain=1.950903220161e-01
SMIXI_c127_0_03 (mix_i_src_c127_0_03 mix_i_c127_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_03 (mix_q_src_c127_0_03 0 bpf_c127_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_0_03 (mix_q_src_c127_0_03 mix_q_c127_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_04 (mix_i_src_c127_0_04 0 bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_0_04 (mix_i_src_c127_0_04 mix_i_c127_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_04 (mix_q_src_c127_0_04 0 bpf_c127_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_0_04 (mix_q_src_c127_0_04 mix_q_c127_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_05 (mix_i_src_c127_0_05 0 bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_0_05 (mix_i_src_c127_0_05 mix_i_c127_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_05 (mix_q_src_c127_0_05 0 bpf_c127_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_0_05 (mix_q_src_c127_0_05 mix_q_c127_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_06 (mix_i_src_c127_0_06 0 bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_0_06 (mix_i_src_c127_0_06 mix_i_c127_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_06 (mix_q_src_c127_0_06 0 bpf_c127_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_0_06 (mix_q_src_c127_0_06 mix_q_c127_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_07 (mix_i_src_c127_0_07 0 bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_0_07 (mix_i_src_c127_0_07 mix_i_c127_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_07 (mix_q_src_c127_0_07 0 bpf_c127_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_0_07 (mix_q_src_c127_0_07 mix_q_c127_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_08 (mix_i_src_c127_0_08 0 bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_0_08 (mix_i_src_c127_0_08 mix_i_c127_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_08 (mix_q_src_c127_0_08 0 bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_0_08 (mix_q_src_c127_0_08 mix_q_c127_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_09 (mix_i_src_c127_0_09 0 bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_0_09 (mix_i_src_c127_0_09 mix_i_c127_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_09 (mix_q_src_c127_0_09 0 bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_0_09 (mix_q_src_c127_0_09 mix_q_c127_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_10 (mix_i_src_c127_0_10 0 bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_0_10 (mix_i_src_c127_0_10 mix_i_c127_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_10 (mix_q_src_c127_0_10 0 bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_0_10 (mix_q_src_c127_0_10 mix_q_c127_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_11 (mix_i_src_c127_0_11 0 bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_0_11 (mix_i_src_c127_0_11 mix_i_c127_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_11 (mix_q_src_c127_0_11 0 bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_0_11 (mix_q_src_c127_0_11 mix_q_c127_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_12 (mix_i_src_c127_0_12 0 bpf_c127_0 0) vcvs gain=1.950903220161e-01
SMIXI_c127_0_12 (mix_i_src_c127_0_12 mix_i_c127_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_12 (mix_q_src_c127_0_12 0 bpf_c127_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_0_12 (mix_q_src_c127_0_12 mix_q_c127_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_13 (mix_i_src_c127_0_13 0 bpf_c127_0 0) vcvs gain=5.555702330196e-01
SMIXI_c127_0_13 (mix_i_src_c127_0_13 mix_i_c127_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_13 (mix_q_src_c127_0_13 0 bpf_c127_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_0_13 (mix_q_src_c127_0_13 mix_q_c127_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_14 (mix_i_src_c127_0_14 0 bpf_c127_0 0) vcvs gain=8.314696123025e-01
SMIXI_c127_0_14 (mix_i_src_c127_0_14 mix_i_c127_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_14 (mix_q_src_c127_0_14 0 bpf_c127_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_0_14 (mix_q_src_c127_0_14 mix_q_c127_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_0_15 (mix_i_src_c127_0_15 0 bpf_c127_0 0) vcvs gain=9.807852804032e-01
SMIXI_c127_0_15 (mix_i_src_c127_0_15 mix_i_c127_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_0_15 (mix_q_src_c127_0_15 0 bpf_c127_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_0_15 (mix_q_src_c127_0_15 mix_q_c127_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c127_0 (mix_i_c127_0 0) resistor r=1G
RMIXQ_c127_0 (mix_q_c127_0 0) resistor r=1G
RINTI_c127_0 (mix_i_c127_0 Icar_c127_0) resistor r=1k
CINTI_c127_0 (Icar_c127_0 0) capacitor c=80p
RINTQ_c127_0 (mix_q_c127_0 Qcar_c127_0) resistor r=1k
CINTQ_c127_0 (Qcar_c127_0 0) capacitor c=80p
save bpf_c127_0 Icar_c127_0 Qcar_c127_0

// bl127, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c127_1 (bl127 n_cbpf_c127_1) capacitor c=1.013211836423e-13
LBPF_c127_1 (n_cbpf_c127_1 bpf_c127_1) inductor l=1.000000000000e-06
RBPF_c127_1 (bpf_c127_1 0) resistor r=1.570796326795e+02
EMIXI_c127_1_00 (mix_i_src_c127_1_00 0 bpf_c127_1 0) vcvs gain=9.807852804032e-01
SMIXI_c127_1_00 (mix_i_src_c127_1_00 mix_i_c127_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_00 (mix_q_src_c127_1_00 0 bpf_c127_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_1_00 (mix_q_src_c127_1_00 mix_q_c127_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_01 (mix_i_src_c127_1_01 0 bpf_c127_1 0) vcvs gain=8.314696123025e-01
SMIXI_c127_1_01 (mix_i_src_c127_1_01 mix_i_c127_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_01 (mix_q_src_c127_1_01 0 bpf_c127_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_1_01 (mix_q_src_c127_1_01 mix_q_c127_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_02 (mix_i_src_c127_1_02 0 bpf_c127_1 0) vcvs gain=5.555702330196e-01
SMIXI_c127_1_02 (mix_i_src_c127_1_02 mix_i_c127_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_02 (mix_q_src_c127_1_02 0 bpf_c127_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_1_02 (mix_q_src_c127_1_02 mix_q_c127_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_03 (mix_i_src_c127_1_03 0 bpf_c127_1 0) vcvs gain=1.950903220161e-01
SMIXI_c127_1_03 (mix_i_src_c127_1_03 mix_i_c127_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_03 (mix_q_src_c127_1_03 0 bpf_c127_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_1_03 (mix_q_src_c127_1_03 mix_q_c127_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_04 (mix_i_src_c127_1_04 0 bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_1_04 (mix_i_src_c127_1_04 mix_i_c127_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_04 (mix_q_src_c127_1_04 0 bpf_c127_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_1_04 (mix_q_src_c127_1_04 mix_q_c127_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_05 (mix_i_src_c127_1_05 0 bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_1_05 (mix_i_src_c127_1_05 mix_i_c127_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_05 (mix_q_src_c127_1_05 0 bpf_c127_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_1_05 (mix_q_src_c127_1_05 mix_q_c127_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_06 (mix_i_src_c127_1_06 0 bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_1_06 (mix_i_src_c127_1_06 mix_i_c127_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_06 (mix_q_src_c127_1_06 0 bpf_c127_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_1_06 (mix_q_src_c127_1_06 mix_q_c127_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_07 (mix_i_src_c127_1_07 0 bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_1_07 (mix_i_src_c127_1_07 mix_i_c127_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_07 (mix_q_src_c127_1_07 0 bpf_c127_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_1_07 (mix_q_src_c127_1_07 mix_q_c127_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_08 (mix_i_src_c127_1_08 0 bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_1_08 (mix_i_src_c127_1_08 mix_i_c127_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_08 (mix_q_src_c127_1_08 0 bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_1_08 (mix_q_src_c127_1_08 mix_q_c127_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_09 (mix_i_src_c127_1_09 0 bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_1_09 (mix_i_src_c127_1_09 mix_i_c127_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_09 (mix_q_src_c127_1_09 0 bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_1_09 (mix_q_src_c127_1_09 mix_q_c127_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_10 (mix_i_src_c127_1_10 0 bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_1_10 (mix_i_src_c127_1_10 mix_i_c127_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_10 (mix_q_src_c127_1_10 0 bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_1_10 (mix_q_src_c127_1_10 mix_q_c127_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_11 (mix_i_src_c127_1_11 0 bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_1_11 (mix_i_src_c127_1_11 mix_i_c127_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_11 (mix_q_src_c127_1_11 0 bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_1_11 (mix_q_src_c127_1_11 mix_q_c127_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_12 (mix_i_src_c127_1_12 0 bpf_c127_1 0) vcvs gain=1.950903220161e-01
SMIXI_c127_1_12 (mix_i_src_c127_1_12 mix_i_c127_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_12 (mix_q_src_c127_1_12 0 bpf_c127_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_1_12 (mix_q_src_c127_1_12 mix_q_c127_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_13 (mix_i_src_c127_1_13 0 bpf_c127_1 0) vcvs gain=5.555702330196e-01
SMIXI_c127_1_13 (mix_i_src_c127_1_13 mix_i_c127_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_13 (mix_q_src_c127_1_13 0 bpf_c127_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_1_13 (mix_q_src_c127_1_13 mix_q_c127_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_14 (mix_i_src_c127_1_14 0 bpf_c127_1 0) vcvs gain=8.314696123025e-01
SMIXI_c127_1_14 (mix_i_src_c127_1_14 mix_i_c127_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_14 (mix_q_src_c127_1_14 0 bpf_c127_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_1_14 (mix_q_src_c127_1_14 mix_q_c127_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_1_15 (mix_i_src_c127_1_15 0 bpf_c127_1 0) vcvs gain=9.807852804032e-01
SMIXI_c127_1_15 (mix_i_src_c127_1_15 mix_i_c127_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_1_15 (mix_q_src_c127_1_15 0 bpf_c127_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_1_15 (mix_q_src_c127_1_15 mix_q_c127_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c127_1 (mix_i_c127_1 0) resistor r=1G
RMIXQ_c127_1 (mix_q_c127_1 0) resistor r=1G
RINTI_c127_1 (mix_i_c127_1 Icar_c127_1) resistor r=1k
CINTI_c127_1 (Icar_c127_1 0) capacitor c=80p
RINTQ_c127_1 (mix_q_c127_1 Qcar_c127_1) resistor r=1k
CINTQ_c127_1 (Qcar_c127_1 0) capacitor c=80p
save bpf_c127_1 Icar_c127_1 Qcar_c127_1

// bl127, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c127_2 (bl127 n_cbpf_c127_2) capacitor c=4.503163717437e-14
LBPF_c127_2 (n_cbpf_c127_2 bpf_c127_2) inductor l=1.000000000000e-06
RBPF_c127_2 (bpf_c127_2 0) resistor r=2.356194490192e+02
EMIXI_c127_2_00 (mix_i_src_c127_2_00 0 bpf_c127_2 0) vcvs gain=9.807852804032e-01
SMIXI_c127_2_00 (mix_i_src_c127_2_00 mix_i_c127_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_00 (mix_q_src_c127_2_00 0 bpf_c127_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_2_00 (mix_q_src_c127_2_00 mix_q_c127_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_01 (mix_i_src_c127_2_01 0 bpf_c127_2 0) vcvs gain=8.314696123025e-01
SMIXI_c127_2_01 (mix_i_src_c127_2_01 mix_i_c127_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_01 (mix_q_src_c127_2_01 0 bpf_c127_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_2_01 (mix_q_src_c127_2_01 mix_q_c127_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_02 (mix_i_src_c127_2_02 0 bpf_c127_2 0) vcvs gain=5.555702330196e-01
SMIXI_c127_2_02 (mix_i_src_c127_2_02 mix_i_c127_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_02 (mix_q_src_c127_2_02 0 bpf_c127_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_2_02 (mix_q_src_c127_2_02 mix_q_c127_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_03 (mix_i_src_c127_2_03 0 bpf_c127_2 0) vcvs gain=1.950903220161e-01
SMIXI_c127_2_03 (mix_i_src_c127_2_03 mix_i_c127_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_03 (mix_q_src_c127_2_03 0 bpf_c127_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_2_03 (mix_q_src_c127_2_03 mix_q_c127_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_04 (mix_i_src_c127_2_04 0 bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_2_04 (mix_i_src_c127_2_04 mix_i_c127_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_04 (mix_q_src_c127_2_04 0 bpf_c127_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_2_04 (mix_q_src_c127_2_04 mix_q_c127_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_05 (mix_i_src_c127_2_05 0 bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_2_05 (mix_i_src_c127_2_05 mix_i_c127_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_05 (mix_q_src_c127_2_05 0 bpf_c127_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_2_05 (mix_q_src_c127_2_05 mix_q_c127_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_06 (mix_i_src_c127_2_06 0 bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_2_06 (mix_i_src_c127_2_06 mix_i_c127_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_06 (mix_q_src_c127_2_06 0 bpf_c127_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_2_06 (mix_q_src_c127_2_06 mix_q_c127_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_07 (mix_i_src_c127_2_07 0 bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_2_07 (mix_i_src_c127_2_07 mix_i_c127_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_07 (mix_q_src_c127_2_07 0 bpf_c127_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_2_07 (mix_q_src_c127_2_07 mix_q_c127_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_08 (mix_i_src_c127_2_08 0 bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_2_08 (mix_i_src_c127_2_08 mix_i_c127_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_08 (mix_q_src_c127_2_08 0 bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_2_08 (mix_q_src_c127_2_08 mix_q_c127_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_09 (mix_i_src_c127_2_09 0 bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_2_09 (mix_i_src_c127_2_09 mix_i_c127_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_09 (mix_q_src_c127_2_09 0 bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_2_09 (mix_q_src_c127_2_09 mix_q_c127_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_10 (mix_i_src_c127_2_10 0 bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_2_10 (mix_i_src_c127_2_10 mix_i_c127_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_10 (mix_q_src_c127_2_10 0 bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_2_10 (mix_q_src_c127_2_10 mix_q_c127_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_11 (mix_i_src_c127_2_11 0 bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_2_11 (mix_i_src_c127_2_11 mix_i_c127_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_11 (mix_q_src_c127_2_11 0 bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_2_11 (mix_q_src_c127_2_11 mix_q_c127_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_12 (mix_i_src_c127_2_12 0 bpf_c127_2 0) vcvs gain=1.950903220161e-01
SMIXI_c127_2_12 (mix_i_src_c127_2_12 mix_i_c127_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_12 (mix_q_src_c127_2_12 0 bpf_c127_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_2_12 (mix_q_src_c127_2_12 mix_q_c127_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_13 (mix_i_src_c127_2_13 0 bpf_c127_2 0) vcvs gain=5.555702330196e-01
SMIXI_c127_2_13 (mix_i_src_c127_2_13 mix_i_c127_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_13 (mix_q_src_c127_2_13 0 bpf_c127_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_2_13 (mix_q_src_c127_2_13 mix_q_c127_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_14 (mix_i_src_c127_2_14 0 bpf_c127_2 0) vcvs gain=8.314696123025e-01
SMIXI_c127_2_14 (mix_i_src_c127_2_14 mix_i_c127_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_14 (mix_q_src_c127_2_14 0 bpf_c127_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_2_14 (mix_q_src_c127_2_14 mix_q_c127_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_2_15 (mix_i_src_c127_2_15 0 bpf_c127_2 0) vcvs gain=9.807852804032e-01
SMIXI_c127_2_15 (mix_i_src_c127_2_15 mix_i_c127_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_2_15 (mix_q_src_c127_2_15 0 bpf_c127_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_2_15 (mix_q_src_c127_2_15 mix_q_c127_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c127_2 (mix_i_c127_2 0) resistor r=1G
RMIXQ_c127_2 (mix_q_c127_2 0) resistor r=1G
RINTI_c127_2 (mix_i_c127_2 Icar_c127_2) resistor r=1k
CINTI_c127_2 (Icar_c127_2 0) capacitor c=80p
RINTQ_c127_2 (mix_q_c127_2 Qcar_c127_2) resistor r=1k
CINTQ_c127_2 (Qcar_c127_2 0) capacitor c=80p
save bpf_c127_2 Icar_c127_2 Qcar_c127_2

// bl127, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c127_3 (bl127 n_cbpf_c127_3) capacitor c=2.533029591058e-14
LBPF_c127_3 (n_cbpf_c127_3 bpf_c127_3) inductor l=1.000000000000e-06
RBPF_c127_3 (bpf_c127_3 0) resistor r=3.141592653590e+02
EMIXI_c127_3_00 (mix_i_src_c127_3_00 0 bpf_c127_3 0) vcvs gain=9.807852804032e-01
SMIXI_c127_3_00 (mix_i_src_c127_3_00 mix_i_c127_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_00 (mix_q_src_c127_3_00 0 bpf_c127_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_3_00 (mix_q_src_c127_3_00 mix_q_c127_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_01 (mix_i_src_c127_3_01 0 bpf_c127_3 0) vcvs gain=8.314696123025e-01
SMIXI_c127_3_01 (mix_i_src_c127_3_01 mix_i_c127_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_01 (mix_q_src_c127_3_01 0 bpf_c127_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_3_01 (mix_q_src_c127_3_01 mix_q_c127_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_02 (mix_i_src_c127_3_02 0 bpf_c127_3 0) vcvs gain=5.555702330196e-01
SMIXI_c127_3_02 (mix_i_src_c127_3_02 mix_i_c127_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_02 (mix_q_src_c127_3_02 0 bpf_c127_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_3_02 (mix_q_src_c127_3_02 mix_q_c127_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_03 (mix_i_src_c127_3_03 0 bpf_c127_3 0) vcvs gain=1.950903220161e-01
SMIXI_c127_3_03 (mix_i_src_c127_3_03 mix_i_c127_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_03 (mix_q_src_c127_3_03 0 bpf_c127_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_3_03 (mix_q_src_c127_3_03 mix_q_c127_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_04 (mix_i_src_c127_3_04 0 bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_3_04 (mix_i_src_c127_3_04 mix_i_c127_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_04 (mix_q_src_c127_3_04 0 bpf_c127_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c127_3_04 (mix_q_src_c127_3_04 mix_q_c127_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_05 (mix_i_src_c127_3_05 0 bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_3_05 (mix_i_src_c127_3_05 mix_i_c127_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_05 (mix_q_src_c127_3_05 0 bpf_c127_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c127_3_05 (mix_q_src_c127_3_05 mix_q_c127_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_06 (mix_i_src_c127_3_06 0 bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_3_06 (mix_i_src_c127_3_06 mix_i_c127_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_06 (mix_q_src_c127_3_06 0 bpf_c127_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c127_3_06 (mix_q_src_c127_3_06 mix_q_c127_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_07 (mix_i_src_c127_3_07 0 bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_3_07 (mix_i_src_c127_3_07 mix_i_c127_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_07 (mix_q_src_c127_3_07 0 bpf_c127_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c127_3_07 (mix_q_src_c127_3_07 mix_q_c127_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_08 (mix_i_src_c127_3_08 0 bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c127_3_08 (mix_i_src_c127_3_08 mix_i_c127_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_08 (mix_q_src_c127_3_08 0 bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c127_3_08 (mix_q_src_c127_3_08 mix_q_c127_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_09 (mix_i_src_c127_3_09 0 bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c127_3_09 (mix_i_src_c127_3_09 mix_i_c127_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_09 (mix_q_src_c127_3_09 0 bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_3_09 (mix_q_src_c127_3_09 mix_q_c127_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_10 (mix_i_src_c127_3_10 0 bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c127_3_10 (mix_i_src_c127_3_10 mix_i_c127_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_10 (mix_q_src_c127_3_10 0 bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_3_10 (mix_q_src_c127_3_10 mix_q_c127_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_11 (mix_i_src_c127_3_11 0 bpf_c127_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c127_3_11 (mix_i_src_c127_3_11 mix_i_c127_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_11 (mix_q_src_c127_3_11 0 bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_3_11 (mix_q_src_c127_3_11 mix_q_c127_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_12 (mix_i_src_c127_3_12 0 bpf_c127_3 0) vcvs gain=1.950903220161e-01
SMIXI_c127_3_12 (mix_i_src_c127_3_12 mix_i_c127_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_12 (mix_q_src_c127_3_12 0 bpf_c127_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c127_3_12 (mix_q_src_c127_3_12 mix_q_c127_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_13 (mix_i_src_c127_3_13 0 bpf_c127_3 0) vcvs gain=5.555702330196e-01
SMIXI_c127_3_13 (mix_i_src_c127_3_13 mix_i_c127_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_13 (mix_q_src_c127_3_13 0 bpf_c127_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c127_3_13 (mix_q_src_c127_3_13 mix_q_c127_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_14 (mix_i_src_c127_3_14 0 bpf_c127_3 0) vcvs gain=8.314696123025e-01
SMIXI_c127_3_14 (mix_i_src_c127_3_14 mix_i_c127_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c127_3_14 (mix_q_src_c127_3_14 0 bpf_c127_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c127_3_14 (mix_q_src_c127_3_14 mix_q_c127_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c127_3_15 (mix_i_src_c127_3_15 0 bpf_c127_3 0) vcvs gain=9.807852804032e-01
