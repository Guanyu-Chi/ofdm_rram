SMIXQ_c070_3_11 (mix_q_src_c070_3_11 mix_q_c070_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_12 (mix_i_src_c070_3_12 0 bpf_c070_3 0) vcvs gain=1.950903220161e-01
SMIXI_c070_3_12 (mix_i_src_c070_3_12 mix_i_c070_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_12 (mix_q_src_c070_3_12 0 bpf_c070_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c070_3_12 (mix_q_src_c070_3_12 mix_q_c070_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_13 (mix_i_src_c070_3_13 0 bpf_c070_3 0) vcvs gain=5.555702330196e-01
SMIXI_c070_3_13 (mix_i_src_c070_3_13 mix_i_c070_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_13 (mix_q_src_c070_3_13 0 bpf_c070_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c070_3_13 (mix_q_src_c070_3_13 mix_q_c070_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_14 (mix_i_src_c070_3_14 0 bpf_c070_3 0) vcvs gain=8.314696123025e-01
SMIXI_c070_3_14 (mix_i_src_c070_3_14 mix_i_c070_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_14 (mix_q_src_c070_3_14 0 bpf_c070_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c070_3_14 (mix_q_src_c070_3_14 mix_q_c070_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c070_3_15 (mix_i_src_c070_3_15 0 bpf_c070_3 0) vcvs gain=9.807852804032e-01
SMIXI_c070_3_15 (mix_i_src_c070_3_15 mix_i_c070_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c070_3_15 (mix_q_src_c070_3_15 0 bpf_c070_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c070_3_15 (mix_q_src_c070_3_15 mix_q_c070_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c070_3 (mix_i_c070_3 0) resistor r=1G
RMIXQ_c070_3 (mix_q_c070_3 0) resistor r=1G
RINTI_c070_3 (mix_i_c070_3 Icar_c070_3) resistor r=1k
CINTI_c070_3 (Icar_c070_3 0) capacitor c=80p
RINTQ_c070_3 (mix_q_c070_3 Qcar_c070_3) resistor r=1k
CINTQ_c070_3 (Qcar_c070_3 0) capacitor c=80p

// bl071, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c071_0 (bl071 n_cbpf_c071_0) capacitor c=4.052847345694e-13
LBPF_c071_0 (n_cbpf_c071_0 bpf_c071_0) inductor l=1.000000000000e-06
RBPF_c071_0 (bpf_c071_0 0) resistor r=7.853981633974e+01
EMIXI_c071_0_00 (mix_i_src_c071_0_00 0 bpf_c071_0 0) vcvs gain=9.807852804032e-01
SMIXI_c071_0_00 (mix_i_src_c071_0_00 mix_i_c071_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_00 (mix_q_src_c071_0_00 0 bpf_c071_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_0_00 (mix_q_src_c071_0_00 mix_q_c071_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_01 (mix_i_src_c071_0_01 0 bpf_c071_0 0) vcvs gain=8.314696123025e-01
SMIXI_c071_0_01 (mix_i_src_c071_0_01 mix_i_c071_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_01 (mix_q_src_c071_0_01 0 bpf_c071_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_0_01 (mix_q_src_c071_0_01 mix_q_c071_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_02 (mix_i_src_c071_0_02 0 bpf_c071_0 0) vcvs gain=5.555702330196e-01
SMIXI_c071_0_02 (mix_i_src_c071_0_02 mix_i_c071_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_02 (mix_q_src_c071_0_02 0 bpf_c071_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_0_02 (mix_q_src_c071_0_02 mix_q_c071_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_03 (mix_i_src_c071_0_03 0 bpf_c071_0 0) vcvs gain=1.950903220161e-01
SMIXI_c071_0_03 (mix_i_src_c071_0_03 mix_i_c071_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_03 (mix_q_src_c071_0_03 0 bpf_c071_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_0_03 (mix_q_src_c071_0_03 mix_q_c071_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_04 (mix_i_src_c071_0_04 0 bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_0_04 (mix_i_src_c071_0_04 mix_i_c071_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_04 (mix_q_src_c071_0_04 0 bpf_c071_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_0_04 (mix_q_src_c071_0_04 mix_q_c071_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_05 (mix_i_src_c071_0_05 0 bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_0_05 (mix_i_src_c071_0_05 mix_i_c071_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_05 (mix_q_src_c071_0_05 0 bpf_c071_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_0_05 (mix_q_src_c071_0_05 mix_q_c071_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_06 (mix_i_src_c071_0_06 0 bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_0_06 (mix_i_src_c071_0_06 mix_i_c071_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_06 (mix_q_src_c071_0_06 0 bpf_c071_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_0_06 (mix_q_src_c071_0_06 mix_q_c071_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_07 (mix_i_src_c071_0_07 0 bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_0_07 (mix_i_src_c071_0_07 mix_i_c071_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_07 (mix_q_src_c071_0_07 0 bpf_c071_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_0_07 (mix_q_src_c071_0_07 mix_q_c071_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_08 (mix_i_src_c071_0_08 0 bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_0_08 (mix_i_src_c071_0_08 mix_i_c071_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_08 (mix_q_src_c071_0_08 0 bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_0_08 (mix_q_src_c071_0_08 mix_q_c071_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_09 (mix_i_src_c071_0_09 0 bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_0_09 (mix_i_src_c071_0_09 mix_i_c071_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_09 (mix_q_src_c071_0_09 0 bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_0_09 (mix_q_src_c071_0_09 mix_q_c071_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_10 (mix_i_src_c071_0_10 0 bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_0_10 (mix_i_src_c071_0_10 mix_i_c071_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_10 (mix_q_src_c071_0_10 0 bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_0_10 (mix_q_src_c071_0_10 mix_q_c071_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_11 (mix_i_src_c071_0_11 0 bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_0_11 (mix_i_src_c071_0_11 mix_i_c071_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_11 (mix_q_src_c071_0_11 0 bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_0_11 (mix_q_src_c071_0_11 mix_q_c071_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_12 (mix_i_src_c071_0_12 0 bpf_c071_0 0) vcvs gain=1.950903220161e-01
SMIXI_c071_0_12 (mix_i_src_c071_0_12 mix_i_c071_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_12 (mix_q_src_c071_0_12 0 bpf_c071_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_0_12 (mix_q_src_c071_0_12 mix_q_c071_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_13 (mix_i_src_c071_0_13 0 bpf_c071_0 0) vcvs gain=5.555702330196e-01
SMIXI_c071_0_13 (mix_i_src_c071_0_13 mix_i_c071_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_13 (mix_q_src_c071_0_13 0 bpf_c071_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_0_13 (mix_q_src_c071_0_13 mix_q_c071_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_14 (mix_i_src_c071_0_14 0 bpf_c071_0 0) vcvs gain=8.314696123025e-01
SMIXI_c071_0_14 (mix_i_src_c071_0_14 mix_i_c071_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_14 (mix_q_src_c071_0_14 0 bpf_c071_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_0_14 (mix_q_src_c071_0_14 mix_q_c071_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_0_15 (mix_i_src_c071_0_15 0 bpf_c071_0 0) vcvs gain=9.807852804032e-01
SMIXI_c071_0_15 (mix_i_src_c071_0_15 mix_i_c071_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_0_15 (mix_q_src_c071_0_15 0 bpf_c071_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_0_15 (mix_q_src_c071_0_15 mix_q_c071_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c071_0 (mix_i_c071_0 0) resistor r=1G
RMIXQ_c071_0 (mix_q_c071_0 0) resistor r=1G
RINTI_c071_0 (mix_i_c071_0 Icar_c071_0) resistor r=1k
CINTI_c071_0 (Icar_c071_0 0) capacitor c=80p
RINTQ_c071_0 (mix_q_c071_0 Qcar_c071_0) resistor r=1k
CINTQ_c071_0 (Qcar_c071_0 0) capacitor c=80p

// bl071, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c071_1 (bl071 n_cbpf_c071_1) capacitor c=1.013211836423e-13
LBPF_c071_1 (n_cbpf_c071_1 bpf_c071_1) inductor l=1.000000000000e-06
RBPF_c071_1 (bpf_c071_1 0) resistor r=1.570796326795e+02
EMIXI_c071_1_00 (mix_i_src_c071_1_00 0 bpf_c071_1 0) vcvs gain=9.807852804032e-01
SMIXI_c071_1_00 (mix_i_src_c071_1_00 mix_i_c071_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_00 (mix_q_src_c071_1_00 0 bpf_c071_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_1_00 (mix_q_src_c071_1_00 mix_q_c071_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_01 (mix_i_src_c071_1_01 0 bpf_c071_1 0) vcvs gain=8.314696123025e-01
SMIXI_c071_1_01 (mix_i_src_c071_1_01 mix_i_c071_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_01 (mix_q_src_c071_1_01 0 bpf_c071_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_1_01 (mix_q_src_c071_1_01 mix_q_c071_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_02 (mix_i_src_c071_1_02 0 bpf_c071_1 0) vcvs gain=5.555702330196e-01
SMIXI_c071_1_02 (mix_i_src_c071_1_02 mix_i_c071_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_02 (mix_q_src_c071_1_02 0 bpf_c071_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_1_02 (mix_q_src_c071_1_02 mix_q_c071_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_03 (mix_i_src_c071_1_03 0 bpf_c071_1 0) vcvs gain=1.950903220161e-01
SMIXI_c071_1_03 (mix_i_src_c071_1_03 mix_i_c071_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_03 (mix_q_src_c071_1_03 0 bpf_c071_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_1_03 (mix_q_src_c071_1_03 mix_q_c071_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_04 (mix_i_src_c071_1_04 0 bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_1_04 (mix_i_src_c071_1_04 mix_i_c071_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_04 (mix_q_src_c071_1_04 0 bpf_c071_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_1_04 (mix_q_src_c071_1_04 mix_q_c071_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_05 (mix_i_src_c071_1_05 0 bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_1_05 (mix_i_src_c071_1_05 mix_i_c071_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_05 (mix_q_src_c071_1_05 0 bpf_c071_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_1_05 (mix_q_src_c071_1_05 mix_q_c071_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_06 (mix_i_src_c071_1_06 0 bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_1_06 (mix_i_src_c071_1_06 mix_i_c071_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_06 (mix_q_src_c071_1_06 0 bpf_c071_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_1_06 (mix_q_src_c071_1_06 mix_q_c071_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_07 (mix_i_src_c071_1_07 0 bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_1_07 (mix_i_src_c071_1_07 mix_i_c071_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_07 (mix_q_src_c071_1_07 0 bpf_c071_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_1_07 (mix_q_src_c071_1_07 mix_q_c071_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_08 (mix_i_src_c071_1_08 0 bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_1_08 (mix_i_src_c071_1_08 mix_i_c071_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_08 (mix_q_src_c071_1_08 0 bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_1_08 (mix_q_src_c071_1_08 mix_q_c071_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_09 (mix_i_src_c071_1_09 0 bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_1_09 (mix_i_src_c071_1_09 mix_i_c071_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_09 (mix_q_src_c071_1_09 0 bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_1_09 (mix_q_src_c071_1_09 mix_q_c071_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_10 (mix_i_src_c071_1_10 0 bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_1_10 (mix_i_src_c071_1_10 mix_i_c071_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_10 (mix_q_src_c071_1_10 0 bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_1_10 (mix_q_src_c071_1_10 mix_q_c071_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_11 (mix_i_src_c071_1_11 0 bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_1_11 (mix_i_src_c071_1_11 mix_i_c071_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_11 (mix_q_src_c071_1_11 0 bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_1_11 (mix_q_src_c071_1_11 mix_q_c071_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_12 (mix_i_src_c071_1_12 0 bpf_c071_1 0) vcvs gain=1.950903220161e-01
SMIXI_c071_1_12 (mix_i_src_c071_1_12 mix_i_c071_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_12 (mix_q_src_c071_1_12 0 bpf_c071_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_1_12 (mix_q_src_c071_1_12 mix_q_c071_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_13 (mix_i_src_c071_1_13 0 bpf_c071_1 0) vcvs gain=5.555702330196e-01
SMIXI_c071_1_13 (mix_i_src_c071_1_13 mix_i_c071_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_13 (mix_q_src_c071_1_13 0 bpf_c071_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_1_13 (mix_q_src_c071_1_13 mix_q_c071_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_14 (mix_i_src_c071_1_14 0 bpf_c071_1 0) vcvs gain=8.314696123025e-01
SMIXI_c071_1_14 (mix_i_src_c071_1_14 mix_i_c071_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_14 (mix_q_src_c071_1_14 0 bpf_c071_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_1_14 (mix_q_src_c071_1_14 mix_q_c071_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_1_15 (mix_i_src_c071_1_15 0 bpf_c071_1 0) vcvs gain=9.807852804032e-01
SMIXI_c071_1_15 (mix_i_src_c071_1_15 mix_i_c071_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_1_15 (mix_q_src_c071_1_15 0 bpf_c071_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_1_15 (mix_q_src_c071_1_15 mix_q_c071_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c071_1 (mix_i_c071_1 0) resistor r=1G
RMIXQ_c071_1 (mix_q_c071_1 0) resistor r=1G
RINTI_c071_1 (mix_i_c071_1 Icar_c071_1) resistor r=1k
CINTI_c071_1 (Icar_c071_1 0) capacitor c=80p
RINTQ_c071_1 (mix_q_c071_1 Qcar_c071_1) resistor r=1k
CINTQ_c071_1 (Qcar_c071_1 0) capacitor c=80p

// bl071, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c071_2 (bl071 n_cbpf_c071_2) capacitor c=4.503163717437e-14
LBPF_c071_2 (n_cbpf_c071_2 bpf_c071_2) inductor l=1.000000000000e-06
RBPF_c071_2 (bpf_c071_2 0) resistor r=2.356194490192e+02
EMIXI_c071_2_00 (mix_i_src_c071_2_00 0 bpf_c071_2 0) vcvs gain=9.807852804032e-01
SMIXI_c071_2_00 (mix_i_src_c071_2_00 mix_i_c071_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_00 (mix_q_src_c071_2_00 0 bpf_c071_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_2_00 (mix_q_src_c071_2_00 mix_q_c071_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_01 (mix_i_src_c071_2_01 0 bpf_c071_2 0) vcvs gain=8.314696123025e-01
SMIXI_c071_2_01 (mix_i_src_c071_2_01 mix_i_c071_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_01 (mix_q_src_c071_2_01 0 bpf_c071_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_2_01 (mix_q_src_c071_2_01 mix_q_c071_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_02 (mix_i_src_c071_2_02 0 bpf_c071_2 0) vcvs gain=5.555702330196e-01
SMIXI_c071_2_02 (mix_i_src_c071_2_02 mix_i_c071_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_02 (mix_q_src_c071_2_02 0 bpf_c071_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_2_02 (mix_q_src_c071_2_02 mix_q_c071_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_03 (mix_i_src_c071_2_03 0 bpf_c071_2 0) vcvs gain=1.950903220161e-01
SMIXI_c071_2_03 (mix_i_src_c071_2_03 mix_i_c071_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_03 (mix_q_src_c071_2_03 0 bpf_c071_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_2_03 (mix_q_src_c071_2_03 mix_q_c071_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_04 (mix_i_src_c071_2_04 0 bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_2_04 (mix_i_src_c071_2_04 mix_i_c071_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_04 (mix_q_src_c071_2_04 0 bpf_c071_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_2_04 (mix_q_src_c071_2_04 mix_q_c071_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_05 (mix_i_src_c071_2_05 0 bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_2_05 (mix_i_src_c071_2_05 mix_i_c071_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_05 (mix_q_src_c071_2_05 0 bpf_c071_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_2_05 (mix_q_src_c071_2_05 mix_q_c071_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_06 (mix_i_src_c071_2_06 0 bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_2_06 (mix_i_src_c071_2_06 mix_i_c071_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_06 (mix_q_src_c071_2_06 0 bpf_c071_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_2_06 (mix_q_src_c071_2_06 mix_q_c071_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_07 (mix_i_src_c071_2_07 0 bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_2_07 (mix_i_src_c071_2_07 mix_i_c071_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_07 (mix_q_src_c071_2_07 0 bpf_c071_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_2_07 (mix_q_src_c071_2_07 mix_q_c071_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_08 (mix_i_src_c071_2_08 0 bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_2_08 (mix_i_src_c071_2_08 mix_i_c071_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_08 (mix_q_src_c071_2_08 0 bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_2_08 (mix_q_src_c071_2_08 mix_q_c071_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_09 (mix_i_src_c071_2_09 0 bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_2_09 (mix_i_src_c071_2_09 mix_i_c071_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_09 (mix_q_src_c071_2_09 0 bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_2_09 (mix_q_src_c071_2_09 mix_q_c071_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_10 (mix_i_src_c071_2_10 0 bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_2_10 (mix_i_src_c071_2_10 mix_i_c071_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_10 (mix_q_src_c071_2_10 0 bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_2_10 (mix_q_src_c071_2_10 mix_q_c071_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_11 (mix_i_src_c071_2_11 0 bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_2_11 (mix_i_src_c071_2_11 mix_i_c071_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_11 (mix_q_src_c071_2_11 0 bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_2_11 (mix_q_src_c071_2_11 mix_q_c071_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_12 (mix_i_src_c071_2_12 0 bpf_c071_2 0) vcvs gain=1.950903220161e-01
SMIXI_c071_2_12 (mix_i_src_c071_2_12 mix_i_c071_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_12 (mix_q_src_c071_2_12 0 bpf_c071_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_2_12 (mix_q_src_c071_2_12 mix_q_c071_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_13 (mix_i_src_c071_2_13 0 bpf_c071_2 0) vcvs gain=5.555702330196e-01
SMIXI_c071_2_13 (mix_i_src_c071_2_13 mix_i_c071_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_13 (mix_q_src_c071_2_13 0 bpf_c071_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_2_13 (mix_q_src_c071_2_13 mix_q_c071_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_14 (mix_i_src_c071_2_14 0 bpf_c071_2 0) vcvs gain=8.314696123025e-01
SMIXI_c071_2_14 (mix_i_src_c071_2_14 mix_i_c071_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_14 (mix_q_src_c071_2_14 0 bpf_c071_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_2_14 (mix_q_src_c071_2_14 mix_q_c071_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_2_15 (mix_i_src_c071_2_15 0 bpf_c071_2 0) vcvs gain=9.807852804032e-01
SMIXI_c071_2_15 (mix_i_src_c071_2_15 mix_i_c071_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_2_15 (mix_q_src_c071_2_15 0 bpf_c071_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_2_15 (mix_q_src_c071_2_15 mix_q_c071_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c071_2 (mix_i_c071_2 0) resistor r=1G
RMIXQ_c071_2 (mix_q_c071_2 0) resistor r=1G
RINTI_c071_2 (mix_i_c071_2 Icar_c071_2) resistor r=1k
CINTI_c071_2 (Icar_c071_2 0) capacitor c=80p
RINTQ_c071_2 (mix_q_c071_2 Qcar_c071_2) resistor r=1k
CINTQ_c071_2 (Qcar_c071_2 0) capacitor c=80p

// bl071, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c071_3 (bl071 n_cbpf_c071_3) capacitor c=2.533029591058e-14
LBPF_c071_3 (n_cbpf_c071_3 bpf_c071_3) inductor l=1.000000000000e-06
RBPF_c071_3 (bpf_c071_3 0) resistor r=3.141592653590e+02
EMIXI_c071_3_00 (mix_i_src_c071_3_00 0 bpf_c071_3 0) vcvs gain=9.807852804032e-01
SMIXI_c071_3_00 (mix_i_src_c071_3_00 mix_i_c071_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_00 (mix_q_src_c071_3_00 0 bpf_c071_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_3_00 (mix_q_src_c071_3_00 mix_q_c071_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_01 (mix_i_src_c071_3_01 0 bpf_c071_3 0) vcvs gain=8.314696123025e-01
SMIXI_c071_3_01 (mix_i_src_c071_3_01 mix_i_c071_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_01 (mix_q_src_c071_3_01 0 bpf_c071_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_3_01 (mix_q_src_c071_3_01 mix_q_c071_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_02 (mix_i_src_c071_3_02 0 bpf_c071_3 0) vcvs gain=5.555702330196e-01
SMIXI_c071_3_02 (mix_i_src_c071_3_02 mix_i_c071_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_02 (mix_q_src_c071_3_02 0 bpf_c071_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_3_02 (mix_q_src_c071_3_02 mix_q_c071_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_03 (mix_i_src_c071_3_03 0 bpf_c071_3 0) vcvs gain=1.950903220161e-01
SMIXI_c071_3_03 (mix_i_src_c071_3_03 mix_i_c071_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_03 (mix_q_src_c071_3_03 0 bpf_c071_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_3_03 (mix_q_src_c071_3_03 mix_q_c071_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_04 (mix_i_src_c071_3_04 0 bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_3_04 (mix_i_src_c071_3_04 mix_i_c071_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_04 (mix_q_src_c071_3_04 0 bpf_c071_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c071_3_04 (mix_q_src_c071_3_04 mix_q_c071_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_05 (mix_i_src_c071_3_05 0 bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_3_05 (mix_i_src_c071_3_05 mix_i_c071_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_05 (mix_q_src_c071_3_05 0 bpf_c071_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c071_3_05 (mix_q_src_c071_3_05 mix_q_c071_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_06 (mix_i_src_c071_3_06 0 bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_3_06 (mix_i_src_c071_3_06 mix_i_c071_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_06 (mix_q_src_c071_3_06 0 bpf_c071_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c071_3_06 (mix_q_src_c071_3_06 mix_q_c071_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_07 (mix_i_src_c071_3_07 0 bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_3_07 (mix_i_src_c071_3_07 mix_i_c071_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_07 (mix_q_src_c071_3_07 0 bpf_c071_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c071_3_07 (mix_q_src_c071_3_07 mix_q_c071_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_08 (mix_i_src_c071_3_08 0 bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c071_3_08 (mix_i_src_c071_3_08 mix_i_c071_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_08 (mix_q_src_c071_3_08 0 bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_3_08 (mix_q_src_c071_3_08 mix_q_c071_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_09 (mix_i_src_c071_3_09 0 bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c071_3_09 (mix_i_src_c071_3_09 mix_i_c071_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_09 (mix_q_src_c071_3_09 0 bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_3_09 (mix_q_src_c071_3_09 mix_q_c071_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_10 (mix_i_src_c071_3_10 0 bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c071_3_10 (mix_i_src_c071_3_10 mix_i_c071_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_10 (mix_q_src_c071_3_10 0 bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_3_10 (mix_q_src_c071_3_10 mix_q_c071_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_11 (mix_i_src_c071_3_11 0 bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c071_3_11 (mix_i_src_c071_3_11 mix_i_c071_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_11 (mix_q_src_c071_3_11 0 bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_3_11 (mix_q_src_c071_3_11 mix_q_c071_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_12 (mix_i_src_c071_3_12 0 bpf_c071_3 0) vcvs gain=1.950903220161e-01
SMIXI_c071_3_12 (mix_i_src_c071_3_12 mix_i_c071_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_12 (mix_q_src_c071_3_12 0 bpf_c071_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c071_3_12 (mix_q_src_c071_3_12 mix_q_c071_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_13 (mix_i_src_c071_3_13 0 bpf_c071_3 0) vcvs gain=5.555702330196e-01
SMIXI_c071_3_13 (mix_i_src_c071_3_13 mix_i_c071_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_13 (mix_q_src_c071_3_13 0 bpf_c071_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c071_3_13 (mix_q_src_c071_3_13 mix_q_c071_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_14 (mix_i_src_c071_3_14 0 bpf_c071_3 0) vcvs gain=8.314696123025e-01
SMIXI_c071_3_14 (mix_i_src_c071_3_14 mix_i_c071_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_14 (mix_q_src_c071_3_14 0 bpf_c071_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c071_3_14 (mix_q_src_c071_3_14 mix_q_c071_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c071_3_15 (mix_i_src_c071_3_15 0 bpf_c071_3 0) vcvs gain=9.807852804032e-01
SMIXI_c071_3_15 (mix_i_src_c071_3_15 mix_i_c071_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c071_3_15 (mix_q_src_c071_3_15 0 bpf_c071_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c071_3_15 (mix_q_src_c071_3_15 mix_q_c071_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c071_3 (mix_i_c071_3 0) resistor r=1G
RMIXQ_c071_3 (mix_q_c071_3 0) resistor r=1G
RINTI_c071_3 (mix_i_c071_3 Icar_c071_3) resistor r=1k
CINTI_c071_3 (Icar_c071_3 0) capacitor c=80p
RINTQ_c071_3 (mix_q_c071_3 Qcar_c071_3) resistor r=1k
CINTQ_c071_3 (Qcar_c071_3 0) capacitor c=80p

// bl072, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c072_0 (bl072 n_cbpf_c072_0) capacitor c=4.052847345694e-13
LBPF_c072_0 (n_cbpf_c072_0 bpf_c072_0) inductor l=1.000000000000e-06
RBPF_c072_0 (bpf_c072_0 0) resistor r=7.853981633974e+01
EMIXI_c072_0_00 (mix_i_src_c072_0_00 0 bpf_c072_0 0) vcvs gain=9.807852804032e-01
SMIXI_c072_0_00 (mix_i_src_c072_0_00 mix_i_c072_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_00 (mix_q_src_c072_0_00 0 bpf_c072_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_0_00 (mix_q_src_c072_0_00 mix_q_c072_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_01 (mix_i_src_c072_0_01 0 bpf_c072_0 0) vcvs gain=8.314696123025e-01
SMIXI_c072_0_01 (mix_i_src_c072_0_01 mix_i_c072_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_01 (mix_q_src_c072_0_01 0 bpf_c072_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_0_01 (mix_q_src_c072_0_01 mix_q_c072_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_02 (mix_i_src_c072_0_02 0 bpf_c072_0 0) vcvs gain=5.555702330196e-01
SMIXI_c072_0_02 (mix_i_src_c072_0_02 mix_i_c072_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_02 (mix_q_src_c072_0_02 0 bpf_c072_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_0_02 (mix_q_src_c072_0_02 mix_q_c072_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_03 (mix_i_src_c072_0_03 0 bpf_c072_0 0) vcvs gain=1.950903220161e-01
SMIXI_c072_0_03 (mix_i_src_c072_0_03 mix_i_c072_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_03 (mix_q_src_c072_0_03 0 bpf_c072_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_0_03 (mix_q_src_c072_0_03 mix_q_c072_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_04 (mix_i_src_c072_0_04 0 bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_0_04 (mix_i_src_c072_0_04 mix_i_c072_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_04 (mix_q_src_c072_0_04 0 bpf_c072_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_0_04 (mix_q_src_c072_0_04 mix_q_c072_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_05 (mix_i_src_c072_0_05 0 bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_0_05 (mix_i_src_c072_0_05 mix_i_c072_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_05 (mix_q_src_c072_0_05 0 bpf_c072_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_0_05 (mix_q_src_c072_0_05 mix_q_c072_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_06 (mix_i_src_c072_0_06 0 bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_0_06 (mix_i_src_c072_0_06 mix_i_c072_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_06 (mix_q_src_c072_0_06 0 bpf_c072_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_0_06 (mix_q_src_c072_0_06 mix_q_c072_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_07 (mix_i_src_c072_0_07 0 bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_0_07 (mix_i_src_c072_0_07 mix_i_c072_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_07 (mix_q_src_c072_0_07 0 bpf_c072_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_0_07 (mix_q_src_c072_0_07 mix_q_c072_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_08 (mix_i_src_c072_0_08 0 bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_0_08 (mix_i_src_c072_0_08 mix_i_c072_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_08 (mix_q_src_c072_0_08 0 bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_0_08 (mix_q_src_c072_0_08 mix_q_c072_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_09 (mix_i_src_c072_0_09 0 bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_0_09 (mix_i_src_c072_0_09 mix_i_c072_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_09 (mix_q_src_c072_0_09 0 bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_0_09 (mix_q_src_c072_0_09 mix_q_c072_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_10 (mix_i_src_c072_0_10 0 bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_0_10 (mix_i_src_c072_0_10 mix_i_c072_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_10 (mix_q_src_c072_0_10 0 bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_0_10 (mix_q_src_c072_0_10 mix_q_c072_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_11 (mix_i_src_c072_0_11 0 bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_0_11 (mix_i_src_c072_0_11 mix_i_c072_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_11 (mix_q_src_c072_0_11 0 bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_0_11 (mix_q_src_c072_0_11 mix_q_c072_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_12 (mix_i_src_c072_0_12 0 bpf_c072_0 0) vcvs gain=1.950903220161e-01
SMIXI_c072_0_12 (mix_i_src_c072_0_12 mix_i_c072_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_12 (mix_q_src_c072_0_12 0 bpf_c072_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_0_12 (mix_q_src_c072_0_12 mix_q_c072_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_13 (mix_i_src_c072_0_13 0 bpf_c072_0 0) vcvs gain=5.555702330196e-01
SMIXI_c072_0_13 (mix_i_src_c072_0_13 mix_i_c072_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_13 (mix_q_src_c072_0_13 0 bpf_c072_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_0_13 (mix_q_src_c072_0_13 mix_q_c072_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_14 (mix_i_src_c072_0_14 0 bpf_c072_0 0) vcvs gain=8.314696123025e-01
SMIXI_c072_0_14 (mix_i_src_c072_0_14 mix_i_c072_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_14 (mix_q_src_c072_0_14 0 bpf_c072_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_0_14 (mix_q_src_c072_0_14 mix_q_c072_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_0_15 (mix_i_src_c072_0_15 0 bpf_c072_0 0) vcvs gain=9.807852804032e-01
SMIXI_c072_0_15 (mix_i_src_c072_0_15 mix_i_c072_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_0_15 (mix_q_src_c072_0_15 0 bpf_c072_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_0_15 (mix_q_src_c072_0_15 mix_q_c072_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c072_0 (mix_i_c072_0 0) resistor r=1G
RMIXQ_c072_0 (mix_q_c072_0 0) resistor r=1G
RINTI_c072_0 (mix_i_c072_0 Icar_c072_0) resistor r=1k
CINTI_c072_0 (Icar_c072_0 0) capacitor c=80p
RINTQ_c072_0 (mix_q_c072_0 Qcar_c072_0) resistor r=1k
CINTQ_c072_0 (Qcar_c072_0 0) capacitor c=80p

// bl072, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c072_1 (bl072 n_cbpf_c072_1) capacitor c=1.013211836423e-13
LBPF_c072_1 (n_cbpf_c072_1 bpf_c072_1) inductor l=1.000000000000e-06
RBPF_c072_1 (bpf_c072_1 0) resistor r=1.570796326795e+02
EMIXI_c072_1_00 (mix_i_src_c072_1_00 0 bpf_c072_1 0) vcvs gain=9.807852804032e-01
SMIXI_c072_1_00 (mix_i_src_c072_1_00 mix_i_c072_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_00 (mix_q_src_c072_1_00 0 bpf_c072_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_1_00 (mix_q_src_c072_1_00 mix_q_c072_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_01 (mix_i_src_c072_1_01 0 bpf_c072_1 0) vcvs gain=8.314696123025e-01
SMIXI_c072_1_01 (mix_i_src_c072_1_01 mix_i_c072_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_01 (mix_q_src_c072_1_01 0 bpf_c072_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_1_01 (mix_q_src_c072_1_01 mix_q_c072_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_02 (mix_i_src_c072_1_02 0 bpf_c072_1 0) vcvs gain=5.555702330196e-01
SMIXI_c072_1_02 (mix_i_src_c072_1_02 mix_i_c072_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_02 (mix_q_src_c072_1_02 0 bpf_c072_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_1_02 (mix_q_src_c072_1_02 mix_q_c072_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_03 (mix_i_src_c072_1_03 0 bpf_c072_1 0) vcvs gain=1.950903220161e-01
SMIXI_c072_1_03 (mix_i_src_c072_1_03 mix_i_c072_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_03 (mix_q_src_c072_1_03 0 bpf_c072_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_1_03 (mix_q_src_c072_1_03 mix_q_c072_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_04 (mix_i_src_c072_1_04 0 bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_1_04 (mix_i_src_c072_1_04 mix_i_c072_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_04 (mix_q_src_c072_1_04 0 bpf_c072_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_1_04 (mix_q_src_c072_1_04 mix_q_c072_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_05 (mix_i_src_c072_1_05 0 bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_1_05 (mix_i_src_c072_1_05 mix_i_c072_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_05 (mix_q_src_c072_1_05 0 bpf_c072_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_1_05 (mix_q_src_c072_1_05 mix_q_c072_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_06 (mix_i_src_c072_1_06 0 bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_1_06 (mix_i_src_c072_1_06 mix_i_c072_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_06 (mix_q_src_c072_1_06 0 bpf_c072_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_1_06 (mix_q_src_c072_1_06 mix_q_c072_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_07 (mix_i_src_c072_1_07 0 bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_1_07 (mix_i_src_c072_1_07 mix_i_c072_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_07 (mix_q_src_c072_1_07 0 bpf_c072_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_1_07 (mix_q_src_c072_1_07 mix_q_c072_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_08 (mix_i_src_c072_1_08 0 bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_1_08 (mix_i_src_c072_1_08 mix_i_c072_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_08 (mix_q_src_c072_1_08 0 bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_1_08 (mix_q_src_c072_1_08 mix_q_c072_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_09 (mix_i_src_c072_1_09 0 bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_1_09 (mix_i_src_c072_1_09 mix_i_c072_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_09 (mix_q_src_c072_1_09 0 bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_1_09 (mix_q_src_c072_1_09 mix_q_c072_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_10 (mix_i_src_c072_1_10 0 bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_1_10 (mix_i_src_c072_1_10 mix_i_c072_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_10 (mix_q_src_c072_1_10 0 bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_1_10 (mix_q_src_c072_1_10 mix_q_c072_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_11 (mix_i_src_c072_1_11 0 bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_1_11 (mix_i_src_c072_1_11 mix_i_c072_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_11 (mix_q_src_c072_1_11 0 bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_1_11 (mix_q_src_c072_1_11 mix_q_c072_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_12 (mix_i_src_c072_1_12 0 bpf_c072_1 0) vcvs gain=1.950903220161e-01
SMIXI_c072_1_12 (mix_i_src_c072_1_12 mix_i_c072_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_12 (mix_q_src_c072_1_12 0 bpf_c072_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_1_12 (mix_q_src_c072_1_12 mix_q_c072_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_13 (mix_i_src_c072_1_13 0 bpf_c072_1 0) vcvs gain=5.555702330196e-01
SMIXI_c072_1_13 (mix_i_src_c072_1_13 mix_i_c072_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_13 (mix_q_src_c072_1_13 0 bpf_c072_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_1_13 (mix_q_src_c072_1_13 mix_q_c072_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_14 (mix_i_src_c072_1_14 0 bpf_c072_1 0) vcvs gain=8.314696123025e-01
SMIXI_c072_1_14 (mix_i_src_c072_1_14 mix_i_c072_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_14 (mix_q_src_c072_1_14 0 bpf_c072_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_1_14 (mix_q_src_c072_1_14 mix_q_c072_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_1_15 (mix_i_src_c072_1_15 0 bpf_c072_1 0) vcvs gain=9.807852804032e-01
SMIXI_c072_1_15 (mix_i_src_c072_1_15 mix_i_c072_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_1_15 (mix_q_src_c072_1_15 0 bpf_c072_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_1_15 (mix_q_src_c072_1_15 mix_q_c072_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c072_1 (mix_i_c072_1 0) resistor r=1G
RMIXQ_c072_1 (mix_q_c072_1 0) resistor r=1G
RINTI_c072_1 (mix_i_c072_1 Icar_c072_1) resistor r=1k
CINTI_c072_1 (Icar_c072_1 0) capacitor c=80p
RINTQ_c072_1 (mix_q_c072_1 Qcar_c072_1) resistor r=1k
CINTQ_c072_1 (Qcar_c072_1 0) capacitor c=80p

// bl072, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c072_2 (bl072 n_cbpf_c072_2) capacitor c=4.503163717437e-14
LBPF_c072_2 (n_cbpf_c072_2 bpf_c072_2) inductor l=1.000000000000e-06
RBPF_c072_2 (bpf_c072_2 0) resistor r=2.356194490192e+02
EMIXI_c072_2_00 (mix_i_src_c072_2_00 0 bpf_c072_2 0) vcvs gain=9.807852804032e-01
SMIXI_c072_2_00 (mix_i_src_c072_2_00 mix_i_c072_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_00 (mix_q_src_c072_2_00 0 bpf_c072_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_2_00 (mix_q_src_c072_2_00 mix_q_c072_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_01 (mix_i_src_c072_2_01 0 bpf_c072_2 0) vcvs gain=8.314696123025e-01
SMIXI_c072_2_01 (mix_i_src_c072_2_01 mix_i_c072_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_01 (mix_q_src_c072_2_01 0 bpf_c072_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_2_01 (mix_q_src_c072_2_01 mix_q_c072_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_02 (mix_i_src_c072_2_02 0 bpf_c072_2 0) vcvs gain=5.555702330196e-01
SMIXI_c072_2_02 (mix_i_src_c072_2_02 mix_i_c072_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_02 (mix_q_src_c072_2_02 0 bpf_c072_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_2_02 (mix_q_src_c072_2_02 mix_q_c072_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_03 (mix_i_src_c072_2_03 0 bpf_c072_2 0) vcvs gain=1.950903220161e-01
SMIXI_c072_2_03 (mix_i_src_c072_2_03 mix_i_c072_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_03 (mix_q_src_c072_2_03 0 bpf_c072_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_2_03 (mix_q_src_c072_2_03 mix_q_c072_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_04 (mix_i_src_c072_2_04 0 bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_2_04 (mix_i_src_c072_2_04 mix_i_c072_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_04 (mix_q_src_c072_2_04 0 bpf_c072_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_2_04 (mix_q_src_c072_2_04 mix_q_c072_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_05 (mix_i_src_c072_2_05 0 bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_2_05 (mix_i_src_c072_2_05 mix_i_c072_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_05 (mix_q_src_c072_2_05 0 bpf_c072_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_2_05 (mix_q_src_c072_2_05 mix_q_c072_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_06 (mix_i_src_c072_2_06 0 bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_2_06 (mix_i_src_c072_2_06 mix_i_c072_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_06 (mix_q_src_c072_2_06 0 bpf_c072_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_2_06 (mix_q_src_c072_2_06 mix_q_c072_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_07 (mix_i_src_c072_2_07 0 bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_2_07 (mix_i_src_c072_2_07 mix_i_c072_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_07 (mix_q_src_c072_2_07 0 bpf_c072_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_2_07 (mix_q_src_c072_2_07 mix_q_c072_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_08 (mix_i_src_c072_2_08 0 bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_2_08 (mix_i_src_c072_2_08 mix_i_c072_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_08 (mix_q_src_c072_2_08 0 bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_2_08 (mix_q_src_c072_2_08 mix_q_c072_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_09 (mix_i_src_c072_2_09 0 bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_2_09 (mix_i_src_c072_2_09 mix_i_c072_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_09 (mix_q_src_c072_2_09 0 bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_2_09 (mix_q_src_c072_2_09 mix_q_c072_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_10 (mix_i_src_c072_2_10 0 bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_2_10 (mix_i_src_c072_2_10 mix_i_c072_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_10 (mix_q_src_c072_2_10 0 bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_2_10 (mix_q_src_c072_2_10 mix_q_c072_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_11 (mix_i_src_c072_2_11 0 bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_2_11 (mix_i_src_c072_2_11 mix_i_c072_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_11 (mix_q_src_c072_2_11 0 bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_2_11 (mix_q_src_c072_2_11 mix_q_c072_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_12 (mix_i_src_c072_2_12 0 bpf_c072_2 0) vcvs gain=1.950903220161e-01
SMIXI_c072_2_12 (mix_i_src_c072_2_12 mix_i_c072_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_12 (mix_q_src_c072_2_12 0 bpf_c072_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_2_12 (mix_q_src_c072_2_12 mix_q_c072_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_13 (mix_i_src_c072_2_13 0 bpf_c072_2 0) vcvs gain=5.555702330196e-01
SMIXI_c072_2_13 (mix_i_src_c072_2_13 mix_i_c072_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_13 (mix_q_src_c072_2_13 0 bpf_c072_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_2_13 (mix_q_src_c072_2_13 mix_q_c072_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_14 (mix_i_src_c072_2_14 0 bpf_c072_2 0) vcvs gain=8.314696123025e-01
SMIXI_c072_2_14 (mix_i_src_c072_2_14 mix_i_c072_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_14 (mix_q_src_c072_2_14 0 bpf_c072_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_2_14 (mix_q_src_c072_2_14 mix_q_c072_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_2_15 (mix_i_src_c072_2_15 0 bpf_c072_2 0) vcvs gain=9.807852804032e-01
SMIXI_c072_2_15 (mix_i_src_c072_2_15 mix_i_c072_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_2_15 (mix_q_src_c072_2_15 0 bpf_c072_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_2_15 (mix_q_src_c072_2_15 mix_q_c072_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c072_2 (mix_i_c072_2 0) resistor r=1G
RMIXQ_c072_2 (mix_q_c072_2 0) resistor r=1G
RINTI_c072_2 (mix_i_c072_2 Icar_c072_2) resistor r=1k
CINTI_c072_2 (Icar_c072_2 0) capacitor c=80p
RINTQ_c072_2 (mix_q_c072_2 Qcar_c072_2) resistor r=1k
CINTQ_c072_2 (Qcar_c072_2 0) capacitor c=80p

// bl072, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c072_3 (bl072 n_cbpf_c072_3) capacitor c=2.533029591058e-14
LBPF_c072_3 (n_cbpf_c072_3 bpf_c072_3) inductor l=1.000000000000e-06
RBPF_c072_3 (bpf_c072_3 0) resistor r=3.141592653590e+02
EMIXI_c072_3_00 (mix_i_src_c072_3_00 0 bpf_c072_3 0) vcvs gain=9.807852804032e-01
SMIXI_c072_3_00 (mix_i_src_c072_3_00 mix_i_c072_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_00 (mix_q_src_c072_3_00 0 bpf_c072_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_3_00 (mix_q_src_c072_3_00 mix_q_c072_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_01 (mix_i_src_c072_3_01 0 bpf_c072_3 0) vcvs gain=8.314696123025e-01
SMIXI_c072_3_01 (mix_i_src_c072_3_01 mix_i_c072_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_01 (mix_q_src_c072_3_01 0 bpf_c072_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_3_01 (mix_q_src_c072_3_01 mix_q_c072_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_02 (mix_i_src_c072_3_02 0 bpf_c072_3 0) vcvs gain=5.555702330196e-01
SMIXI_c072_3_02 (mix_i_src_c072_3_02 mix_i_c072_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_02 (mix_q_src_c072_3_02 0 bpf_c072_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_3_02 (mix_q_src_c072_3_02 mix_q_c072_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_03 (mix_i_src_c072_3_03 0 bpf_c072_3 0) vcvs gain=1.950903220161e-01
SMIXI_c072_3_03 (mix_i_src_c072_3_03 mix_i_c072_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_03 (mix_q_src_c072_3_03 0 bpf_c072_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_3_03 (mix_q_src_c072_3_03 mix_q_c072_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_04 (mix_i_src_c072_3_04 0 bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_3_04 (mix_i_src_c072_3_04 mix_i_c072_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_04 (mix_q_src_c072_3_04 0 bpf_c072_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c072_3_04 (mix_q_src_c072_3_04 mix_q_c072_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_05 (mix_i_src_c072_3_05 0 bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_3_05 (mix_i_src_c072_3_05 mix_i_c072_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_05 (mix_q_src_c072_3_05 0 bpf_c072_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c072_3_05 (mix_q_src_c072_3_05 mix_q_c072_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_06 (mix_i_src_c072_3_06 0 bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_3_06 (mix_i_src_c072_3_06 mix_i_c072_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_06 (mix_q_src_c072_3_06 0 bpf_c072_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c072_3_06 (mix_q_src_c072_3_06 mix_q_c072_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_07 (mix_i_src_c072_3_07 0 bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_3_07 (mix_i_src_c072_3_07 mix_i_c072_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_07 (mix_q_src_c072_3_07 0 bpf_c072_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c072_3_07 (mix_q_src_c072_3_07 mix_q_c072_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_08 (mix_i_src_c072_3_08 0 bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c072_3_08 (mix_i_src_c072_3_08 mix_i_c072_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_08 (mix_q_src_c072_3_08 0 bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_3_08 (mix_q_src_c072_3_08 mix_q_c072_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_09 (mix_i_src_c072_3_09 0 bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c072_3_09 (mix_i_src_c072_3_09 mix_i_c072_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_09 (mix_q_src_c072_3_09 0 bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_3_09 (mix_q_src_c072_3_09 mix_q_c072_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_10 (mix_i_src_c072_3_10 0 bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c072_3_10 (mix_i_src_c072_3_10 mix_i_c072_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_10 (mix_q_src_c072_3_10 0 bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_3_10 (mix_q_src_c072_3_10 mix_q_c072_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_11 (mix_i_src_c072_3_11 0 bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c072_3_11 (mix_i_src_c072_3_11 mix_i_c072_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_11 (mix_q_src_c072_3_11 0 bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_3_11 (mix_q_src_c072_3_11 mix_q_c072_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_12 (mix_i_src_c072_3_12 0 bpf_c072_3 0) vcvs gain=1.950903220161e-01
SMIXI_c072_3_12 (mix_i_src_c072_3_12 mix_i_c072_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_12 (mix_q_src_c072_3_12 0 bpf_c072_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c072_3_12 (mix_q_src_c072_3_12 mix_q_c072_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_13 (mix_i_src_c072_3_13 0 bpf_c072_3 0) vcvs gain=5.555702330196e-01
SMIXI_c072_3_13 (mix_i_src_c072_3_13 mix_i_c072_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_13 (mix_q_src_c072_3_13 0 bpf_c072_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c072_3_13 (mix_q_src_c072_3_13 mix_q_c072_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_14 (mix_i_src_c072_3_14 0 bpf_c072_3 0) vcvs gain=8.314696123025e-01
SMIXI_c072_3_14 (mix_i_src_c072_3_14 mix_i_c072_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_14 (mix_q_src_c072_3_14 0 bpf_c072_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c072_3_14 (mix_q_src_c072_3_14 mix_q_c072_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c072_3_15 (mix_i_src_c072_3_15 0 bpf_c072_3 0) vcvs gain=9.807852804032e-01
SMIXI_c072_3_15 (mix_i_src_c072_3_15 mix_i_c072_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c072_3_15 (mix_q_src_c072_3_15 0 bpf_c072_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c072_3_15 (mix_q_src_c072_3_15 mix_q_c072_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c072_3 (mix_i_c072_3 0) resistor r=1G
RMIXQ_c072_3 (mix_q_c072_3 0) resistor r=1G
RINTI_c072_3 (mix_i_c072_3 Icar_c072_3) resistor r=1k
CINTI_c072_3 (Icar_c072_3 0) capacitor c=80p
RINTQ_c072_3 (mix_q_c072_3 Qcar_c072_3) resistor r=1k
CINTQ_c072_3 (Qcar_c072_3 0) capacitor c=80p

// bl073, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c073_0 (bl073 n_cbpf_c073_0) capacitor c=4.052847345694e-13
LBPF_c073_0 (n_cbpf_c073_0 bpf_c073_0) inductor l=1.000000000000e-06
RBPF_c073_0 (bpf_c073_0 0) resistor r=7.853981633974e+01
EMIXI_c073_0_00 (mix_i_src_c073_0_00 0 bpf_c073_0 0) vcvs gain=9.807852804032e-01
SMIXI_c073_0_00 (mix_i_src_c073_0_00 mix_i_c073_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_00 (mix_q_src_c073_0_00 0 bpf_c073_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_0_00 (mix_q_src_c073_0_00 mix_q_c073_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_01 (mix_i_src_c073_0_01 0 bpf_c073_0 0) vcvs gain=8.314696123025e-01
SMIXI_c073_0_01 (mix_i_src_c073_0_01 mix_i_c073_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_01 (mix_q_src_c073_0_01 0 bpf_c073_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_0_01 (mix_q_src_c073_0_01 mix_q_c073_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_02 (mix_i_src_c073_0_02 0 bpf_c073_0 0) vcvs gain=5.555702330196e-01
SMIXI_c073_0_02 (mix_i_src_c073_0_02 mix_i_c073_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_02 (mix_q_src_c073_0_02 0 bpf_c073_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_0_02 (mix_q_src_c073_0_02 mix_q_c073_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_03 (mix_i_src_c073_0_03 0 bpf_c073_0 0) vcvs gain=1.950903220161e-01
SMIXI_c073_0_03 (mix_i_src_c073_0_03 mix_i_c073_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_03 (mix_q_src_c073_0_03 0 bpf_c073_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_0_03 (mix_q_src_c073_0_03 mix_q_c073_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_04 (mix_i_src_c073_0_04 0 bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_0_04 (mix_i_src_c073_0_04 mix_i_c073_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_04 (mix_q_src_c073_0_04 0 bpf_c073_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_0_04 (mix_q_src_c073_0_04 mix_q_c073_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_05 (mix_i_src_c073_0_05 0 bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_0_05 (mix_i_src_c073_0_05 mix_i_c073_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_05 (mix_q_src_c073_0_05 0 bpf_c073_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_0_05 (mix_q_src_c073_0_05 mix_q_c073_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_06 (mix_i_src_c073_0_06 0 bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_0_06 (mix_i_src_c073_0_06 mix_i_c073_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_06 (mix_q_src_c073_0_06 0 bpf_c073_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_0_06 (mix_q_src_c073_0_06 mix_q_c073_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_07 (mix_i_src_c073_0_07 0 bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_0_07 (mix_i_src_c073_0_07 mix_i_c073_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_07 (mix_q_src_c073_0_07 0 bpf_c073_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_0_07 (mix_q_src_c073_0_07 mix_q_c073_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_08 (mix_i_src_c073_0_08 0 bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_0_08 (mix_i_src_c073_0_08 mix_i_c073_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_08 (mix_q_src_c073_0_08 0 bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_0_08 (mix_q_src_c073_0_08 mix_q_c073_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_09 (mix_i_src_c073_0_09 0 bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_0_09 (mix_i_src_c073_0_09 mix_i_c073_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_09 (mix_q_src_c073_0_09 0 bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_0_09 (mix_q_src_c073_0_09 mix_q_c073_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_10 (mix_i_src_c073_0_10 0 bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_0_10 (mix_i_src_c073_0_10 mix_i_c073_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_10 (mix_q_src_c073_0_10 0 bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_0_10 (mix_q_src_c073_0_10 mix_q_c073_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_11 (mix_i_src_c073_0_11 0 bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_0_11 (mix_i_src_c073_0_11 mix_i_c073_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_11 (mix_q_src_c073_0_11 0 bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_0_11 (mix_q_src_c073_0_11 mix_q_c073_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_12 (mix_i_src_c073_0_12 0 bpf_c073_0 0) vcvs gain=1.950903220161e-01
SMIXI_c073_0_12 (mix_i_src_c073_0_12 mix_i_c073_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_12 (mix_q_src_c073_0_12 0 bpf_c073_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_0_12 (mix_q_src_c073_0_12 mix_q_c073_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_13 (mix_i_src_c073_0_13 0 bpf_c073_0 0) vcvs gain=5.555702330196e-01
SMIXI_c073_0_13 (mix_i_src_c073_0_13 mix_i_c073_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_13 (mix_q_src_c073_0_13 0 bpf_c073_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_0_13 (mix_q_src_c073_0_13 mix_q_c073_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_14 (mix_i_src_c073_0_14 0 bpf_c073_0 0) vcvs gain=8.314696123025e-01
SMIXI_c073_0_14 (mix_i_src_c073_0_14 mix_i_c073_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_14 (mix_q_src_c073_0_14 0 bpf_c073_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_0_14 (mix_q_src_c073_0_14 mix_q_c073_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_0_15 (mix_i_src_c073_0_15 0 bpf_c073_0 0) vcvs gain=9.807852804032e-01
SMIXI_c073_0_15 (mix_i_src_c073_0_15 mix_i_c073_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_0_15 (mix_q_src_c073_0_15 0 bpf_c073_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_0_15 (mix_q_src_c073_0_15 mix_q_c073_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c073_0 (mix_i_c073_0 0) resistor r=1G
RMIXQ_c073_0 (mix_q_c073_0 0) resistor r=1G
RINTI_c073_0 (mix_i_c073_0 Icar_c073_0) resistor r=1k
CINTI_c073_0 (Icar_c073_0 0) capacitor c=80p
RINTQ_c073_0 (mix_q_c073_0 Qcar_c073_0) resistor r=1k
CINTQ_c073_0 (Qcar_c073_0 0) capacitor c=80p

// bl073, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c073_1 (bl073 n_cbpf_c073_1) capacitor c=1.013211836423e-13
LBPF_c073_1 (n_cbpf_c073_1 bpf_c073_1) inductor l=1.000000000000e-06
RBPF_c073_1 (bpf_c073_1 0) resistor r=1.570796326795e+02
EMIXI_c073_1_00 (mix_i_src_c073_1_00 0 bpf_c073_1 0) vcvs gain=9.807852804032e-01
SMIXI_c073_1_00 (mix_i_src_c073_1_00 mix_i_c073_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_00 (mix_q_src_c073_1_00 0 bpf_c073_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_1_00 (mix_q_src_c073_1_00 mix_q_c073_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_01 (mix_i_src_c073_1_01 0 bpf_c073_1 0) vcvs gain=8.314696123025e-01
SMIXI_c073_1_01 (mix_i_src_c073_1_01 mix_i_c073_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_01 (mix_q_src_c073_1_01 0 bpf_c073_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_1_01 (mix_q_src_c073_1_01 mix_q_c073_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_02 (mix_i_src_c073_1_02 0 bpf_c073_1 0) vcvs gain=5.555702330196e-01
SMIXI_c073_1_02 (mix_i_src_c073_1_02 mix_i_c073_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_02 (mix_q_src_c073_1_02 0 bpf_c073_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_1_02 (mix_q_src_c073_1_02 mix_q_c073_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_03 (mix_i_src_c073_1_03 0 bpf_c073_1 0) vcvs gain=1.950903220161e-01
SMIXI_c073_1_03 (mix_i_src_c073_1_03 mix_i_c073_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_03 (mix_q_src_c073_1_03 0 bpf_c073_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_1_03 (mix_q_src_c073_1_03 mix_q_c073_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_04 (mix_i_src_c073_1_04 0 bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_1_04 (mix_i_src_c073_1_04 mix_i_c073_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_04 (mix_q_src_c073_1_04 0 bpf_c073_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_1_04 (mix_q_src_c073_1_04 mix_q_c073_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_05 (mix_i_src_c073_1_05 0 bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_1_05 (mix_i_src_c073_1_05 mix_i_c073_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_05 (mix_q_src_c073_1_05 0 bpf_c073_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_1_05 (mix_q_src_c073_1_05 mix_q_c073_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_06 (mix_i_src_c073_1_06 0 bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_1_06 (mix_i_src_c073_1_06 mix_i_c073_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_06 (mix_q_src_c073_1_06 0 bpf_c073_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_1_06 (mix_q_src_c073_1_06 mix_q_c073_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_07 (mix_i_src_c073_1_07 0 bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_1_07 (mix_i_src_c073_1_07 mix_i_c073_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_07 (mix_q_src_c073_1_07 0 bpf_c073_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_1_07 (mix_q_src_c073_1_07 mix_q_c073_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_08 (mix_i_src_c073_1_08 0 bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_1_08 (mix_i_src_c073_1_08 mix_i_c073_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_08 (mix_q_src_c073_1_08 0 bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_1_08 (mix_q_src_c073_1_08 mix_q_c073_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_09 (mix_i_src_c073_1_09 0 bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_1_09 (mix_i_src_c073_1_09 mix_i_c073_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_09 (mix_q_src_c073_1_09 0 bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_1_09 (mix_q_src_c073_1_09 mix_q_c073_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_10 (mix_i_src_c073_1_10 0 bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_1_10 (mix_i_src_c073_1_10 mix_i_c073_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_10 (mix_q_src_c073_1_10 0 bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_1_10 (mix_q_src_c073_1_10 mix_q_c073_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_11 (mix_i_src_c073_1_11 0 bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_1_11 (mix_i_src_c073_1_11 mix_i_c073_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_11 (mix_q_src_c073_1_11 0 bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_1_11 (mix_q_src_c073_1_11 mix_q_c073_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_12 (mix_i_src_c073_1_12 0 bpf_c073_1 0) vcvs gain=1.950903220161e-01
SMIXI_c073_1_12 (mix_i_src_c073_1_12 mix_i_c073_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_12 (mix_q_src_c073_1_12 0 bpf_c073_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_1_12 (mix_q_src_c073_1_12 mix_q_c073_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_13 (mix_i_src_c073_1_13 0 bpf_c073_1 0) vcvs gain=5.555702330196e-01
SMIXI_c073_1_13 (mix_i_src_c073_1_13 mix_i_c073_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_13 (mix_q_src_c073_1_13 0 bpf_c073_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_1_13 (mix_q_src_c073_1_13 mix_q_c073_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_14 (mix_i_src_c073_1_14 0 bpf_c073_1 0) vcvs gain=8.314696123025e-01
SMIXI_c073_1_14 (mix_i_src_c073_1_14 mix_i_c073_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_14 (mix_q_src_c073_1_14 0 bpf_c073_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_1_14 (mix_q_src_c073_1_14 mix_q_c073_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_1_15 (mix_i_src_c073_1_15 0 bpf_c073_1 0) vcvs gain=9.807852804032e-01
SMIXI_c073_1_15 (mix_i_src_c073_1_15 mix_i_c073_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_1_15 (mix_q_src_c073_1_15 0 bpf_c073_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_1_15 (mix_q_src_c073_1_15 mix_q_c073_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c073_1 (mix_i_c073_1 0) resistor r=1G
RMIXQ_c073_1 (mix_q_c073_1 0) resistor r=1G
RINTI_c073_1 (mix_i_c073_1 Icar_c073_1) resistor r=1k
CINTI_c073_1 (Icar_c073_1 0) capacitor c=80p
RINTQ_c073_1 (mix_q_c073_1 Qcar_c073_1) resistor r=1k
CINTQ_c073_1 (Qcar_c073_1 0) capacitor c=80p

// bl073, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c073_2 (bl073 n_cbpf_c073_2) capacitor c=4.503163717437e-14
LBPF_c073_2 (n_cbpf_c073_2 bpf_c073_2) inductor l=1.000000000000e-06
RBPF_c073_2 (bpf_c073_2 0) resistor r=2.356194490192e+02
EMIXI_c073_2_00 (mix_i_src_c073_2_00 0 bpf_c073_2 0) vcvs gain=9.807852804032e-01
SMIXI_c073_2_00 (mix_i_src_c073_2_00 mix_i_c073_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_00 (mix_q_src_c073_2_00 0 bpf_c073_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_2_00 (mix_q_src_c073_2_00 mix_q_c073_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_01 (mix_i_src_c073_2_01 0 bpf_c073_2 0) vcvs gain=8.314696123025e-01
SMIXI_c073_2_01 (mix_i_src_c073_2_01 mix_i_c073_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_01 (mix_q_src_c073_2_01 0 bpf_c073_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_2_01 (mix_q_src_c073_2_01 mix_q_c073_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_02 (mix_i_src_c073_2_02 0 bpf_c073_2 0) vcvs gain=5.555702330196e-01
SMIXI_c073_2_02 (mix_i_src_c073_2_02 mix_i_c073_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_02 (mix_q_src_c073_2_02 0 bpf_c073_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_2_02 (mix_q_src_c073_2_02 mix_q_c073_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_03 (mix_i_src_c073_2_03 0 bpf_c073_2 0) vcvs gain=1.950903220161e-01
SMIXI_c073_2_03 (mix_i_src_c073_2_03 mix_i_c073_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_03 (mix_q_src_c073_2_03 0 bpf_c073_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_2_03 (mix_q_src_c073_2_03 mix_q_c073_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_04 (mix_i_src_c073_2_04 0 bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_2_04 (mix_i_src_c073_2_04 mix_i_c073_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_04 (mix_q_src_c073_2_04 0 bpf_c073_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_2_04 (mix_q_src_c073_2_04 mix_q_c073_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_05 (mix_i_src_c073_2_05 0 bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_2_05 (mix_i_src_c073_2_05 mix_i_c073_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_05 (mix_q_src_c073_2_05 0 bpf_c073_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_2_05 (mix_q_src_c073_2_05 mix_q_c073_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_06 (mix_i_src_c073_2_06 0 bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_2_06 (mix_i_src_c073_2_06 mix_i_c073_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_06 (mix_q_src_c073_2_06 0 bpf_c073_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_2_06 (mix_q_src_c073_2_06 mix_q_c073_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_07 (mix_i_src_c073_2_07 0 bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_2_07 (mix_i_src_c073_2_07 mix_i_c073_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_07 (mix_q_src_c073_2_07 0 bpf_c073_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_2_07 (mix_q_src_c073_2_07 mix_q_c073_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_08 (mix_i_src_c073_2_08 0 bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_2_08 (mix_i_src_c073_2_08 mix_i_c073_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_08 (mix_q_src_c073_2_08 0 bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_2_08 (mix_q_src_c073_2_08 mix_q_c073_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_09 (mix_i_src_c073_2_09 0 bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_2_09 (mix_i_src_c073_2_09 mix_i_c073_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_09 (mix_q_src_c073_2_09 0 bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_2_09 (mix_q_src_c073_2_09 mix_q_c073_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_10 (mix_i_src_c073_2_10 0 bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_2_10 (mix_i_src_c073_2_10 mix_i_c073_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_10 (mix_q_src_c073_2_10 0 bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_2_10 (mix_q_src_c073_2_10 mix_q_c073_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_11 (mix_i_src_c073_2_11 0 bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_2_11 (mix_i_src_c073_2_11 mix_i_c073_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_11 (mix_q_src_c073_2_11 0 bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_2_11 (mix_q_src_c073_2_11 mix_q_c073_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_12 (mix_i_src_c073_2_12 0 bpf_c073_2 0) vcvs gain=1.950903220161e-01
SMIXI_c073_2_12 (mix_i_src_c073_2_12 mix_i_c073_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_12 (mix_q_src_c073_2_12 0 bpf_c073_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_2_12 (mix_q_src_c073_2_12 mix_q_c073_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_13 (mix_i_src_c073_2_13 0 bpf_c073_2 0) vcvs gain=5.555702330196e-01
SMIXI_c073_2_13 (mix_i_src_c073_2_13 mix_i_c073_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_13 (mix_q_src_c073_2_13 0 bpf_c073_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_2_13 (mix_q_src_c073_2_13 mix_q_c073_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_14 (mix_i_src_c073_2_14 0 bpf_c073_2 0) vcvs gain=8.314696123025e-01
SMIXI_c073_2_14 (mix_i_src_c073_2_14 mix_i_c073_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_14 (mix_q_src_c073_2_14 0 bpf_c073_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_2_14 (mix_q_src_c073_2_14 mix_q_c073_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_2_15 (mix_i_src_c073_2_15 0 bpf_c073_2 0) vcvs gain=9.807852804032e-01
SMIXI_c073_2_15 (mix_i_src_c073_2_15 mix_i_c073_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_2_15 (mix_q_src_c073_2_15 0 bpf_c073_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_2_15 (mix_q_src_c073_2_15 mix_q_c073_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c073_2 (mix_i_c073_2 0) resistor r=1G
RMIXQ_c073_2 (mix_q_c073_2 0) resistor r=1G
RINTI_c073_2 (mix_i_c073_2 Icar_c073_2) resistor r=1k
CINTI_c073_2 (Icar_c073_2 0) capacitor c=80p
RINTQ_c073_2 (mix_q_c073_2 Qcar_c073_2) resistor r=1k
CINTQ_c073_2 (Qcar_c073_2 0) capacitor c=80p

// bl073, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c073_3 (bl073 n_cbpf_c073_3) capacitor c=2.533029591058e-14
LBPF_c073_3 (n_cbpf_c073_3 bpf_c073_3) inductor l=1.000000000000e-06
RBPF_c073_3 (bpf_c073_3 0) resistor r=3.141592653590e+02
EMIXI_c073_3_00 (mix_i_src_c073_3_00 0 bpf_c073_3 0) vcvs gain=9.807852804032e-01
SMIXI_c073_3_00 (mix_i_src_c073_3_00 mix_i_c073_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_00 (mix_q_src_c073_3_00 0 bpf_c073_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_3_00 (mix_q_src_c073_3_00 mix_q_c073_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_01 (mix_i_src_c073_3_01 0 bpf_c073_3 0) vcvs gain=8.314696123025e-01
SMIXI_c073_3_01 (mix_i_src_c073_3_01 mix_i_c073_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_01 (mix_q_src_c073_3_01 0 bpf_c073_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_3_01 (mix_q_src_c073_3_01 mix_q_c073_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_02 (mix_i_src_c073_3_02 0 bpf_c073_3 0) vcvs gain=5.555702330196e-01
SMIXI_c073_3_02 (mix_i_src_c073_3_02 mix_i_c073_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_02 (mix_q_src_c073_3_02 0 bpf_c073_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_3_02 (mix_q_src_c073_3_02 mix_q_c073_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_03 (mix_i_src_c073_3_03 0 bpf_c073_3 0) vcvs gain=1.950903220161e-01
SMIXI_c073_3_03 (mix_i_src_c073_3_03 mix_i_c073_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_03 (mix_q_src_c073_3_03 0 bpf_c073_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_3_03 (mix_q_src_c073_3_03 mix_q_c073_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_04 (mix_i_src_c073_3_04 0 bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_3_04 (mix_i_src_c073_3_04 mix_i_c073_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_04 (mix_q_src_c073_3_04 0 bpf_c073_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c073_3_04 (mix_q_src_c073_3_04 mix_q_c073_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_05 (mix_i_src_c073_3_05 0 bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_3_05 (mix_i_src_c073_3_05 mix_i_c073_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_05 (mix_q_src_c073_3_05 0 bpf_c073_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c073_3_05 (mix_q_src_c073_3_05 mix_q_c073_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_06 (mix_i_src_c073_3_06 0 bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_3_06 (mix_i_src_c073_3_06 mix_i_c073_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_06 (mix_q_src_c073_3_06 0 bpf_c073_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c073_3_06 (mix_q_src_c073_3_06 mix_q_c073_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_07 (mix_i_src_c073_3_07 0 bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_3_07 (mix_i_src_c073_3_07 mix_i_c073_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_07 (mix_q_src_c073_3_07 0 bpf_c073_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c073_3_07 (mix_q_src_c073_3_07 mix_q_c073_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_08 (mix_i_src_c073_3_08 0 bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c073_3_08 (mix_i_src_c073_3_08 mix_i_c073_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_08 (mix_q_src_c073_3_08 0 bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_3_08 (mix_q_src_c073_3_08 mix_q_c073_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_09 (mix_i_src_c073_3_09 0 bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c073_3_09 (mix_i_src_c073_3_09 mix_i_c073_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_09 (mix_q_src_c073_3_09 0 bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_3_09 (mix_q_src_c073_3_09 mix_q_c073_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_10 (mix_i_src_c073_3_10 0 bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c073_3_10 (mix_i_src_c073_3_10 mix_i_c073_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_10 (mix_q_src_c073_3_10 0 bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_3_10 (mix_q_src_c073_3_10 mix_q_c073_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_11 (mix_i_src_c073_3_11 0 bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c073_3_11 (mix_i_src_c073_3_11 mix_i_c073_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_11 (mix_q_src_c073_3_11 0 bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_3_11 (mix_q_src_c073_3_11 mix_q_c073_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_12 (mix_i_src_c073_3_12 0 bpf_c073_3 0) vcvs gain=1.950903220161e-01
SMIXI_c073_3_12 (mix_i_src_c073_3_12 mix_i_c073_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_12 (mix_q_src_c073_3_12 0 bpf_c073_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c073_3_12 (mix_q_src_c073_3_12 mix_q_c073_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_13 (mix_i_src_c073_3_13 0 bpf_c073_3 0) vcvs gain=5.555702330196e-01
SMIXI_c073_3_13 (mix_i_src_c073_3_13 mix_i_c073_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_13 (mix_q_src_c073_3_13 0 bpf_c073_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c073_3_13 (mix_q_src_c073_3_13 mix_q_c073_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_14 (mix_i_src_c073_3_14 0 bpf_c073_3 0) vcvs gain=8.314696123025e-01
SMIXI_c073_3_14 (mix_i_src_c073_3_14 mix_i_c073_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_14 (mix_q_src_c073_3_14 0 bpf_c073_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c073_3_14 (mix_q_src_c073_3_14 mix_q_c073_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c073_3_15 (mix_i_src_c073_3_15 0 bpf_c073_3 0) vcvs gain=9.807852804032e-01
SMIXI_c073_3_15 (mix_i_src_c073_3_15 mix_i_c073_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c073_3_15 (mix_q_src_c073_3_15 0 bpf_c073_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c073_3_15 (mix_q_src_c073_3_15 mix_q_c073_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c073_3 (mix_i_c073_3 0) resistor r=1G
RMIXQ_c073_3 (mix_q_c073_3 0) resistor r=1G
RINTI_c073_3 (mix_i_c073_3 Icar_c073_3) resistor r=1k
CINTI_c073_3 (Icar_c073_3 0) capacitor c=80p
RINTQ_c073_3 (mix_q_c073_3 Qcar_c073_3) resistor r=1k
CINTQ_c073_3 (Qcar_c073_3 0) capacitor c=80p

// bl074, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c074_0 (bl074 n_cbpf_c074_0) capacitor c=4.052847345694e-13
LBPF_c074_0 (n_cbpf_c074_0 bpf_c074_0) inductor l=1.000000000000e-06
RBPF_c074_0 (bpf_c074_0 0) resistor r=7.853981633974e+01
EMIXI_c074_0_00 (mix_i_src_c074_0_00 0 bpf_c074_0 0) vcvs gain=9.807852804032e-01
SMIXI_c074_0_00 (mix_i_src_c074_0_00 mix_i_c074_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_00 (mix_q_src_c074_0_00 0 bpf_c074_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_0_00 (mix_q_src_c074_0_00 mix_q_c074_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_01 (mix_i_src_c074_0_01 0 bpf_c074_0 0) vcvs gain=8.314696123025e-01
SMIXI_c074_0_01 (mix_i_src_c074_0_01 mix_i_c074_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_01 (mix_q_src_c074_0_01 0 bpf_c074_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_0_01 (mix_q_src_c074_0_01 mix_q_c074_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_02 (mix_i_src_c074_0_02 0 bpf_c074_0 0) vcvs gain=5.555702330196e-01
SMIXI_c074_0_02 (mix_i_src_c074_0_02 mix_i_c074_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_02 (mix_q_src_c074_0_02 0 bpf_c074_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_0_02 (mix_q_src_c074_0_02 mix_q_c074_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_03 (mix_i_src_c074_0_03 0 bpf_c074_0 0) vcvs gain=1.950903220161e-01
SMIXI_c074_0_03 (mix_i_src_c074_0_03 mix_i_c074_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_03 (mix_q_src_c074_0_03 0 bpf_c074_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_0_03 (mix_q_src_c074_0_03 mix_q_c074_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_04 (mix_i_src_c074_0_04 0 bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_0_04 (mix_i_src_c074_0_04 mix_i_c074_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_04 (mix_q_src_c074_0_04 0 bpf_c074_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_0_04 (mix_q_src_c074_0_04 mix_q_c074_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_05 (mix_i_src_c074_0_05 0 bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_0_05 (mix_i_src_c074_0_05 mix_i_c074_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_05 (mix_q_src_c074_0_05 0 bpf_c074_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_0_05 (mix_q_src_c074_0_05 mix_q_c074_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_06 (mix_i_src_c074_0_06 0 bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_0_06 (mix_i_src_c074_0_06 mix_i_c074_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_06 (mix_q_src_c074_0_06 0 bpf_c074_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_0_06 (mix_q_src_c074_0_06 mix_q_c074_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_07 (mix_i_src_c074_0_07 0 bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_0_07 (mix_i_src_c074_0_07 mix_i_c074_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_07 (mix_q_src_c074_0_07 0 bpf_c074_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_0_07 (mix_q_src_c074_0_07 mix_q_c074_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_08 (mix_i_src_c074_0_08 0 bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_0_08 (mix_i_src_c074_0_08 mix_i_c074_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_08 (mix_q_src_c074_0_08 0 bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_0_08 (mix_q_src_c074_0_08 mix_q_c074_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_09 (mix_i_src_c074_0_09 0 bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_0_09 (mix_i_src_c074_0_09 mix_i_c074_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_09 (mix_q_src_c074_0_09 0 bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_0_09 (mix_q_src_c074_0_09 mix_q_c074_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_10 (mix_i_src_c074_0_10 0 bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_0_10 (mix_i_src_c074_0_10 mix_i_c074_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_10 (mix_q_src_c074_0_10 0 bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_0_10 (mix_q_src_c074_0_10 mix_q_c074_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_11 (mix_i_src_c074_0_11 0 bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_0_11 (mix_i_src_c074_0_11 mix_i_c074_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_11 (mix_q_src_c074_0_11 0 bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_0_11 (mix_q_src_c074_0_11 mix_q_c074_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_12 (mix_i_src_c074_0_12 0 bpf_c074_0 0) vcvs gain=1.950903220161e-01
SMIXI_c074_0_12 (mix_i_src_c074_0_12 mix_i_c074_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_12 (mix_q_src_c074_0_12 0 bpf_c074_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_0_12 (mix_q_src_c074_0_12 mix_q_c074_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_13 (mix_i_src_c074_0_13 0 bpf_c074_0 0) vcvs gain=5.555702330196e-01
SMIXI_c074_0_13 (mix_i_src_c074_0_13 mix_i_c074_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_13 (mix_q_src_c074_0_13 0 bpf_c074_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_0_13 (mix_q_src_c074_0_13 mix_q_c074_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_14 (mix_i_src_c074_0_14 0 bpf_c074_0 0) vcvs gain=8.314696123025e-01
SMIXI_c074_0_14 (mix_i_src_c074_0_14 mix_i_c074_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_14 (mix_q_src_c074_0_14 0 bpf_c074_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_0_14 (mix_q_src_c074_0_14 mix_q_c074_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_0_15 (mix_i_src_c074_0_15 0 bpf_c074_0 0) vcvs gain=9.807852804032e-01
SMIXI_c074_0_15 (mix_i_src_c074_0_15 mix_i_c074_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_0_15 (mix_q_src_c074_0_15 0 bpf_c074_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_0_15 (mix_q_src_c074_0_15 mix_q_c074_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c074_0 (mix_i_c074_0 0) resistor r=1G
RMIXQ_c074_0 (mix_q_c074_0 0) resistor r=1G
RINTI_c074_0 (mix_i_c074_0 Icar_c074_0) resistor r=1k
CINTI_c074_0 (Icar_c074_0 0) capacitor c=80p
RINTQ_c074_0 (mix_q_c074_0 Qcar_c074_0) resistor r=1k
CINTQ_c074_0 (Qcar_c074_0 0) capacitor c=80p

// bl074, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c074_1 (bl074 n_cbpf_c074_1) capacitor c=1.013211836423e-13
LBPF_c074_1 (n_cbpf_c074_1 bpf_c074_1) inductor l=1.000000000000e-06
RBPF_c074_1 (bpf_c074_1 0) resistor r=1.570796326795e+02
EMIXI_c074_1_00 (mix_i_src_c074_1_00 0 bpf_c074_1 0) vcvs gain=9.807852804032e-01
SMIXI_c074_1_00 (mix_i_src_c074_1_00 mix_i_c074_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_00 (mix_q_src_c074_1_00 0 bpf_c074_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_1_00 (mix_q_src_c074_1_00 mix_q_c074_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_01 (mix_i_src_c074_1_01 0 bpf_c074_1 0) vcvs gain=8.314696123025e-01
SMIXI_c074_1_01 (mix_i_src_c074_1_01 mix_i_c074_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_01 (mix_q_src_c074_1_01 0 bpf_c074_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_1_01 (mix_q_src_c074_1_01 mix_q_c074_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_02 (mix_i_src_c074_1_02 0 bpf_c074_1 0) vcvs gain=5.555702330196e-01
SMIXI_c074_1_02 (mix_i_src_c074_1_02 mix_i_c074_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_02 (mix_q_src_c074_1_02 0 bpf_c074_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_1_02 (mix_q_src_c074_1_02 mix_q_c074_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_03 (mix_i_src_c074_1_03 0 bpf_c074_1 0) vcvs gain=1.950903220161e-01
SMIXI_c074_1_03 (mix_i_src_c074_1_03 mix_i_c074_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_03 (mix_q_src_c074_1_03 0 bpf_c074_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_1_03 (mix_q_src_c074_1_03 mix_q_c074_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_04 (mix_i_src_c074_1_04 0 bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_1_04 (mix_i_src_c074_1_04 mix_i_c074_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_04 (mix_q_src_c074_1_04 0 bpf_c074_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_1_04 (mix_q_src_c074_1_04 mix_q_c074_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_05 (mix_i_src_c074_1_05 0 bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_1_05 (mix_i_src_c074_1_05 mix_i_c074_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_05 (mix_q_src_c074_1_05 0 bpf_c074_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_1_05 (mix_q_src_c074_1_05 mix_q_c074_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_06 (mix_i_src_c074_1_06 0 bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_1_06 (mix_i_src_c074_1_06 mix_i_c074_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_06 (mix_q_src_c074_1_06 0 bpf_c074_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_1_06 (mix_q_src_c074_1_06 mix_q_c074_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_07 (mix_i_src_c074_1_07 0 bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_1_07 (mix_i_src_c074_1_07 mix_i_c074_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_07 (mix_q_src_c074_1_07 0 bpf_c074_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_1_07 (mix_q_src_c074_1_07 mix_q_c074_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_08 (mix_i_src_c074_1_08 0 bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_1_08 (mix_i_src_c074_1_08 mix_i_c074_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_08 (mix_q_src_c074_1_08 0 bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_1_08 (mix_q_src_c074_1_08 mix_q_c074_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_09 (mix_i_src_c074_1_09 0 bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_1_09 (mix_i_src_c074_1_09 mix_i_c074_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_09 (mix_q_src_c074_1_09 0 bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_1_09 (mix_q_src_c074_1_09 mix_q_c074_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_10 (mix_i_src_c074_1_10 0 bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_1_10 (mix_i_src_c074_1_10 mix_i_c074_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_10 (mix_q_src_c074_1_10 0 bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_1_10 (mix_q_src_c074_1_10 mix_q_c074_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_11 (mix_i_src_c074_1_11 0 bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_1_11 (mix_i_src_c074_1_11 mix_i_c074_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_11 (mix_q_src_c074_1_11 0 bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_1_11 (mix_q_src_c074_1_11 mix_q_c074_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_12 (mix_i_src_c074_1_12 0 bpf_c074_1 0) vcvs gain=1.950903220161e-01
SMIXI_c074_1_12 (mix_i_src_c074_1_12 mix_i_c074_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_12 (mix_q_src_c074_1_12 0 bpf_c074_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_1_12 (mix_q_src_c074_1_12 mix_q_c074_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_13 (mix_i_src_c074_1_13 0 bpf_c074_1 0) vcvs gain=5.555702330196e-01
SMIXI_c074_1_13 (mix_i_src_c074_1_13 mix_i_c074_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_13 (mix_q_src_c074_1_13 0 bpf_c074_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_1_13 (mix_q_src_c074_1_13 mix_q_c074_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_14 (mix_i_src_c074_1_14 0 bpf_c074_1 0) vcvs gain=8.314696123025e-01
SMIXI_c074_1_14 (mix_i_src_c074_1_14 mix_i_c074_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_14 (mix_q_src_c074_1_14 0 bpf_c074_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_1_14 (mix_q_src_c074_1_14 mix_q_c074_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_1_15 (mix_i_src_c074_1_15 0 bpf_c074_1 0) vcvs gain=9.807852804032e-01
SMIXI_c074_1_15 (mix_i_src_c074_1_15 mix_i_c074_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_1_15 (mix_q_src_c074_1_15 0 bpf_c074_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_1_15 (mix_q_src_c074_1_15 mix_q_c074_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c074_1 (mix_i_c074_1 0) resistor r=1G
RMIXQ_c074_1 (mix_q_c074_1 0) resistor r=1G
RINTI_c074_1 (mix_i_c074_1 Icar_c074_1) resistor r=1k
CINTI_c074_1 (Icar_c074_1 0) capacitor c=80p
RINTQ_c074_1 (mix_q_c074_1 Qcar_c074_1) resistor r=1k
CINTQ_c074_1 (Qcar_c074_1 0) capacitor c=80p

// bl074, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c074_2 (bl074 n_cbpf_c074_2) capacitor c=4.503163717437e-14
LBPF_c074_2 (n_cbpf_c074_2 bpf_c074_2) inductor l=1.000000000000e-06
RBPF_c074_2 (bpf_c074_2 0) resistor r=2.356194490192e+02
EMIXI_c074_2_00 (mix_i_src_c074_2_00 0 bpf_c074_2 0) vcvs gain=9.807852804032e-01
SMIXI_c074_2_00 (mix_i_src_c074_2_00 mix_i_c074_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_00 (mix_q_src_c074_2_00 0 bpf_c074_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_2_00 (mix_q_src_c074_2_00 mix_q_c074_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_01 (mix_i_src_c074_2_01 0 bpf_c074_2 0) vcvs gain=8.314696123025e-01
SMIXI_c074_2_01 (mix_i_src_c074_2_01 mix_i_c074_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_01 (mix_q_src_c074_2_01 0 bpf_c074_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_2_01 (mix_q_src_c074_2_01 mix_q_c074_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_02 (mix_i_src_c074_2_02 0 bpf_c074_2 0) vcvs gain=5.555702330196e-01
SMIXI_c074_2_02 (mix_i_src_c074_2_02 mix_i_c074_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_02 (mix_q_src_c074_2_02 0 bpf_c074_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_2_02 (mix_q_src_c074_2_02 mix_q_c074_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_03 (mix_i_src_c074_2_03 0 bpf_c074_2 0) vcvs gain=1.950903220161e-01
SMIXI_c074_2_03 (mix_i_src_c074_2_03 mix_i_c074_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_03 (mix_q_src_c074_2_03 0 bpf_c074_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_2_03 (mix_q_src_c074_2_03 mix_q_c074_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_04 (mix_i_src_c074_2_04 0 bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_2_04 (mix_i_src_c074_2_04 mix_i_c074_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_04 (mix_q_src_c074_2_04 0 bpf_c074_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_2_04 (mix_q_src_c074_2_04 mix_q_c074_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_05 (mix_i_src_c074_2_05 0 bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_2_05 (mix_i_src_c074_2_05 mix_i_c074_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_05 (mix_q_src_c074_2_05 0 bpf_c074_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_2_05 (mix_q_src_c074_2_05 mix_q_c074_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_06 (mix_i_src_c074_2_06 0 bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_2_06 (mix_i_src_c074_2_06 mix_i_c074_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_06 (mix_q_src_c074_2_06 0 bpf_c074_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_2_06 (mix_q_src_c074_2_06 mix_q_c074_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_07 (mix_i_src_c074_2_07 0 bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_2_07 (mix_i_src_c074_2_07 mix_i_c074_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_07 (mix_q_src_c074_2_07 0 bpf_c074_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_2_07 (mix_q_src_c074_2_07 mix_q_c074_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_08 (mix_i_src_c074_2_08 0 bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_2_08 (mix_i_src_c074_2_08 mix_i_c074_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_08 (mix_q_src_c074_2_08 0 bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_2_08 (mix_q_src_c074_2_08 mix_q_c074_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_09 (mix_i_src_c074_2_09 0 bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_2_09 (mix_i_src_c074_2_09 mix_i_c074_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_09 (mix_q_src_c074_2_09 0 bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_2_09 (mix_q_src_c074_2_09 mix_q_c074_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_10 (mix_i_src_c074_2_10 0 bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_2_10 (mix_i_src_c074_2_10 mix_i_c074_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_10 (mix_q_src_c074_2_10 0 bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_2_10 (mix_q_src_c074_2_10 mix_q_c074_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_11 (mix_i_src_c074_2_11 0 bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_2_11 (mix_i_src_c074_2_11 mix_i_c074_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_11 (mix_q_src_c074_2_11 0 bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_2_11 (mix_q_src_c074_2_11 mix_q_c074_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_12 (mix_i_src_c074_2_12 0 bpf_c074_2 0) vcvs gain=1.950903220161e-01
SMIXI_c074_2_12 (mix_i_src_c074_2_12 mix_i_c074_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_12 (mix_q_src_c074_2_12 0 bpf_c074_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_2_12 (mix_q_src_c074_2_12 mix_q_c074_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_13 (mix_i_src_c074_2_13 0 bpf_c074_2 0) vcvs gain=5.555702330196e-01
SMIXI_c074_2_13 (mix_i_src_c074_2_13 mix_i_c074_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_13 (mix_q_src_c074_2_13 0 bpf_c074_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_2_13 (mix_q_src_c074_2_13 mix_q_c074_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_14 (mix_i_src_c074_2_14 0 bpf_c074_2 0) vcvs gain=8.314696123025e-01
SMIXI_c074_2_14 (mix_i_src_c074_2_14 mix_i_c074_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_14 (mix_q_src_c074_2_14 0 bpf_c074_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_2_14 (mix_q_src_c074_2_14 mix_q_c074_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_2_15 (mix_i_src_c074_2_15 0 bpf_c074_2 0) vcvs gain=9.807852804032e-01
SMIXI_c074_2_15 (mix_i_src_c074_2_15 mix_i_c074_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_2_15 (mix_q_src_c074_2_15 0 bpf_c074_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_2_15 (mix_q_src_c074_2_15 mix_q_c074_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c074_2 (mix_i_c074_2 0) resistor r=1G
RMIXQ_c074_2 (mix_q_c074_2 0) resistor r=1G
RINTI_c074_2 (mix_i_c074_2 Icar_c074_2) resistor r=1k
CINTI_c074_2 (Icar_c074_2 0) capacitor c=80p
RINTQ_c074_2 (mix_q_c074_2 Qcar_c074_2) resistor r=1k
CINTQ_c074_2 (Qcar_c074_2 0) capacitor c=80p

// bl074, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c074_3 (bl074 n_cbpf_c074_3) capacitor c=2.533029591058e-14
LBPF_c074_3 (n_cbpf_c074_3 bpf_c074_3) inductor l=1.000000000000e-06
RBPF_c074_3 (bpf_c074_3 0) resistor r=3.141592653590e+02
EMIXI_c074_3_00 (mix_i_src_c074_3_00 0 bpf_c074_3 0) vcvs gain=9.807852804032e-01
SMIXI_c074_3_00 (mix_i_src_c074_3_00 mix_i_c074_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_00 (mix_q_src_c074_3_00 0 bpf_c074_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_3_00 (mix_q_src_c074_3_00 mix_q_c074_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_01 (mix_i_src_c074_3_01 0 bpf_c074_3 0) vcvs gain=8.314696123025e-01
SMIXI_c074_3_01 (mix_i_src_c074_3_01 mix_i_c074_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_01 (mix_q_src_c074_3_01 0 bpf_c074_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_3_01 (mix_q_src_c074_3_01 mix_q_c074_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_02 (mix_i_src_c074_3_02 0 bpf_c074_3 0) vcvs gain=5.555702330196e-01
SMIXI_c074_3_02 (mix_i_src_c074_3_02 mix_i_c074_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_02 (mix_q_src_c074_3_02 0 bpf_c074_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_3_02 (mix_q_src_c074_3_02 mix_q_c074_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_03 (mix_i_src_c074_3_03 0 bpf_c074_3 0) vcvs gain=1.950903220161e-01
SMIXI_c074_3_03 (mix_i_src_c074_3_03 mix_i_c074_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_03 (mix_q_src_c074_3_03 0 bpf_c074_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_3_03 (mix_q_src_c074_3_03 mix_q_c074_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_04 (mix_i_src_c074_3_04 0 bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_3_04 (mix_i_src_c074_3_04 mix_i_c074_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_04 (mix_q_src_c074_3_04 0 bpf_c074_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c074_3_04 (mix_q_src_c074_3_04 mix_q_c074_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_05 (mix_i_src_c074_3_05 0 bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_3_05 (mix_i_src_c074_3_05 mix_i_c074_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_05 (mix_q_src_c074_3_05 0 bpf_c074_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c074_3_05 (mix_q_src_c074_3_05 mix_q_c074_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_06 (mix_i_src_c074_3_06 0 bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_3_06 (mix_i_src_c074_3_06 mix_i_c074_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_06 (mix_q_src_c074_3_06 0 bpf_c074_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c074_3_06 (mix_q_src_c074_3_06 mix_q_c074_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_07 (mix_i_src_c074_3_07 0 bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_3_07 (mix_i_src_c074_3_07 mix_i_c074_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_07 (mix_q_src_c074_3_07 0 bpf_c074_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c074_3_07 (mix_q_src_c074_3_07 mix_q_c074_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_08 (mix_i_src_c074_3_08 0 bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c074_3_08 (mix_i_src_c074_3_08 mix_i_c074_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_08 (mix_q_src_c074_3_08 0 bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_3_08 (mix_q_src_c074_3_08 mix_q_c074_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_09 (mix_i_src_c074_3_09 0 bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c074_3_09 (mix_i_src_c074_3_09 mix_i_c074_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_09 (mix_q_src_c074_3_09 0 bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_3_09 (mix_q_src_c074_3_09 mix_q_c074_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_10 (mix_i_src_c074_3_10 0 bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c074_3_10 (mix_i_src_c074_3_10 mix_i_c074_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_10 (mix_q_src_c074_3_10 0 bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_3_10 (mix_q_src_c074_3_10 mix_q_c074_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_11 (mix_i_src_c074_3_11 0 bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c074_3_11 (mix_i_src_c074_3_11 mix_i_c074_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_11 (mix_q_src_c074_3_11 0 bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_3_11 (mix_q_src_c074_3_11 mix_q_c074_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_12 (mix_i_src_c074_3_12 0 bpf_c074_3 0) vcvs gain=1.950903220161e-01
SMIXI_c074_3_12 (mix_i_src_c074_3_12 mix_i_c074_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_12 (mix_q_src_c074_3_12 0 bpf_c074_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c074_3_12 (mix_q_src_c074_3_12 mix_q_c074_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_13 (mix_i_src_c074_3_13 0 bpf_c074_3 0) vcvs gain=5.555702330196e-01
SMIXI_c074_3_13 (mix_i_src_c074_3_13 mix_i_c074_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_13 (mix_q_src_c074_3_13 0 bpf_c074_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c074_3_13 (mix_q_src_c074_3_13 mix_q_c074_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_14 (mix_i_src_c074_3_14 0 bpf_c074_3 0) vcvs gain=8.314696123025e-01
SMIXI_c074_3_14 (mix_i_src_c074_3_14 mix_i_c074_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_14 (mix_q_src_c074_3_14 0 bpf_c074_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c074_3_14 (mix_q_src_c074_3_14 mix_q_c074_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c074_3_15 (mix_i_src_c074_3_15 0 bpf_c074_3 0) vcvs gain=9.807852804032e-01
SMIXI_c074_3_15 (mix_i_src_c074_3_15 mix_i_c074_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c074_3_15 (mix_q_src_c074_3_15 0 bpf_c074_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c074_3_15 (mix_q_src_c074_3_15 mix_q_c074_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c074_3 (mix_i_c074_3 0) resistor r=1G
RMIXQ_c074_3 (mix_q_c074_3 0) resistor r=1G
RINTI_c074_3 (mix_i_c074_3 Icar_c074_3) resistor r=1k
CINTI_c074_3 (Icar_c074_3 0) capacitor c=80p
RINTQ_c074_3 (mix_q_c074_3 Qcar_c074_3) resistor r=1k
CINTQ_c074_3 (Qcar_c074_3 0) capacitor c=80p

// bl075, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c075_0 (bl075 n_cbpf_c075_0) capacitor c=4.052847345694e-13
LBPF_c075_0 (n_cbpf_c075_0 bpf_c075_0) inductor l=1.000000000000e-06
RBPF_c075_0 (bpf_c075_0 0) resistor r=7.853981633974e+01
EMIXI_c075_0_00 (mix_i_src_c075_0_00 0 bpf_c075_0 0) vcvs gain=9.807852804032e-01
SMIXI_c075_0_00 (mix_i_src_c075_0_00 mix_i_c075_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_00 (mix_q_src_c075_0_00 0 bpf_c075_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_0_00 (mix_q_src_c075_0_00 mix_q_c075_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_01 (mix_i_src_c075_0_01 0 bpf_c075_0 0) vcvs gain=8.314696123025e-01
SMIXI_c075_0_01 (mix_i_src_c075_0_01 mix_i_c075_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_01 (mix_q_src_c075_0_01 0 bpf_c075_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_0_01 (mix_q_src_c075_0_01 mix_q_c075_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_02 (mix_i_src_c075_0_02 0 bpf_c075_0 0) vcvs gain=5.555702330196e-01
SMIXI_c075_0_02 (mix_i_src_c075_0_02 mix_i_c075_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_02 (mix_q_src_c075_0_02 0 bpf_c075_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_0_02 (mix_q_src_c075_0_02 mix_q_c075_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_03 (mix_i_src_c075_0_03 0 bpf_c075_0 0) vcvs gain=1.950903220161e-01
SMIXI_c075_0_03 (mix_i_src_c075_0_03 mix_i_c075_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_03 (mix_q_src_c075_0_03 0 bpf_c075_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_0_03 (mix_q_src_c075_0_03 mix_q_c075_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_04 (mix_i_src_c075_0_04 0 bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_0_04 (mix_i_src_c075_0_04 mix_i_c075_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_04 (mix_q_src_c075_0_04 0 bpf_c075_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_0_04 (mix_q_src_c075_0_04 mix_q_c075_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_05 (mix_i_src_c075_0_05 0 bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_0_05 (mix_i_src_c075_0_05 mix_i_c075_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_05 (mix_q_src_c075_0_05 0 bpf_c075_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_0_05 (mix_q_src_c075_0_05 mix_q_c075_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_06 (mix_i_src_c075_0_06 0 bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_0_06 (mix_i_src_c075_0_06 mix_i_c075_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_06 (mix_q_src_c075_0_06 0 bpf_c075_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_0_06 (mix_q_src_c075_0_06 mix_q_c075_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_07 (mix_i_src_c075_0_07 0 bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_0_07 (mix_i_src_c075_0_07 mix_i_c075_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_07 (mix_q_src_c075_0_07 0 bpf_c075_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_0_07 (mix_q_src_c075_0_07 mix_q_c075_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_08 (mix_i_src_c075_0_08 0 bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_0_08 (mix_i_src_c075_0_08 mix_i_c075_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_08 (mix_q_src_c075_0_08 0 bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_0_08 (mix_q_src_c075_0_08 mix_q_c075_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_09 (mix_i_src_c075_0_09 0 bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_0_09 (mix_i_src_c075_0_09 mix_i_c075_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_09 (mix_q_src_c075_0_09 0 bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_0_09 (mix_q_src_c075_0_09 mix_q_c075_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_10 (mix_i_src_c075_0_10 0 bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_0_10 (mix_i_src_c075_0_10 mix_i_c075_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_10 (mix_q_src_c075_0_10 0 bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_0_10 (mix_q_src_c075_0_10 mix_q_c075_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_11 (mix_i_src_c075_0_11 0 bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_0_11 (mix_i_src_c075_0_11 mix_i_c075_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_11 (mix_q_src_c075_0_11 0 bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_0_11 (mix_q_src_c075_0_11 mix_q_c075_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_12 (mix_i_src_c075_0_12 0 bpf_c075_0 0) vcvs gain=1.950903220161e-01
SMIXI_c075_0_12 (mix_i_src_c075_0_12 mix_i_c075_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_12 (mix_q_src_c075_0_12 0 bpf_c075_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_0_12 (mix_q_src_c075_0_12 mix_q_c075_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_13 (mix_i_src_c075_0_13 0 bpf_c075_0 0) vcvs gain=5.555702330196e-01
SMIXI_c075_0_13 (mix_i_src_c075_0_13 mix_i_c075_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_13 (mix_q_src_c075_0_13 0 bpf_c075_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_0_13 (mix_q_src_c075_0_13 mix_q_c075_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_14 (mix_i_src_c075_0_14 0 bpf_c075_0 0) vcvs gain=8.314696123025e-01
SMIXI_c075_0_14 (mix_i_src_c075_0_14 mix_i_c075_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_14 (mix_q_src_c075_0_14 0 bpf_c075_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_0_14 (mix_q_src_c075_0_14 mix_q_c075_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_0_15 (mix_i_src_c075_0_15 0 bpf_c075_0 0) vcvs gain=9.807852804032e-01
SMIXI_c075_0_15 (mix_i_src_c075_0_15 mix_i_c075_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_0_15 (mix_q_src_c075_0_15 0 bpf_c075_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_0_15 (mix_q_src_c075_0_15 mix_q_c075_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c075_0 (mix_i_c075_0 0) resistor r=1G
RMIXQ_c075_0 (mix_q_c075_0 0) resistor r=1G
RINTI_c075_0 (mix_i_c075_0 Icar_c075_0) resistor r=1k
CINTI_c075_0 (Icar_c075_0 0) capacitor c=80p
RINTQ_c075_0 (mix_q_c075_0 Qcar_c075_0) resistor r=1k
CINTQ_c075_0 (Qcar_c075_0 0) capacitor c=80p

// bl075, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c075_1 (bl075 n_cbpf_c075_1) capacitor c=1.013211836423e-13
LBPF_c075_1 (n_cbpf_c075_1 bpf_c075_1) inductor l=1.000000000000e-06
RBPF_c075_1 (bpf_c075_1 0) resistor r=1.570796326795e+02
EMIXI_c075_1_00 (mix_i_src_c075_1_00 0 bpf_c075_1 0) vcvs gain=9.807852804032e-01
SMIXI_c075_1_00 (mix_i_src_c075_1_00 mix_i_c075_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_00 (mix_q_src_c075_1_00 0 bpf_c075_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_1_00 (mix_q_src_c075_1_00 mix_q_c075_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_01 (mix_i_src_c075_1_01 0 bpf_c075_1 0) vcvs gain=8.314696123025e-01
SMIXI_c075_1_01 (mix_i_src_c075_1_01 mix_i_c075_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_01 (mix_q_src_c075_1_01 0 bpf_c075_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_1_01 (mix_q_src_c075_1_01 mix_q_c075_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_02 (mix_i_src_c075_1_02 0 bpf_c075_1 0) vcvs gain=5.555702330196e-01
SMIXI_c075_1_02 (mix_i_src_c075_1_02 mix_i_c075_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_02 (mix_q_src_c075_1_02 0 bpf_c075_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_1_02 (mix_q_src_c075_1_02 mix_q_c075_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_03 (mix_i_src_c075_1_03 0 bpf_c075_1 0) vcvs gain=1.950903220161e-01
SMIXI_c075_1_03 (mix_i_src_c075_1_03 mix_i_c075_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_03 (mix_q_src_c075_1_03 0 bpf_c075_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_1_03 (mix_q_src_c075_1_03 mix_q_c075_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_04 (mix_i_src_c075_1_04 0 bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_1_04 (mix_i_src_c075_1_04 mix_i_c075_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_04 (mix_q_src_c075_1_04 0 bpf_c075_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_1_04 (mix_q_src_c075_1_04 mix_q_c075_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_05 (mix_i_src_c075_1_05 0 bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_1_05 (mix_i_src_c075_1_05 mix_i_c075_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_05 (mix_q_src_c075_1_05 0 bpf_c075_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_1_05 (mix_q_src_c075_1_05 mix_q_c075_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_06 (mix_i_src_c075_1_06 0 bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_1_06 (mix_i_src_c075_1_06 mix_i_c075_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_06 (mix_q_src_c075_1_06 0 bpf_c075_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_1_06 (mix_q_src_c075_1_06 mix_q_c075_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_07 (mix_i_src_c075_1_07 0 bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_1_07 (mix_i_src_c075_1_07 mix_i_c075_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_07 (mix_q_src_c075_1_07 0 bpf_c075_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_1_07 (mix_q_src_c075_1_07 mix_q_c075_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_08 (mix_i_src_c075_1_08 0 bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_1_08 (mix_i_src_c075_1_08 mix_i_c075_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_08 (mix_q_src_c075_1_08 0 bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_1_08 (mix_q_src_c075_1_08 mix_q_c075_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_09 (mix_i_src_c075_1_09 0 bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_1_09 (mix_i_src_c075_1_09 mix_i_c075_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_09 (mix_q_src_c075_1_09 0 bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_1_09 (mix_q_src_c075_1_09 mix_q_c075_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_10 (mix_i_src_c075_1_10 0 bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_1_10 (mix_i_src_c075_1_10 mix_i_c075_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_10 (mix_q_src_c075_1_10 0 bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_1_10 (mix_q_src_c075_1_10 mix_q_c075_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_11 (mix_i_src_c075_1_11 0 bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_1_11 (mix_i_src_c075_1_11 mix_i_c075_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_11 (mix_q_src_c075_1_11 0 bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_1_11 (mix_q_src_c075_1_11 mix_q_c075_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_12 (mix_i_src_c075_1_12 0 bpf_c075_1 0) vcvs gain=1.950903220161e-01
SMIXI_c075_1_12 (mix_i_src_c075_1_12 mix_i_c075_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_12 (mix_q_src_c075_1_12 0 bpf_c075_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_1_12 (mix_q_src_c075_1_12 mix_q_c075_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_13 (mix_i_src_c075_1_13 0 bpf_c075_1 0) vcvs gain=5.555702330196e-01
SMIXI_c075_1_13 (mix_i_src_c075_1_13 mix_i_c075_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_13 (mix_q_src_c075_1_13 0 bpf_c075_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_1_13 (mix_q_src_c075_1_13 mix_q_c075_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_14 (mix_i_src_c075_1_14 0 bpf_c075_1 0) vcvs gain=8.314696123025e-01
SMIXI_c075_1_14 (mix_i_src_c075_1_14 mix_i_c075_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_14 (mix_q_src_c075_1_14 0 bpf_c075_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_1_14 (mix_q_src_c075_1_14 mix_q_c075_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_1_15 (mix_i_src_c075_1_15 0 bpf_c075_1 0) vcvs gain=9.807852804032e-01
SMIXI_c075_1_15 (mix_i_src_c075_1_15 mix_i_c075_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_1_15 (mix_q_src_c075_1_15 0 bpf_c075_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_1_15 (mix_q_src_c075_1_15 mix_q_c075_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c075_1 (mix_i_c075_1 0) resistor r=1G
RMIXQ_c075_1 (mix_q_c075_1 0) resistor r=1G
RINTI_c075_1 (mix_i_c075_1 Icar_c075_1) resistor r=1k
CINTI_c075_1 (Icar_c075_1 0) capacitor c=80p
RINTQ_c075_1 (mix_q_c075_1 Qcar_c075_1) resistor r=1k
CINTQ_c075_1 (Qcar_c075_1 0) capacitor c=80p

// bl075, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c075_2 (bl075 n_cbpf_c075_2) capacitor c=4.503163717437e-14
LBPF_c075_2 (n_cbpf_c075_2 bpf_c075_2) inductor l=1.000000000000e-06
RBPF_c075_2 (bpf_c075_2 0) resistor r=2.356194490192e+02
EMIXI_c075_2_00 (mix_i_src_c075_2_00 0 bpf_c075_2 0) vcvs gain=9.807852804032e-01
SMIXI_c075_2_00 (mix_i_src_c075_2_00 mix_i_c075_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_00 (mix_q_src_c075_2_00 0 bpf_c075_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_2_00 (mix_q_src_c075_2_00 mix_q_c075_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_01 (mix_i_src_c075_2_01 0 bpf_c075_2 0) vcvs gain=8.314696123025e-01
SMIXI_c075_2_01 (mix_i_src_c075_2_01 mix_i_c075_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_01 (mix_q_src_c075_2_01 0 bpf_c075_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_2_01 (mix_q_src_c075_2_01 mix_q_c075_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_02 (mix_i_src_c075_2_02 0 bpf_c075_2 0) vcvs gain=5.555702330196e-01
SMIXI_c075_2_02 (mix_i_src_c075_2_02 mix_i_c075_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_02 (mix_q_src_c075_2_02 0 bpf_c075_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_2_02 (mix_q_src_c075_2_02 mix_q_c075_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_03 (mix_i_src_c075_2_03 0 bpf_c075_2 0) vcvs gain=1.950903220161e-01
SMIXI_c075_2_03 (mix_i_src_c075_2_03 mix_i_c075_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_03 (mix_q_src_c075_2_03 0 bpf_c075_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_2_03 (mix_q_src_c075_2_03 mix_q_c075_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_04 (mix_i_src_c075_2_04 0 bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_2_04 (mix_i_src_c075_2_04 mix_i_c075_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_04 (mix_q_src_c075_2_04 0 bpf_c075_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_2_04 (mix_q_src_c075_2_04 mix_q_c075_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_05 (mix_i_src_c075_2_05 0 bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_2_05 (mix_i_src_c075_2_05 mix_i_c075_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_05 (mix_q_src_c075_2_05 0 bpf_c075_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_2_05 (mix_q_src_c075_2_05 mix_q_c075_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_06 (mix_i_src_c075_2_06 0 bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_2_06 (mix_i_src_c075_2_06 mix_i_c075_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_06 (mix_q_src_c075_2_06 0 bpf_c075_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_2_06 (mix_q_src_c075_2_06 mix_q_c075_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_07 (mix_i_src_c075_2_07 0 bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_2_07 (mix_i_src_c075_2_07 mix_i_c075_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_07 (mix_q_src_c075_2_07 0 bpf_c075_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_2_07 (mix_q_src_c075_2_07 mix_q_c075_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_08 (mix_i_src_c075_2_08 0 bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_2_08 (mix_i_src_c075_2_08 mix_i_c075_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_08 (mix_q_src_c075_2_08 0 bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_2_08 (mix_q_src_c075_2_08 mix_q_c075_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_09 (mix_i_src_c075_2_09 0 bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_2_09 (mix_i_src_c075_2_09 mix_i_c075_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_09 (mix_q_src_c075_2_09 0 bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_2_09 (mix_q_src_c075_2_09 mix_q_c075_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_10 (mix_i_src_c075_2_10 0 bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_2_10 (mix_i_src_c075_2_10 mix_i_c075_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_10 (mix_q_src_c075_2_10 0 bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_2_10 (mix_q_src_c075_2_10 mix_q_c075_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_11 (mix_i_src_c075_2_11 0 bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_2_11 (mix_i_src_c075_2_11 mix_i_c075_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_11 (mix_q_src_c075_2_11 0 bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_2_11 (mix_q_src_c075_2_11 mix_q_c075_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_12 (mix_i_src_c075_2_12 0 bpf_c075_2 0) vcvs gain=1.950903220161e-01
SMIXI_c075_2_12 (mix_i_src_c075_2_12 mix_i_c075_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_12 (mix_q_src_c075_2_12 0 bpf_c075_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_2_12 (mix_q_src_c075_2_12 mix_q_c075_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_13 (mix_i_src_c075_2_13 0 bpf_c075_2 0) vcvs gain=5.555702330196e-01
SMIXI_c075_2_13 (mix_i_src_c075_2_13 mix_i_c075_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_13 (mix_q_src_c075_2_13 0 bpf_c075_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_2_13 (mix_q_src_c075_2_13 mix_q_c075_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_14 (mix_i_src_c075_2_14 0 bpf_c075_2 0) vcvs gain=8.314696123025e-01
SMIXI_c075_2_14 (mix_i_src_c075_2_14 mix_i_c075_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_14 (mix_q_src_c075_2_14 0 bpf_c075_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_2_14 (mix_q_src_c075_2_14 mix_q_c075_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_2_15 (mix_i_src_c075_2_15 0 bpf_c075_2 0) vcvs gain=9.807852804032e-01
SMIXI_c075_2_15 (mix_i_src_c075_2_15 mix_i_c075_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_2_15 (mix_q_src_c075_2_15 0 bpf_c075_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_2_15 (mix_q_src_c075_2_15 mix_q_c075_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c075_2 (mix_i_c075_2 0) resistor r=1G
RMIXQ_c075_2 (mix_q_c075_2 0) resistor r=1G
RINTI_c075_2 (mix_i_c075_2 Icar_c075_2) resistor r=1k
CINTI_c075_2 (Icar_c075_2 0) capacitor c=80p
RINTQ_c075_2 (mix_q_c075_2 Qcar_c075_2) resistor r=1k
CINTQ_c075_2 (Qcar_c075_2 0) capacitor c=80p

// bl075, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c075_3 (bl075 n_cbpf_c075_3) capacitor c=2.533029591058e-14
LBPF_c075_3 (n_cbpf_c075_3 bpf_c075_3) inductor l=1.000000000000e-06
RBPF_c075_3 (bpf_c075_3 0) resistor r=3.141592653590e+02
EMIXI_c075_3_00 (mix_i_src_c075_3_00 0 bpf_c075_3 0) vcvs gain=9.807852804032e-01
SMIXI_c075_3_00 (mix_i_src_c075_3_00 mix_i_c075_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_00 (mix_q_src_c075_3_00 0 bpf_c075_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_3_00 (mix_q_src_c075_3_00 mix_q_c075_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_01 (mix_i_src_c075_3_01 0 bpf_c075_3 0) vcvs gain=8.314696123025e-01
SMIXI_c075_3_01 (mix_i_src_c075_3_01 mix_i_c075_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_01 (mix_q_src_c075_3_01 0 bpf_c075_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_3_01 (mix_q_src_c075_3_01 mix_q_c075_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_02 (mix_i_src_c075_3_02 0 bpf_c075_3 0) vcvs gain=5.555702330196e-01
SMIXI_c075_3_02 (mix_i_src_c075_3_02 mix_i_c075_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_02 (mix_q_src_c075_3_02 0 bpf_c075_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_3_02 (mix_q_src_c075_3_02 mix_q_c075_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_03 (mix_i_src_c075_3_03 0 bpf_c075_3 0) vcvs gain=1.950903220161e-01
SMIXI_c075_3_03 (mix_i_src_c075_3_03 mix_i_c075_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_03 (mix_q_src_c075_3_03 0 bpf_c075_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_3_03 (mix_q_src_c075_3_03 mix_q_c075_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_04 (mix_i_src_c075_3_04 0 bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_3_04 (mix_i_src_c075_3_04 mix_i_c075_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_04 (mix_q_src_c075_3_04 0 bpf_c075_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c075_3_04 (mix_q_src_c075_3_04 mix_q_c075_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_05 (mix_i_src_c075_3_05 0 bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_3_05 (mix_i_src_c075_3_05 mix_i_c075_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_05 (mix_q_src_c075_3_05 0 bpf_c075_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c075_3_05 (mix_q_src_c075_3_05 mix_q_c075_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_06 (mix_i_src_c075_3_06 0 bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_3_06 (mix_i_src_c075_3_06 mix_i_c075_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_06 (mix_q_src_c075_3_06 0 bpf_c075_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c075_3_06 (mix_q_src_c075_3_06 mix_q_c075_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_07 (mix_i_src_c075_3_07 0 bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_3_07 (mix_i_src_c075_3_07 mix_i_c075_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_07 (mix_q_src_c075_3_07 0 bpf_c075_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c075_3_07 (mix_q_src_c075_3_07 mix_q_c075_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_08 (mix_i_src_c075_3_08 0 bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c075_3_08 (mix_i_src_c075_3_08 mix_i_c075_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_08 (mix_q_src_c075_3_08 0 bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_3_08 (mix_q_src_c075_3_08 mix_q_c075_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_09 (mix_i_src_c075_3_09 0 bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c075_3_09 (mix_i_src_c075_3_09 mix_i_c075_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_09 (mix_q_src_c075_3_09 0 bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_3_09 (mix_q_src_c075_3_09 mix_q_c075_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_10 (mix_i_src_c075_3_10 0 bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c075_3_10 (mix_i_src_c075_3_10 mix_i_c075_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_10 (mix_q_src_c075_3_10 0 bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_3_10 (mix_q_src_c075_3_10 mix_q_c075_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_11 (mix_i_src_c075_3_11 0 bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c075_3_11 (mix_i_src_c075_3_11 mix_i_c075_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_11 (mix_q_src_c075_3_11 0 bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_3_11 (mix_q_src_c075_3_11 mix_q_c075_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_12 (mix_i_src_c075_3_12 0 bpf_c075_3 0) vcvs gain=1.950903220161e-01
SMIXI_c075_3_12 (mix_i_src_c075_3_12 mix_i_c075_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_12 (mix_q_src_c075_3_12 0 bpf_c075_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c075_3_12 (mix_q_src_c075_3_12 mix_q_c075_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_13 (mix_i_src_c075_3_13 0 bpf_c075_3 0) vcvs gain=5.555702330196e-01
SMIXI_c075_3_13 (mix_i_src_c075_3_13 mix_i_c075_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_13 (mix_q_src_c075_3_13 0 bpf_c075_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c075_3_13 (mix_q_src_c075_3_13 mix_q_c075_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_14 (mix_i_src_c075_3_14 0 bpf_c075_3 0) vcvs gain=8.314696123025e-01
SMIXI_c075_3_14 (mix_i_src_c075_3_14 mix_i_c075_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_14 (mix_q_src_c075_3_14 0 bpf_c075_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c075_3_14 (mix_q_src_c075_3_14 mix_q_c075_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c075_3_15 (mix_i_src_c075_3_15 0 bpf_c075_3 0) vcvs gain=9.807852804032e-01
SMIXI_c075_3_15 (mix_i_src_c075_3_15 mix_i_c075_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c075_3_15 (mix_q_src_c075_3_15 0 bpf_c075_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c075_3_15 (mix_q_src_c075_3_15 mix_q_c075_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c075_3 (mix_i_c075_3 0) resistor r=1G
RMIXQ_c075_3 (mix_q_c075_3 0) resistor r=1G
RINTI_c075_3 (mix_i_c075_3 Icar_c075_3) resistor r=1k
CINTI_c075_3 (Icar_c075_3 0) capacitor c=80p
RINTQ_c075_3 (mix_q_c075_3 Qcar_c075_3) resistor r=1k
CINTQ_c075_3 (Qcar_c075_3 0) capacitor c=80p

// bl076, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c076_0 (bl076 n_cbpf_c076_0) capacitor c=4.052847345694e-13
LBPF_c076_0 (n_cbpf_c076_0 bpf_c076_0) inductor l=1.000000000000e-06
RBPF_c076_0 (bpf_c076_0 0) resistor r=7.853981633974e+01
EMIXI_c076_0_00 (mix_i_src_c076_0_00 0 bpf_c076_0 0) vcvs gain=9.807852804032e-01
SMIXI_c076_0_00 (mix_i_src_c076_0_00 mix_i_c076_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_00 (mix_q_src_c076_0_00 0 bpf_c076_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_0_00 (mix_q_src_c076_0_00 mix_q_c076_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_01 (mix_i_src_c076_0_01 0 bpf_c076_0 0) vcvs gain=8.314696123025e-01
SMIXI_c076_0_01 (mix_i_src_c076_0_01 mix_i_c076_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_01 (mix_q_src_c076_0_01 0 bpf_c076_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_0_01 (mix_q_src_c076_0_01 mix_q_c076_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_02 (mix_i_src_c076_0_02 0 bpf_c076_0 0) vcvs gain=5.555702330196e-01
SMIXI_c076_0_02 (mix_i_src_c076_0_02 mix_i_c076_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_02 (mix_q_src_c076_0_02 0 bpf_c076_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_0_02 (mix_q_src_c076_0_02 mix_q_c076_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_03 (mix_i_src_c076_0_03 0 bpf_c076_0 0) vcvs gain=1.950903220161e-01
SMIXI_c076_0_03 (mix_i_src_c076_0_03 mix_i_c076_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_03 (mix_q_src_c076_0_03 0 bpf_c076_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_0_03 (mix_q_src_c076_0_03 mix_q_c076_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_04 (mix_i_src_c076_0_04 0 bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_0_04 (mix_i_src_c076_0_04 mix_i_c076_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_04 (mix_q_src_c076_0_04 0 bpf_c076_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_0_04 (mix_q_src_c076_0_04 mix_q_c076_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_05 (mix_i_src_c076_0_05 0 bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_0_05 (mix_i_src_c076_0_05 mix_i_c076_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_05 (mix_q_src_c076_0_05 0 bpf_c076_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_0_05 (mix_q_src_c076_0_05 mix_q_c076_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_06 (mix_i_src_c076_0_06 0 bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_0_06 (mix_i_src_c076_0_06 mix_i_c076_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_06 (mix_q_src_c076_0_06 0 bpf_c076_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_0_06 (mix_q_src_c076_0_06 mix_q_c076_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_07 (mix_i_src_c076_0_07 0 bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_0_07 (mix_i_src_c076_0_07 mix_i_c076_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_07 (mix_q_src_c076_0_07 0 bpf_c076_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_0_07 (mix_q_src_c076_0_07 mix_q_c076_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_08 (mix_i_src_c076_0_08 0 bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_0_08 (mix_i_src_c076_0_08 mix_i_c076_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_08 (mix_q_src_c076_0_08 0 bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_0_08 (mix_q_src_c076_0_08 mix_q_c076_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_09 (mix_i_src_c076_0_09 0 bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_0_09 (mix_i_src_c076_0_09 mix_i_c076_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_09 (mix_q_src_c076_0_09 0 bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_0_09 (mix_q_src_c076_0_09 mix_q_c076_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_10 (mix_i_src_c076_0_10 0 bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_0_10 (mix_i_src_c076_0_10 mix_i_c076_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_10 (mix_q_src_c076_0_10 0 bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_0_10 (mix_q_src_c076_0_10 mix_q_c076_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_11 (mix_i_src_c076_0_11 0 bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_0_11 (mix_i_src_c076_0_11 mix_i_c076_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_11 (mix_q_src_c076_0_11 0 bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_0_11 (mix_q_src_c076_0_11 mix_q_c076_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_12 (mix_i_src_c076_0_12 0 bpf_c076_0 0) vcvs gain=1.950903220161e-01
SMIXI_c076_0_12 (mix_i_src_c076_0_12 mix_i_c076_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_12 (mix_q_src_c076_0_12 0 bpf_c076_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_0_12 (mix_q_src_c076_0_12 mix_q_c076_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_13 (mix_i_src_c076_0_13 0 bpf_c076_0 0) vcvs gain=5.555702330196e-01
SMIXI_c076_0_13 (mix_i_src_c076_0_13 mix_i_c076_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_13 (mix_q_src_c076_0_13 0 bpf_c076_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_0_13 (mix_q_src_c076_0_13 mix_q_c076_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_14 (mix_i_src_c076_0_14 0 bpf_c076_0 0) vcvs gain=8.314696123025e-01
SMIXI_c076_0_14 (mix_i_src_c076_0_14 mix_i_c076_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_14 (mix_q_src_c076_0_14 0 bpf_c076_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_0_14 (mix_q_src_c076_0_14 mix_q_c076_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_0_15 (mix_i_src_c076_0_15 0 bpf_c076_0 0) vcvs gain=9.807852804032e-01
SMIXI_c076_0_15 (mix_i_src_c076_0_15 mix_i_c076_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_0_15 (mix_q_src_c076_0_15 0 bpf_c076_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_0_15 (mix_q_src_c076_0_15 mix_q_c076_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c076_0 (mix_i_c076_0 0) resistor r=1G
RMIXQ_c076_0 (mix_q_c076_0 0) resistor r=1G
RINTI_c076_0 (mix_i_c076_0 Icar_c076_0) resistor r=1k
CINTI_c076_0 (Icar_c076_0 0) capacitor c=80p
RINTQ_c076_0 (mix_q_c076_0 Qcar_c076_0) resistor r=1k
CINTQ_c076_0 (Qcar_c076_0 0) capacitor c=80p

// bl076, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c076_1 (bl076 n_cbpf_c076_1) capacitor c=1.013211836423e-13
LBPF_c076_1 (n_cbpf_c076_1 bpf_c076_1) inductor l=1.000000000000e-06
RBPF_c076_1 (bpf_c076_1 0) resistor r=1.570796326795e+02
EMIXI_c076_1_00 (mix_i_src_c076_1_00 0 bpf_c076_1 0) vcvs gain=9.807852804032e-01
SMIXI_c076_1_00 (mix_i_src_c076_1_00 mix_i_c076_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_00 (mix_q_src_c076_1_00 0 bpf_c076_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_1_00 (mix_q_src_c076_1_00 mix_q_c076_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_01 (mix_i_src_c076_1_01 0 bpf_c076_1 0) vcvs gain=8.314696123025e-01
SMIXI_c076_1_01 (mix_i_src_c076_1_01 mix_i_c076_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_01 (mix_q_src_c076_1_01 0 bpf_c076_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_1_01 (mix_q_src_c076_1_01 mix_q_c076_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_02 (mix_i_src_c076_1_02 0 bpf_c076_1 0) vcvs gain=5.555702330196e-01
SMIXI_c076_1_02 (mix_i_src_c076_1_02 mix_i_c076_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_02 (mix_q_src_c076_1_02 0 bpf_c076_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_1_02 (mix_q_src_c076_1_02 mix_q_c076_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_03 (mix_i_src_c076_1_03 0 bpf_c076_1 0) vcvs gain=1.950903220161e-01
SMIXI_c076_1_03 (mix_i_src_c076_1_03 mix_i_c076_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_03 (mix_q_src_c076_1_03 0 bpf_c076_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_1_03 (mix_q_src_c076_1_03 mix_q_c076_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_04 (mix_i_src_c076_1_04 0 bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_1_04 (mix_i_src_c076_1_04 mix_i_c076_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_04 (mix_q_src_c076_1_04 0 bpf_c076_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_1_04 (mix_q_src_c076_1_04 mix_q_c076_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_05 (mix_i_src_c076_1_05 0 bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_1_05 (mix_i_src_c076_1_05 mix_i_c076_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_05 (mix_q_src_c076_1_05 0 bpf_c076_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_1_05 (mix_q_src_c076_1_05 mix_q_c076_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_06 (mix_i_src_c076_1_06 0 bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_1_06 (mix_i_src_c076_1_06 mix_i_c076_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_06 (mix_q_src_c076_1_06 0 bpf_c076_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_1_06 (mix_q_src_c076_1_06 mix_q_c076_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_07 (mix_i_src_c076_1_07 0 bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_1_07 (mix_i_src_c076_1_07 mix_i_c076_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_07 (mix_q_src_c076_1_07 0 bpf_c076_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_1_07 (mix_q_src_c076_1_07 mix_q_c076_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_08 (mix_i_src_c076_1_08 0 bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_1_08 (mix_i_src_c076_1_08 mix_i_c076_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_08 (mix_q_src_c076_1_08 0 bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_1_08 (mix_q_src_c076_1_08 mix_q_c076_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_09 (mix_i_src_c076_1_09 0 bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_1_09 (mix_i_src_c076_1_09 mix_i_c076_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_09 (mix_q_src_c076_1_09 0 bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_1_09 (mix_q_src_c076_1_09 mix_q_c076_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_10 (mix_i_src_c076_1_10 0 bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_1_10 (mix_i_src_c076_1_10 mix_i_c076_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_10 (mix_q_src_c076_1_10 0 bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_1_10 (mix_q_src_c076_1_10 mix_q_c076_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_11 (mix_i_src_c076_1_11 0 bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_1_11 (mix_i_src_c076_1_11 mix_i_c076_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_11 (mix_q_src_c076_1_11 0 bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_1_11 (mix_q_src_c076_1_11 mix_q_c076_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_12 (mix_i_src_c076_1_12 0 bpf_c076_1 0) vcvs gain=1.950903220161e-01
SMIXI_c076_1_12 (mix_i_src_c076_1_12 mix_i_c076_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_12 (mix_q_src_c076_1_12 0 bpf_c076_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_1_12 (mix_q_src_c076_1_12 mix_q_c076_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_13 (mix_i_src_c076_1_13 0 bpf_c076_1 0) vcvs gain=5.555702330196e-01
SMIXI_c076_1_13 (mix_i_src_c076_1_13 mix_i_c076_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_13 (mix_q_src_c076_1_13 0 bpf_c076_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_1_13 (mix_q_src_c076_1_13 mix_q_c076_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_14 (mix_i_src_c076_1_14 0 bpf_c076_1 0) vcvs gain=8.314696123025e-01
SMIXI_c076_1_14 (mix_i_src_c076_1_14 mix_i_c076_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_14 (mix_q_src_c076_1_14 0 bpf_c076_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_1_14 (mix_q_src_c076_1_14 mix_q_c076_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_1_15 (mix_i_src_c076_1_15 0 bpf_c076_1 0) vcvs gain=9.807852804032e-01
SMIXI_c076_1_15 (mix_i_src_c076_1_15 mix_i_c076_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_1_15 (mix_q_src_c076_1_15 0 bpf_c076_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_1_15 (mix_q_src_c076_1_15 mix_q_c076_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c076_1 (mix_i_c076_1 0) resistor r=1G
RMIXQ_c076_1 (mix_q_c076_1 0) resistor r=1G
RINTI_c076_1 (mix_i_c076_1 Icar_c076_1) resistor r=1k
CINTI_c076_1 (Icar_c076_1 0) capacitor c=80p
RINTQ_c076_1 (mix_q_c076_1 Qcar_c076_1) resistor r=1k
CINTQ_c076_1 (Qcar_c076_1 0) capacitor c=80p

// bl076, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c076_2 (bl076 n_cbpf_c076_2) capacitor c=4.503163717437e-14
LBPF_c076_2 (n_cbpf_c076_2 bpf_c076_2) inductor l=1.000000000000e-06
RBPF_c076_2 (bpf_c076_2 0) resistor r=2.356194490192e+02
EMIXI_c076_2_00 (mix_i_src_c076_2_00 0 bpf_c076_2 0) vcvs gain=9.807852804032e-01
SMIXI_c076_2_00 (mix_i_src_c076_2_00 mix_i_c076_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_00 (mix_q_src_c076_2_00 0 bpf_c076_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_2_00 (mix_q_src_c076_2_00 mix_q_c076_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_01 (mix_i_src_c076_2_01 0 bpf_c076_2 0) vcvs gain=8.314696123025e-01
SMIXI_c076_2_01 (mix_i_src_c076_2_01 mix_i_c076_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_01 (mix_q_src_c076_2_01 0 bpf_c076_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_2_01 (mix_q_src_c076_2_01 mix_q_c076_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_02 (mix_i_src_c076_2_02 0 bpf_c076_2 0) vcvs gain=5.555702330196e-01
SMIXI_c076_2_02 (mix_i_src_c076_2_02 mix_i_c076_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_02 (mix_q_src_c076_2_02 0 bpf_c076_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_2_02 (mix_q_src_c076_2_02 mix_q_c076_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_03 (mix_i_src_c076_2_03 0 bpf_c076_2 0) vcvs gain=1.950903220161e-01
SMIXI_c076_2_03 (mix_i_src_c076_2_03 mix_i_c076_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_03 (mix_q_src_c076_2_03 0 bpf_c076_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_2_03 (mix_q_src_c076_2_03 mix_q_c076_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_04 (mix_i_src_c076_2_04 0 bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_2_04 (mix_i_src_c076_2_04 mix_i_c076_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_04 (mix_q_src_c076_2_04 0 bpf_c076_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_2_04 (mix_q_src_c076_2_04 mix_q_c076_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_05 (mix_i_src_c076_2_05 0 bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_2_05 (mix_i_src_c076_2_05 mix_i_c076_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_05 (mix_q_src_c076_2_05 0 bpf_c076_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_2_05 (mix_q_src_c076_2_05 mix_q_c076_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_06 (mix_i_src_c076_2_06 0 bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_2_06 (mix_i_src_c076_2_06 mix_i_c076_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_06 (mix_q_src_c076_2_06 0 bpf_c076_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_2_06 (mix_q_src_c076_2_06 mix_q_c076_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_07 (mix_i_src_c076_2_07 0 bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_2_07 (mix_i_src_c076_2_07 mix_i_c076_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_07 (mix_q_src_c076_2_07 0 bpf_c076_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_2_07 (mix_q_src_c076_2_07 mix_q_c076_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_08 (mix_i_src_c076_2_08 0 bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_2_08 (mix_i_src_c076_2_08 mix_i_c076_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_08 (mix_q_src_c076_2_08 0 bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_2_08 (mix_q_src_c076_2_08 mix_q_c076_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_09 (mix_i_src_c076_2_09 0 bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_2_09 (mix_i_src_c076_2_09 mix_i_c076_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_09 (mix_q_src_c076_2_09 0 bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_2_09 (mix_q_src_c076_2_09 mix_q_c076_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_10 (mix_i_src_c076_2_10 0 bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_2_10 (mix_i_src_c076_2_10 mix_i_c076_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_10 (mix_q_src_c076_2_10 0 bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_2_10 (mix_q_src_c076_2_10 mix_q_c076_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_11 (mix_i_src_c076_2_11 0 bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_2_11 (mix_i_src_c076_2_11 mix_i_c076_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_11 (mix_q_src_c076_2_11 0 bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_2_11 (mix_q_src_c076_2_11 mix_q_c076_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_12 (mix_i_src_c076_2_12 0 bpf_c076_2 0) vcvs gain=1.950903220161e-01
SMIXI_c076_2_12 (mix_i_src_c076_2_12 mix_i_c076_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_12 (mix_q_src_c076_2_12 0 bpf_c076_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_2_12 (mix_q_src_c076_2_12 mix_q_c076_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_13 (mix_i_src_c076_2_13 0 bpf_c076_2 0) vcvs gain=5.555702330196e-01
SMIXI_c076_2_13 (mix_i_src_c076_2_13 mix_i_c076_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_13 (mix_q_src_c076_2_13 0 bpf_c076_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_2_13 (mix_q_src_c076_2_13 mix_q_c076_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_14 (mix_i_src_c076_2_14 0 bpf_c076_2 0) vcvs gain=8.314696123025e-01
SMIXI_c076_2_14 (mix_i_src_c076_2_14 mix_i_c076_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_14 (mix_q_src_c076_2_14 0 bpf_c076_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_2_14 (mix_q_src_c076_2_14 mix_q_c076_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_2_15 (mix_i_src_c076_2_15 0 bpf_c076_2 0) vcvs gain=9.807852804032e-01
SMIXI_c076_2_15 (mix_i_src_c076_2_15 mix_i_c076_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_2_15 (mix_q_src_c076_2_15 0 bpf_c076_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_2_15 (mix_q_src_c076_2_15 mix_q_c076_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c076_2 (mix_i_c076_2 0) resistor r=1G
RMIXQ_c076_2 (mix_q_c076_2 0) resistor r=1G
RINTI_c076_2 (mix_i_c076_2 Icar_c076_2) resistor r=1k
CINTI_c076_2 (Icar_c076_2 0) capacitor c=80p
RINTQ_c076_2 (mix_q_c076_2 Qcar_c076_2) resistor r=1k
CINTQ_c076_2 (Qcar_c076_2 0) capacitor c=80p

// bl076, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c076_3 (bl076 n_cbpf_c076_3) capacitor c=2.533029591058e-14
LBPF_c076_3 (n_cbpf_c076_3 bpf_c076_3) inductor l=1.000000000000e-06
RBPF_c076_3 (bpf_c076_3 0) resistor r=3.141592653590e+02
EMIXI_c076_3_00 (mix_i_src_c076_3_00 0 bpf_c076_3 0) vcvs gain=9.807852804032e-01
SMIXI_c076_3_00 (mix_i_src_c076_3_00 mix_i_c076_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_00 (mix_q_src_c076_3_00 0 bpf_c076_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_3_00 (mix_q_src_c076_3_00 mix_q_c076_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_01 (mix_i_src_c076_3_01 0 bpf_c076_3 0) vcvs gain=8.314696123025e-01
SMIXI_c076_3_01 (mix_i_src_c076_3_01 mix_i_c076_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_01 (mix_q_src_c076_3_01 0 bpf_c076_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_3_01 (mix_q_src_c076_3_01 mix_q_c076_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_02 (mix_i_src_c076_3_02 0 bpf_c076_3 0) vcvs gain=5.555702330196e-01
SMIXI_c076_3_02 (mix_i_src_c076_3_02 mix_i_c076_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_02 (mix_q_src_c076_3_02 0 bpf_c076_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_3_02 (mix_q_src_c076_3_02 mix_q_c076_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_03 (mix_i_src_c076_3_03 0 bpf_c076_3 0) vcvs gain=1.950903220161e-01
SMIXI_c076_3_03 (mix_i_src_c076_3_03 mix_i_c076_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_03 (mix_q_src_c076_3_03 0 bpf_c076_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_3_03 (mix_q_src_c076_3_03 mix_q_c076_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_04 (mix_i_src_c076_3_04 0 bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_3_04 (mix_i_src_c076_3_04 mix_i_c076_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_04 (mix_q_src_c076_3_04 0 bpf_c076_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c076_3_04 (mix_q_src_c076_3_04 mix_q_c076_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_05 (mix_i_src_c076_3_05 0 bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_3_05 (mix_i_src_c076_3_05 mix_i_c076_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_05 (mix_q_src_c076_3_05 0 bpf_c076_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c076_3_05 (mix_q_src_c076_3_05 mix_q_c076_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_06 (mix_i_src_c076_3_06 0 bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_3_06 (mix_i_src_c076_3_06 mix_i_c076_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_06 (mix_q_src_c076_3_06 0 bpf_c076_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c076_3_06 (mix_q_src_c076_3_06 mix_q_c076_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_07 (mix_i_src_c076_3_07 0 bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_3_07 (mix_i_src_c076_3_07 mix_i_c076_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_07 (mix_q_src_c076_3_07 0 bpf_c076_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c076_3_07 (mix_q_src_c076_3_07 mix_q_c076_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_08 (mix_i_src_c076_3_08 0 bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c076_3_08 (mix_i_src_c076_3_08 mix_i_c076_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_08 (mix_q_src_c076_3_08 0 bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_3_08 (mix_q_src_c076_3_08 mix_q_c076_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_09 (mix_i_src_c076_3_09 0 bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c076_3_09 (mix_i_src_c076_3_09 mix_i_c076_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_09 (mix_q_src_c076_3_09 0 bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_3_09 (mix_q_src_c076_3_09 mix_q_c076_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_10 (mix_i_src_c076_3_10 0 bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c076_3_10 (mix_i_src_c076_3_10 mix_i_c076_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_10 (mix_q_src_c076_3_10 0 bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_3_10 (mix_q_src_c076_3_10 mix_q_c076_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_11 (mix_i_src_c076_3_11 0 bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c076_3_11 (mix_i_src_c076_3_11 mix_i_c076_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_11 (mix_q_src_c076_3_11 0 bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_3_11 (mix_q_src_c076_3_11 mix_q_c076_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_12 (mix_i_src_c076_3_12 0 bpf_c076_3 0) vcvs gain=1.950903220161e-01
SMIXI_c076_3_12 (mix_i_src_c076_3_12 mix_i_c076_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_12 (mix_q_src_c076_3_12 0 bpf_c076_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c076_3_12 (mix_q_src_c076_3_12 mix_q_c076_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_13 (mix_i_src_c076_3_13 0 bpf_c076_3 0) vcvs gain=5.555702330196e-01
SMIXI_c076_3_13 (mix_i_src_c076_3_13 mix_i_c076_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_13 (mix_q_src_c076_3_13 0 bpf_c076_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c076_3_13 (mix_q_src_c076_3_13 mix_q_c076_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_14 (mix_i_src_c076_3_14 0 bpf_c076_3 0) vcvs gain=8.314696123025e-01
SMIXI_c076_3_14 (mix_i_src_c076_3_14 mix_i_c076_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_14 (mix_q_src_c076_3_14 0 bpf_c076_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c076_3_14 (mix_q_src_c076_3_14 mix_q_c076_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c076_3_15 (mix_i_src_c076_3_15 0 bpf_c076_3 0) vcvs gain=9.807852804032e-01
SMIXI_c076_3_15 (mix_i_src_c076_3_15 mix_i_c076_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c076_3_15 (mix_q_src_c076_3_15 0 bpf_c076_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c076_3_15 (mix_q_src_c076_3_15 mix_q_c076_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c076_3 (mix_i_c076_3 0) resistor r=1G
RMIXQ_c076_3 (mix_q_c076_3 0) resistor r=1G
RINTI_c076_3 (mix_i_c076_3 Icar_c076_3) resistor r=1k
CINTI_c076_3 (Icar_c076_3 0) capacitor c=80p
RINTQ_c076_3 (mix_q_c076_3 Qcar_c076_3) resistor r=1k
CINTQ_c076_3 (Qcar_c076_3 0) capacitor c=80p

// bl077, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c077_0 (bl077 n_cbpf_c077_0) capacitor c=4.052847345694e-13
LBPF_c077_0 (n_cbpf_c077_0 bpf_c077_0) inductor l=1.000000000000e-06
RBPF_c077_0 (bpf_c077_0 0) resistor r=7.853981633974e+01
EMIXI_c077_0_00 (mix_i_src_c077_0_00 0 bpf_c077_0 0) vcvs gain=9.807852804032e-01
SMIXI_c077_0_00 (mix_i_src_c077_0_00 mix_i_c077_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_00 (mix_q_src_c077_0_00 0 bpf_c077_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_0_00 (mix_q_src_c077_0_00 mix_q_c077_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_01 (mix_i_src_c077_0_01 0 bpf_c077_0 0) vcvs gain=8.314696123025e-01
SMIXI_c077_0_01 (mix_i_src_c077_0_01 mix_i_c077_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_01 (mix_q_src_c077_0_01 0 bpf_c077_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_0_01 (mix_q_src_c077_0_01 mix_q_c077_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_02 (mix_i_src_c077_0_02 0 bpf_c077_0 0) vcvs gain=5.555702330196e-01
SMIXI_c077_0_02 (mix_i_src_c077_0_02 mix_i_c077_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_02 (mix_q_src_c077_0_02 0 bpf_c077_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_0_02 (mix_q_src_c077_0_02 mix_q_c077_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_03 (mix_i_src_c077_0_03 0 bpf_c077_0 0) vcvs gain=1.950903220161e-01
SMIXI_c077_0_03 (mix_i_src_c077_0_03 mix_i_c077_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_03 (mix_q_src_c077_0_03 0 bpf_c077_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_0_03 (mix_q_src_c077_0_03 mix_q_c077_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_04 (mix_i_src_c077_0_04 0 bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_0_04 (mix_i_src_c077_0_04 mix_i_c077_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_04 (mix_q_src_c077_0_04 0 bpf_c077_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_0_04 (mix_q_src_c077_0_04 mix_q_c077_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_05 (mix_i_src_c077_0_05 0 bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_0_05 (mix_i_src_c077_0_05 mix_i_c077_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_05 (mix_q_src_c077_0_05 0 bpf_c077_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_0_05 (mix_q_src_c077_0_05 mix_q_c077_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_06 (mix_i_src_c077_0_06 0 bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_0_06 (mix_i_src_c077_0_06 mix_i_c077_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_06 (mix_q_src_c077_0_06 0 bpf_c077_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_0_06 (mix_q_src_c077_0_06 mix_q_c077_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_07 (mix_i_src_c077_0_07 0 bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_0_07 (mix_i_src_c077_0_07 mix_i_c077_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_07 (mix_q_src_c077_0_07 0 bpf_c077_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_0_07 (mix_q_src_c077_0_07 mix_q_c077_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_08 (mix_i_src_c077_0_08 0 bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_0_08 (mix_i_src_c077_0_08 mix_i_c077_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_08 (mix_q_src_c077_0_08 0 bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_0_08 (mix_q_src_c077_0_08 mix_q_c077_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_09 (mix_i_src_c077_0_09 0 bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_0_09 (mix_i_src_c077_0_09 mix_i_c077_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_09 (mix_q_src_c077_0_09 0 bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_0_09 (mix_q_src_c077_0_09 mix_q_c077_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_10 (mix_i_src_c077_0_10 0 bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_0_10 (mix_i_src_c077_0_10 mix_i_c077_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_10 (mix_q_src_c077_0_10 0 bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_0_10 (mix_q_src_c077_0_10 mix_q_c077_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_11 (mix_i_src_c077_0_11 0 bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_0_11 (mix_i_src_c077_0_11 mix_i_c077_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_11 (mix_q_src_c077_0_11 0 bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_0_11 (mix_q_src_c077_0_11 mix_q_c077_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_12 (mix_i_src_c077_0_12 0 bpf_c077_0 0) vcvs gain=1.950903220161e-01
SMIXI_c077_0_12 (mix_i_src_c077_0_12 mix_i_c077_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_12 (mix_q_src_c077_0_12 0 bpf_c077_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_0_12 (mix_q_src_c077_0_12 mix_q_c077_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_13 (mix_i_src_c077_0_13 0 bpf_c077_0 0) vcvs gain=5.555702330196e-01
SMIXI_c077_0_13 (mix_i_src_c077_0_13 mix_i_c077_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_13 (mix_q_src_c077_0_13 0 bpf_c077_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_0_13 (mix_q_src_c077_0_13 mix_q_c077_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_14 (mix_i_src_c077_0_14 0 bpf_c077_0 0) vcvs gain=8.314696123025e-01
SMIXI_c077_0_14 (mix_i_src_c077_0_14 mix_i_c077_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_14 (mix_q_src_c077_0_14 0 bpf_c077_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_0_14 (mix_q_src_c077_0_14 mix_q_c077_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_0_15 (mix_i_src_c077_0_15 0 bpf_c077_0 0) vcvs gain=9.807852804032e-01
SMIXI_c077_0_15 (mix_i_src_c077_0_15 mix_i_c077_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_0_15 (mix_q_src_c077_0_15 0 bpf_c077_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_0_15 (mix_q_src_c077_0_15 mix_q_c077_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c077_0 (mix_i_c077_0 0) resistor r=1G
RMIXQ_c077_0 (mix_q_c077_0 0) resistor r=1G
RINTI_c077_0 (mix_i_c077_0 Icar_c077_0) resistor r=1k
CINTI_c077_0 (Icar_c077_0 0) capacitor c=80p
RINTQ_c077_0 (mix_q_c077_0 Qcar_c077_0) resistor r=1k
CINTQ_c077_0 (Qcar_c077_0 0) capacitor c=80p

// bl077, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c077_1 (bl077 n_cbpf_c077_1) capacitor c=1.013211836423e-13
LBPF_c077_1 (n_cbpf_c077_1 bpf_c077_1) inductor l=1.000000000000e-06
RBPF_c077_1 (bpf_c077_1 0) resistor r=1.570796326795e+02
EMIXI_c077_1_00 (mix_i_src_c077_1_00 0 bpf_c077_1 0) vcvs gain=9.807852804032e-01
SMIXI_c077_1_00 (mix_i_src_c077_1_00 mix_i_c077_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_00 (mix_q_src_c077_1_00 0 bpf_c077_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_1_00 (mix_q_src_c077_1_00 mix_q_c077_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_01 (mix_i_src_c077_1_01 0 bpf_c077_1 0) vcvs gain=8.314696123025e-01
SMIXI_c077_1_01 (mix_i_src_c077_1_01 mix_i_c077_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_01 (mix_q_src_c077_1_01 0 bpf_c077_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_1_01 (mix_q_src_c077_1_01 mix_q_c077_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_02 (mix_i_src_c077_1_02 0 bpf_c077_1 0) vcvs gain=5.555702330196e-01
SMIXI_c077_1_02 (mix_i_src_c077_1_02 mix_i_c077_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_02 (mix_q_src_c077_1_02 0 bpf_c077_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_1_02 (mix_q_src_c077_1_02 mix_q_c077_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_03 (mix_i_src_c077_1_03 0 bpf_c077_1 0) vcvs gain=1.950903220161e-01
SMIXI_c077_1_03 (mix_i_src_c077_1_03 mix_i_c077_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_03 (mix_q_src_c077_1_03 0 bpf_c077_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_1_03 (mix_q_src_c077_1_03 mix_q_c077_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_04 (mix_i_src_c077_1_04 0 bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_1_04 (mix_i_src_c077_1_04 mix_i_c077_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_04 (mix_q_src_c077_1_04 0 bpf_c077_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_1_04 (mix_q_src_c077_1_04 mix_q_c077_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_05 (mix_i_src_c077_1_05 0 bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_1_05 (mix_i_src_c077_1_05 mix_i_c077_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_05 (mix_q_src_c077_1_05 0 bpf_c077_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_1_05 (mix_q_src_c077_1_05 mix_q_c077_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_06 (mix_i_src_c077_1_06 0 bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_1_06 (mix_i_src_c077_1_06 mix_i_c077_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_06 (mix_q_src_c077_1_06 0 bpf_c077_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_1_06 (mix_q_src_c077_1_06 mix_q_c077_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_07 (mix_i_src_c077_1_07 0 bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_1_07 (mix_i_src_c077_1_07 mix_i_c077_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_07 (mix_q_src_c077_1_07 0 bpf_c077_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_1_07 (mix_q_src_c077_1_07 mix_q_c077_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_08 (mix_i_src_c077_1_08 0 bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_1_08 (mix_i_src_c077_1_08 mix_i_c077_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_08 (mix_q_src_c077_1_08 0 bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_1_08 (mix_q_src_c077_1_08 mix_q_c077_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_09 (mix_i_src_c077_1_09 0 bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_1_09 (mix_i_src_c077_1_09 mix_i_c077_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_09 (mix_q_src_c077_1_09 0 bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_1_09 (mix_q_src_c077_1_09 mix_q_c077_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_10 (mix_i_src_c077_1_10 0 bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_1_10 (mix_i_src_c077_1_10 mix_i_c077_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_10 (mix_q_src_c077_1_10 0 bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_1_10 (mix_q_src_c077_1_10 mix_q_c077_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_11 (mix_i_src_c077_1_11 0 bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_1_11 (mix_i_src_c077_1_11 mix_i_c077_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_11 (mix_q_src_c077_1_11 0 bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_1_11 (mix_q_src_c077_1_11 mix_q_c077_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_12 (mix_i_src_c077_1_12 0 bpf_c077_1 0) vcvs gain=1.950903220161e-01
SMIXI_c077_1_12 (mix_i_src_c077_1_12 mix_i_c077_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_12 (mix_q_src_c077_1_12 0 bpf_c077_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_1_12 (mix_q_src_c077_1_12 mix_q_c077_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_13 (mix_i_src_c077_1_13 0 bpf_c077_1 0) vcvs gain=5.555702330196e-01
SMIXI_c077_1_13 (mix_i_src_c077_1_13 mix_i_c077_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_13 (mix_q_src_c077_1_13 0 bpf_c077_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_1_13 (mix_q_src_c077_1_13 mix_q_c077_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_14 (mix_i_src_c077_1_14 0 bpf_c077_1 0) vcvs gain=8.314696123025e-01
SMIXI_c077_1_14 (mix_i_src_c077_1_14 mix_i_c077_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_14 (mix_q_src_c077_1_14 0 bpf_c077_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_1_14 (mix_q_src_c077_1_14 mix_q_c077_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_1_15 (mix_i_src_c077_1_15 0 bpf_c077_1 0) vcvs gain=9.807852804032e-01
SMIXI_c077_1_15 (mix_i_src_c077_1_15 mix_i_c077_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_1_15 (mix_q_src_c077_1_15 0 bpf_c077_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_1_15 (mix_q_src_c077_1_15 mix_q_c077_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c077_1 (mix_i_c077_1 0) resistor r=1G
RMIXQ_c077_1 (mix_q_c077_1 0) resistor r=1G
RINTI_c077_1 (mix_i_c077_1 Icar_c077_1) resistor r=1k
CINTI_c077_1 (Icar_c077_1 0) capacitor c=80p
RINTQ_c077_1 (mix_q_c077_1 Qcar_c077_1) resistor r=1k
CINTQ_c077_1 (Qcar_c077_1 0) capacitor c=80p

// bl077, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c077_2 (bl077 n_cbpf_c077_2) capacitor c=4.503163717437e-14
LBPF_c077_2 (n_cbpf_c077_2 bpf_c077_2) inductor l=1.000000000000e-06
RBPF_c077_2 (bpf_c077_2 0) resistor r=2.356194490192e+02
EMIXI_c077_2_00 (mix_i_src_c077_2_00 0 bpf_c077_2 0) vcvs gain=9.807852804032e-01
SMIXI_c077_2_00 (mix_i_src_c077_2_00 mix_i_c077_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_00 (mix_q_src_c077_2_00 0 bpf_c077_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_2_00 (mix_q_src_c077_2_00 mix_q_c077_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_01 (mix_i_src_c077_2_01 0 bpf_c077_2 0) vcvs gain=8.314696123025e-01
SMIXI_c077_2_01 (mix_i_src_c077_2_01 mix_i_c077_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_01 (mix_q_src_c077_2_01 0 bpf_c077_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_2_01 (mix_q_src_c077_2_01 mix_q_c077_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_02 (mix_i_src_c077_2_02 0 bpf_c077_2 0) vcvs gain=5.555702330196e-01
SMIXI_c077_2_02 (mix_i_src_c077_2_02 mix_i_c077_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_02 (mix_q_src_c077_2_02 0 bpf_c077_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_2_02 (mix_q_src_c077_2_02 mix_q_c077_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_03 (mix_i_src_c077_2_03 0 bpf_c077_2 0) vcvs gain=1.950903220161e-01
SMIXI_c077_2_03 (mix_i_src_c077_2_03 mix_i_c077_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_03 (mix_q_src_c077_2_03 0 bpf_c077_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_2_03 (mix_q_src_c077_2_03 mix_q_c077_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_04 (mix_i_src_c077_2_04 0 bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_2_04 (mix_i_src_c077_2_04 mix_i_c077_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_04 (mix_q_src_c077_2_04 0 bpf_c077_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_2_04 (mix_q_src_c077_2_04 mix_q_c077_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_05 (mix_i_src_c077_2_05 0 bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_2_05 (mix_i_src_c077_2_05 mix_i_c077_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_05 (mix_q_src_c077_2_05 0 bpf_c077_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_2_05 (mix_q_src_c077_2_05 mix_q_c077_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_06 (mix_i_src_c077_2_06 0 bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_2_06 (mix_i_src_c077_2_06 mix_i_c077_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_06 (mix_q_src_c077_2_06 0 bpf_c077_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_2_06 (mix_q_src_c077_2_06 mix_q_c077_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_07 (mix_i_src_c077_2_07 0 bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_2_07 (mix_i_src_c077_2_07 mix_i_c077_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_07 (mix_q_src_c077_2_07 0 bpf_c077_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_2_07 (mix_q_src_c077_2_07 mix_q_c077_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_08 (mix_i_src_c077_2_08 0 bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_2_08 (mix_i_src_c077_2_08 mix_i_c077_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_08 (mix_q_src_c077_2_08 0 bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_2_08 (mix_q_src_c077_2_08 mix_q_c077_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_09 (mix_i_src_c077_2_09 0 bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_2_09 (mix_i_src_c077_2_09 mix_i_c077_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_09 (mix_q_src_c077_2_09 0 bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_2_09 (mix_q_src_c077_2_09 mix_q_c077_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_10 (mix_i_src_c077_2_10 0 bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_2_10 (mix_i_src_c077_2_10 mix_i_c077_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_10 (mix_q_src_c077_2_10 0 bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_2_10 (mix_q_src_c077_2_10 mix_q_c077_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_11 (mix_i_src_c077_2_11 0 bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_2_11 (mix_i_src_c077_2_11 mix_i_c077_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_11 (mix_q_src_c077_2_11 0 bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_2_11 (mix_q_src_c077_2_11 mix_q_c077_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_12 (mix_i_src_c077_2_12 0 bpf_c077_2 0) vcvs gain=1.950903220161e-01
SMIXI_c077_2_12 (mix_i_src_c077_2_12 mix_i_c077_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_12 (mix_q_src_c077_2_12 0 bpf_c077_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_2_12 (mix_q_src_c077_2_12 mix_q_c077_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_13 (mix_i_src_c077_2_13 0 bpf_c077_2 0) vcvs gain=5.555702330196e-01
SMIXI_c077_2_13 (mix_i_src_c077_2_13 mix_i_c077_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_13 (mix_q_src_c077_2_13 0 bpf_c077_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_2_13 (mix_q_src_c077_2_13 mix_q_c077_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_14 (mix_i_src_c077_2_14 0 bpf_c077_2 0) vcvs gain=8.314696123025e-01
SMIXI_c077_2_14 (mix_i_src_c077_2_14 mix_i_c077_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_14 (mix_q_src_c077_2_14 0 bpf_c077_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_2_14 (mix_q_src_c077_2_14 mix_q_c077_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_2_15 (mix_i_src_c077_2_15 0 bpf_c077_2 0) vcvs gain=9.807852804032e-01
SMIXI_c077_2_15 (mix_i_src_c077_2_15 mix_i_c077_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_2_15 (mix_q_src_c077_2_15 0 bpf_c077_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_2_15 (mix_q_src_c077_2_15 mix_q_c077_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c077_2 (mix_i_c077_2 0) resistor r=1G
RMIXQ_c077_2 (mix_q_c077_2 0) resistor r=1G
RINTI_c077_2 (mix_i_c077_2 Icar_c077_2) resistor r=1k
CINTI_c077_2 (Icar_c077_2 0) capacitor c=80p
RINTQ_c077_2 (mix_q_c077_2 Qcar_c077_2) resistor r=1k
CINTQ_c077_2 (Qcar_c077_2 0) capacitor c=80p

// bl077, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c077_3 (bl077 n_cbpf_c077_3) capacitor c=2.533029591058e-14
LBPF_c077_3 (n_cbpf_c077_3 bpf_c077_3) inductor l=1.000000000000e-06
RBPF_c077_3 (bpf_c077_3 0) resistor r=3.141592653590e+02
EMIXI_c077_3_00 (mix_i_src_c077_3_00 0 bpf_c077_3 0) vcvs gain=9.807852804032e-01
SMIXI_c077_3_00 (mix_i_src_c077_3_00 mix_i_c077_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_00 (mix_q_src_c077_3_00 0 bpf_c077_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_3_00 (mix_q_src_c077_3_00 mix_q_c077_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_01 (mix_i_src_c077_3_01 0 bpf_c077_3 0) vcvs gain=8.314696123025e-01
SMIXI_c077_3_01 (mix_i_src_c077_3_01 mix_i_c077_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_01 (mix_q_src_c077_3_01 0 bpf_c077_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_3_01 (mix_q_src_c077_3_01 mix_q_c077_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_02 (mix_i_src_c077_3_02 0 bpf_c077_3 0) vcvs gain=5.555702330196e-01
SMIXI_c077_3_02 (mix_i_src_c077_3_02 mix_i_c077_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_02 (mix_q_src_c077_3_02 0 bpf_c077_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_3_02 (mix_q_src_c077_3_02 mix_q_c077_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_03 (mix_i_src_c077_3_03 0 bpf_c077_3 0) vcvs gain=1.950903220161e-01
SMIXI_c077_3_03 (mix_i_src_c077_3_03 mix_i_c077_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_03 (mix_q_src_c077_3_03 0 bpf_c077_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_3_03 (mix_q_src_c077_3_03 mix_q_c077_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_04 (mix_i_src_c077_3_04 0 bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_3_04 (mix_i_src_c077_3_04 mix_i_c077_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_04 (mix_q_src_c077_3_04 0 bpf_c077_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c077_3_04 (mix_q_src_c077_3_04 mix_q_c077_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_05 (mix_i_src_c077_3_05 0 bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_3_05 (mix_i_src_c077_3_05 mix_i_c077_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_05 (mix_q_src_c077_3_05 0 bpf_c077_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c077_3_05 (mix_q_src_c077_3_05 mix_q_c077_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_06 (mix_i_src_c077_3_06 0 bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_3_06 (mix_i_src_c077_3_06 mix_i_c077_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_06 (mix_q_src_c077_3_06 0 bpf_c077_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c077_3_06 (mix_q_src_c077_3_06 mix_q_c077_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_07 (mix_i_src_c077_3_07 0 bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_3_07 (mix_i_src_c077_3_07 mix_i_c077_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_07 (mix_q_src_c077_3_07 0 bpf_c077_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c077_3_07 (mix_q_src_c077_3_07 mix_q_c077_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_08 (mix_i_src_c077_3_08 0 bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c077_3_08 (mix_i_src_c077_3_08 mix_i_c077_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_08 (mix_q_src_c077_3_08 0 bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_3_08 (mix_q_src_c077_3_08 mix_q_c077_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_09 (mix_i_src_c077_3_09 0 bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c077_3_09 (mix_i_src_c077_3_09 mix_i_c077_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_09 (mix_q_src_c077_3_09 0 bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_3_09 (mix_q_src_c077_3_09 mix_q_c077_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_10 (mix_i_src_c077_3_10 0 bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c077_3_10 (mix_i_src_c077_3_10 mix_i_c077_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_10 (mix_q_src_c077_3_10 0 bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_3_10 (mix_q_src_c077_3_10 mix_q_c077_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_11 (mix_i_src_c077_3_11 0 bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c077_3_11 (mix_i_src_c077_3_11 mix_i_c077_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_11 (mix_q_src_c077_3_11 0 bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_3_11 (mix_q_src_c077_3_11 mix_q_c077_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_12 (mix_i_src_c077_3_12 0 bpf_c077_3 0) vcvs gain=1.950903220161e-01
SMIXI_c077_3_12 (mix_i_src_c077_3_12 mix_i_c077_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_12 (mix_q_src_c077_3_12 0 bpf_c077_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c077_3_12 (mix_q_src_c077_3_12 mix_q_c077_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_13 (mix_i_src_c077_3_13 0 bpf_c077_3 0) vcvs gain=5.555702330196e-01
SMIXI_c077_3_13 (mix_i_src_c077_3_13 mix_i_c077_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_13 (mix_q_src_c077_3_13 0 bpf_c077_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c077_3_13 (mix_q_src_c077_3_13 mix_q_c077_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_14 (mix_i_src_c077_3_14 0 bpf_c077_3 0) vcvs gain=8.314696123025e-01
SMIXI_c077_3_14 (mix_i_src_c077_3_14 mix_i_c077_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_14 (mix_q_src_c077_3_14 0 bpf_c077_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c077_3_14 (mix_q_src_c077_3_14 mix_q_c077_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c077_3_15 (mix_i_src_c077_3_15 0 bpf_c077_3 0) vcvs gain=9.807852804032e-01
SMIXI_c077_3_15 (mix_i_src_c077_3_15 mix_i_c077_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c077_3_15 (mix_q_src_c077_3_15 0 bpf_c077_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c077_3_15 (mix_q_src_c077_3_15 mix_q_c077_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c077_3 (mix_i_c077_3 0) resistor r=1G
RMIXQ_c077_3 (mix_q_c077_3 0) resistor r=1G
RINTI_c077_3 (mix_i_c077_3 Icar_c077_3) resistor r=1k
CINTI_c077_3 (Icar_c077_3 0) capacitor c=80p
RINTQ_c077_3 (mix_q_c077_3 Qcar_c077_3) resistor r=1k
CINTQ_c077_3 (Qcar_c077_3 0) capacitor c=80p

// bl078, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c078_0 (bl078 n_cbpf_c078_0) capacitor c=4.052847345694e-13
LBPF_c078_0 (n_cbpf_c078_0 bpf_c078_0) inductor l=1.000000000000e-06
RBPF_c078_0 (bpf_c078_0 0) resistor r=7.853981633974e+01
EMIXI_c078_0_00 (mix_i_src_c078_0_00 0 bpf_c078_0 0) vcvs gain=9.807852804032e-01
SMIXI_c078_0_00 (mix_i_src_c078_0_00 mix_i_c078_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_00 (mix_q_src_c078_0_00 0 bpf_c078_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_0_00 (mix_q_src_c078_0_00 mix_q_c078_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_01 (mix_i_src_c078_0_01 0 bpf_c078_0 0) vcvs gain=8.314696123025e-01
SMIXI_c078_0_01 (mix_i_src_c078_0_01 mix_i_c078_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_01 (mix_q_src_c078_0_01 0 bpf_c078_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_0_01 (mix_q_src_c078_0_01 mix_q_c078_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_02 (mix_i_src_c078_0_02 0 bpf_c078_0 0) vcvs gain=5.555702330196e-01
SMIXI_c078_0_02 (mix_i_src_c078_0_02 mix_i_c078_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_02 (mix_q_src_c078_0_02 0 bpf_c078_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_0_02 (mix_q_src_c078_0_02 mix_q_c078_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_03 (mix_i_src_c078_0_03 0 bpf_c078_0 0) vcvs gain=1.950903220161e-01
SMIXI_c078_0_03 (mix_i_src_c078_0_03 mix_i_c078_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_03 (mix_q_src_c078_0_03 0 bpf_c078_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_0_03 (mix_q_src_c078_0_03 mix_q_c078_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_04 (mix_i_src_c078_0_04 0 bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_0_04 (mix_i_src_c078_0_04 mix_i_c078_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_04 (mix_q_src_c078_0_04 0 bpf_c078_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_0_04 (mix_q_src_c078_0_04 mix_q_c078_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_05 (mix_i_src_c078_0_05 0 bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_0_05 (mix_i_src_c078_0_05 mix_i_c078_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_05 (mix_q_src_c078_0_05 0 bpf_c078_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_0_05 (mix_q_src_c078_0_05 mix_q_c078_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_06 (mix_i_src_c078_0_06 0 bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_0_06 (mix_i_src_c078_0_06 mix_i_c078_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_06 (mix_q_src_c078_0_06 0 bpf_c078_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_0_06 (mix_q_src_c078_0_06 mix_q_c078_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_07 (mix_i_src_c078_0_07 0 bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_0_07 (mix_i_src_c078_0_07 mix_i_c078_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_07 (mix_q_src_c078_0_07 0 bpf_c078_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_0_07 (mix_q_src_c078_0_07 mix_q_c078_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_08 (mix_i_src_c078_0_08 0 bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_0_08 (mix_i_src_c078_0_08 mix_i_c078_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_08 (mix_q_src_c078_0_08 0 bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_0_08 (mix_q_src_c078_0_08 mix_q_c078_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_09 (mix_i_src_c078_0_09 0 bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_0_09 (mix_i_src_c078_0_09 mix_i_c078_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_09 (mix_q_src_c078_0_09 0 bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_0_09 (mix_q_src_c078_0_09 mix_q_c078_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_10 (mix_i_src_c078_0_10 0 bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_0_10 (mix_i_src_c078_0_10 mix_i_c078_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_10 (mix_q_src_c078_0_10 0 bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_0_10 (mix_q_src_c078_0_10 mix_q_c078_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_11 (mix_i_src_c078_0_11 0 bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_0_11 (mix_i_src_c078_0_11 mix_i_c078_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_11 (mix_q_src_c078_0_11 0 bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_0_11 (mix_q_src_c078_0_11 mix_q_c078_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_12 (mix_i_src_c078_0_12 0 bpf_c078_0 0) vcvs gain=1.950903220161e-01
SMIXI_c078_0_12 (mix_i_src_c078_0_12 mix_i_c078_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_12 (mix_q_src_c078_0_12 0 bpf_c078_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_0_12 (mix_q_src_c078_0_12 mix_q_c078_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_13 (mix_i_src_c078_0_13 0 bpf_c078_0 0) vcvs gain=5.555702330196e-01
SMIXI_c078_0_13 (mix_i_src_c078_0_13 mix_i_c078_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_13 (mix_q_src_c078_0_13 0 bpf_c078_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_0_13 (mix_q_src_c078_0_13 mix_q_c078_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_14 (mix_i_src_c078_0_14 0 bpf_c078_0 0) vcvs gain=8.314696123025e-01
SMIXI_c078_0_14 (mix_i_src_c078_0_14 mix_i_c078_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_14 (mix_q_src_c078_0_14 0 bpf_c078_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_0_14 (mix_q_src_c078_0_14 mix_q_c078_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_0_15 (mix_i_src_c078_0_15 0 bpf_c078_0 0) vcvs gain=9.807852804032e-01
SMIXI_c078_0_15 (mix_i_src_c078_0_15 mix_i_c078_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_0_15 (mix_q_src_c078_0_15 0 bpf_c078_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_0_15 (mix_q_src_c078_0_15 mix_q_c078_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c078_0 (mix_i_c078_0 0) resistor r=1G
RMIXQ_c078_0 (mix_q_c078_0 0) resistor r=1G
RINTI_c078_0 (mix_i_c078_0 Icar_c078_0) resistor r=1k
CINTI_c078_0 (Icar_c078_0 0) capacitor c=80p
RINTQ_c078_0 (mix_q_c078_0 Qcar_c078_0) resistor r=1k
CINTQ_c078_0 (Qcar_c078_0 0) capacitor c=80p

// bl078, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c078_1 (bl078 n_cbpf_c078_1) capacitor c=1.013211836423e-13
LBPF_c078_1 (n_cbpf_c078_1 bpf_c078_1) inductor l=1.000000000000e-06
RBPF_c078_1 (bpf_c078_1 0) resistor r=1.570796326795e+02
EMIXI_c078_1_00 (mix_i_src_c078_1_00 0 bpf_c078_1 0) vcvs gain=9.807852804032e-01
SMIXI_c078_1_00 (mix_i_src_c078_1_00 mix_i_c078_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_00 (mix_q_src_c078_1_00 0 bpf_c078_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_1_00 (mix_q_src_c078_1_00 mix_q_c078_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_01 (mix_i_src_c078_1_01 0 bpf_c078_1 0) vcvs gain=8.314696123025e-01
SMIXI_c078_1_01 (mix_i_src_c078_1_01 mix_i_c078_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_01 (mix_q_src_c078_1_01 0 bpf_c078_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_1_01 (mix_q_src_c078_1_01 mix_q_c078_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_02 (mix_i_src_c078_1_02 0 bpf_c078_1 0) vcvs gain=5.555702330196e-01
SMIXI_c078_1_02 (mix_i_src_c078_1_02 mix_i_c078_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_02 (mix_q_src_c078_1_02 0 bpf_c078_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_1_02 (mix_q_src_c078_1_02 mix_q_c078_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_03 (mix_i_src_c078_1_03 0 bpf_c078_1 0) vcvs gain=1.950903220161e-01
SMIXI_c078_1_03 (mix_i_src_c078_1_03 mix_i_c078_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_03 (mix_q_src_c078_1_03 0 bpf_c078_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_1_03 (mix_q_src_c078_1_03 mix_q_c078_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_04 (mix_i_src_c078_1_04 0 bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_1_04 (mix_i_src_c078_1_04 mix_i_c078_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_04 (mix_q_src_c078_1_04 0 bpf_c078_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_1_04 (mix_q_src_c078_1_04 mix_q_c078_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_05 (mix_i_src_c078_1_05 0 bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_1_05 (mix_i_src_c078_1_05 mix_i_c078_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_05 (mix_q_src_c078_1_05 0 bpf_c078_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_1_05 (mix_q_src_c078_1_05 mix_q_c078_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_06 (mix_i_src_c078_1_06 0 bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_1_06 (mix_i_src_c078_1_06 mix_i_c078_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_06 (mix_q_src_c078_1_06 0 bpf_c078_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_1_06 (mix_q_src_c078_1_06 mix_q_c078_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_07 (mix_i_src_c078_1_07 0 bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_1_07 (mix_i_src_c078_1_07 mix_i_c078_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_07 (mix_q_src_c078_1_07 0 bpf_c078_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_1_07 (mix_q_src_c078_1_07 mix_q_c078_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_08 (mix_i_src_c078_1_08 0 bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_1_08 (mix_i_src_c078_1_08 mix_i_c078_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_08 (mix_q_src_c078_1_08 0 bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_1_08 (mix_q_src_c078_1_08 mix_q_c078_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_09 (mix_i_src_c078_1_09 0 bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_1_09 (mix_i_src_c078_1_09 mix_i_c078_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_09 (mix_q_src_c078_1_09 0 bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_1_09 (mix_q_src_c078_1_09 mix_q_c078_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_10 (mix_i_src_c078_1_10 0 bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_1_10 (mix_i_src_c078_1_10 mix_i_c078_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_10 (mix_q_src_c078_1_10 0 bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_1_10 (mix_q_src_c078_1_10 mix_q_c078_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_11 (mix_i_src_c078_1_11 0 bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_1_11 (mix_i_src_c078_1_11 mix_i_c078_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_11 (mix_q_src_c078_1_11 0 bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_1_11 (mix_q_src_c078_1_11 mix_q_c078_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_12 (mix_i_src_c078_1_12 0 bpf_c078_1 0) vcvs gain=1.950903220161e-01
SMIXI_c078_1_12 (mix_i_src_c078_1_12 mix_i_c078_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_12 (mix_q_src_c078_1_12 0 bpf_c078_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_1_12 (mix_q_src_c078_1_12 mix_q_c078_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_13 (mix_i_src_c078_1_13 0 bpf_c078_1 0) vcvs gain=5.555702330196e-01
SMIXI_c078_1_13 (mix_i_src_c078_1_13 mix_i_c078_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_13 (mix_q_src_c078_1_13 0 bpf_c078_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_1_13 (mix_q_src_c078_1_13 mix_q_c078_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_14 (mix_i_src_c078_1_14 0 bpf_c078_1 0) vcvs gain=8.314696123025e-01
SMIXI_c078_1_14 (mix_i_src_c078_1_14 mix_i_c078_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_14 (mix_q_src_c078_1_14 0 bpf_c078_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_1_14 (mix_q_src_c078_1_14 mix_q_c078_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_1_15 (mix_i_src_c078_1_15 0 bpf_c078_1 0) vcvs gain=9.807852804032e-01
SMIXI_c078_1_15 (mix_i_src_c078_1_15 mix_i_c078_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_1_15 (mix_q_src_c078_1_15 0 bpf_c078_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_1_15 (mix_q_src_c078_1_15 mix_q_c078_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c078_1 (mix_i_c078_1 0) resistor r=1G
RMIXQ_c078_1 (mix_q_c078_1 0) resistor r=1G
RINTI_c078_1 (mix_i_c078_1 Icar_c078_1) resistor r=1k
CINTI_c078_1 (Icar_c078_1 0) capacitor c=80p
RINTQ_c078_1 (mix_q_c078_1 Qcar_c078_1) resistor r=1k
CINTQ_c078_1 (Qcar_c078_1 0) capacitor c=80p

// bl078, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c078_2 (bl078 n_cbpf_c078_2) capacitor c=4.503163717437e-14
LBPF_c078_2 (n_cbpf_c078_2 bpf_c078_2) inductor l=1.000000000000e-06
RBPF_c078_2 (bpf_c078_2 0) resistor r=2.356194490192e+02
EMIXI_c078_2_00 (mix_i_src_c078_2_00 0 bpf_c078_2 0) vcvs gain=9.807852804032e-01
SMIXI_c078_2_00 (mix_i_src_c078_2_00 mix_i_c078_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_00 (mix_q_src_c078_2_00 0 bpf_c078_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_2_00 (mix_q_src_c078_2_00 mix_q_c078_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_01 (mix_i_src_c078_2_01 0 bpf_c078_2 0) vcvs gain=8.314696123025e-01
SMIXI_c078_2_01 (mix_i_src_c078_2_01 mix_i_c078_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_01 (mix_q_src_c078_2_01 0 bpf_c078_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_2_01 (mix_q_src_c078_2_01 mix_q_c078_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_02 (mix_i_src_c078_2_02 0 bpf_c078_2 0) vcvs gain=5.555702330196e-01
SMIXI_c078_2_02 (mix_i_src_c078_2_02 mix_i_c078_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_02 (mix_q_src_c078_2_02 0 bpf_c078_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_2_02 (mix_q_src_c078_2_02 mix_q_c078_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_03 (mix_i_src_c078_2_03 0 bpf_c078_2 0) vcvs gain=1.950903220161e-01
SMIXI_c078_2_03 (mix_i_src_c078_2_03 mix_i_c078_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_03 (mix_q_src_c078_2_03 0 bpf_c078_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_2_03 (mix_q_src_c078_2_03 mix_q_c078_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_04 (mix_i_src_c078_2_04 0 bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_2_04 (mix_i_src_c078_2_04 mix_i_c078_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_04 (mix_q_src_c078_2_04 0 bpf_c078_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_2_04 (mix_q_src_c078_2_04 mix_q_c078_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_05 (mix_i_src_c078_2_05 0 bpf_c078_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_2_05 (mix_i_src_c078_2_05 mix_i_c078_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_05 (mix_q_src_c078_2_05 0 bpf_c078_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_2_05 (mix_q_src_c078_2_05 mix_q_c078_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_06 (mix_i_src_c078_2_06 0 bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_2_06 (mix_i_src_c078_2_06 mix_i_c078_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_06 (mix_q_src_c078_2_06 0 bpf_c078_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_2_06 (mix_q_src_c078_2_06 mix_q_c078_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_07 (mix_i_src_c078_2_07 0 bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_2_07 (mix_i_src_c078_2_07 mix_i_c078_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_07 (mix_q_src_c078_2_07 0 bpf_c078_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_2_07 (mix_q_src_c078_2_07 mix_q_c078_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_08 (mix_i_src_c078_2_08 0 bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_2_08 (mix_i_src_c078_2_08 mix_i_c078_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_08 (mix_q_src_c078_2_08 0 bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_2_08 (mix_q_src_c078_2_08 mix_q_c078_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_09 (mix_i_src_c078_2_09 0 bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_2_09 (mix_i_src_c078_2_09 mix_i_c078_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_09 (mix_q_src_c078_2_09 0 bpf_c078_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_2_09 (mix_q_src_c078_2_09 mix_q_c078_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_10 (mix_i_src_c078_2_10 0 bpf_c078_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_2_10 (mix_i_src_c078_2_10 mix_i_c078_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_10 (mix_q_src_c078_2_10 0 bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_2_10 (mix_q_src_c078_2_10 mix_q_c078_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_11 (mix_i_src_c078_2_11 0 bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_2_11 (mix_i_src_c078_2_11 mix_i_c078_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_11 (mix_q_src_c078_2_11 0 bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_2_11 (mix_q_src_c078_2_11 mix_q_c078_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_12 (mix_i_src_c078_2_12 0 bpf_c078_2 0) vcvs gain=1.950903220161e-01
SMIXI_c078_2_12 (mix_i_src_c078_2_12 mix_i_c078_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_12 (mix_q_src_c078_2_12 0 bpf_c078_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_2_12 (mix_q_src_c078_2_12 mix_q_c078_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_13 (mix_i_src_c078_2_13 0 bpf_c078_2 0) vcvs gain=5.555702330196e-01
SMIXI_c078_2_13 (mix_i_src_c078_2_13 mix_i_c078_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_13 (mix_q_src_c078_2_13 0 bpf_c078_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_2_13 (mix_q_src_c078_2_13 mix_q_c078_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_14 (mix_i_src_c078_2_14 0 bpf_c078_2 0) vcvs gain=8.314696123025e-01
SMIXI_c078_2_14 (mix_i_src_c078_2_14 mix_i_c078_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_14 (mix_q_src_c078_2_14 0 bpf_c078_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_2_14 (mix_q_src_c078_2_14 mix_q_c078_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_2_15 (mix_i_src_c078_2_15 0 bpf_c078_2 0) vcvs gain=9.807852804032e-01
SMIXI_c078_2_15 (mix_i_src_c078_2_15 mix_i_c078_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_2_15 (mix_q_src_c078_2_15 0 bpf_c078_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_2_15 (mix_q_src_c078_2_15 mix_q_c078_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c078_2 (mix_i_c078_2 0) resistor r=1G
RMIXQ_c078_2 (mix_q_c078_2 0) resistor r=1G
RINTI_c078_2 (mix_i_c078_2 Icar_c078_2) resistor r=1k
CINTI_c078_2 (Icar_c078_2 0) capacitor c=80p
RINTQ_c078_2 (mix_q_c078_2 Qcar_c078_2) resistor r=1k
CINTQ_c078_2 (Qcar_c078_2 0) capacitor c=80p

// bl078, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c078_3 (bl078 n_cbpf_c078_3) capacitor c=2.533029591058e-14
LBPF_c078_3 (n_cbpf_c078_3 bpf_c078_3) inductor l=1.000000000000e-06
RBPF_c078_3 (bpf_c078_3 0) resistor r=3.141592653590e+02
EMIXI_c078_3_00 (mix_i_src_c078_3_00 0 bpf_c078_3 0) vcvs gain=9.807852804032e-01
SMIXI_c078_3_00 (mix_i_src_c078_3_00 mix_i_c078_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_00 (mix_q_src_c078_3_00 0 bpf_c078_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_3_00 (mix_q_src_c078_3_00 mix_q_c078_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_01 (mix_i_src_c078_3_01 0 bpf_c078_3 0) vcvs gain=8.314696123025e-01
SMIXI_c078_3_01 (mix_i_src_c078_3_01 mix_i_c078_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_01 (mix_q_src_c078_3_01 0 bpf_c078_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_3_01 (mix_q_src_c078_3_01 mix_q_c078_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_02 (mix_i_src_c078_3_02 0 bpf_c078_3 0) vcvs gain=5.555702330196e-01
SMIXI_c078_3_02 (mix_i_src_c078_3_02 mix_i_c078_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_02 (mix_q_src_c078_3_02 0 bpf_c078_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_3_02 (mix_q_src_c078_3_02 mix_q_c078_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_03 (mix_i_src_c078_3_03 0 bpf_c078_3 0) vcvs gain=1.950903220161e-01
SMIXI_c078_3_03 (mix_i_src_c078_3_03 mix_i_c078_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_03 (mix_q_src_c078_3_03 0 bpf_c078_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_3_03 (mix_q_src_c078_3_03 mix_q_c078_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_04 (mix_i_src_c078_3_04 0 bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_3_04 (mix_i_src_c078_3_04 mix_i_c078_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_04 (mix_q_src_c078_3_04 0 bpf_c078_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c078_3_04 (mix_q_src_c078_3_04 mix_q_c078_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_05 (mix_i_src_c078_3_05 0 bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_3_05 (mix_i_src_c078_3_05 mix_i_c078_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_05 (mix_q_src_c078_3_05 0 bpf_c078_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c078_3_05 (mix_q_src_c078_3_05 mix_q_c078_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_06 (mix_i_src_c078_3_06 0 bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_3_06 (mix_i_src_c078_3_06 mix_i_c078_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_06 (mix_q_src_c078_3_06 0 bpf_c078_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c078_3_06 (mix_q_src_c078_3_06 mix_q_c078_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_07 (mix_i_src_c078_3_07 0 bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_3_07 (mix_i_src_c078_3_07 mix_i_c078_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_07 (mix_q_src_c078_3_07 0 bpf_c078_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c078_3_07 (mix_q_src_c078_3_07 mix_q_c078_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_08 (mix_i_src_c078_3_08 0 bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c078_3_08 (mix_i_src_c078_3_08 mix_i_c078_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_08 (mix_q_src_c078_3_08 0 bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_3_08 (mix_q_src_c078_3_08 mix_q_c078_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_09 (mix_i_src_c078_3_09 0 bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c078_3_09 (mix_i_src_c078_3_09 mix_i_c078_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_09 (mix_q_src_c078_3_09 0 bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_3_09 (mix_q_src_c078_3_09 mix_q_c078_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_10 (mix_i_src_c078_3_10 0 bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c078_3_10 (mix_i_src_c078_3_10 mix_i_c078_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_10 (mix_q_src_c078_3_10 0 bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_3_10 (mix_q_src_c078_3_10 mix_q_c078_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_11 (mix_i_src_c078_3_11 0 bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c078_3_11 (mix_i_src_c078_3_11 mix_i_c078_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_11 (mix_q_src_c078_3_11 0 bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_3_11 (mix_q_src_c078_3_11 mix_q_c078_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_12 (mix_i_src_c078_3_12 0 bpf_c078_3 0) vcvs gain=1.950903220161e-01
SMIXI_c078_3_12 (mix_i_src_c078_3_12 mix_i_c078_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_12 (mix_q_src_c078_3_12 0 bpf_c078_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c078_3_12 (mix_q_src_c078_3_12 mix_q_c078_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_13 (mix_i_src_c078_3_13 0 bpf_c078_3 0) vcvs gain=5.555702330196e-01
SMIXI_c078_3_13 (mix_i_src_c078_3_13 mix_i_c078_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_13 (mix_q_src_c078_3_13 0 bpf_c078_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c078_3_13 (mix_q_src_c078_3_13 mix_q_c078_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_14 (mix_i_src_c078_3_14 0 bpf_c078_3 0) vcvs gain=8.314696123025e-01
SMIXI_c078_3_14 (mix_i_src_c078_3_14 mix_i_c078_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_14 (mix_q_src_c078_3_14 0 bpf_c078_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c078_3_14 (mix_q_src_c078_3_14 mix_q_c078_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c078_3_15 (mix_i_src_c078_3_15 0 bpf_c078_3 0) vcvs gain=9.807852804032e-01
SMIXI_c078_3_15 (mix_i_src_c078_3_15 mix_i_c078_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c078_3_15 (mix_q_src_c078_3_15 0 bpf_c078_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c078_3_15 (mix_q_src_c078_3_15 mix_q_c078_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c078_3 (mix_i_c078_3 0) resistor r=1G
RMIXQ_c078_3 (mix_q_c078_3 0) resistor r=1G
RINTI_c078_3 (mix_i_c078_3 Icar_c078_3) resistor r=1k
CINTI_c078_3 (Icar_c078_3 0) capacitor c=80p
RINTQ_c078_3 (mix_q_c078_3 Qcar_c078_3) resistor r=1k
CINTQ_c078_3 (Qcar_c078_3 0) capacitor c=80p

// bl079, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c079_0 (bl079 n_cbpf_c079_0) capacitor c=4.052847345694e-13
LBPF_c079_0 (n_cbpf_c079_0 bpf_c079_0) inductor l=1.000000000000e-06
RBPF_c079_0 (bpf_c079_0 0) resistor r=7.853981633974e+01
EMIXI_c079_0_00 (mix_i_src_c079_0_00 0 bpf_c079_0 0) vcvs gain=9.807852804032e-01
SMIXI_c079_0_00 (mix_i_src_c079_0_00 mix_i_c079_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_00 (mix_q_src_c079_0_00 0 bpf_c079_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_0_00 (mix_q_src_c079_0_00 mix_q_c079_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_01 (mix_i_src_c079_0_01 0 bpf_c079_0 0) vcvs gain=8.314696123025e-01
SMIXI_c079_0_01 (mix_i_src_c079_0_01 mix_i_c079_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_01 (mix_q_src_c079_0_01 0 bpf_c079_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_0_01 (mix_q_src_c079_0_01 mix_q_c079_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_02 (mix_i_src_c079_0_02 0 bpf_c079_0 0) vcvs gain=5.555702330196e-01
SMIXI_c079_0_02 (mix_i_src_c079_0_02 mix_i_c079_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_02 (mix_q_src_c079_0_02 0 bpf_c079_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_0_02 (mix_q_src_c079_0_02 mix_q_c079_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_03 (mix_i_src_c079_0_03 0 bpf_c079_0 0) vcvs gain=1.950903220161e-01
SMIXI_c079_0_03 (mix_i_src_c079_0_03 mix_i_c079_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_03 (mix_q_src_c079_0_03 0 bpf_c079_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_0_03 (mix_q_src_c079_0_03 mix_q_c079_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_04 (mix_i_src_c079_0_04 0 bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_0_04 (mix_i_src_c079_0_04 mix_i_c079_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_04 (mix_q_src_c079_0_04 0 bpf_c079_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_0_04 (mix_q_src_c079_0_04 mix_q_c079_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_05 (mix_i_src_c079_0_05 0 bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_0_05 (mix_i_src_c079_0_05 mix_i_c079_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_05 (mix_q_src_c079_0_05 0 bpf_c079_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_0_05 (mix_q_src_c079_0_05 mix_q_c079_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_06 (mix_i_src_c079_0_06 0 bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_0_06 (mix_i_src_c079_0_06 mix_i_c079_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_06 (mix_q_src_c079_0_06 0 bpf_c079_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_0_06 (mix_q_src_c079_0_06 mix_q_c079_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_07 (mix_i_src_c079_0_07 0 bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_0_07 (mix_i_src_c079_0_07 mix_i_c079_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_07 (mix_q_src_c079_0_07 0 bpf_c079_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_0_07 (mix_q_src_c079_0_07 mix_q_c079_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_08 (mix_i_src_c079_0_08 0 bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_0_08 (mix_i_src_c079_0_08 mix_i_c079_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_08 (mix_q_src_c079_0_08 0 bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_0_08 (mix_q_src_c079_0_08 mix_q_c079_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_09 (mix_i_src_c079_0_09 0 bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_0_09 (mix_i_src_c079_0_09 mix_i_c079_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_09 (mix_q_src_c079_0_09 0 bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_0_09 (mix_q_src_c079_0_09 mix_q_c079_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_10 (mix_i_src_c079_0_10 0 bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_0_10 (mix_i_src_c079_0_10 mix_i_c079_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_10 (mix_q_src_c079_0_10 0 bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_0_10 (mix_q_src_c079_0_10 mix_q_c079_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_11 (mix_i_src_c079_0_11 0 bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_0_11 (mix_i_src_c079_0_11 mix_i_c079_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_11 (mix_q_src_c079_0_11 0 bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_0_11 (mix_q_src_c079_0_11 mix_q_c079_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_12 (mix_i_src_c079_0_12 0 bpf_c079_0 0) vcvs gain=1.950903220161e-01
SMIXI_c079_0_12 (mix_i_src_c079_0_12 mix_i_c079_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_12 (mix_q_src_c079_0_12 0 bpf_c079_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_0_12 (mix_q_src_c079_0_12 mix_q_c079_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_13 (mix_i_src_c079_0_13 0 bpf_c079_0 0) vcvs gain=5.555702330196e-01
SMIXI_c079_0_13 (mix_i_src_c079_0_13 mix_i_c079_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_13 (mix_q_src_c079_0_13 0 bpf_c079_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_0_13 (mix_q_src_c079_0_13 mix_q_c079_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_14 (mix_i_src_c079_0_14 0 bpf_c079_0 0) vcvs gain=8.314696123025e-01
SMIXI_c079_0_14 (mix_i_src_c079_0_14 mix_i_c079_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_14 (mix_q_src_c079_0_14 0 bpf_c079_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_0_14 (mix_q_src_c079_0_14 mix_q_c079_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_0_15 (mix_i_src_c079_0_15 0 bpf_c079_0 0) vcvs gain=9.807852804032e-01
SMIXI_c079_0_15 (mix_i_src_c079_0_15 mix_i_c079_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_0_15 (mix_q_src_c079_0_15 0 bpf_c079_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_0_15 (mix_q_src_c079_0_15 mix_q_c079_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c079_0 (mix_i_c079_0 0) resistor r=1G
RMIXQ_c079_0 (mix_q_c079_0 0) resistor r=1G
RINTI_c079_0 (mix_i_c079_0 Icar_c079_0) resistor r=1k
CINTI_c079_0 (Icar_c079_0 0) capacitor c=80p
RINTQ_c079_0 (mix_q_c079_0 Qcar_c079_0) resistor r=1k
CINTQ_c079_0 (Qcar_c079_0 0) capacitor c=80p

// bl079, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c079_1 (bl079 n_cbpf_c079_1) capacitor c=1.013211836423e-13
LBPF_c079_1 (n_cbpf_c079_1 bpf_c079_1) inductor l=1.000000000000e-06
RBPF_c079_1 (bpf_c079_1 0) resistor r=1.570796326795e+02
EMIXI_c079_1_00 (mix_i_src_c079_1_00 0 bpf_c079_1 0) vcvs gain=9.807852804032e-01
SMIXI_c079_1_00 (mix_i_src_c079_1_00 mix_i_c079_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_00 (mix_q_src_c079_1_00 0 bpf_c079_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_1_00 (mix_q_src_c079_1_00 mix_q_c079_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_01 (mix_i_src_c079_1_01 0 bpf_c079_1 0) vcvs gain=8.314696123025e-01
SMIXI_c079_1_01 (mix_i_src_c079_1_01 mix_i_c079_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_01 (mix_q_src_c079_1_01 0 bpf_c079_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_1_01 (mix_q_src_c079_1_01 mix_q_c079_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_02 (mix_i_src_c079_1_02 0 bpf_c079_1 0) vcvs gain=5.555702330196e-01
SMIXI_c079_1_02 (mix_i_src_c079_1_02 mix_i_c079_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_02 (mix_q_src_c079_1_02 0 bpf_c079_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_1_02 (mix_q_src_c079_1_02 mix_q_c079_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_03 (mix_i_src_c079_1_03 0 bpf_c079_1 0) vcvs gain=1.950903220161e-01
SMIXI_c079_1_03 (mix_i_src_c079_1_03 mix_i_c079_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_03 (mix_q_src_c079_1_03 0 bpf_c079_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_1_03 (mix_q_src_c079_1_03 mix_q_c079_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_04 (mix_i_src_c079_1_04 0 bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_1_04 (mix_i_src_c079_1_04 mix_i_c079_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_04 (mix_q_src_c079_1_04 0 bpf_c079_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_1_04 (mix_q_src_c079_1_04 mix_q_c079_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_05 (mix_i_src_c079_1_05 0 bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_1_05 (mix_i_src_c079_1_05 mix_i_c079_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_05 (mix_q_src_c079_1_05 0 bpf_c079_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_1_05 (mix_q_src_c079_1_05 mix_q_c079_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_06 (mix_i_src_c079_1_06 0 bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_1_06 (mix_i_src_c079_1_06 mix_i_c079_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_06 (mix_q_src_c079_1_06 0 bpf_c079_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_1_06 (mix_q_src_c079_1_06 mix_q_c079_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_07 (mix_i_src_c079_1_07 0 bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_1_07 (mix_i_src_c079_1_07 mix_i_c079_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_07 (mix_q_src_c079_1_07 0 bpf_c079_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_1_07 (mix_q_src_c079_1_07 mix_q_c079_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_08 (mix_i_src_c079_1_08 0 bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_1_08 (mix_i_src_c079_1_08 mix_i_c079_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_08 (mix_q_src_c079_1_08 0 bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_1_08 (mix_q_src_c079_1_08 mix_q_c079_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_09 (mix_i_src_c079_1_09 0 bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_1_09 (mix_i_src_c079_1_09 mix_i_c079_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_09 (mix_q_src_c079_1_09 0 bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_1_09 (mix_q_src_c079_1_09 mix_q_c079_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_10 (mix_i_src_c079_1_10 0 bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_1_10 (mix_i_src_c079_1_10 mix_i_c079_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_10 (mix_q_src_c079_1_10 0 bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_1_10 (mix_q_src_c079_1_10 mix_q_c079_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_11 (mix_i_src_c079_1_11 0 bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_1_11 (mix_i_src_c079_1_11 mix_i_c079_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_11 (mix_q_src_c079_1_11 0 bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_1_11 (mix_q_src_c079_1_11 mix_q_c079_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_12 (mix_i_src_c079_1_12 0 bpf_c079_1 0) vcvs gain=1.950903220161e-01
SMIXI_c079_1_12 (mix_i_src_c079_1_12 mix_i_c079_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_12 (mix_q_src_c079_1_12 0 bpf_c079_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_1_12 (mix_q_src_c079_1_12 mix_q_c079_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_13 (mix_i_src_c079_1_13 0 bpf_c079_1 0) vcvs gain=5.555702330196e-01
SMIXI_c079_1_13 (mix_i_src_c079_1_13 mix_i_c079_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_13 (mix_q_src_c079_1_13 0 bpf_c079_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_1_13 (mix_q_src_c079_1_13 mix_q_c079_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_14 (mix_i_src_c079_1_14 0 bpf_c079_1 0) vcvs gain=8.314696123025e-01
SMIXI_c079_1_14 (mix_i_src_c079_1_14 mix_i_c079_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_14 (mix_q_src_c079_1_14 0 bpf_c079_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_1_14 (mix_q_src_c079_1_14 mix_q_c079_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_1_15 (mix_i_src_c079_1_15 0 bpf_c079_1 0) vcvs gain=9.807852804032e-01
SMIXI_c079_1_15 (mix_i_src_c079_1_15 mix_i_c079_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_1_15 (mix_q_src_c079_1_15 0 bpf_c079_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_1_15 (mix_q_src_c079_1_15 mix_q_c079_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c079_1 (mix_i_c079_1 0) resistor r=1G
RMIXQ_c079_1 (mix_q_c079_1 0) resistor r=1G
RINTI_c079_1 (mix_i_c079_1 Icar_c079_1) resistor r=1k
CINTI_c079_1 (Icar_c079_1 0) capacitor c=80p
RINTQ_c079_1 (mix_q_c079_1 Qcar_c079_1) resistor r=1k
CINTQ_c079_1 (Qcar_c079_1 0) capacitor c=80p

// bl079, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c079_2 (bl079 n_cbpf_c079_2) capacitor c=4.503163717437e-14
LBPF_c079_2 (n_cbpf_c079_2 bpf_c079_2) inductor l=1.000000000000e-06
RBPF_c079_2 (bpf_c079_2 0) resistor r=2.356194490192e+02
EMIXI_c079_2_00 (mix_i_src_c079_2_00 0 bpf_c079_2 0) vcvs gain=9.807852804032e-01
SMIXI_c079_2_00 (mix_i_src_c079_2_00 mix_i_c079_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_00 (mix_q_src_c079_2_00 0 bpf_c079_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_2_00 (mix_q_src_c079_2_00 mix_q_c079_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_01 (mix_i_src_c079_2_01 0 bpf_c079_2 0) vcvs gain=8.314696123025e-01
SMIXI_c079_2_01 (mix_i_src_c079_2_01 mix_i_c079_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_01 (mix_q_src_c079_2_01 0 bpf_c079_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_2_01 (mix_q_src_c079_2_01 mix_q_c079_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_02 (mix_i_src_c079_2_02 0 bpf_c079_2 0) vcvs gain=5.555702330196e-01
SMIXI_c079_2_02 (mix_i_src_c079_2_02 mix_i_c079_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_02 (mix_q_src_c079_2_02 0 bpf_c079_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_2_02 (mix_q_src_c079_2_02 mix_q_c079_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_03 (mix_i_src_c079_2_03 0 bpf_c079_2 0) vcvs gain=1.950903220161e-01
SMIXI_c079_2_03 (mix_i_src_c079_2_03 mix_i_c079_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_03 (mix_q_src_c079_2_03 0 bpf_c079_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_2_03 (mix_q_src_c079_2_03 mix_q_c079_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_04 (mix_i_src_c079_2_04 0 bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_2_04 (mix_i_src_c079_2_04 mix_i_c079_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_04 (mix_q_src_c079_2_04 0 bpf_c079_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_2_04 (mix_q_src_c079_2_04 mix_q_c079_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_05 (mix_i_src_c079_2_05 0 bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_2_05 (mix_i_src_c079_2_05 mix_i_c079_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_05 (mix_q_src_c079_2_05 0 bpf_c079_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_2_05 (mix_q_src_c079_2_05 mix_q_c079_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_06 (mix_i_src_c079_2_06 0 bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_2_06 (mix_i_src_c079_2_06 mix_i_c079_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_06 (mix_q_src_c079_2_06 0 bpf_c079_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_2_06 (mix_q_src_c079_2_06 mix_q_c079_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_07 (mix_i_src_c079_2_07 0 bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_2_07 (mix_i_src_c079_2_07 mix_i_c079_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_07 (mix_q_src_c079_2_07 0 bpf_c079_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_2_07 (mix_q_src_c079_2_07 mix_q_c079_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_08 (mix_i_src_c079_2_08 0 bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_2_08 (mix_i_src_c079_2_08 mix_i_c079_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_08 (mix_q_src_c079_2_08 0 bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_2_08 (mix_q_src_c079_2_08 mix_q_c079_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_09 (mix_i_src_c079_2_09 0 bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_2_09 (mix_i_src_c079_2_09 mix_i_c079_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_09 (mix_q_src_c079_2_09 0 bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_2_09 (mix_q_src_c079_2_09 mix_q_c079_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_10 (mix_i_src_c079_2_10 0 bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_2_10 (mix_i_src_c079_2_10 mix_i_c079_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_10 (mix_q_src_c079_2_10 0 bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_2_10 (mix_q_src_c079_2_10 mix_q_c079_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_11 (mix_i_src_c079_2_11 0 bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_2_11 (mix_i_src_c079_2_11 mix_i_c079_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_11 (mix_q_src_c079_2_11 0 bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_2_11 (mix_q_src_c079_2_11 mix_q_c079_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_12 (mix_i_src_c079_2_12 0 bpf_c079_2 0) vcvs gain=1.950903220161e-01
SMIXI_c079_2_12 (mix_i_src_c079_2_12 mix_i_c079_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_12 (mix_q_src_c079_2_12 0 bpf_c079_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_2_12 (mix_q_src_c079_2_12 mix_q_c079_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_13 (mix_i_src_c079_2_13 0 bpf_c079_2 0) vcvs gain=5.555702330196e-01
SMIXI_c079_2_13 (mix_i_src_c079_2_13 mix_i_c079_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_13 (mix_q_src_c079_2_13 0 bpf_c079_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_2_13 (mix_q_src_c079_2_13 mix_q_c079_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_14 (mix_i_src_c079_2_14 0 bpf_c079_2 0) vcvs gain=8.314696123025e-01
SMIXI_c079_2_14 (mix_i_src_c079_2_14 mix_i_c079_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_14 (mix_q_src_c079_2_14 0 bpf_c079_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_2_14 (mix_q_src_c079_2_14 mix_q_c079_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_2_15 (mix_i_src_c079_2_15 0 bpf_c079_2 0) vcvs gain=9.807852804032e-01
SMIXI_c079_2_15 (mix_i_src_c079_2_15 mix_i_c079_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_2_15 (mix_q_src_c079_2_15 0 bpf_c079_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_2_15 (mix_q_src_c079_2_15 mix_q_c079_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c079_2 (mix_i_c079_2 0) resistor r=1G
RMIXQ_c079_2 (mix_q_c079_2 0) resistor r=1G
RINTI_c079_2 (mix_i_c079_2 Icar_c079_2) resistor r=1k
CINTI_c079_2 (Icar_c079_2 0) capacitor c=80p
RINTQ_c079_2 (mix_q_c079_2 Qcar_c079_2) resistor r=1k
CINTQ_c079_2 (Qcar_c079_2 0) capacitor c=80p

// bl079, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c079_3 (bl079 n_cbpf_c079_3) capacitor c=2.533029591058e-14
LBPF_c079_3 (n_cbpf_c079_3 bpf_c079_3) inductor l=1.000000000000e-06
RBPF_c079_3 (bpf_c079_3 0) resistor r=3.141592653590e+02
EMIXI_c079_3_00 (mix_i_src_c079_3_00 0 bpf_c079_3 0) vcvs gain=9.807852804032e-01
SMIXI_c079_3_00 (mix_i_src_c079_3_00 mix_i_c079_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_00 (mix_q_src_c079_3_00 0 bpf_c079_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_3_00 (mix_q_src_c079_3_00 mix_q_c079_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_01 (mix_i_src_c079_3_01 0 bpf_c079_3 0) vcvs gain=8.314696123025e-01
SMIXI_c079_3_01 (mix_i_src_c079_3_01 mix_i_c079_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_01 (mix_q_src_c079_3_01 0 bpf_c079_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_3_01 (mix_q_src_c079_3_01 mix_q_c079_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_02 (mix_i_src_c079_3_02 0 bpf_c079_3 0) vcvs gain=5.555702330196e-01
SMIXI_c079_3_02 (mix_i_src_c079_3_02 mix_i_c079_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_02 (mix_q_src_c079_3_02 0 bpf_c079_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_3_02 (mix_q_src_c079_3_02 mix_q_c079_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_03 (mix_i_src_c079_3_03 0 bpf_c079_3 0) vcvs gain=1.950903220161e-01
SMIXI_c079_3_03 (mix_i_src_c079_3_03 mix_i_c079_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_03 (mix_q_src_c079_3_03 0 bpf_c079_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_3_03 (mix_q_src_c079_3_03 mix_q_c079_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_04 (mix_i_src_c079_3_04 0 bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_3_04 (mix_i_src_c079_3_04 mix_i_c079_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_04 (mix_q_src_c079_3_04 0 bpf_c079_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c079_3_04 (mix_q_src_c079_3_04 mix_q_c079_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_05 (mix_i_src_c079_3_05 0 bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_3_05 (mix_i_src_c079_3_05 mix_i_c079_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_05 (mix_q_src_c079_3_05 0 bpf_c079_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c079_3_05 (mix_q_src_c079_3_05 mix_q_c079_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_06 (mix_i_src_c079_3_06 0 bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_3_06 (mix_i_src_c079_3_06 mix_i_c079_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_06 (mix_q_src_c079_3_06 0 bpf_c079_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c079_3_06 (mix_q_src_c079_3_06 mix_q_c079_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_07 (mix_i_src_c079_3_07 0 bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_3_07 (mix_i_src_c079_3_07 mix_i_c079_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_07 (mix_q_src_c079_3_07 0 bpf_c079_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c079_3_07 (mix_q_src_c079_3_07 mix_q_c079_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_08 (mix_i_src_c079_3_08 0 bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c079_3_08 (mix_i_src_c079_3_08 mix_i_c079_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_08 (mix_q_src_c079_3_08 0 bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_3_08 (mix_q_src_c079_3_08 mix_q_c079_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_09 (mix_i_src_c079_3_09 0 bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c079_3_09 (mix_i_src_c079_3_09 mix_i_c079_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_09 (mix_q_src_c079_3_09 0 bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_3_09 (mix_q_src_c079_3_09 mix_q_c079_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_10 (mix_i_src_c079_3_10 0 bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c079_3_10 (mix_i_src_c079_3_10 mix_i_c079_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_10 (mix_q_src_c079_3_10 0 bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_3_10 (mix_q_src_c079_3_10 mix_q_c079_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_11 (mix_i_src_c079_3_11 0 bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c079_3_11 (mix_i_src_c079_3_11 mix_i_c079_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_11 (mix_q_src_c079_3_11 0 bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_3_11 (mix_q_src_c079_3_11 mix_q_c079_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_12 (mix_i_src_c079_3_12 0 bpf_c079_3 0) vcvs gain=1.950903220161e-01
SMIXI_c079_3_12 (mix_i_src_c079_3_12 mix_i_c079_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_12 (mix_q_src_c079_3_12 0 bpf_c079_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c079_3_12 (mix_q_src_c079_3_12 mix_q_c079_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_13 (mix_i_src_c079_3_13 0 bpf_c079_3 0) vcvs gain=5.555702330196e-01
SMIXI_c079_3_13 (mix_i_src_c079_3_13 mix_i_c079_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_13 (mix_q_src_c079_3_13 0 bpf_c079_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c079_3_13 (mix_q_src_c079_3_13 mix_q_c079_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_14 (mix_i_src_c079_3_14 0 bpf_c079_3 0) vcvs gain=8.314696123025e-01
SMIXI_c079_3_14 (mix_i_src_c079_3_14 mix_i_c079_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_14 (mix_q_src_c079_3_14 0 bpf_c079_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c079_3_14 (mix_q_src_c079_3_14 mix_q_c079_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c079_3_15 (mix_i_src_c079_3_15 0 bpf_c079_3 0) vcvs gain=9.807852804032e-01
SMIXI_c079_3_15 (mix_i_src_c079_3_15 mix_i_c079_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c079_3_15 (mix_q_src_c079_3_15 0 bpf_c079_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c079_3_15 (mix_q_src_c079_3_15 mix_q_c079_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c079_3 (mix_i_c079_3 0) resistor r=1G
RMIXQ_c079_3 (mix_q_c079_3 0) resistor r=1G
RINTI_c079_3 (mix_i_c079_3 Icar_c079_3) resistor r=1k
CINTI_c079_3 (Icar_c079_3 0) capacitor c=80p
RINTQ_c079_3 (mix_q_c079_3 Qcar_c079_3) resistor r=1k
CINTQ_c079_3 (Qcar_c079_3 0) capacitor c=80p

// bl080, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c080_0 (bl080 n_cbpf_c080_0) capacitor c=4.052847345694e-13
LBPF_c080_0 (n_cbpf_c080_0 bpf_c080_0) inductor l=1.000000000000e-06
RBPF_c080_0 (bpf_c080_0 0) resistor r=7.853981633974e+01
EMIXI_c080_0_00 (mix_i_src_c080_0_00 0 bpf_c080_0 0) vcvs gain=9.807852804032e-01
SMIXI_c080_0_00 (mix_i_src_c080_0_00 mix_i_c080_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_00 (mix_q_src_c080_0_00 0 bpf_c080_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_0_00 (mix_q_src_c080_0_00 mix_q_c080_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_01 (mix_i_src_c080_0_01 0 bpf_c080_0 0) vcvs gain=8.314696123025e-01
SMIXI_c080_0_01 (mix_i_src_c080_0_01 mix_i_c080_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_01 (mix_q_src_c080_0_01 0 bpf_c080_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_0_01 (mix_q_src_c080_0_01 mix_q_c080_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_02 (mix_i_src_c080_0_02 0 bpf_c080_0 0) vcvs gain=5.555702330196e-01
SMIXI_c080_0_02 (mix_i_src_c080_0_02 mix_i_c080_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_02 (mix_q_src_c080_0_02 0 bpf_c080_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_0_02 (mix_q_src_c080_0_02 mix_q_c080_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_03 (mix_i_src_c080_0_03 0 bpf_c080_0 0) vcvs gain=1.950903220161e-01
SMIXI_c080_0_03 (mix_i_src_c080_0_03 mix_i_c080_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_03 (mix_q_src_c080_0_03 0 bpf_c080_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_0_03 (mix_q_src_c080_0_03 mix_q_c080_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_04 (mix_i_src_c080_0_04 0 bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_0_04 (mix_i_src_c080_0_04 mix_i_c080_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_04 (mix_q_src_c080_0_04 0 bpf_c080_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_0_04 (mix_q_src_c080_0_04 mix_q_c080_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_05 (mix_i_src_c080_0_05 0 bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_0_05 (mix_i_src_c080_0_05 mix_i_c080_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_05 (mix_q_src_c080_0_05 0 bpf_c080_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_0_05 (mix_q_src_c080_0_05 mix_q_c080_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_06 (mix_i_src_c080_0_06 0 bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_0_06 (mix_i_src_c080_0_06 mix_i_c080_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_06 (mix_q_src_c080_0_06 0 bpf_c080_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_0_06 (mix_q_src_c080_0_06 mix_q_c080_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_07 (mix_i_src_c080_0_07 0 bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_0_07 (mix_i_src_c080_0_07 mix_i_c080_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_07 (mix_q_src_c080_0_07 0 bpf_c080_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_0_07 (mix_q_src_c080_0_07 mix_q_c080_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_08 (mix_i_src_c080_0_08 0 bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_0_08 (mix_i_src_c080_0_08 mix_i_c080_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_08 (mix_q_src_c080_0_08 0 bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_0_08 (mix_q_src_c080_0_08 mix_q_c080_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_09 (mix_i_src_c080_0_09 0 bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_0_09 (mix_i_src_c080_0_09 mix_i_c080_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_09 (mix_q_src_c080_0_09 0 bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_0_09 (mix_q_src_c080_0_09 mix_q_c080_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_10 (mix_i_src_c080_0_10 0 bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_0_10 (mix_i_src_c080_0_10 mix_i_c080_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_10 (mix_q_src_c080_0_10 0 bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_0_10 (mix_q_src_c080_0_10 mix_q_c080_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_11 (mix_i_src_c080_0_11 0 bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_0_11 (mix_i_src_c080_0_11 mix_i_c080_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_11 (mix_q_src_c080_0_11 0 bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_0_11 (mix_q_src_c080_0_11 mix_q_c080_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_12 (mix_i_src_c080_0_12 0 bpf_c080_0 0) vcvs gain=1.950903220161e-01
SMIXI_c080_0_12 (mix_i_src_c080_0_12 mix_i_c080_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_12 (mix_q_src_c080_0_12 0 bpf_c080_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_0_12 (mix_q_src_c080_0_12 mix_q_c080_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_13 (mix_i_src_c080_0_13 0 bpf_c080_0 0) vcvs gain=5.555702330196e-01
SMIXI_c080_0_13 (mix_i_src_c080_0_13 mix_i_c080_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_13 (mix_q_src_c080_0_13 0 bpf_c080_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_0_13 (mix_q_src_c080_0_13 mix_q_c080_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_14 (mix_i_src_c080_0_14 0 bpf_c080_0 0) vcvs gain=8.314696123025e-01
SMIXI_c080_0_14 (mix_i_src_c080_0_14 mix_i_c080_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_14 (mix_q_src_c080_0_14 0 bpf_c080_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_0_14 (mix_q_src_c080_0_14 mix_q_c080_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_0_15 (mix_i_src_c080_0_15 0 bpf_c080_0 0) vcvs gain=9.807852804032e-01
SMIXI_c080_0_15 (mix_i_src_c080_0_15 mix_i_c080_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_0_15 (mix_q_src_c080_0_15 0 bpf_c080_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_0_15 (mix_q_src_c080_0_15 mix_q_c080_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c080_0 (mix_i_c080_0 0) resistor r=1G
RMIXQ_c080_0 (mix_q_c080_0 0) resistor r=1G
RINTI_c080_0 (mix_i_c080_0 Icar_c080_0) resistor r=1k
CINTI_c080_0 (Icar_c080_0 0) capacitor c=80p
RINTQ_c080_0 (mix_q_c080_0 Qcar_c080_0) resistor r=1k
CINTQ_c080_0 (Qcar_c080_0 0) capacitor c=80p

// bl080, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c080_1 (bl080 n_cbpf_c080_1) capacitor c=1.013211836423e-13
LBPF_c080_1 (n_cbpf_c080_1 bpf_c080_1) inductor l=1.000000000000e-06
RBPF_c080_1 (bpf_c080_1 0) resistor r=1.570796326795e+02
EMIXI_c080_1_00 (mix_i_src_c080_1_00 0 bpf_c080_1 0) vcvs gain=9.807852804032e-01
SMIXI_c080_1_00 (mix_i_src_c080_1_00 mix_i_c080_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_00 (mix_q_src_c080_1_00 0 bpf_c080_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_1_00 (mix_q_src_c080_1_00 mix_q_c080_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_01 (mix_i_src_c080_1_01 0 bpf_c080_1 0) vcvs gain=8.314696123025e-01
SMIXI_c080_1_01 (mix_i_src_c080_1_01 mix_i_c080_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_01 (mix_q_src_c080_1_01 0 bpf_c080_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_1_01 (mix_q_src_c080_1_01 mix_q_c080_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_02 (mix_i_src_c080_1_02 0 bpf_c080_1 0) vcvs gain=5.555702330196e-01
SMIXI_c080_1_02 (mix_i_src_c080_1_02 mix_i_c080_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_02 (mix_q_src_c080_1_02 0 bpf_c080_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_1_02 (mix_q_src_c080_1_02 mix_q_c080_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_03 (mix_i_src_c080_1_03 0 bpf_c080_1 0) vcvs gain=1.950903220161e-01
SMIXI_c080_1_03 (mix_i_src_c080_1_03 mix_i_c080_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_03 (mix_q_src_c080_1_03 0 bpf_c080_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_1_03 (mix_q_src_c080_1_03 mix_q_c080_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_04 (mix_i_src_c080_1_04 0 bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_1_04 (mix_i_src_c080_1_04 mix_i_c080_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_04 (mix_q_src_c080_1_04 0 bpf_c080_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_1_04 (mix_q_src_c080_1_04 mix_q_c080_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_05 (mix_i_src_c080_1_05 0 bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_1_05 (mix_i_src_c080_1_05 mix_i_c080_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_05 (mix_q_src_c080_1_05 0 bpf_c080_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_1_05 (mix_q_src_c080_1_05 mix_q_c080_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_06 (mix_i_src_c080_1_06 0 bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_1_06 (mix_i_src_c080_1_06 mix_i_c080_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_06 (mix_q_src_c080_1_06 0 bpf_c080_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_1_06 (mix_q_src_c080_1_06 mix_q_c080_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_07 (mix_i_src_c080_1_07 0 bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_1_07 (mix_i_src_c080_1_07 mix_i_c080_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_07 (mix_q_src_c080_1_07 0 bpf_c080_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_1_07 (mix_q_src_c080_1_07 mix_q_c080_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_08 (mix_i_src_c080_1_08 0 bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_1_08 (mix_i_src_c080_1_08 mix_i_c080_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_08 (mix_q_src_c080_1_08 0 bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_1_08 (mix_q_src_c080_1_08 mix_q_c080_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_09 (mix_i_src_c080_1_09 0 bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_1_09 (mix_i_src_c080_1_09 mix_i_c080_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_09 (mix_q_src_c080_1_09 0 bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_1_09 (mix_q_src_c080_1_09 mix_q_c080_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_10 (mix_i_src_c080_1_10 0 bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_1_10 (mix_i_src_c080_1_10 mix_i_c080_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_10 (mix_q_src_c080_1_10 0 bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_1_10 (mix_q_src_c080_1_10 mix_q_c080_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_11 (mix_i_src_c080_1_11 0 bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_1_11 (mix_i_src_c080_1_11 mix_i_c080_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_11 (mix_q_src_c080_1_11 0 bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_1_11 (mix_q_src_c080_1_11 mix_q_c080_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_12 (mix_i_src_c080_1_12 0 bpf_c080_1 0) vcvs gain=1.950903220161e-01
SMIXI_c080_1_12 (mix_i_src_c080_1_12 mix_i_c080_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_12 (mix_q_src_c080_1_12 0 bpf_c080_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_1_12 (mix_q_src_c080_1_12 mix_q_c080_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_13 (mix_i_src_c080_1_13 0 bpf_c080_1 0) vcvs gain=5.555702330196e-01
SMIXI_c080_1_13 (mix_i_src_c080_1_13 mix_i_c080_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_13 (mix_q_src_c080_1_13 0 bpf_c080_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_1_13 (mix_q_src_c080_1_13 mix_q_c080_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_14 (mix_i_src_c080_1_14 0 bpf_c080_1 0) vcvs gain=8.314696123025e-01
SMIXI_c080_1_14 (mix_i_src_c080_1_14 mix_i_c080_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_14 (mix_q_src_c080_1_14 0 bpf_c080_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_1_14 (mix_q_src_c080_1_14 mix_q_c080_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_1_15 (mix_i_src_c080_1_15 0 bpf_c080_1 0) vcvs gain=9.807852804032e-01
SMIXI_c080_1_15 (mix_i_src_c080_1_15 mix_i_c080_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_1_15 (mix_q_src_c080_1_15 0 bpf_c080_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_1_15 (mix_q_src_c080_1_15 mix_q_c080_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c080_1 (mix_i_c080_1 0) resistor r=1G
RMIXQ_c080_1 (mix_q_c080_1 0) resistor r=1G
RINTI_c080_1 (mix_i_c080_1 Icar_c080_1) resistor r=1k
CINTI_c080_1 (Icar_c080_1 0) capacitor c=80p
RINTQ_c080_1 (mix_q_c080_1 Qcar_c080_1) resistor r=1k
CINTQ_c080_1 (Qcar_c080_1 0) capacitor c=80p

// bl080, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c080_2 (bl080 n_cbpf_c080_2) capacitor c=4.503163717437e-14
LBPF_c080_2 (n_cbpf_c080_2 bpf_c080_2) inductor l=1.000000000000e-06
RBPF_c080_2 (bpf_c080_2 0) resistor r=2.356194490192e+02
EMIXI_c080_2_00 (mix_i_src_c080_2_00 0 bpf_c080_2 0) vcvs gain=9.807852804032e-01
SMIXI_c080_2_00 (mix_i_src_c080_2_00 mix_i_c080_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_00 (mix_q_src_c080_2_00 0 bpf_c080_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_2_00 (mix_q_src_c080_2_00 mix_q_c080_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_01 (mix_i_src_c080_2_01 0 bpf_c080_2 0) vcvs gain=8.314696123025e-01
SMIXI_c080_2_01 (mix_i_src_c080_2_01 mix_i_c080_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_01 (mix_q_src_c080_2_01 0 bpf_c080_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_2_01 (mix_q_src_c080_2_01 mix_q_c080_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_02 (mix_i_src_c080_2_02 0 bpf_c080_2 0) vcvs gain=5.555702330196e-01
SMIXI_c080_2_02 (mix_i_src_c080_2_02 mix_i_c080_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_02 (mix_q_src_c080_2_02 0 bpf_c080_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_2_02 (mix_q_src_c080_2_02 mix_q_c080_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_03 (mix_i_src_c080_2_03 0 bpf_c080_2 0) vcvs gain=1.950903220161e-01
SMIXI_c080_2_03 (mix_i_src_c080_2_03 mix_i_c080_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_03 (mix_q_src_c080_2_03 0 bpf_c080_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_2_03 (mix_q_src_c080_2_03 mix_q_c080_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_04 (mix_i_src_c080_2_04 0 bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_2_04 (mix_i_src_c080_2_04 mix_i_c080_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_04 (mix_q_src_c080_2_04 0 bpf_c080_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_2_04 (mix_q_src_c080_2_04 mix_q_c080_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_05 (mix_i_src_c080_2_05 0 bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_2_05 (mix_i_src_c080_2_05 mix_i_c080_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_05 (mix_q_src_c080_2_05 0 bpf_c080_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_2_05 (mix_q_src_c080_2_05 mix_q_c080_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_06 (mix_i_src_c080_2_06 0 bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_2_06 (mix_i_src_c080_2_06 mix_i_c080_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_06 (mix_q_src_c080_2_06 0 bpf_c080_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_2_06 (mix_q_src_c080_2_06 mix_q_c080_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_07 (mix_i_src_c080_2_07 0 bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_2_07 (mix_i_src_c080_2_07 mix_i_c080_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_07 (mix_q_src_c080_2_07 0 bpf_c080_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_2_07 (mix_q_src_c080_2_07 mix_q_c080_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_08 (mix_i_src_c080_2_08 0 bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_2_08 (mix_i_src_c080_2_08 mix_i_c080_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_08 (mix_q_src_c080_2_08 0 bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_2_08 (mix_q_src_c080_2_08 mix_q_c080_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_09 (mix_i_src_c080_2_09 0 bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_2_09 (mix_i_src_c080_2_09 mix_i_c080_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_09 (mix_q_src_c080_2_09 0 bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_2_09 (mix_q_src_c080_2_09 mix_q_c080_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_10 (mix_i_src_c080_2_10 0 bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_2_10 (mix_i_src_c080_2_10 mix_i_c080_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_10 (mix_q_src_c080_2_10 0 bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_2_10 (mix_q_src_c080_2_10 mix_q_c080_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_11 (mix_i_src_c080_2_11 0 bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_2_11 (mix_i_src_c080_2_11 mix_i_c080_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_11 (mix_q_src_c080_2_11 0 bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_2_11 (mix_q_src_c080_2_11 mix_q_c080_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_12 (mix_i_src_c080_2_12 0 bpf_c080_2 0) vcvs gain=1.950903220161e-01
SMIXI_c080_2_12 (mix_i_src_c080_2_12 mix_i_c080_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_12 (mix_q_src_c080_2_12 0 bpf_c080_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_2_12 (mix_q_src_c080_2_12 mix_q_c080_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_13 (mix_i_src_c080_2_13 0 bpf_c080_2 0) vcvs gain=5.555702330196e-01
SMIXI_c080_2_13 (mix_i_src_c080_2_13 mix_i_c080_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_13 (mix_q_src_c080_2_13 0 bpf_c080_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_2_13 (mix_q_src_c080_2_13 mix_q_c080_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_14 (mix_i_src_c080_2_14 0 bpf_c080_2 0) vcvs gain=8.314696123025e-01
SMIXI_c080_2_14 (mix_i_src_c080_2_14 mix_i_c080_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_14 (mix_q_src_c080_2_14 0 bpf_c080_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_2_14 (mix_q_src_c080_2_14 mix_q_c080_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_2_15 (mix_i_src_c080_2_15 0 bpf_c080_2 0) vcvs gain=9.807852804032e-01
SMIXI_c080_2_15 (mix_i_src_c080_2_15 mix_i_c080_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_2_15 (mix_q_src_c080_2_15 0 bpf_c080_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_2_15 (mix_q_src_c080_2_15 mix_q_c080_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c080_2 (mix_i_c080_2 0) resistor r=1G
RMIXQ_c080_2 (mix_q_c080_2 0) resistor r=1G
RINTI_c080_2 (mix_i_c080_2 Icar_c080_2) resistor r=1k
CINTI_c080_2 (Icar_c080_2 0) capacitor c=80p
RINTQ_c080_2 (mix_q_c080_2 Qcar_c080_2) resistor r=1k
CINTQ_c080_2 (Qcar_c080_2 0) capacitor c=80p

// bl080, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c080_3 (bl080 n_cbpf_c080_3) capacitor c=2.533029591058e-14
LBPF_c080_3 (n_cbpf_c080_3 bpf_c080_3) inductor l=1.000000000000e-06
RBPF_c080_3 (bpf_c080_3 0) resistor r=3.141592653590e+02
EMIXI_c080_3_00 (mix_i_src_c080_3_00 0 bpf_c080_3 0) vcvs gain=9.807852804032e-01
SMIXI_c080_3_00 (mix_i_src_c080_3_00 mix_i_c080_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_00 (mix_q_src_c080_3_00 0 bpf_c080_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_3_00 (mix_q_src_c080_3_00 mix_q_c080_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_01 (mix_i_src_c080_3_01 0 bpf_c080_3 0) vcvs gain=8.314696123025e-01
SMIXI_c080_3_01 (mix_i_src_c080_3_01 mix_i_c080_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_01 (mix_q_src_c080_3_01 0 bpf_c080_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_3_01 (mix_q_src_c080_3_01 mix_q_c080_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_02 (mix_i_src_c080_3_02 0 bpf_c080_3 0) vcvs gain=5.555702330196e-01
SMIXI_c080_3_02 (mix_i_src_c080_3_02 mix_i_c080_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_02 (mix_q_src_c080_3_02 0 bpf_c080_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_3_02 (mix_q_src_c080_3_02 mix_q_c080_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_03 (mix_i_src_c080_3_03 0 bpf_c080_3 0) vcvs gain=1.950903220161e-01
SMIXI_c080_3_03 (mix_i_src_c080_3_03 mix_i_c080_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_03 (mix_q_src_c080_3_03 0 bpf_c080_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_3_03 (mix_q_src_c080_3_03 mix_q_c080_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_04 (mix_i_src_c080_3_04 0 bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_3_04 (mix_i_src_c080_3_04 mix_i_c080_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_04 (mix_q_src_c080_3_04 0 bpf_c080_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c080_3_04 (mix_q_src_c080_3_04 mix_q_c080_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_05 (mix_i_src_c080_3_05 0 bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_3_05 (mix_i_src_c080_3_05 mix_i_c080_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_05 (mix_q_src_c080_3_05 0 bpf_c080_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c080_3_05 (mix_q_src_c080_3_05 mix_q_c080_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_06 (mix_i_src_c080_3_06 0 bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_3_06 (mix_i_src_c080_3_06 mix_i_c080_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_06 (mix_q_src_c080_3_06 0 bpf_c080_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c080_3_06 (mix_q_src_c080_3_06 mix_q_c080_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_07 (mix_i_src_c080_3_07 0 bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_3_07 (mix_i_src_c080_3_07 mix_i_c080_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_07 (mix_q_src_c080_3_07 0 bpf_c080_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c080_3_07 (mix_q_src_c080_3_07 mix_q_c080_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_08 (mix_i_src_c080_3_08 0 bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c080_3_08 (mix_i_src_c080_3_08 mix_i_c080_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_08 (mix_q_src_c080_3_08 0 bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_3_08 (mix_q_src_c080_3_08 mix_q_c080_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_09 (mix_i_src_c080_3_09 0 bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c080_3_09 (mix_i_src_c080_3_09 mix_i_c080_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_09 (mix_q_src_c080_3_09 0 bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_3_09 (mix_q_src_c080_3_09 mix_q_c080_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_10 (mix_i_src_c080_3_10 0 bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c080_3_10 (mix_i_src_c080_3_10 mix_i_c080_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_10 (mix_q_src_c080_3_10 0 bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_3_10 (mix_q_src_c080_3_10 mix_q_c080_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_11 (mix_i_src_c080_3_11 0 bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c080_3_11 (mix_i_src_c080_3_11 mix_i_c080_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_11 (mix_q_src_c080_3_11 0 bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_3_11 (mix_q_src_c080_3_11 mix_q_c080_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_12 (mix_i_src_c080_3_12 0 bpf_c080_3 0) vcvs gain=1.950903220161e-01
SMIXI_c080_3_12 (mix_i_src_c080_3_12 mix_i_c080_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_12 (mix_q_src_c080_3_12 0 bpf_c080_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c080_3_12 (mix_q_src_c080_3_12 mix_q_c080_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_13 (mix_i_src_c080_3_13 0 bpf_c080_3 0) vcvs gain=5.555702330196e-01
SMIXI_c080_3_13 (mix_i_src_c080_3_13 mix_i_c080_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_13 (mix_q_src_c080_3_13 0 bpf_c080_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c080_3_13 (mix_q_src_c080_3_13 mix_q_c080_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_14 (mix_i_src_c080_3_14 0 bpf_c080_3 0) vcvs gain=8.314696123025e-01
SMIXI_c080_3_14 (mix_i_src_c080_3_14 mix_i_c080_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_14 (mix_q_src_c080_3_14 0 bpf_c080_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c080_3_14 (mix_q_src_c080_3_14 mix_q_c080_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c080_3_15 (mix_i_src_c080_3_15 0 bpf_c080_3 0) vcvs gain=9.807852804032e-01
SMIXI_c080_3_15 (mix_i_src_c080_3_15 mix_i_c080_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c080_3_15 (mix_q_src_c080_3_15 0 bpf_c080_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c080_3_15 (mix_q_src_c080_3_15 mix_q_c080_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c080_3 (mix_i_c080_3 0) resistor r=1G
RMIXQ_c080_3 (mix_q_c080_3 0) resistor r=1G
RINTI_c080_3 (mix_i_c080_3 Icar_c080_3) resistor r=1k
CINTI_c080_3 (Icar_c080_3 0) capacitor c=80p
RINTQ_c080_3 (mix_q_c080_3 Qcar_c080_3) resistor r=1k
CINTQ_c080_3 (Qcar_c080_3 0) capacitor c=80p

// bl081, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c081_0 (bl081 n_cbpf_c081_0) capacitor c=4.052847345694e-13
LBPF_c081_0 (n_cbpf_c081_0 bpf_c081_0) inductor l=1.000000000000e-06
RBPF_c081_0 (bpf_c081_0 0) resistor r=7.853981633974e+01
EMIXI_c081_0_00 (mix_i_src_c081_0_00 0 bpf_c081_0 0) vcvs gain=9.807852804032e-01
SMIXI_c081_0_00 (mix_i_src_c081_0_00 mix_i_c081_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_00 (mix_q_src_c081_0_00 0 bpf_c081_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_0_00 (mix_q_src_c081_0_00 mix_q_c081_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_01 (mix_i_src_c081_0_01 0 bpf_c081_0 0) vcvs gain=8.314696123025e-01
SMIXI_c081_0_01 (mix_i_src_c081_0_01 mix_i_c081_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_01 (mix_q_src_c081_0_01 0 bpf_c081_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_0_01 (mix_q_src_c081_0_01 mix_q_c081_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_02 (mix_i_src_c081_0_02 0 bpf_c081_0 0) vcvs gain=5.555702330196e-01
SMIXI_c081_0_02 (mix_i_src_c081_0_02 mix_i_c081_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_02 (mix_q_src_c081_0_02 0 bpf_c081_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_0_02 (mix_q_src_c081_0_02 mix_q_c081_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_03 (mix_i_src_c081_0_03 0 bpf_c081_0 0) vcvs gain=1.950903220161e-01
SMIXI_c081_0_03 (mix_i_src_c081_0_03 mix_i_c081_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_03 (mix_q_src_c081_0_03 0 bpf_c081_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_0_03 (mix_q_src_c081_0_03 mix_q_c081_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_04 (mix_i_src_c081_0_04 0 bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_0_04 (mix_i_src_c081_0_04 mix_i_c081_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_04 (mix_q_src_c081_0_04 0 bpf_c081_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_0_04 (mix_q_src_c081_0_04 mix_q_c081_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_05 (mix_i_src_c081_0_05 0 bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_0_05 (mix_i_src_c081_0_05 mix_i_c081_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_05 (mix_q_src_c081_0_05 0 bpf_c081_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_0_05 (mix_q_src_c081_0_05 mix_q_c081_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_06 (mix_i_src_c081_0_06 0 bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_0_06 (mix_i_src_c081_0_06 mix_i_c081_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_06 (mix_q_src_c081_0_06 0 bpf_c081_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_0_06 (mix_q_src_c081_0_06 mix_q_c081_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_07 (mix_i_src_c081_0_07 0 bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_0_07 (mix_i_src_c081_0_07 mix_i_c081_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_07 (mix_q_src_c081_0_07 0 bpf_c081_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_0_07 (mix_q_src_c081_0_07 mix_q_c081_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_08 (mix_i_src_c081_0_08 0 bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_0_08 (mix_i_src_c081_0_08 mix_i_c081_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_08 (mix_q_src_c081_0_08 0 bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_0_08 (mix_q_src_c081_0_08 mix_q_c081_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_09 (mix_i_src_c081_0_09 0 bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_0_09 (mix_i_src_c081_0_09 mix_i_c081_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_09 (mix_q_src_c081_0_09 0 bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_0_09 (mix_q_src_c081_0_09 mix_q_c081_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_10 (mix_i_src_c081_0_10 0 bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_0_10 (mix_i_src_c081_0_10 mix_i_c081_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_10 (mix_q_src_c081_0_10 0 bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_0_10 (mix_q_src_c081_0_10 mix_q_c081_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_11 (mix_i_src_c081_0_11 0 bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_0_11 (mix_i_src_c081_0_11 mix_i_c081_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_11 (mix_q_src_c081_0_11 0 bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_0_11 (mix_q_src_c081_0_11 mix_q_c081_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_12 (mix_i_src_c081_0_12 0 bpf_c081_0 0) vcvs gain=1.950903220161e-01
SMIXI_c081_0_12 (mix_i_src_c081_0_12 mix_i_c081_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_12 (mix_q_src_c081_0_12 0 bpf_c081_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_0_12 (mix_q_src_c081_0_12 mix_q_c081_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_13 (mix_i_src_c081_0_13 0 bpf_c081_0 0) vcvs gain=5.555702330196e-01
SMIXI_c081_0_13 (mix_i_src_c081_0_13 mix_i_c081_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_13 (mix_q_src_c081_0_13 0 bpf_c081_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_0_13 (mix_q_src_c081_0_13 mix_q_c081_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_14 (mix_i_src_c081_0_14 0 bpf_c081_0 0) vcvs gain=8.314696123025e-01
SMIXI_c081_0_14 (mix_i_src_c081_0_14 mix_i_c081_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_14 (mix_q_src_c081_0_14 0 bpf_c081_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_0_14 (mix_q_src_c081_0_14 mix_q_c081_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_0_15 (mix_i_src_c081_0_15 0 bpf_c081_0 0) vcvs gain=9.807852804032e-01
SMIXI_c081_0_15 (mix_i_src_c081_0_15 mix_i_c081_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_0_15 (mix_q_src_c081_0_15 0 bpf_c081_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_0_15 (mix_q_src_c081_0_15 mix_q_c081_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c081_0 (mix_i_c081_0 0) resistor r=1G
RMIXQ_c081_0 (mix_q_c081_0 0) resistor r=1G
RINTI_c081_0 (mix_i_c081_0 Icar_c081_0) resistor r=1k
CINTI_c081_0 (Icar_c081_0 0) capacitor c=80p
RINTQ_c081_0 (mix_q_c081_0 Qcar_c081_0) resistor r=1k
CINTQ_c081_0 (Qcar_c081_0 0) capacitor c=80p

// bl081, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c081_1 (bl081 n_cbpf_c081_1) capacitor c=1.013211836423e-13
LBPF_c081_1 (n_cbpf_c081_1 bpf_c081_1) inductor l=1.000000000000e-06
RBPF_c081_1 (bpf_c081_1 0) resistor r=1.570796326795e+02
EMIXI_c081_1_00 (mix_i_src_c081_1_00 0 bpf_c081_1 0) vcvs gain=9.807852804032e-01
SMIXI_c081_1_00 (mix_i_src_c081_1_00 mix_i_c081_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_00 (mix_q_src_c081_1_00 0 bpf_c081_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_1_00 (mix_q_src_c081_1_00 mix_q_c081_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_01 (mix_i_src_c081_1_01 0 bpf_c081_1 0) vcvs gain=8.314696123025e-01
SMIXI_c081_1_01 (mix_i_src_c081_1_01 mix_i_c081_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_01 (mix_q_src_c081_1_01 0 bpf_c081_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_1_01 (mix_q_src_c081_1_01 mix_q_c081_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_02 (mix_i_src_c081_1_02 0 bpf_c081_1 0) vcvs gain=5.555702330196e-01
SMIXI_c081_1_02 (mix_i_src_c081_1_02 mix_i_c081_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_02 (mix_q_src_c081_1_02 0 bpf_c081_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_1_02 (mix_q_src_c081_1_02 mix_q_c081_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_03 (mix_i_src_c081_1_03 0 bpf_c081_1 0) vcvs gain=1.950903220161e-01
SMIXI_c081_1_03 (mix_i_src_c081_1_03 mix_i_c081_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_03 (mix_q_src_c081_1_03 0 bpf_c081_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_1_03 (mix_q_src_c081_1_03 mix_q_c081_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_04 (mix_i_src_c081_1_04 0 bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_1_04 (mix_i_src_c081_1_04 mix_i_c081_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_04 (mix_q_src_c081_1_04 0 bpf_c081_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_1_04 (mix_q_src_c081_1_04 mix_q_c081_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_05 (mix_i_src_c081_1_05 0 bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_1_05 (mix_i_src_c081_1_05 mix_i_c081_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_05 (mix_q_src_c081_1_05 0 bpf_c081_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_1_05 (mix_q_src_c081_1_05 mix_q_c081_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_06 (mix_i_src_c081_1_06 0 bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_1_06 (mix_i_src_c081_1_06 mix_i_c081_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_06 (mix_q_src_c081_1_06 0 bpf_c081_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_1_06 (mix_q_src_c081_1_06 mix_q_c081_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_07 (mix_i_src_c081_1_07 0 bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_1_07 (mix_i_src_c081_1_07 mix_i_c081_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_07 (mix_q_src_c081_1_07 0 bpf_c081_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_1_07 (mix_q_src_c081_1_07 mix_q_c081_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_08 (mix_i_src_c081_1_08 0 bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_1_08 (mix_i_src_c081_1_08 mix_i_c081_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_08 (mix_q_src_c081_1_08 0 bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_1_08 (mix_q_src_c081_1_08 mix_q_c081_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_09 (mix_i_src_c081_1_09 0 bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_1_09 (mix_i_src_c081_1_09 mix_i_c081_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_09 (mix_q_src_c081_1_09 0 bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_1_09 (mix_q_src_c081_1_09 mix_q_c081_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_10 (mix_i_src_c081_1_10 0 bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_1_10 (mix_i_src_c081_1_10 mix_i_c081_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_10 (mix_q_src_c081_1_10 0 bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_1_10 (mix_q_src_c081_1_10 mix_q_c081_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_11 (mix_i_src_c081_1_11 0 bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_1_11 (mix_i_src_c081_1_11 mix_i_c081_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_11 (mix_q_src_c081_1_11 0 bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_1_11 (mix_q_src_c081_1_11 mix_q_c081_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_12 (mix_i_src_c081_1_12 0 bpf_c081_1 0) vcvs gain=1.950903220161e-01
SMIXI_c081_1_12 (mix_i_src_c081_1_12 mix_i_c081_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_12 (mix_q_src_c081_1_12 0 bpf_c081_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_1_12 (mix_q_src_c081_1_12 mix_q_c081_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_13 (mix_i_src_c081_1_13 0 bpf_c081_1 0) vcvs gain=5.555702330196e-01
SMIXI_c081_1_13 (mix_i_src_c081_1_13 mix_i_c081_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_13 (mix_q_src_c081_1_13 0 bpf_c081_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_1_13 (mix_q_src_c081_1_13 mix_q_c081_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_14 (mix_i_src_c081_1_14 0 bpf_c081_1 0) vcvs gain=8.314696123025e-01
SMIXI_c081_1_14 (mix_i_src_c081_1_14 mix_i_c081_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_14 (mix_q_src_c081_1_14 0 bpf_c081_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_1_14 (mix_q_src_c081_1_14 mix_q_c081_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_1_15 (mix_i_src_c081_1_15 0 bpf_c081_1 0) vcvs gain=9.807852804032e-01
SMIXI_c081_1_15 (mix_i_src_c081_1_15 mix_i_c081_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_1_15 (mix_q_src_c081_1_15 0 bpf_c081_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_1_15 (mix_q_src_c081_1_15 mix_q_c081_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c081_1 (mix_i_c081_1 0) resistor r=1G
RMIXQ_c081_1 (mix_q_c081_1 0) resistor r=1G
RINTI_c081_1 (mix_i_c081_1 Icar_c081_1) resistor r=1k
CINTI_c081_1 (Icar_c081_1 0) capacitor c=80p
RINTQ_c081_1 (mix_q_c081_1 Qcar_c081_1) resistor r=1k
CINTQ_c081_1 (Qcar_c081_1 0) capacitor c=80p

// bl081, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c081_2 (bl081 n_cbpf_c081_2) capacitor c=4.503163717437e-14
LBPF_c081_2 (n_cbpf_c081_2 bpf_c081_2) inductor l=1.000000000000e-06
RBPF_c081_2 (bpf_c081_2 0) resistor r=2.356194490192e+02
EMIXI_c081_2_00 (mix_i_src_c081_2_00 0 bpf_c081_2 0) vcvs gain=9.807852804032e-01
SMIXI_c081_2_00 (mix_i_src_c081_2_00 mix_i_c081_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_00 (mix_q_src_c081_2_00 0 bpf_c081_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_2_00 (mix_q_src_c081_2_00 mix_q_c081_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_01 (mix_i_src_c081_2_01 0 bpf_c081_2 0) vcvs gain=8.314696123025e-01
SMIXI_c081_2_01 (mix_i_src_c081_2_01 mix_i_c081_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_01 (mix_q_src_c081_2_01 0 bpf_c081_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_2_01 (mix_q_src_c081_2_01 mix_q_c081_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_02 (mix_i_src_c081_2_02 0 bpf_c081_2 0) vcvs gain=5.555702330196e-01
SMIXI_c081_2_02 (mix_i_src_c081_2_02 mix_i_c081_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_02 (mix_q_src_c081_2_02 0 bpf_c081_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_2_02 (mix_q_src_c081_2_02 mix_q_c081_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_03 (mix_i_src_c081_2_03 0 bpf_c081_2 0) vcvs gain=1.950903220161e-01
SMIXI_c081_2_03 (mix_i_src_c081_2_03 mix_i_c081_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_03 (mix_q_src_c081_2_03 0 bpf_c081_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_2_03 (mix_q_src_c081_2_03 mix_q_c081_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_04 (mix_i_src_c081_2_04 0 bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_2_04 (mix_i_src_c081_2_04 mix_i_c081_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_04 (mix_q_src_c081_2_04 0 bpf_c081_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_2_04 (mix_q_src_c081_2_04 mix_q_c081_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_05 (mix_i_src_c081_2_05 0 bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_2_05 (mix_i_src_c081_2_05 mix_i_c081_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_05 (mix_q_src_c081_2_05 0 bpf_c081_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_2_05 (mix_q_src_c081_2_05 mix_q_c081_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_06 (mix_i_src_c081_2_06 0 bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_2_06 (mix_i_src_c081_2_06 mix_i_c081_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_06 (mix_q_src_c081_2_06 0 bpf_c081_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_2_06 (mix_q_src_c081_2_06 mix_q_c081_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_07 (mix_i_src_c081_2_07 0 bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_2_07 (mix_i_src_c081_2_07 mix_i_c081_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_07 (mix_q_src_c081_2_07 0 bpf_c081_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_2_07 (mix_q_src_c081_2_07 mix_q_c081_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_08 (mix_i_src_c081_2_08 0 bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_2_08 (mix_i_src_c081_2_08 mix_i_c081_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_08 (mix_q_src_c081_2_08 0 bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_2_08 (mix_q_src_c081_2_08 mix_q_c081_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_09 (mix_i_src_c081_2_09 0 bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_2_09 (mix_i_src_c081_2_09 mix_i_c081_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_09 (mix_q_src_c081_2_09 0 bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_2_09 (mix_q_src_c081_2_09 mix_q_c081_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_10 (mix_i_src_c081_2_10 0 bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_2_10 (mix_i_src_c081_2_10 mix_i_c081_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_10 (mix_q_src_c081_2_10 0 bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_2_10 (mix_q_src_c081_2_10 mix_q_c081_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_11 (mix_i_src_c081_2_11 0 bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_2_11 (mix_i_src_c081_2_11 mix_i_c081_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_11 (mix_q_src_c081_2_11 0 bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_2_11 (mix_q_src_c081_2_11 mix_q_c081_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_12 (mix_i_src_c081_2_12 0 bpf_c081_2 0) vcvs gain=1.950903220161e-01
SMIXI_c081_2_12 (mix_i_src_c081_2_12 mix_i_c081_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_12 (mix_q_src_c081_2_12 0 bpf_c081_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_2_12 (mix_q_src_c081_2_12 mix_q_c081_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_13 (mix_i_src_c081_2_13 0 bpf_c081_2 0) vcvs gain=5.555702330196e-01
SMIXI_c081_2_13 (mix_i_src_c081_2_13 mix_i_c081_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_13 (mix_q_src_c081_2_13 0 bpf_c081_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_2_13 (mix_q_src_c081_2_13 mix_q_c081_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_14 (mix_i_src_c081_2_14 0 bpf_c081_2 0) vcvs gain=8.314696123025e-01
SMIXI_c081_2_14 (mix_i_src_c081_2_14 mix_i_c081_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_14 (mix_q_src_c081_2_14 0 bpf_c081_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_2_14 (mix_q_src_c081_2_14 mix_q_c081_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_2_15 (mix_i_src_c081_2_15 0 bpf_c081_2 0) vcvs gain=9.807852804032e-01
SMIXI_c081_2_15 (mix_i_src_c081_2_15 mix_i_c081_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_2_15 (mix_q_src_c081_2_15 0 bpf_c081_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_2_15 (mix_q_src_c081_2_15 mix_q_c081_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c081_2 (mix_i_c081_2 0) resistor r=1G
RMIXQ_c081_2 (mix_q_c081_2 0) resistor r=1G
RINTI_c081_2 (mix_i_c081_2 Icar_c081_2) resistor r=1k
CINTI_c081_2 (Icar_c081_2 0) capacitor c=80p
RINTQ_c081_2 (mix_q_c081_2 Qcar_c081_2) resistor r=1k
CINTQ_c081_2 (Qcar_c081_2 0) capacitor c=80p

// bl081, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c081_3 (bl081 n_cbpf_c081_3) capacitor c=2.533029591058e-14
LBPF_c081_3 (n_cbpf_c081_3 bpf_c081_3) inductor l=1.000000000000e-06
RBPF_c081_3 (bpf_c081_3 0) resistor r=3.141592653590e+02
EMIXI_c081_3_00 (mix_i_src_c081_3_00 0 bpf_c081_3 0) vcvs gain=9.807852804032e-01
SMIXI_c081_3_00 (mix_i_src_c081_3_00 mix_i_c081_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_00 (mix_q_src_c081_3_00 0 bpf_c081_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_3_00 (mix_q_src_c081_3_00 mix_q_c081_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_01 (mix_i_src_c081_3_01 0 bpf_c081_3 0) vcvs gain=8.314696123025e-01
SMIXI_c081_3_01 (mix_i_src_c081_3_01 mix_i_c081_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_01 (mix_q_src_c081_3_01 0 bpf_c081_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_3_01 (mix_q_src_c081_3_01 mix_q_c081_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_02 (mix_i_src_c081_3_02 0 bpf_c081_3 0) vcvs gain=5.555702330196e-01
SMIXI_c081_3_02 (mix_i_src_c081_3_02 mix_i_c081_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_02 (mix_q_src_c081_3_02 0 bpf_c081_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_3_02 (mix_q_src_c081_3_02 mix_q_c081_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_03 (mix_i_src_c081_3_03 0 bpf_c081_3 0) vcvs gain=1.950903220161e-01
SMIXI_c081_3_03 (mix_i_src_c081_3_03 mix_i_c081_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_03 (mix_q_src_c081_3_03 0 bpf_c081_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_3_03 (mix_q_src_c081_3_03 mix_q_c081_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_04 (mix_i_src_c081_3_04 0 bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_3_04 (mix_i_src_c081_3_04 mix_i_c081_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_04 (mix_q_src_c081_3_04 0 bpf_c081_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c081_3_04 (mix_q_src_c081_3_04 mix_q_c081_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_05 (mix_i_src_c081_3_05 0 bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_3_05 (mix_i_src_c081_3_05 mix_i_c081_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_05 (mix_q_src_c081_3_05 0 bpf_c081_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c081_3_05 (mix_q_src_c081_3_05 mix_q_c081_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_06 (mix_i_src_c081_3_06 0 bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_3_06 (mix_i_src_c081_3_06 mix_i_c081_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_06 (mix_q_src_c081_3_06 0 bpf_c081_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c081_3_06 (mix_q_src_c081_3_06 mix_q_c081_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_07 (mix_i_src_c081_3_07 0 bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_3_07 (mix_i_src_c081_3_07 mix_i_c081_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_07 (mix_q_src_c081_3_07 0 bpf_c081_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c081_3_07 (mix_q_src_c081_3_07 mix_q_c081_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_08 (mix_i_src_c081_3_08 0 bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c081_3_08 (mix_i_src_c081_3_08 mix_i_c081_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_08 (mix_q_src_c081_3_08 0 bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_3_08 (mix_q_src_c081_3_08 mix_q_c081_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_09 (mix_i_src_c081_3_09 0 bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c081_3_09 (mix_i_src_c081_3_09 mix_i_c081_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_09 (mix_q_src_c081_3_09 0 bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_3_09 (mix_q_src_c081_3_09 mix_q_c081_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_10 (mix_i_src_c081_3_10 0 bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c081_3_10 (mix_i_src_c081_3_10 mix_i_c081_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_10 (mix_q_src_c081_3_10 0 bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_3_10 (mix_q_src_c081_3_10 mix_q_c081_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_11 (mix_i_src_c081_3_11 0 bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c081_3_11 (mix_i_src_c081_3_11 mix_i_c081_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_11 (mix_q_src_c081_3_11 0 bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_3_11 (mix_q_src_c081_3_11 mix_q_c081_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_12 (mix_i_src_c081_3_12 0 bpf_c081_3 0) vcvs gain=1.950903220161e-01
SMIXI_c081_3_12 (mix_i_src_c081_3_12 mix_i_c081_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_12 (mix_q_src_c081_3_12 0 bpf_c081_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c081_3_12 (mix_q_src_c081_3_12 mix_q_c081_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_13 (mix_i_src_c081_3_13 0 bpf_c081_3 0) vcvs gain=5.555702330196e-01
SMIXI_c081_3_13 (mix_i_src_c081_3_13 mix_i_c081_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_13 (mix_q_src_c081_3_13 0 bpf_c081_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c081_3_13 (mix_q_src_c081_3_13 mix_q_c081_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_14 (mix_i_src_c081_3_14 0 bpf_c081_3 0) vcvs gain=8.314696123025e-01
SMIXI_c081_3_14 (mix_i_src_c081_3_14 mix_i_c081_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_14 (mix_q_src_c081_3_14 0 bpf_c081_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c081_3_14 (mix_q_src_c081_3_14 mix_q_c081_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c081_3_15 (mix_i_src_c081_3_15 0 bpf_c081_3 0) vcvs gain=9.807852804032e-01
SMIXI_c081_3_15 (mix_i_src_c081_3_15 mix_i_c081_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c081_3_15 (mix_q_src_c081_3_15 0 bpf_c081_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c081_3_15 (mix_q_src_c081_3_15 mix_q_c081_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c081_3 (mix_i_c081_3 0) resistor r=1G
RMIXQ_c081_3 (mix_q_c081_3 0) resistor r=1G
RINTI_c081_3 (mix_i_c081_3 Icar_c081_3) resistor r=1k
CINTI_c081_3 (Icar_c081_3 0) capacitor c=80p
RINTQ_c081_3 (mix_q_c081_3 Qcar_c081_3) resistor r=1k
CINTQ_c081_3 (Qcar_c081_3 0) capacitor c=80p

// bl082, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c082_0 (bl082 n_cbpf_c082_0) capacitor c=4.052847345694e-13
LBPF_c082_0 (n_cbpf_c082_0 bpf_c082_0) inductor l=1.000000000000e-06
RBPF_c082_0 (bpf_c082_0 0) resistor r=7.853981633974e+01
EMIXI_c082_0_00 (mix_i_src_c082_0_00 0 bpf_c082_0 0) vcvs gain=9.807852804032e-01
SMIXI_c082_0_00 (mix_i_src_c082_0_00 mix_i_c082_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_00 (mix_q_src_c082_0_00 0 bpf_c082_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_0_00 (mix_q_src_c082_0_00 mix_q_c082_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_01 (mix_i_src_c082_0_01 0 bpf_c082_0 0) vcvs gain=8.314696123025e-01
SMIXI_c082_0_01 (mix_i_src_c082_0_01 mix_i_c082_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_01 (mix_q_src_c082_0_01 0 bpf_c082_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_0_01 (mix_q_src_c082_0_01 mix_q_c082_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_02 (mix_i_src_c082_0_02 0 bpf_c082_0 0) vcvs gain=5.555702330196e-01
SMIXI_c082_0_02 (mix_i_src_c082_0_02 mix_i_c082_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_02 (mix_q_src_c082_0_02 0 bpf_c082_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_0_02 (mix_q_src_c082_0_02 mix_q_c082_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_03 (mix_i_src_c082_0_03 0 bpf_c082_0 0) vcvs gain=1.950903220161e-01
SMIXI_c082_0_03 (mix_i_src_c082_0_03 mix_i_c082_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_03 (mix_q_src_c082_0_03 0 bpf_c082_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_0_03 (mix_q_src_c082_0_03 mix_q_c082_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_04 (mix_i_src_c082_0_04 0 bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_0_04 (mix_i_src_c082_0_04 mix_i_c082_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_04 (mix_q_src_c082_0_04 0 bpf_c082_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_0_04 (mix_q_src_c082_0_04 mix_q_c082_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_05 (mix_i_src_c082_0_05 0 bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_0_05 (mix_i_src_c082_0_05 mix_i_c082_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_05 (mix_q_src_c082_0_05 0 bpf_c082_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_0_05 (mix_q_src_c082_0_05 mix_q_c082_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_06 (mix_i_src_c082_0_06 0 bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_0_06 (mix_i_src_c082_0_06 mix_i_c082_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_06 (mix_q_src_c082_0_06 0 bpf_c082_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_0_06 (mix_q_src_c082_0_06 mix_q_c082_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_07 (mix_i_src_c082_0_07 0 bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_0_07 (mix_i_src_c082_0_07 mix_i_c082_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_07 (mix_q_src_c082_0_07 0 bpf_c082_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_0_07 (mix_q_src_c082_0_07 mix_q_c082_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_08 (mix_i_src_c082_0_08 0 bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_0_08 (mix_i_src_c082_0_08 mix_i_c082_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_08 (mix_q_src_c082_0_08 0 bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_0_08 (mix_q_src_c082_0_08 mix_q_c082_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_09 (mix_i_src_c082_0_09 0 bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_0_09 (mix_i_src_c082_0_09 mix_i_c082_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_09 (mix_q_src_c082_0_09 0 bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_0_09 (mix_q_src_c082_0_09 mix_q_c082_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_10 (mix_i_src_c082_0_10 0 bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_0_10 (mix_i_src_c082_0_10 mix_i_c082_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_10 (mix_q_src_c082_0_10 0 bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_0_10 (mix_q_src_c082_0_10 mix_q_c082_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_11 (mix_i_src_c082_0_11 0 bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_0_11 (mix_i_src_c082_0_11 mix_i_c082_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_11 (mix_q_src_c082_0_11 0 bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_0_11 (mix_q_src_c082_0_11 mix_q_c082_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_12 (mix_i_src_c082_0_12 0 bpf_c082_0 0) vcvs gain=1.950903220161e-01
SMIXI_c082_0_12 (mix_i_src_c082_0_12 mix_i_c082_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_12 (mix_q_src_c082_0_12 0 bpf_c082_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_0_12 (mix_q_src_c082_0_12 mix_q_c082_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_13 (mix_i_src_c082_0_13 0 bpf_c082_0 0) vcvs gain=5.555702330196e-01
SMIXI_c082_0_13 (mix_i_src_c082_0_13 mix_i_c082_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_13 (mix_q_src_c082_0_13 0 bpf_c082_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_0_13 (mix_q_src_c082_0_13 mix_q_c082_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_14 (mix_i_src_c082_0_14 0 bpf_c082_0 0) vcvs gain=8.314696123025e-01
SMIXI_c082_0_14 (mix_i_src_c082_0_14 mix_i_c082_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_14 (mix_q_src_c082_0_14 0 bpf_c082_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_0_14 (mix_q_src_c082_0_14 mix_q_c082_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_0_15 (mix_i_src_c082_0_15 0 bpf_c082_0 0) vcvs gain=9.807852804032e-01
SMIXI_c082_0_15 (mix_i_src_c082_0_15 mix_i_c082_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_0_15 (mix_q_src_c082_0_15 0 bpf_c082_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_0_15 (mix_q_src_c082_0_15 mix_q_c082_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c082_0 (mix_i_c082_0 0) resistor r=1G
RMIXQ_c082_0 (mix_q_c082_0 0) resistor r=1G
RINTI_c082_0 (mix_i_c082_0 Icar_c082_0) resistor r=1k
CINTI_c082_0 (Icar_c082_0 0) capacitor c=80p
RINTQ_c082_0 (mix_q_c082_0 Qcar_c082_0) resistor r=1k
CINTQ_c082_0 (Qcar_c082_0 0) capacitor c=80p

// bl082, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c082_1 (bl082 n_cbpf_c082_1) capacitor c=1.013211836423e-13
LBPF_c082_1 (n_cbpf_c082_1 bpf_c082_1) inductor l=1.000000000000e-06
RBPF_c082_1 (bpf_c082_1 0) resistor r=1.570796326795e+02
EMIXI_c082_1_00 (mix_i_src_c082_1_00 0 bpf_c082_1 0) vcvs gain=9.807852804032e-01
SMIXI_c082_1_00 (mix_i_src_c082_1_00 mix_i_c082_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_00 (mix_q_src_c082_1_00 0 bpf_c082_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_1_00 (mix_q_src_c082_1_00 mix_q_c082_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_01 (mix_i_src_c082_1_01 0 bpf_c082_1 0) vcvs gain=8.314696123025e-01
SMIXI_c082_1_01 (mix_i_src_c082_1_01 mix_i_c082_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_01 (mix_q_src_c082_1_01 0 bpf_c082_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_1_01 (mix_q_src_c082_1_01 mix_q_c082_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_02 (mix_i_src_c082_1_02 0 bpf_c082_1 0) vcvs gain=5.555702330196e-01
SMIXI_c082_1_02 (mix_i_src_c082_1_02 mix_i_c082_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_02 (mix_q_src_c082_1_02 0 bpf_c082_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_1_02 (mix_q_src_c082_1_02 mix_q_c082_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_03 (mix_i_src_c082_1_03 0 bpf_c082_1 0) vcvs gain=1.950903220161e-01
SMIXI_c082_1_03 (mix_i_src_c082_1_03 mix_i_c082_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_03 (mix_q_src_c082_1_03 0 bpf_c082_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_1_03 (mix_q_src_c082_1_03 mix_q_c082_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_04 (mix_i_src_c082_1_04 0 bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_1_04 (mix_i_src_c082_1_04 mix_i_c082_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_04 (mix_q_src_c082_1_04 0 bpf_c082_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_1_04 (mix_q_src_c082_1_04 mix_q_c082_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_05 (mix_i_src_c082_1_05 0 bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_1_05 (mix_i_src_c082_1_05 mix_i_c082_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_05 (mix_q_src_c082_1_05 0 bpf_c082_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_1_05 (mix_q_src_c082_1_05 mix_q_c082_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_06 (mix_i_src_c082_1_06 0 bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_1_06 (mix_i_src_c082_1_06 mix_i_c082_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_06 (mix_q_src_c082_1_06 0 bpf_c082_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_1_06 (mix_q_src_c082_1_06 mix_q_c082_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_07 (mix_i_src_c082_1_07 0 bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_1_07 (mix_i_src_c082_1_07 mix_i_c082_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_07 (mix_q_src_c082_1_07 0 bpf_c082_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_1_07 (mix_q_src_c082_1_07 mix_q_c082_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_08 (mix_i_src_c082_1_08 0 bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_1_08 (mix_i_src_c082_1_08 mix_i_c082_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_08 (mix_q_src_c082_1_08 0 bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_1_08 (mix_q_src_c082_1_08 mix_q_c082_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_09 (mix_i_src_c082_1_09 0 bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_1_09 (mix_i_src_c082_1_09 mix_i_c082_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_09 (mix_q_src_c082_1_09 0 bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_1_09 (mix_q_src_c082_1_09 mix_q_c082_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_10 (mix_i_src_c082_1_10 0 bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_1_10 (mix_i_src_c082_1_10 mix_i_c082_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_10 (mix_q_src_c082_1_10 0 bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_1_10 (mix_q_src_c082_1_10 mix_q_c082_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_11 (mix_i_src_c082_1_11 0 bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_1_11 (mix_i_src_c082_1_11 mix_i_c082_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_11 (mix_q_src_c082_1_11 0 bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_1_11 (mix_q_src_c082_1_11 mix_q_c082_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_12 (mix_i_src_c082_1_12 0 bpf_c082_1 0) vcvs gain=1.950903220161e-01
SMIXI_c082_1_12 (mix_i_src_c082_1_12 mix_i_c082_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_12 (mix_q_src_c082_1_12 0 bpf_c082_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_1_12 (mix_q_src_c082_1_12 mix_q_c082_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_13 (mix_i_src_c082_1_13 0 bpf_c082_1 0) vcvs gain=5.555702330196e-01
SMIXI_c082_1_13 (mix_i_src_c082_1_13 mix_i_c082_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_13 (mix_q_src_c082_1_13 0 bpf_c082_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_1_13 (mix_q_src_c082_1_13 mix_q_c082_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_14 (mix_i_src_c082_1_14 0 bpf_c082_1 0) vcvs gain=8.314696123025e-01
SMIXI_c082_1_14 (mix_i_src_c082_1_14 mix_i_c082_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_14 (mix_q_src_c082_1_14 0 bpf_c082_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_1_14 (mix_q_src_c082_1_14 mix_q_c082_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_1_15 (mix_i_src_c082_1_15 0 bpf_c082_1 0) vcvs gain=9.807852804032e-01
SMIXI_c082_1_15 (mix_i_src_c082_1_15 mix_i_c082_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_1_15 (mix_q_src_c082_1_15 0 bpf_c082_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_1_15 (mix_q_src_c082_1_15 mix_q_c082_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c082_1 (mix_i_c082_1 0) resistor r=1G
RMIXQ_c082_1 (mix_q_c082_1 0) resistor r=1G
RINTI_c082_1 (mix_i_c082_1 Icar_c082_1) resistor r=1k
CINTI_c082_1 (Icar_c082_1 0) capacitor c=80p
RINTQ_c082_1 (mix_q_c082_1 Qcar_c082_1) resistor r=1k
CINTQ_c082_1 (Qcar_c082_1 0) capacitor c=80p

// bl082, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c082_2 (bl082 n_cbpf_c082_2) capacitor c=4.503163717437e-14
LBPF_c082_2 (n_cbpf_c082_2 bpf_c082_2) inductor l=1.000000000000e-06
RBPF_c082_2 (bpf_c082_2 0) resistor r=2.356194490192e+02
EMIXI_c082_2_00 (mix_i_src_c082_2_00 0 bpf_c082_2 0) vcvs gain=9.807852804032e-01
SMIXI_c082_2_00 (mix_i_src_c082_2_00 mix_i_c082_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_00 (mix_q_src_c082_2_00 0 bpf_c082_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_2_00 (mix_q_src_c082_2_00 mix_q_c082_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_01 (mix_i_src_c082_2_01 0 bpf_c082_2 0) vcvs gain=8.314696123025e-01
SMIXI_c082_2_01 (mix_i_src_c082_2_01 mix_i_c082_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_01 (mix_q_src_c082_2_01 0 bpf_c082_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_2_01 (mix_q_src_c082_2_01 mix_q_c082_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_02 (mix_i_src_c082_2_02 0 bpf_c082_2 0) vcvs gain=5.555702330196e-01
SMIXI_c082_2_02 (mix_i_src_c082_2_02 mix_i_c082_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_02 (mix_q_src_c082_2_02 0 bpf_c082_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_2_02 (mix_q_src_c082_2_02 mix_q_c082_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_03 (mix_i_src_c082_2_03 0 bpf_c082_2 0) vcvs gain=1.950903220161e-01
SMIXI_c082_2_03 (mix_i_src_c082_2_03 mix_i_c082_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_03 (mix_q_src_c082_2_03 0 bpf_c082_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_2_03 (mix_q_src_c082_2_03 mix_q_c082_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_04 (mix_i_src_c082_2_04 0 bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_2_04 (mix_i_src_c082_2_04 mix_i_c082_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_04 (mix_q_src_c082_2_04 0 bpf_c082_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_2_04 (mix_q_src_c082_2_04 mix_q_c082_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_05 (mix_i_src_c082_2_05 0 bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_2_05 (mix_i_src_c082_2_05 mix_i_c082_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_05 (mix_q_src_c082_2_05 0 bpf_c082_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_2_05 (mix_q_src_c082_2_05 mix_q_c082_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_06 (mix_i_src_c082_2_06 0 bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_2_06 (mix_i_src_c082_2_06 mix_i_c082_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_06 (mix_q_src_c082_2_06 0 bpf_c082_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_2_06 (mix_q_src_c082_2_06 mix_q_c082_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_07 (mix_i_src_c082_2_07 0 bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_2_07 (mix_i_src_c082_2_07 mix_i_c082_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_07 (mix_q_src_c082_2_07 0 bpf_c082_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_2_07 (mix_q_src_c082_2_07 mix_q_c082_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_08 (mix_i_src_c082_2_08 0 bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_2_08 (mix_i_src_c082_2_08 mix_i_c082_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_08 (mix_q_src_c082_2_08 0 bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_2_08 (mix_q_src_c082_2_08 mix_q_c082_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_09 (mix_i_src_c082_2_09 0 bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_2_09 (mix_i_src_c082_2_09 mix_i_c082_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_09 (mix_q_src_c082_2_09 0 bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_2_09 (mix_q_src_c082_2_09 mix_q_c082_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_10 (mix_i_src_c082_2_10 0 bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_2_10 (mix_i_src_c082_2_10 mix_i_c082_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_10 (mix_q_src_c082_2_10 0 bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_2_10 (mix_q_src_c082_2_10 mix_q_c082_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_11 (mix_i_src_c082_2_11 0 bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_2_11 (mix_i_src_c082_2_11 mix_i_c082_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_11 (mix_q_src_c082_2_11 0 bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_2_11 (mix_q_src_c082_2_11 mix_q_c082_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_12 (mix_i_src_c082_2_12 0 bpf_c082_2 0) vcvs gain=1.950903220161e-01
SMIXI_c082_2_12 (mix_i_src_c082_2_12 mix_i_c082_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_12 (mix_q_src_c082_2_12 0 bpf_c082_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_2_12 (mix_q_src_c082_2_12 mix_q_c082_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_13 (mix_i_src_c082_2_13 0 bpf_c082_2 0) vcvs gain=5.555702330196e-01
SMIXI_c082_2_13 (mix_i_src_c082_2_13 mix_i_c082_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_13 (mix_q_src_c082_2_13 0 bpf_c082_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_2_13 (mix_q_src_c082_2_13 mix_q_c082_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_14 (mix_i_src_c082_2_14 0 bpf_c082_2 0) vcvs gain=8.314696123025e-01
SMIXI_c082_2_14 (mix_i_src_c082_2_14 mix_i_c082_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_14 (mix_q_src_c082_2_14 0 bpf_c082_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_2_14 (mix_q_src_c082_2_14 mix_q_c082_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_2_15 (mix_i_src_c082_2_15 0 bpf_c082_2 0) vcvs gain=9.807852804032e-01
SMIXI_c082_2_15 (mix_i_src_c082_2_15 mix_i_c082_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_2_15 (mix_q_src_c082_2_15 0 bpf_c082_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_2_15 (mix_q_src_c082_2_15 mix_q_c082_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c082_2 (mix_i_c082_2 0) resistor r=1G
RMIXQ_c082_2 (mix_q_c082_2 0) resistor r=1G
RINTI_c082_2 (mix_i_c082_2 Icar_c082_2) resistor r=1k
CINTI_c082_2 (Icar_c082_2 0) capacitor c=80p
RINTQ_c082_2 (mix_q_c082_2 Qcar_c082_2) resistor r=1k
CINTQ_c082_2 (Qcar_c082_2 0) capacitor c=80p

// bl082, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c082_3 (bl082 n_cbpf_c082_3) capacitor c=2.533029591058e-14
LBPF_c082_3 (n_cbpf_c082_3 bpf_c082_3) inductor l=1.000000000000e-06
RBPF_c082_3 (bpf_c082_3 0) resistor r=3.141592653590e+02
EMIXI_c082_3_00 (mix_i_src_c082_3_00 0 bpf_c082_3 0) vcvs gain=9.807852804032e-01
SMIXI_c082_3_00 (mix_i_src_c082_3_00 mix_i_c082_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_00 (mix_q_src_c082_3_00 0 bpf_c082_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_3_00 (mix_q_src_c082_3_00 mix_q_c082_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_01 (mix_i_src_c082_3_01 0 bpf_c082_3 0) vcvs gain=8.314696123025e-01
SMIXI_c082_3_01 (mix_i_src_c082_3_01 mix_i_c082_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_01 (mix_q_src_c082_3_01 0 bpf_c082_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_3_01 (mix_q_src_c082_3_01 mix_q_c082_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_02 (mix_i_src_c082_3_02 0 bpf_c082_3 0) vcvs gain=5.555702330196e-01
SMIXI_c082_3_02 (mix_i_src_c082_3_02 mix_i_c082_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_02 (mix_q_src_c082_3_02 0 bpf_c082_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_3_02 (mix_q_src_c082_3_02 mix_q_c082_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_03 (mix_i_src_c082_3_03 0 bpf_c082_3 0) vcvs gain=1.950903220161e-01
SMIXI_c082_3_03 (mix_i_src_c082_3_03 mix_i_c082_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_03 (mix_q_src_c082_3_03 0 bpf_c082_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_3_03 (mix_q_src_c082_3_03 mix_q_c082_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_04 (mix_i_src_c082_3_04 0 bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_3_04 (mix_i_src_c082_3_04 mix_i_c082_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_04 (mix_q_src_c082_3_04 0 bpf_c082_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c082_3_04 (mix_q_src_c082_3_04 mix_q_c082_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_05 (mix_i_src_c082_3_05 0 bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_3_05 (mix_i_src_c082_3_05 mix_i_c082_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_05 (mix_q_src_c082_3_05 0 bpf_c082_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c082_3_05 (mix_q_src_c082_3_05 mix_q_c082_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_06 (mix_i_src_c082_3_06 0 bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_3_06 (mix_i_src_c082_3_06 mix_i_c082_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_06 (mix_q_src_c082_3_06 0 bpf_c082_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c082_3_06 (mix_q_src_c082_3_06 mix_q_c082_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_07 (mix_i_src_c082_3_07 0 bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_3_07 (mix_i_src_c082_3_07 mix_i_c082_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_07 (mix_q_src_c082_3_07 0 bpf_c082_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c082_3_07 (mix_q_src_c082_3_07 mix_q_c082_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_08 (mix_i_src_c082_3_08 0 bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c082_3_08 (mix_i_src_c082_3_08 mix_i_c082_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_08 (mix_q_src_c082_3_08 0 bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_3_08 (mix_q_src_c082_3_08 mix_q_c082_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_09 (mix_i_src_c082_3_09 0 bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c082_3_09 (mix_i_src_c082_3_09 mix_i_c082_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_09 (mix_q_src_c082_3_09 0 bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_3_09 (mix_q_src_c082_3_09 mix_q_c082_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_10 (mix_i_src_c082_3_10 0 bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c082_3_10 (mix_i_src_c082_3_10 mix_i_c082_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_10 (mix_q_src_c082_3_10 0 bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_3_10 (mix_q_src_c082_3_10 mix_q_c082_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_11 (mix_i_src_c082_3_11 0 bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c082_3_11 (mix_i_src_c082_3_11 mix_i_c082_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_11 (mix_q_src_c082_3_11 0 bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_3_11 (mix_q_src_c082_3_11 mix_q_c082_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_12 (mix_i_src_c082_3_12 0 bpf_c082_3 0) vcvs gain=1.950903220161e-01
SMIXI_c082_3_12 (mix_i_src_c082_3_12 mix_i_c082_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_12 (mix_q_src_c082_3_12 0 bpf_c082_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c082_3_12 (mix_q_src_c082_3_12 mix_q_c082_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_13 (mix_i_src_c082_3_13 0 bpf_c082_3 0) vcvs gain=5.555702330196e-01
SMIXI_c082_3_13 (mix_i_src_c082_3_13 mix_i_c082_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_13 (mix_q_src_c082_3_13 0 bpf_c082_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c082_3_13 (mix_q_src_c082_3_13 mix_q_c082_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_14 (mix_i_src_c082_3_14 0 bpf_c082_3 0) vcvs gain=8.314696123025e-01
SMIXI_c082_3_14 (mix_i_src_c082_3_14 mix_i_c082_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_14 (mix_q_src_c082_3_14 0 bpf_c082_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c082_3_14 (mix_q_src_c082_3_14 mix_q_c082_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c082_3_15 (mix_i_src_c082_3_15 0 bpf_c082_3 0) vcvs gain=9.807852804032e-01
SMIXI_c082_3_15 (mix_i_src_c082_3_15 mix_i_c082_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c082_3_15 (mix_q_src_c082_3_15 0 bpf_c082_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c082_3_15 (mix_q_src_c082_3_15 mix_q_c082_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c082_3 (mix_i_c082_3 0) resistor r=1G
RMIXQ_c082_3 (mix_q_c082_3 0) resistor r=1G
RINTI_c082_3 (mix_i_c082_3 Icar_c082_3) resistor r=1k
CINTI_c082_3 (Icar_c082_3 0) capacitor c=80p
RINTQ_c082_3 (mix_q_c082_3 Qcar_c082_3) resistor r=1k
CINTQ_c082_3 (Qcar_c082_3 0) capacitor c=80p

// bl083, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c083_0 (bl083 n_cbpf_c083_0) capacitor c=4.052847345694e-13
LBPF_c083_0 (n_cbpf_c083_0 bpf_c083_0) inductor l=1.000000000000e-06
RBPF_c083_0 (bpf_c083_0 0) resistor r=7.853981633974e+01
EMIXI_c083_0_00 (mix_i_src_c083_0_00 0 bpf_c083_0 0) vcvs gain=9.807852804032e-01
SMIXI_c083_0_00 (mix_i_src_c083_0_00 mix_i_c083_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_00 (mix_q_src_c083_0_00 0 bpf_c083_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_0_00 (mix_q_src_c083_0_00 mix_q_c083_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_01 (mix_i_src_c083_0_01 0 bpf_c083_0 0) vcvs gain=8.314696123025e-01
SMIXI_c083_0_01 (mix_i_src_c083_0_01 mix_i_c083_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_01 (mix_q_src_c083_0_01 0 bpf_c083_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_0_01 (mix_q_src_c083_0_01 mix_q_c083_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_02 (mix_i_src_c083_0_02 0 bpf_c083_0 0) vcvs gain=5.555702330196e-01
SMIXI_c083_0_02 (mix_i_src_c083_0_02 mix_i_c083_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_02 (mix_q_src_c083_0_02 0 bpf_c083_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_0_02 (mix_q_src_c083_0_02 mix_q_c083_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_03 (mix_i_src_c083_0_03 0 bpf_c083_0 0) vcvs gain=1.950903220161e-01
SMIXI_c083_0_03 (mix_i_src_c083_0_03 mix_i_c083_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_03 (mix_q_src_c083_0_03 0 bpf_c083_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_0_03 (mix_q_src_c083_0_03 mix_q_c083_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_04 (mix_i_src_c083_0_04 0 bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_0_04 (mix_i_src_c083_0_04 mix_i_c083_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_04 (mix_q_src_c083_0_04 0 bpf_c083_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_0_04 (mix_q_src_c083_0_04 mix_q_c083_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_05 (mix_i_src_c083_0_05 0 bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_0_05 (mix_i_src_c083_0_05 mix_i_c083_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_05 (mix_q_src_c083_0_05 0 bpf_c083_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_0_05 (mix_q_src_c083_0_05 mix_q_c083_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_06 (mix_i_src_c083_0_06 0 bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_0_06 (mix_i_src_c083_0_06 mix_i_c083_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_06 (mix_q_src_c083_0_06 0 bpf_c083_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_0_06 (mix_q_src_c083_0_06 mix_q_c083_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_07 (mix_i_src_c083_0_07 0 bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_0_07 (mix_i_src_c083_0_07 mix_i_c083_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_07 (mix_q_src_c083_0_07 0 bpf_c083_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_0_07 (mix_q_src_c083_0_07 mix_q_c083_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_08 (mix_i_src_c083_0_08 0 bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_0_08 (mix_i_src_c083_0_08 mix_i_c083_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_08 (mix_q_src_c083_0_08 0 bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_0_08 (mix_q_src_c083_0_08 mix_q_c083_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_09 (mix_i_src_c083_0_09 0 bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_0_09 (mix_i_src_c083_0_09 mix_i_c083_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_09 (mix_q_src_c083_0_09 0 bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_0_09 (mix_q_src_c083_0_09 mix_q_c083_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_10 (mix_i_src_c083_0_10 0 bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_0_10 (mix_i_src_c083_0_10 mix_i_c083_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_10 (mix_q_src_c083_0_10 0 bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_0_10 (mix_q_src_c083_0_10 mix_q_c083_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_11 (mix_i_src_c083_0_11 0 bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_0_11 (mix_i_src_c083_0_11 mix_i_c083_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_11 (mix_q_src_c083_0_11 0 bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_0_11 (mix_q_src_c083_0_11 mix_q_c083_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_12 (mix_i_src_c083_0_12 0 bpf_c083_0 0) vcvs gain=1.950903220161e-01
SMIXI_c083_0_12 (mix_i_src_c083_0_12 mix_i_c083_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_12 (mix_q_src_c083_0_12 0 bpf_c083_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_0_12 (mix_q_src_c083_0_12 mix_q_c083_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_13 (mix_i_src_c083_0_13 0 bpf_c083_0 0) vcvs gain=5.555702330196e-01
SMIXI_c083_0_13 (mix_i_src_c083_0_13 mix_i_c083_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_13 (mix_q_src_c083_0_13 0 bpf_c083_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_0_13 (mix_q_src_c083_0_13 mix_q_c083_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_14 (mix_i_src_c083_0_14 0 bpf_c083_0 0) vcvs gain=8.314696123025e-01
SMIXI_c083_0_14 (mix_i_src_c083_0_14 mix_i_c083_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_14 (mix_q_src_c083_0_14 0 bpf_c083_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_0_14 (mix_q_src_c083_0_14 mix_q_c083_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_0_15 (mix_i_src_c083_0_15 0 bpf_c083_0 0) vcvs gain=9.807852804032e-01
SMIXI_c083_0_15 (mix_i_src_c083_0_15 mix_i_c083_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_0_15 (mix_q_src_c083_0_15 0 bpf_c083_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_0_15 (mix_q_src_c083_0_15 mix_q_c083_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c083_0 (mix_i_c083_0 0) resistor r=1G
RMIXQ_c083_0 (mix_q_c083_0 0) resistor r=1G
RINTI_c083_0 (mix_i_c083_0 Icar_c083_0) resistor r=1k
CINTI_c083_0 (Icar_c083_0 0) capacitor c=80p
RINTQ_c083_0 (mix_q_c083_0 Qcar_c083_0) resistor r=1k
CINTQ_c083_0 (Qcar_c083_0 0) capacitor c=80p

// bl083, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c083_1 (bl083 n_cbpf_c083_1) capacitor c=1.013211836423e-13
LBPF_c083_1 (n_cbpf_c083_1 bpf_c083_1) inductor l=1.000000000000e-06
RBPF_c083_1 (bpf_c083_1 0) resistor r=1.570796326795e+02
EMIXI_c083_1_00 (mix_i_src_c083_1_00 0 bpf_c083_1 0) vcvs gain=9.807852804032e-01
SMIXI_c083_1_00 (mix_i_src_c083_1_00 mix_i_c083_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_00 (mix_q_src_c083_1_00 0 bpf_c083_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_1_00 (mix_q_src_c083_1_00 mix_q_c083_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_01 (mix_i_src_c083_1_01 0 bpf_c083_1 0) vcvs gain=8.314696123025e-01
SMIXI_c083_1_01 (mix_i_src_c083_1_01 mix_i_c083_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_01 (mix_q_src_c083_1_01 0 bpf_c083_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_1_01 (mix_q_src_c083_1_01 mix_q_c083_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_02 (mix_i_src_c083_1_02 0 bpf_c083_1 0) vcvs gain=5.555702330196e-01
SMIXI_c083_1_02 (mix_i_src_c083_1_02 mix_i_c083_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_02 (mix_q_src_c083_1_02 0 bpf_c083_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_1_02 (mix_q_src_c083_1_02 mix_q_c083_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_03 (mix_i_src_c083_1_03 0 bpf_c083_1 0) vcvs gain=1.950903220161e-01
SMIXI_c083_1_03 (mix_i_src_c083_1_03 mix_i_c083_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_03 (mix_q_src_c083_1_03 0 bpf_c083_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_1_03 (mix_q_src_c083_1_03 mix_q_c083_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_04 (mix_i_src_c083_1_04 0 bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_1_04 (mix_i_src_c083_1_04 mix_i_c083_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_04 (mix_q_src_c083_1_04 0 bpf_c083_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_1_04 (mix_q_src_c083_1_04 mix_q_c083_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_05 (mix_i_src_c083_1_05 0 bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_1_05 (mix_i_src_c083_1_05 mix_i_c083_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_05 (mix_q_src_c083_1_05 0 bpf_c083_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_1_05 (mix_q_src_c083_1_05 mix_q_c083_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_06 (mix_i_src_c083_1_06 0 bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_1_06 (mix_i_src_c083_1_06 mix_i_c083_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_06 (mix_q_src_c083_1_06 0 bpf_c083_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_1_06 (mix_q_src_c083_1_06 mix_q_c083_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_07 (mix_i_src_c083_1_07 0 bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_1_07 (mix_i_src_c083_1_07 mix_i_c083_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_07 (mix_q_src_c083_1_07 0 bpf_c083_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_1_07 (mix_q_src_c083_1_07 mix_q_c083_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_08 (mix_i_src_c083_1_08 0 bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_1_08 (mix_i_src_c083_1_08 mix_i_c083_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_08 (mix_q_src_c083_1_08 0 bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_1_08 (mix_q_src_c083_1_08 mix_q_c083_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_09 (mix_i_src_c083_1_09 0 bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_1_09 (mix_i_src_c083_1_09 mix_i_c083_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_09 (mix_q_src_c083_1_09 0 bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_1_09 (mix_q_src_c083_1_09 mix_q_c083_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_10 (mix_i_src_c083_1_10 0 bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_1_10 (mix_i_src_c083_1_10 mix_i_c083_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_10 (mix_q_src_c083_1_10 0 bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_1_10 (mix_q_src_c083_1_10 mix_q_c083_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_11 (mix_i_src_c083_1_11 0 bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_1_11 (mix_i_src_c083_1_11 mix_i_c083_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_11 (mix_q_src_c083_1_11 0 bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_1_11 (mix_q_src_c083_1_11 mix_q_c083_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_12 (mix_i_src_c083_1_12 0 bpf_c083_1 0) vcvs gain=1.950903220161e-01
SMIXI_c083_1_12 (mix_i_src_c083_1_12 mix_i_c083_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_12 (mix_q_src_c083_1_12 0 bpf_c083_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_1_12 (mix_q_src_c083_1_12 mix_q_c083_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_13 (mix_i_src_c083_1_13 0 bpf_c083_1 0) vcvs gain=5.555702330196e-01
SMIXI_c083_1_13 (mix_i_src_c083_1_13 mix_i_c083_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_13 (mix_q_src_c083_1_13 0 bpf_c083_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_1_13 (mix_q_src_c083_1_13 mix_q_c083_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_14 (mix_i_src_c083_1_14 0 bpf_c083_1 0) vcvs gain=8.314696123025e-01
SMIXI_c083_1_14 (mix_i_src_c083_1_14 mix_i_c083_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_14 (mix_q_src_c083_1_14 0 bpf_c083_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_1_14 (mix_q_src_c083_1_14 mix_q_c083_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_1_15 (mix_i_src_c083_1_15 0 bpf_c083_1 0) vcvs gain=9.807852804032e-01
SMIXI_c083_1_15 (mix_i_src_c083_1_15 mix_i_c083_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_1_15 (mix_q_src_c083_1_15 0 bpf_c083_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_1_15 (mix_q_src_c083_1_15 mix_q_c083_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c083_1 (mix_i_c083_1 0) resistor r=1G
RMIXQ_c083_1 (mix_q_c083_1 0) resistor r=1G
RINTI_c083_1 (mix_i_c083_1 Icar_c083_1) resistor r=1k
CINTI_c083_1 (Icar_c083_1 0) capacitor c=80p
RINTQ_c083_1 (mix_q_c083_1 Qcar_c083_1) resistor r=1k
CINTQ_c083_1 (Qcar_c083_1 0) capacitor c=80p

// bl083, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c083_2 (bl083 n_cbpf_c083_2) capacitor c=4.503163717437e-14
LBPF_c083_2 (n_cbpf_c083_2 bpf_c083_2) inductor l=1.000000000000e-06
RBPF_c083_2 (bpf_c083_2 0) resistor r=2.356194490192e+02
EMIXI_c083_2_00 (mix_i_src_c083_2_00 0 bpf_c083_2 0) vcvs gain=9.807852804032e-01
SMIXI_c083_2_00 (mix_i_src_c083_2_00 mix_i_c083_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_00 (mix_q_src_c083_2_00 0 bpf_c083_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_2_00 (mix_q_src_c083_2_00 mix_q_c083_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_01 (mix_i_src_c083_2_01 0 bpf_c083_2 0) vcvs gain=8.314696123025e-01
SMIXI_c083_2_01 (mix_i_src_c083_2_01 mix_i_c083_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_01 (mix_q_src_c083_2_01 0 bpf_c083_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_2_01 (mix_q_src_c083_2_01 mix_q_c083_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_02 (mix_i_src_c083_2_02 0 bpf_c083_2 0) vcvs gain=5.555702330196e-01
SMIXI_c083_2_02 (mix_i_src_c083_2_02 mix_i_c083_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_02 (mix_q_src_c083_2_02 0 bpf_c083_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_2_02 (mix_q_src_c083_2_02 mix_q_c083_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_03 (mix_i_src_c083_2_03 0 bpf_c083_2 0) vcvs gain=1.950903220161e-01
SMIXI_c083_2_03 (mix_i_src_c083_2_03 mix_i_c083_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_03 (mix_q_src_c083_2_03 0 bpf_c083_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_2_03 (mix_q_src_c083_2_03 mix_q_c083_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_04 (mix_i_src_c083_2_04 0 bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_2_04 (mix_i_src_c083_2_04 mix_i_c083_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_04 (mix_q_src_c083_2_04 0 bpf_c083_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_2_04 (mix_q_src_c083_2_04 mix_q_c083_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_05 (mix_i_src_c083_2_05 0 bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_2_05 (mix_i_src_c083_2_05 mix_i_c083_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_05 (mix_q_src_c083_2_05 0 bpf_c083_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_2_05 (mix_q_src_c083_2_05 mix_q_c083_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_06 (mix_i_src_c083_2_06 0 bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_2_06 (mix_i_src_c083_2_06 mix_i_c083_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_06 (mix_q_src_c083_2_06 0 bpf_c083_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_2_06 (mix_q_src_c083_2_06 mix_q_c083_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_07 (mix_i_src_c083_2_07 0 bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_2_07 (mix_i_src_c083_2_07 mix_i_c083_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_07 (mix_q_src_c083_2_07 0 bpf_c083_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_2_07 (mix_q_src_c083_2_07 mix_q_c083_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_08 (mix_i_src_c083_2_08 0 bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_2_08 (mix_i_src_c083_2_08 mix_i_c083_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_08 (mix_q_src_c083_2_08 0 bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_2_08 (mix_q_src_c083_2_08 mix_q_c083_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_09 (mix_i_src_c083_2_09 0 bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_2_09 (mix_i_src_c083_2_09 mix_i_c083_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_09 (mix_q_src_c083_2_09 0 bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_2_09 (mix_q_src_c083_2_09 mix_q_c083_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_10 (mix_i_src_c083_2_10 0 bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_2_10 (mix_i_src_c083_2_10 mix_i_c083_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_10 (mix_q_src_c083_2_10 0 bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_2_10 (mix_q_src_c083_2_10 mix_q_c083_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_11 (mix_i_src_c083_2_11 0 bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_2_11 (mix_i_src_c083_2_11 mix_i_c083_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_11 (mix_q_src_c083_2_11 0 bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_2_11 (mix_q_src_c083_2_11 mix_q_c083_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_12 (mix_i_src_c083_2_12 0 bpf_c083_2 0) vcvs gain=1.950903220161e-01
SMIXI_c083_2_12 (mix_i_src_c083_2_12 mix_i_c083_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_12 (mix_q_src_c083_2_12 0 bpf_c083_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_2_12 (mix_q_src_c083_2_12 mix_q_c083_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_13 (mix_i_src_c083_2_13 0 bpf_c083_2 0) vcvs gain=5.555702330196e-01
SMIXI_c083_2_13 (mix_i_src_c083_2_13 mix_i_c083_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_13 (mix_q_src_c083_2_13 0 bpf_c083_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_2_13 (mix_q_src_c083_2_13 mix_q_c083_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_14 (mix_i_src_c083_2_14 0 bpf_c083_2 0) vcvs gain=8.314696123025e-01
SMIXI_c083_2_14 (mix_i_src_c083_2_14 mix_i_c083_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_14 (mix_q_src_c083_2_14 0 bpf_c083_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_2_14 (mix_q_src_c083_2_14 mix_q_c083_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_2_15 (mix_i_src_c083_2_15 0 bpf_c083_2 0) vcvs gain=9.807852804032e-01
SMIXI_c083_2_15 (mix_i_src_c083_2_15 mix_i_c083_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_2_15 (mix_q_src_c083_2_15 0 bpf_c083_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_2_15 (mix_q_src_c083_2_15 mix_q_c083_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c083_2 (mix_i_c083_2 0) resistor r=1G
RMIXQ_c083_2 (mix_q_c083_2 0) resistor r=1G
RINTI_c083_2 (mix_i_c083_2 Icar_c083_2) resistor r=1k
CINTI_c083_2 (Icar_c083_2 0) capacitor c=80p
RINTQ_c083_2 (mix_q_c083_2 Qcar_c083_2) resistor r=1k
CINTQ_c083_2 (Qcar_c083_2 0) capacitor c=80p

// bl083, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c083_3 (bl083 n_cbpf_c083_3) capacitor c=2.533029591058e-14
LBPF_c083_3 (n_cbpf_c083_3 bpf_c083_3) inductor l=1.000000000000e-06
RBPF_c083_3 (bpf_c083_3 0) resistor r=3.141592653590e+02
EMIXI_c083_3_00 (mix_i_src_c083_3_00 0 bpf_c083_3 0) vcvs gain=9.807852804032e-01
SMIXI_c083_3_00 (mix_i_src_c083_3_00 mix_i_c083_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_00 (mix_q_src_c083_3_00 0 bpf_c083_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_3_00 (mix_q_src_c083_3_00 mix_q_c083_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_01 (mix_i_src_c083_3_01 0 bpf_c083_3 0) vcvs gain=8.314696123025e-01
SMIXI_c083_3_01 (mix_i_src_c083_3_01 mix_i_c083_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_01 (mix_q_src_c083_3_01 0 bpf_c083_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_3_01 (mix_q_src_c083_3_01 mix_q_c083_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_02 (mix_i_src_c083_3_02 0 bpf_c083_3 0) vcvs gain=5.555702330196e-01
SMIXI_c083_3_02 (mix_i_src_c083_3_02 mix_i_c083_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_02 (mix_q_src_c083_3_02 0 bpf_c083_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_3_02 (mix_q_src_c083_3_02 mix_q_c083_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_03 (mix_i_src_c083_3_03 0 bpf_c083_3 0) vcvs gain=1.950903220161e-01
SMIXI_c083_3_03 (mix_i_src_c083_3_03 mix_i_c083_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_03 (mix_q_src_c083_3_03 0 bpf_c083_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_3_03 (mix_q_src_c083_3_03 mix_q_c083_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_04 (mix_i_src_c083_3_04 0 bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_3_04 (mix_i_src_c083_3_04 mix_i_c083_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_04 (mix_q_src_c083_3_04 0 bpf_c083_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c083_3_04 (mix_q_src_c083_3_04 mix_q_c083_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_05 (mix_i_src_c083_3_05 0 bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_3_05 (mix_i_src_c083_3_05 mix_i_c083_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_05 (mix_q_src_c083_3_05 0 bpf_c083_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c083_3_05 (mix_q_src_c083_3_05 mix_q_c083_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_06 (mix_i_src_c083_3_06 0 bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_3_06 (mix_i_src_c083_3_06 mix_i_c083_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_06 (mix_q_src_c083_3_06 0 bpf_c083_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c083_3_06 (mix_q_src_c083_3_06 mix_q_c083_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_07 (mix_i_src_c083_3_07 0 bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_3_07 (mix_i_src_c083_3_07 mix_i_c083_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_07 (mix_q_src_c083_3_07 0 bpf_c083_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c083_3_07 (mix_q_src_c083_3_07 mix_q_c083_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_08 (mix_i_src_c083_3_08 0 bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c083_3_08 (mix_i_src_c083_3_08 mix_i_c083_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_08 (mix_q_src_c083_3_08 0 bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_3_08 (mix_q_src_c083_3_08 mix_q_c083_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_09 (mix_i_src_c083_3_09 0 bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c083_3_09 (mix_i_src_c083_3_09 mix_i_c083_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_09 (mix_q_src_c083_3_09 0 bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_3_09 (mix_q_src_c083_3_09 mix_q_c083_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_10 (mix_i_src_c083_3_10 0 bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c083_3_10 (mix_i_src_c083_3_10 mix_i_c083_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_10 (mix_q_src_c083_3_10 0 bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_3_10 (mix_q_src_c083_3_10 mix_q_c083_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_11 (mix_i_src_c083_3_11 0 bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c083_3_11 (mix_i_src_c083_3_11 mix_i_c083_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_11 (mix_q_src_c083_3_11 0 bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_3_11 (mix_q_src_c083_3_11 mix_q_c083_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_12 (mix_i_src_c083_3_12 0 bpf_c083_3 0) vcvs gain=1.950903220161e-01
SMIXI_c083_3_12 (mix_i_src_c083_3_12 mix_i_c083_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_12 (mix_q_src_c083_3_12 0 bpf_c083_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c083_3_12 (mix_q_src_c083_3_12 mix_q_c083_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_13 (mix_i_src_c083_3_13 0 bpf_c083_3 0) vcvs gain=5.555702330196e-01
SMIXI_c083_3_13 (mix_i_src_c083_3_13 mix_i_c083_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_13 (mix_q_src_c083_3_13 0 bpf_c083_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c083_3_13 (mix_q_src_c083_3_13 mix_q_c083_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_14 (mix_i_src_c083_3_14 0 bpf_c083_3 0) vcvs gain=8.314696123025e-01
SMIXI_c083_3_14 (mix_i_src_c083_3_14 mix_i_c083_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_14 (mix_q_src_c083_3_14 0 bpf_c083_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c083_3_14 (mix_q_src_c083_3_14 mix_q_c083_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c083_3_15 (mix_i_src_c083_3_15 0 bpf_c083_3 0) vcvs gain=9.807852804032e-01
SMIXI_c083_3_15 (mix_i_src_c083_3_15 mix_i_c083_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c083_3_15 (mix_q_src_c083_3_15 0 bpf_c083_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c083_3_15 (mix_q_src_c083_3_15 mix_q_c083_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c083_3 (mix_i_c083_3 0) resistor r=1G
RMIXQ_c083_3 (mix_q_c083_3 0) resistor r=1G
RINTI_c083_3 (mix_i_c083_3 Icar_c083_3) resistor r=1k
CINTI_c083_3 (Icar_c083_3 0) capacitor c=80p
RINTQ_c083_3 (mix_q_c083_3 Qcar_c083_3) resistor r=1k
CINTQ_c083_3 (Qcar_c083_3 0) capacitor c=80p

// bl084, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c084_0 (bl084 n_cbpf_c084_0) capacitor c=4.052847345694e-13
LBPF_c084_0 (n_cbpf_c084_0 bpf_c084_0) inductor l=1.000000000000e-06
RBPF_c084_0 (bpf_c084_0 0) resistor r=7.853981633974e+01
EMIXI_c084_0_00 (mix_i_src_c084_0_00 0 bpf_c084_0 0) vcvs gain=9.807852804032e-01
SMIXI_c084_0_00 (mix_i_src_c084_0_00 mix_i_c084_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_00 (mix_q_src_c084_0_00 0 bpf_c084_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_0_00 (mix_q_src_c084_0_00 mix_q_c084_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_01 (mix_i_src_c084_0_01 0 bpf_c084_0 0) vcvs gain=8.314696123025e-01
SMIXI_c084_0_01 (mix_i_src_c084_0_01 mix_i_c084_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_01 (mix_q_src_c084_0_01 0 bpf_c084_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_0_01 (mix_q_src_c084_0_01 mix_q_c084_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_02 (mix_i_src_c084_0_02 0 bpf_c084_0 0) vcvs gain=5.555702330196e-01
SMIXI_c084_0_02 (mix_i_src_c084_0_02 mix_i_c084_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_02 (mix_q_src_c084_0_02 0 bpf_c084_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_0_02 (mix_q_src_c084_0_02 mix_q_c084_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_03 (mix_i_src_c084_0_03 0 bpf_c084_0 0) vcvs gain=1.950903220161e-01
SMIXI_c084_0_03 (mix_i_src_c084_0_03 mix_i_c084_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_03 (mix_q_src_c084_0_03 0 bpf_c084_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_0_03 (mix_q_src_c084_0_03 mix_q_c084_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_04 (mix_i_src_c084_0_04 0 bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_0_04 (mix_i_src_c084_0_04 mix_i_c084_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_04 (mix_q_src_c084_0_04 0 bpf_c084_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_0_04 (mix_q_src_c084_0_04 mix_q_c084_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_05 (mix_i_src_c084_0_05 0 bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_0_05 (mix_i_src_c084_0_05 mix_i_c084_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_05 (mix_q_src_c084_0_05 0 bpf_c084_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_0_05 (mix_q_src_c084_0_05 mix_q_c084_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_06 (mix_i_src_c084_0_06 0 bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_0_06 (mix_i_src_c084_0_06 mix_i_c084_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_06 (mix_q_src_c084_0_06 0 bpf_c084_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_0_06 (mix_q_src_c084_0_06 mix_q_c084_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_07 (mix_i_src_c084_0_07 0 bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_0_07 (mix_i_src_c084_0_07 mix_i_c084_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_07 (mix_q_src_c084_0_07 0 bpf_c084_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_0_07 (mix_q_src_c084_0_07 mix_q_c084_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_08 (mix_i_src_c084_0_08 0 bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_0_08 (mix_i_src_c084_0_08 mix_i_c084_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_08 (mix_q_src_c084_0_08 0 bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_0_08 (mix_q_src_c084_0_08 mix_q_c084_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_09 (mix_i_src_c084_0_09 0 bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_0_09 (mix_i_src_c084_0_09 mix_i_c084_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_09 (mix_q_src_c084_0_09 0 bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_0_09 (mix_q_src_c084_0_09 mix_q_c084_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_10 (mix_i_src_c084_0_10 0 bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_0_10 (mix_i_src_c084_0_10 mix_i_c084_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_10 (mix_q_src_c084_0_10 0 bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_0_10 (mix_q_src_c084_0_10 mix_q_c084_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_11 (mix_i_src_c084_0_11 0 bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_0_11 (mix_i_src_c084_0_11 mix_i_c084_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_11 (mix_q_src_c084_0_11 0 bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_0_11 (mix_q_src_c084_0_11 mix_q_c084_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_12 (mix_i_src_c084_0_12 0 bpf_c084_0 0) vcvs gain=1.950903220161e-01
SMIXI_c084_0_12 (mix_i_src_c084_0_12 mix_i_c084_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_12 (mix_q_src_c084_0_12 0 bpf_c084_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_0_12 (mix_q_src_c084_0_12 mix_q_c084_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_13 (mix_i_src_c084_0_13 0 bpf_c084_0 0) vcvs gain=5.555702330196e-01
SMIXI_c084_0_13 (mix_i_src_c084_0_13 mix_i_c084_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_13 (mix_q_src_c084_0_13 0 bpf_c084_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_0_13 (mix_q_src_c084_0_13 mix_q_c084_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_14 (mix_i_src_c084_0_14 0 bpf_c084_0 0) vcvs gain=8.314696123025e-01
SMIXI_c084_0_14 (mix_i_src_c084_0_14 mix_i_c084_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_14 (mix_q_src_c084_0_14 0 bpf_c084_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_0_14 (mix_q_src_c084_0_14 mix_q_c084_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_0_15 (mix_i_src_c084_0_15 0 bpf_c084_0 0) vcvs gain=9.807852804032e-01
SMIXI_c084_0_15 (mix_i_src_c084_0_15 mix_i_c084_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_0_15 (mix_q_src_c084_0_15 0 bpf_c084_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_0_15 (mix_q_src_c084_0_15 mix_q_c084_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c084_0 (mix_i_c084_0 0) resistor r=1G
RMIXQ_c084_0 (mix_q_c084_0 0) resistor r=1G
RINTI_c084_0 (mix_i_c084_0 Icar_c084_0) resistor r=1k
CINTI_c084_0 (Icar_c084_0 0) capacitor c=80p
RINTQ_c084_0 (mix_q_c084_0 Qcar_c084_0) resistor r=1k
CINTQ_c084_0 (Qcar_c084_0 0) capacitor c=80p

// bl084, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c084_1 (bl084 n_cbpf_c084_1) capacitor c=1.013211836423e-13
LBPF_c084_1 (n_cbpf_c084_1 bpf_c084_1) inductor l=1.000000000000e-06
RBPF_c084_1 (bpf_c084_1 0) resistor r=1.570796326795e+02
EMIXI_c084_1_00 (mix_i_src_c084_1_00 0 bpf_c084_1 0) vcvs gain=9.807852804032e-01
SMIXI_c084_1_00 (mix_i_src_c084_1_00 mix_i_c084_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_00 (mix_q_src_c084_1_00 0 bpf_c084_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_1_00 (mix_q_src_c084_1_00 mix_q_c084_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_01 (mix_i_src_c084_1_01 0 bpf_c084_1 0) vcvs gain=8.314696123025e-01
SMIXI_c084_1_01 (mix_i_src_c084_1_01 mix_i_c084_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_01 (mix_q_src_c084_1_01 0 bpf_c084_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_1_01 (mix_q_src_c084_1_01 mix_q_c084_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_02 (mix_i_src_c084_1_02 0 bpf_c084_1 0) vcvs gain=5.555702330196e-01
SMIXI_c084_1_02 (mix_i_src_c084_1_02 mix_i_c084_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_02 (mix_q_src_c084_1_02 0 bpf_c084_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_1_02 (mix_q_src_c084_1_02 mix_q_c084_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_03 (mix_i_src_c084_1_03 0 bpf_c084_1 0) vcvs gain=1.950903220161e-01
SMIXI_c084_1_03 (mix_i_src_c084_1_03 mix_i_c084_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_03 (mix_q_src_c084_1_03 0 bpf_c084_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_1_03 (mix_q_src_c084_1_03 mix_q_c084_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_04 (mix_i_src_c084_1_04 0 bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_1_04 (mix_i_src_c084_1_04 mix_i_c084_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_04 (mix_q_src_c084_1_04 0 bpf_c084_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_1_04 (mix_q_src_c084_1_04 mix_q_c084_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_05 (mix_i_src_c084_1_05 0 bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_1_05 (mix_i_src_c084_1_05 mix_i_c084_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_05 (mix_q_src_c084_1_05 0 bpf_c084_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_1_05 (mix_q_src_c084_1_05 mix_q_c084_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_06 (mix_i_src_c084_1_06 0 bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_1_06 (mix_i_src_c084_1_06 mix_i_c084_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_06 (mix_q_src_c084_1_06 0 bpf_c084_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_1_06 (mix_q_src_c084_1_06 mix_q_c084_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_07 (mix_i_src_c084_1_07 0 bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_1_07 (mix_i_src_c084_1_07 mix_i_c084_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_07 (mix_q_src_c084_1_07 0 bpf_c084_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_1_07 (mix_q_src_c084_1_07 mix_q_c084_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_08 (mix_i_src_c084_1_08 0 bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_1_08 (mix_i_src_c084_1_08 mix_i_c084_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_08 (mix_q_src_c084_1_08 0 bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_1_08 (mix_q_src_c084_1_08 mix_q_c084_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_09 (mix_i_src_c084_1_09 0 bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_1_09 (mix_i_src_c084_1_09 mix_i_c084_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_09 (mix_q_src_c084_1_09 0 bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_1_09 (mix_q_src_c084_1_09 mix_q_c084_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_10 (mix_i_src_c084_1_10 0 bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_1_10 (mix_i_src_c084_1_10 mix_i_c084_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_10 (mix_q_src_c084_1_10 0 bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_1_10 (mix_q_src_c084_1_10 mix_q_c084_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_11 (mix_i_src_c084_1_11 0 bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_1_11 (mix_i_src_c084_1_11 mix_i_c084_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_11 (mix_q_src_c084_1_11 0 bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_1_11 (mix_q_src_c084_1_11 mix_q_c084_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_12 (mix_i_src_c084_1_12 0 bpf_c084_1 0) vcvs gain=1.950903220161e-01
SMIXI_c084_1_12 (mix_i_src_c084_1_12 mix_i_c084_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_12 (mix_q_src_c084_1_12 0 bpf_c084_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_1_12 (mix_q_src_c084_1_12 mix_q_c084_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_13 (mix_i_src_c084_1_13 0 bpf_c084_1 0) vcvs gain=5.555702330196e-01
SMIXI_c084_1_13 (mix_i_src_c084_1_13 mix_i_c084_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_13 (mix_q_src_c084_1_13 0 bpf_c084_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_1_13 (mix_q_src_c084_1_13 mix_q_c084_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_14 (mix_i_src_c084_1_14 0 bpf_c084_1 0) vcvs gain=8.314696123025e-01
SMIXI_c084_1_14 (mix_i_src_c084_1_14 mix_i_c084_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_14 (mix_q_src_c084_1_14 0 bpf_c084_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_1_14 (mix_q_src_c084_1_14 mix_q_c084_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_1_15 (mix_i_src_c084_1_15 0 bpf_c084_1 0) vcvs gain=9.807852804032e-01
SMIXI_c084_1_15 (mix_i_src_c084_1_15 mix_i_c084_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_1_15 (mix_q_src_c084_1_15 0 bpf_c084_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_1_15 (mix_q_src_c084_1_15 mix_q_c084_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c084_1 (mix_i_c084_1 0) resistor r=1G
RMIXQ_c084_1 (mix_q_c084_1 0) resistor r=1G
RINTI_c084_1 (mix_i_c084_1 Icar_c084_1) resistor r=1k
CINTI_c084_1 (Icar_c084_1 0) capacitor c=80p
RINTQ_c084_1 (mix_q_c084_1 Qcar_c084_1) resistor r=1k
CINTQ_c084_1 (Qcar_c084_1 0) capacitor c=80p

// bl084, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c084_2 (bl084 n_cbpf_c084_2) capacitor c=4.503163717437e-14
LBPF_c084_2 (n_cbpf_c084_2 bpf_c084_2) inductor l=1.000000000000e-06
RBPF_c084_2 (bpf_c084_2 0) resistor r=2.356194490192e+02
EMIXI_c084_2_00 (mix_i_src_c084_2_00 0 bpf_c084_2 0) vcvs gain=9.807852804032e-01
SMIXI_c084_2_00 (mix_i_src_c084_2_00 mix_i_c084_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_00 (mix_q_src_c084_2_00 0 bpf_c084_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_2_00 (mix_q_src_c084_2_00 mix_q_c084_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_01 (mix_i_src_c084_2_01 0 bpf_c084_2 0) vcvs gain=8.314696123025e-01
SMIXI_c084_2_01 (mix_i_src_c084_2_01 mix_i_c084_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_01 (mix_q_src_c084_2_01 0 bpf_c084_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_2_01 (mix_q_src_c084_2_01 mix_q_c084_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_02 (mix_i_src_c084_2_02 0 bpf_c084_2 0) vcvs gain=5.555702330196e-01
SMIXI_c084_2_02 (mix_i_src_c084_2_02 mix_i_c084_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_02 (mix_q_src_c084_2_02 0 bpf_c084_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_2_02 (mix_q_src_c084_2_02 mix_q_c084_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_03 (mix_i_src_c084_2_03 0 bpf_c084_2 0) vcvs gain=1.950903220161e-01
SMIXI_c084_2_03 (mix_i_src_c084_2_03 mix_i_c084_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_03 (mix_q_src_c084_2_03 0 bpf_c084_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_2_03 (mix_q_src_c084_2_03 mix_q_c084_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_04 (mix_i_src_c084_2_04 0 bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_2_04 (mix_i_src_c084_2_04 mix_i_c084_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_04 (mix_q_src_c084_2_04 0 bpf_c084_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_2_04 (mix_q_src_c084_2_04 mix_q_c084_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_05 (mix_i_src_c084_2_05 0 bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_2_05 (mix_i_src_c084_2_05 mix_i_c084_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_05 (mix_q_src_c084_2_05 0 bpf_c084_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_2_05 (mix_q_src_c084_2_05 mix_q_c084_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_06 (mix_i_src_c084_2_06 0 bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_2_06 (mix_i_src_c084_2_06 mix_i_c084_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_06 (mix_q_src_c084_2_06 0 bpf_c084_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_2_06 (mix_q_src_c084_2_06 mix_q_c084_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_07 (mix_i_src_c084_2_07 0 bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_2_07 (mix_i_src_c084_2_07 mix_i_c084_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_07 (mix_q_src_c084_2_07 0 bpf_c084_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_2_07 (mix_q_src_c084_2_07 mix_q_c084_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_08 (mix_i_src_c084_2_08 0 bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_2_08 (mix_i_src_c084_2_08 mix_i_c084_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_08 (mix_q_src_c084_2_08 0 bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_2_08 (mix_q_src_c084_2_08 mix_q_c084_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_09 (mix_i_src_c084_2_09 0 bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_2_09 (mix_i_src_c084_2_09 mix_i_c084_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_09 (mix_q_src_c084_2_09 0 bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_2_09 (mix_q_src_c084_2_09 mix_q_c084_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_10 (mix_i_src_c084_2_10 0 bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_2_10 (mix_i_src_c084_2_10 mix_i_c084_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_10 (mix_q_src_c084_2_10 0 bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_2_10 (mix_q_src_c084_2_10 mix_q_c084_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_11 (mix_i_src_c084_2_11 0 bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_2_11 (mix_i_src_c084_2_11 mix_i_c084_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_11 (mix_q_src_c084_2_11 0 bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_2_11 (mix_q_src_c084_2_11 mix_q_c084_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_12 (mix_i_src_c084_2_12 0 bpf_c084_2 0) vcvs gain=1.950903220161e-01
SMIXI_c084_2_12 (mix_i_src_c084_2_12 mix_i_c084_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_12 (mix_q_src_c084_2_12 0 bpf_c084_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_2_12 (mix_q_src_c084_2_12 mix_q_c084_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_13 (mix_i_src_c084_2_13 0 bpf_c084_2 0) vcvs gain=5.555702330196e-01
SMIXI_c084_2_13 (mix_i_src_c084_2_13 mix_i_c084_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_13 (mix_q_src_c084_2_13 0 bpf_c084_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_2_13 (mix_q_src_c084_2_13 mix_q_c084_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_14 (mix_i_src_c084_2_14 0 bpf_c084_2 0) vcvs gain=8.314696123025e-01
SMIXI_c084_2_14 (mix_i_src_c084_2_14 mix_i_c084_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_14 (mix_q_src_c084_2_14 0 bpf_c084_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_2_14 (mix_q_src_c084_2_14 mix_q_c084_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_2_15 (mix_i_src_c084_2_15 0 bpf_c084_2 0) vcvs gain=9.807852804032e-01
SMIXI_c084_2_15 (mix_i_src_c084_2_15 mix_i_c084_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_2_15 (mix_q_src_c084_2_15 0 bpf_c084_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_2_15 (mix_q_src_c084_2_15 mix_q_c084_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c084_2 (mix_i_c084_2 0) resistor r=1G
RMIXQ_c084_2 (mix_q_c084_2 0) resistor r=1G
RINTI_c084_2 (mix_i_c084_2 Icar_c084_2) resistor r=1k
CINTI_c084_2 (Icar_c084_2 0) capacitor c=80p
RINTQ_c084_2 (mix_q_c084_2 Qcar_c084_2) resistor r=1k
CINTQ_c084_2 (Qcar_c084_2 0) capacitor c=80p

// bl084, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c084_3 (bl084 n_cbpf_c084_3) capacitor c=2.533029591058e-14
LBPF_c084_3 (n_cbpf_c084_3 bpf_c084_3) inductor l=1.000000000000e-06
RBPF_c084_3 (bpf_c084_3 0) resistor r=3.141592653590e+02
EMIXI_c084_3_00 (mix_i_src_c084_3_00 0 bpf_c084_3 0) vcvs gain=9.807852804032e-01
SMIXI_c084_3_00 (mix_i_src_c084_3_00 mix_i_c084_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_00 (mix_q_src_c084_3_00 0 bpf_c084_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_3_00 (mix_q_src_c084_3_00 mix_q_c084_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_01 (mix_i_src_c084_3_01 0 bpf_c084_3 0) vcvs gain=8.314696123025e-01
SMIXI_c084_3_01 (mix_i_src_c084_3_01 mix_i_c084_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_01 (mix_q_src_c084_3_01 0 bpf_c084_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_3_01 (mix_q_src_c084_3_01 mix_q_c084_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_02 (mix_i_src_c084_3_02 0 bpf_c084_3 0) vcvs gain=5.555702330196e-01
SMIXI_c084_3_02 (mix_i_src_c084_3_02 mix_i_c084_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_02 (mix_q_src_c084_3_02 0 bpf_c084_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_3_02 (mix_q_src_c084_3_02 mix_q_c084_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_03 (mix_i_src_c084_3_03 0 bpf_c084_3 0) vcvs gain=1.950903220161e-01
SMIXI_c084_3_03 (mix_i_src_c084_3_03 mix_i_c084_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_03 (mix_q_src_c084_3_03 0 bpf_c084_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_3_03 (mix_q_src_c084_3_03 mix_q_c084_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_04 (mix_i_src_c084_3_04 0 bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_3_04 (mix_i_src_c084_3_04 mix_i_c084_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_04 (mix_q_src_c084_3_04 0 bpf_c084_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c084_3_04 (mix_q_src_c084_3_04 mix_q_c084_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_05 (mix_i_src_c084_3_05 0 bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_3_05 (mix_i_src_c084_3_05 mix_i_c084_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_05 (mix_q_src_c084_3_05 0 bpf_c084_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c084_3_05 (mix_q_src_c084_3_05 mix_q_c084_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_06 (mix_i_src_c084_3_06 0 bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_3_06 (mix_i_src_c084_3_06 mix_i_c084_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_06 (mix_q_src_c084_3_06 0 bpf_c084_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c084_3_06 (mix_q_src_c084_3_06 mix_q_c084_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_07 (mix_i_src_c084_3_07 0 bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_3_07 (mix_i_src_c084_3_07 mix_i_c084_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_07 (mix_q_src_c084_3_07 0 bpf_c084_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c084_3_07 (mix_q_src_c084_3_07 mix_q_c084_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_08 (mix_i_src_c084_3_08 0 bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c084_3_08 (mix_i_src_c084_3_08 mix_i_c084_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_08 (mix_q_src_c084_3_08 0 bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_3_08 (mix_q_src_c084_3_08 mix_q_c084_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_09 (mix_i_src_c084_3_09 0 bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c084_3_09 (mix_i_src_c084_3_09 mix_i_c084_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_09 (mix_q_src_c084_3_09 0 bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_3_09 (mix_q_src_c084_3_09 mix_q_c084_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_10 (mix_i_src_c084_3_10 0 bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c084_3_10 (mix_i_src_c084_3_10 mix_i_c084_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_10 (mix_q_src_c084_3_10 0 bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_3_10 (mix_q_src_c084_3_10 mix_q_c084_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_11 (mix_i_src_c084_3_11 0 bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c084_3_11 (mix_i_src_c084_3_11 mix_i_c084_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_11 (mix_q_src_c084_3_11 0 bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_3_11 (mix_q_src_c084_3_11 mix_q_c084_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_12 (mix_i_src_c084_3_12 0 bpf_c084_3 0) vcvs gain=1.950903220161e-01
SMIXI_c084_3_12 (mix_i_src_c084_3_12 mix_i_c084_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_12 (mix_q_src_c084_3_12 0 bpf_c084_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c084_3_12 (mix_q_src_c084_3_12 mix_q_c084_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_13 (mix_i_src_c084_3_13 0 bpf_c084_3 0) vcvs gain=5.555702330196e-01
SMIXI_c084_3_13 (mix_i_src_c084_3_13 mix_i_c084_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_13 (mix_q_src_c084_3_13 0 bpf_c084_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c084_3_13 (mix_q_src_c084_3_13 mix_q_c084_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_14 (mix_i_src_c084_3_14 0 bpf_c084_3 0) vcvs gain=8.314696123025e-01
SMIXI_c084_3_14 (mix_i_src_c084_3_14 mix_i_c084_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_14 (mix_q_src_c084_3_14 0 bpf_c084_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c084_3_14 (mix_q_src_c084_3_14 mix_q_c084_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c084_3_15 (mix_i_src_c084_3_15 0 bpf_c084_3 0) vcvs gain=9.807852804032e-01
SMIXI_c084_3_15 (mix_i_src_c084_3_15 mix_i_c084_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c084_3_15 (mix_q_src_c084_3_15 0 bpf_c084_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c084_3_15 (mix_q_src_c084_3_15 mix_q_c084_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c084_3 (mix_i_c084_3 0) resistor r=1G
RMIXQ_c084_3 (mix_q_c084_3 0) resistor r=1G
RINTI_c084_3 (mix_i_c084_3 Icar_c084_3) resistor r=1k
CINTI_c084_3 (Icar_c084_3 0) capacitor c=80p
RINTQ_c084_3 (mix_q_c084_3 Qcar_c084_3) resistor r=1k
CINTQ_c084_3 (Qcar_c084_3 0) capacitor c=80p

// bl085, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c085_0 (bl085 n_cbpf_c085_0) capacitor c=4.052847345694e-13
LBPF_c085_0 (n_cbpf_c085_0 bpf_c085_0) inductor l=1.000000000000e-06
RBPF_c085_0 (bpf_c085_0 0) resistor r=7.853981633974e+01
EMIXI_c085_0_00 (mix_i_src_c085_0_00 0 bpf_c085_0 0) vcvs gain=9.807852804032e-01
SMIXI_c085_0_00 (mix_i_src_c085_0_00 mix_i_c085_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_00 (mix_q_src_c085_0_00 0 bpf_c085_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_0_00 (mix_q_src_c085_0_00 mix_q_c085_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_01 (mix_i_src_c085_0_01 0 bpf_c085_0 0) vcvs gain=8.314696123025e-01
SMIXI_c085_0_01 (mix_i_src_c085_0_01 mix_i_c085_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_01 (mix_q_src_c085_0_01 0 bpf_c085_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_0_01 (mix_q_src_c085_0_01 mix_q_c085_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_02 (mix_i_src_c085_0_02 0 bpf_c085_0 0) vcvs gain=5.555702330196e-01
SMIXI_c085_0_02 (mix_i_src_c085_0_02 mix_i_c085_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_02 (mix_q_src_c085_0_02 0 bpf_c085_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_0_02 (mix_q_src_c085_0_02 mix_q_c085_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_03 (mix_i_src_c085_0_03 0 bpf_c085_0 0) vcvs gain=1.950903220161e-01
SMIXI_c085_0_03 (mix_i_src_c085_0_03 mix_i_c085_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_03 (mix_q_src_c085_0_03 0 bpf_c085_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_0_03 (mix_q_src_c085_0_03 mix_q_c085_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_04 (mix_i_src_c085_0_04 0 bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_0_04 (mix_i_src_c085_0_04 mix_i_c085_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_04 (mix_q_src_c085_0_04 0 bpf_c085_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c085_0_04 (mix_q_src_c085_0_04 mix_q_c085_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_05 (mix_i_src_c085_0_05 0 bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_0_05 (mix_i_src_c085_0_05 mix_i_c085_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_05 (mix_q_src_c085_0_05 0 bpf_c085_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c085_0_05 (mix_q_src_c085_0_05 mix_q_c085_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_06 (mix_i_src_c085_0_06 0 bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_0_06 (mix_i_src_c085_0_06 mix_i_c085_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_06 (mix_q_src_c085_0_06 0 bpf_c085_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c085_0_06 (mix_q_src_c085_0_06 mix_q_c085_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_07 (mix_i_src_c085_0_07 0 bpf_c085_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_0_07 (mix_i_src_c085_0_07 mix_i_c085_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_07 (mix_q_src_c085_0_07 0 bpf_c085_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c085_0_07 (mix_q_src_c085_0_07 mix_q_c085_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_08 (mix_i_src_c085_0_08 0 bpf_c085_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c085_0_08 (mix_i_src_c085_0_08 mix_i_c085_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_08 (mix_q_src_c085_0_08 0 bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c085_0_08 (mix_q_src_c085_0_08 mix_q_c085_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_09 (mix_i_src_c085_0_09 0 bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c085_0_09 (mix_i_src_c085_0_09 mix_i_c085_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_09 (mix_q_src_c085_0_09 0 bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c085_0_09 (mix_q_src_c085_0_09 mix_q_c085_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_10 (mix_i_src_c085_0_10 0 bpf_c085_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c085_0_10 (mix_i_src_c085_0_10 mix_i_c085_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_10 (mix_q_src_c085_0_10 0 bpf_c085_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c085_0_10 (mix_q_src_c085_0_10 mix_q_c085_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_11 (mix_i_src_c085_0_11 0 bpf_c085_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c085_0_11 (mix_i_src_c085_0_11 mix_i_c085_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_11 (mix_q_src_c085_0_11 0 bpf_c085_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c085_0_11 (mix_q_src_c085_0_11 mix_q_c085_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c085_0_12 (mix_i_src_c085_0_12 0 bpf_c085_0 0) vcvs gain=1.950903220161e-01
SMIXI_c085_0_12 (mix_i_src_c085_0_12 mix_i_c085_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c085_0_12 (mix_q_src_c085_0_12 0 bpf_c085_0 0) vcvs gain=-9.807852804032e-01
