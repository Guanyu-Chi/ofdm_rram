SMIXI_c042_1_10 (mix_i_src_c042_1_10 mix_i_c042_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_10 (mix_q_src_c042_1_10 0 bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_1_10 (mix_q_src_c042_1_10 mix_q_c042_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_11 (mix_i_src_c042_1_11 0 bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_1_11 (mix_i_src_c042_1_11 mix_i_c042_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_11 (mix_q_src_c042_1_11 0 bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_1_11 (mix_q_src_c042_1_11 mix_q_c042_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_12 (mix_i_src_c042_1_12 0 bpf_c042_1 0) vcvs gain=1.950903220161e-01
SMIXI_c042_1_12 (mix_i_src_c042_1_12 mix_i_c042_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_12 (mix_q_src_c042_1_12 0 bpf_c042_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_1_12 (mix_q_src_c042_1_12 mix_q_c042_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_13 (mix_i_src_c042_1_13 0 bpf_c042_1 0) vcvs gain=5.555702330196e-01
SMIXI_c042_1_13 (mix_i_src_c042_1_13 mix_i_c042_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_13 (mix_q_src_c042_1_13 0 bpf_c042_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_1_13 (mix_q_src_c042_1_13 mix_q_c042_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_14 (mix_i_src_c042_1_14 0 bpf_c042_1 0) vcvs gain=8.314696123025e-01
SMIXI_c042_1_14 (mix_i_src_c042_1_14 mix_i_c042_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_14 (mix_q_src_c042_1_14 0 bpf_c042_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_1_14 (mix_q_src_c042_1_14 mix_q_c042_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_1_15 (mix_i_src_c042_1_15 0 bpf_c042_1 0) vcvs gain=9.807852804032e-01
SMIXI_c042_1_15 (mix_i_src_c042_1_15 mix_i_c042_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_1_15 (mix_q_src_c042_1_15 0 bpf_c042_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_1_15 (mix_q_src_c042_1_15 mix_q_c042_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c042_1 (mix_i_c042_1 0) resistor r=1G
RMIXQ_c042_1 (mix_q_c042_1 0) resistor r=1G
RINTI_c042_1 (mix_i_c042_1 Icar_c042_1) resistor r=1k
CINTI_c042_1 (Icar_c042_1 0) capacitor c=80p
RINTQ_c042_1 (mix_q_c042_1 Qcar_c042_1) resistor r=1k
CINTQ_c042_1 (Qcar_c042_1 0) capacitor c=80p

// bl042, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c042_2 (bl042 n_cbpf_c042_2) capacitor c=4.503163717437e-14
LBPF_c042_2 (n_cbpf_c042_2 bpf_c042_2) inductor l=1.000000000000e-06
RBPF_c042_2 (bpf_c042_2 0) resistor r=2.356194490192e+02
EMIXI_c042_2_00 (mix_i_src_c042_2_00 0 bpf_c042_2 0) vcvs gain=9.807852804032e-01
SMIXI_c042_2_00 (mix_i_src_c042_2_00 mix_i_c042_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_00 (mix_q_src_c042_2_00 0 bpf_c042_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_2_00 (mix_q_src_c042_2_00 mix_q_c042_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_01 (mix_i_src_c042_2_01 0 bpf_c042_2 0) vcvs gain=8.314696123025e-01
SMIXI_c042_2_01 (mix_i_src_c042_2_01 mix_i_c042_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_01 (mix_q_src_c042_2_01 0 bpf_c042_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_2_01 (mix_q_src_c042_2_01 mix_q_c042_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_02 (mix_i_src_c042_2_02 0 bpf_c042_2 0) vcvs gain=5.555702330196e-01
SMIXI_c042_2_02 (mix_i_src_c042_2_02 mix_i_c042_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_02 (mix_q_src_c042_2_02 0 bpf_c042_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_2_02 (mix_q_src_c042_2_02 mix_q_c042_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_03 (mix_i_src_c042_2_03 0 bpf_c042_2 0) vcvs gain=1.950903220161e-01
SMIXI_c042_2_03 (mix_i_src_c042_2_03 mix_i_c042_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_03 (mix_q_src_c042_2_03 0 bpf_c042_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_2_03 (mix_q_src_c042_2_03 mix_q_c042_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_04 (mix_i_src_c042_2_04 0 bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_2_04 (mix_i_src_c042_2_04 mix_i_c042_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_04 (mix_q_src_c042_2_04 0 bpf_c042_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_2_04 (mix_q_src_c042_2_04 mix_q_c042_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_05 (mix_i_src_c042_2_05 0 bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c042_2_05 (mix_i_src_c042_2_05 mix_i_c042_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_05 (mix_q_src_c042_2_05 0 bpf_c042_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_2_05 (mix_q_src_c042_2_05 mix_q_c042_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_06 (mix_i_src_c042_2_06 0 bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_2_06 (mix_i_src_c042_2_06 mix_i_c042_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_06 (mix_q_src_c042_2_06 0 bpf_c042_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_2_06 (mix_q_src_c042_2_06 mix_q_c042_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_07 (mix_i_src_c042_2_07 0 bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_2_07 (mix_i_src_c042_2_07 mix_i_c042_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_07 (mix_q_src_c042_2_07 0 bpf_c042_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_2_07 (mix_q_src_c042_2_07 mix_q_c042_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_08 (mix_i_src_c042_2_08 0 bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_2_08 (mix_i_src_c042_2_08 mix_i_c042_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_08 (mix_q_src_c042_2_08 0 bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_2_08 (mix_q_src_c042_2_08 mix_q_c042_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_09 (mix_i_src_c042_2_09 0 bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_2_09 (mix_i_src_c042_2_09 mix_i_c042_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_09 (mix_q_src_c042_2_09 0 bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_2_09 (mix_q_src_c042_2_09 mix_q_c042_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_10 (mix_i_src_c042_2_10 0 bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c042_2_10 (mix_i_src_c042_2_10 mix_i_c042_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_10 (mix_q_src_c042_2_10 0 bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_2_10 (mix_q_src_c042_2_10 mix_q_c042_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_11 (mix_i_src_c042_2_11 0 bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_2_11 (mix_i_src_c042_2_11 mix_i_c042_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_11 (mix_q_src_c042_2_11 0 bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_2_11 (mix_q_src_c042_2_11 mix_q_c042_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_12 (mix_i_src_c042_2_12 0 bpf_c042_2 0) vcvs gain=1.950903220161e-01
SMIXI_c042_2_12 (mix_i_src_c042_2_12 mix_i_c042_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_12 (mix_q_src_c042_2_12 0 bpf_c042_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_2_12 (mix_q_src_c042_2_12 mix_q_c042_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_13 (mix_i_src_c042_2_13 0 bpf_c042_2 0) vcvs gain=5.555702330196e-01
SMIXI_c042_2_13 (mix_i_src_c042_2_13 mix_i_c042_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_13 (mix_q_src_c042_2_13 0 bpf_c042_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_2_13 (mix_q_src_c042_2_13 mix_q_c042_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_14 (mix_i_src_c042_2_14 0 bpf_c042_2 0) vcvs gain=8.314696123025e-01
SMIXI_c042_2_14 (mix_i_src_c042_2_14 mix_i_c042_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_14 (mix_q_src_c042_2_14 0 bpf_c042_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_2_14 (mix_q_src_c042_2_14 mix_q_c042_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_2_15 (mix_i_src_c042_2_15 0 bpf_c042_2 0) vcvs gain=9.807852804032e-01
SMIXI_c042_2_15 (mix_i_src_c042_2_15 mix_i_c042_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_2_15 (mix_q_src_c042_2_15 0 bpf_c042_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_2_15 (mix_q_src_c042_2_15 mix_q_c042_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c042_2 (mix_i_c042_2 0) resistor r=1G
RMIXQ_c042_2 (mix_q_c042_2 0) resistor r=1G
RINTI_c042_2 (mix_i_c042_2 Icar_c042_2) resistor r=1k
CINTI_c042_2 (Icar_c042_2 0) capacitor c=80p
RINTQ_c042_2 (mix_q_c042_2 Qcar_c042_2) resistor r=1k
CINTQ_c042_2 (Qcar_c042_2 0) capacitor c=80p

// bl042, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c042_3 (bl042 n_cbpf_c042_3) capacitor c=2.533029591058e-14
LBPF_c042_3 (n_cbpf_c042_3 bpf_c042_3) inductor l=1.000000000000e-06
RBPF_c042_3 (bpf_c042_3 0) resistor r=3.141592653590e+02
EMIXI_c042_3_00 (mix_i_src_c042_3_00 0 bpf_c042_3 0) vcvs gain=9.807852804032e-01
SMIXI_c042_3_00 (mix_i_src_c042_3_00 mix_i_c042_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_00 (mix_q_src_c042_3_00 0 bpf_c042_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_3_00 (mix_q_src_c042_3_00 mix_q_c042_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_01 (mix_i_src_c042_3_01 0 bpf_c042_3 0) vcvs gain=8.314696123025e-01
SMIXI_c042_3_01 (mix_i_src_c042_3_01 mix_i_c042_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_01 (mix_q_src_c042_3_01 0 bpf_c042_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_3_01 (mix_q_src_c042_3_01 mix_q_c042_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_02 (mix_i_src_c042_3_02 0 bpf_c042_3 0) vcvs gain=5.555702330196e-01
SMIXI_c042_3_02 (mix_i_src_c042_3_02 mix_i_c042_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_02 (mix_q_src_c042_3_02 0 bpf_c042_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_3_02 (mix_q_src_c042_3_02 mix_q_c042_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_03 (mix_i_src_c042_3_03 0 bpf_c042_3 0) vcvs gain=1.950903220161e-01
SMIXI_c042_3_03 (mix_i_src_c042_3_03 mix_i_c042_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_03 (mix_q_src_c042_3_03 0 bpf_c042_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_3_03 (mix_q_src_c042_3_03 mix_q_c042_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_04 (mix_i_src_c042_3_04 0 bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_3_04 (mix_i_src_c042_3_04 mix_i_c042_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_04 (mix_q_src_c042_3_04 0 bpf_c042_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c042_3_04 (mix_q_src_c042_3_04 mix_q_c042_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_05 (mix_i_src_c042_3_05 0 bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c042_3_05 (mix_i_src_c042_3_05 mix_i_c042_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_05 (mix_q_src_c042_3_05 0 bpf_c042_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c042_3_05 (mix_q_src_c042_3_05 mix_q_c042_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_06 (mix_i_src_c042_3_06 0 bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_3_06 (mix_i_src_c042_3_06 mix_i_c042_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_06 (mix_q_src_c042_3_06 0 bpf_c042_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c042_3_06 (mix_q_src_c042_3_06 mix_q_c042_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_07 (mix_i_src_c042_3_07 0 bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_3_07 (mix_i_src_c042_3_07 mix_i_c042_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_07 (mix_q_src_c042_3_07 0 bpf_c042_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c042_3_07 (mix_q_src_c042_3_07 mix_q_c042_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_08 (mix_i_src_c042_3_08 0 bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c042_3_08 (mix_i_src_c042_3_08 mix_i_c042_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_08 (mix_q_src_c042_3_08 0 bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_3_08 (mix_q_src_c042_3_08 mix_q_c042_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_09 (mix_i_src_c042_3_09 0 bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c042_3_09 (mix_i_src_c042_3_09 mix_i_c042_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_09 (mix_q_src_c042_3_09 0 bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_3_09 (mix_q_src_c042_3_09 mix_q_c042_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_10 (mix_i_src_c042_3_10 0 bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c042_3_10 (mix_i_src_c042_3_10 mix_i_c042_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_10 (mix_q_src_c042_3_10 0 bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_3_10 (mix_q_src_c042_3_10 mix_q_c042_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_11 (mix_i_src_c042_3_11 0 bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c042_3_11 (mix_i_src_c042_3_11 mix_i_c042_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_11 (mix_q_src_c042_3_11 0 bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_3_11 (mix_q_src_c042_3_11 mix_q_c042_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_12 (mix_i_src_c042_3_12 0 bpf_c042_3 0) vcvs gain=1.950903220161e-01
SMIXI_c042_3_12 (mix_i_src_c042_3_12 mix_i_c042_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_12 (mix_q_src_c042_3_12 0 bpf_c042_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c042_3_12 (mix_q_src_c042_3_12 mix_q_c042_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_13 (mix_i_src_c042_3_13 0 bpf_c042_3 0) vcvs gain=5.555702330196e-01
SMIXI_c042_3_13 (mix_i_src_c042_3_13 mix_i_c042_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_13 (mix_q_src_c042_3_13 0 bpf_c042_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c042_3_13 (mix_q_src_c042_3_13 mix_q_c042_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_14 (mix_i_src_c042_3_14 0 bpf_c042_3 0) vcvs gain=8.314696123025e-01
SMIXI_c042_3_14 (mix_i_src_c042_3_14 mix_i_c042_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_14 (mix_q_src_c042_3_14 0 bpf_c042_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c042_3_14 (mix_q_src_c042_3_14 mix_q_c042_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c042_3_15 (mix_i_src_c042_3_15 0 bpf_c042_3 0) vcvs gain=9.807852804032e-01
SMIXI_c042_3_15 (mix_i_src_c042_3_15 mix_i_c042_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c042_3_15 (mix_q_src_c042_3_15 0 bpf_c042_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c042_3_15 (mix_q_src_c042_3_15 mix_q_c042_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c042_3 (mix_i_c042_3 0) resistor r=1G
RMIXQ_c042_3 (mix_q_c042_3 0) resistor r=1G
RINTI_c042_3 (mix_i_c042_3 Icar_c042_3) resistor r=1k
CINTI_c042_3 (Icar_c042_3 0) capacitor c=80p
RINTQ_c042_3 (mix_q_c042_3 Qcar_c042_3) resistor r=1k
CINTQ_c042_3 (Qcar_c042_3 0) capacitor c=80p

// bl043, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c043_0 (bl043 n_cbpf_c043_0) capacitor c=4.052847345694e-13
LBPF_c043_0 (n_cbpf_c043_0 bpf_c043_0) inductor l=1.000000000000e-06
RBPF_c043_0 (bpf_c043_0 0) resistor r=7.853981633974e+01
EMIXI_c043_0_00 (mix_i_src_c043_0_00 0 bpf_c043_0 0) vcvs gain=9.807852804032e-01
SMIXI_c043_0_00 (mix_i_src_c043_0_00 mix_i_c043_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_00 (mix_q_src_c043_0_00 0 bpf_c043_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_0_00 (mix_q_src_c043_0_00 mix_q_c043_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_01 (mix_i_src_c043_0_01 0 bpf_c043_0 0) vcvs gain=8.314696123025e-01
SMIXI_c043_0_01 (mix_i_src_c043_0_01 mix_i_c043_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_01 (mix_q_src_c043_0_01 0 bpf_c043_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_0_01 (mix_q_src_c043_0_01 mix_q_c043_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_02 (mix_i_src_c043_0_02 0 bpf_c043_0 0) vcvs gain=5.555702330196e-01
SMIXI_c043_0_02 (mix_i_src_c043_0_02 mix_i_c043_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_02 (mix_q_src_c043_0_02 0 bpf_c043_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_0_02 (mix_q_src_c043_0_02 mix_q_c043_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_03 (mix_i_src_c043_0_03 0 bpf_c043_0 0) vcvs gain=1.950903220161e-01
SMIXI_c043_0_03 (mix_i_src_c043_0_03 mix_i_c043_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_03 (mix_q_src_c043_0_03 0 bpf_c043_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_0_03 (mix_q_src_c043_0_03 mix_q_c043_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_04 (mix_i_src_c043_0_04 0 bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_0_04 (mix_i_src_c043_0_04 mix_i_c043_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_04 (mix_q_src_c043_0_04 0 bpf_c043_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_0_04 (mix_q_src_c043_0_04 mix_q_c043_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_05 (mix_i_src_c043_0_05 0 bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_0_05 (mix_i_src_c043_0_05 mix_i_c043_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_05 (mix_q_src_c043_0_05 0 bpf_c043_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_0_05 (mix_q_src_c043_0_05 mix_q_c043_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_06 (mix_i_src_c043_0_06 0 bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_0_06 (mix_i_src_c043_0_06 mix_i_c043_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_06 (mix_q_src_c043_0_06 0 bpf_c043_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_0_06 (mix_q_src_c043_0_06 mix_q_c043_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_07 (mix_i_src_c043_0_07 0 bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_0_07 (mix_i_src_c043_0_07 mix_i_c043_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_07 (mix_q_src_c043_0_07 0 bpf_c043_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_0_07 (mix_q_src_c043_0_07 mix_q_c043_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_08 (mix_i_src_c043_0_08 0 bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_0_08 (mix_i_src_c043_0_08 mix_i_c043_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_08 (mix_q_src_c043_0_08 0 bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_0_08 (mix_q_src_c043_0_08 mix_q_c043_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_09 (mix_i_src_c043_0_09 0 bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_0_09 (mix_i_src_c043_0_09 mix_i_c043_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_09 (mix_q_src_c043_0_09 0 bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_0_09 (mix_q_src_c043_0_09 mix_q_c043_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_10 (mix_i_src_c043_0_10 0 bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_0_10 (mix_i_src_c043_0_10 mix_i_c043_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_10 (mix_q_src_c043_0_10 0 bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_0_10 (mix_q_src_c043_0_10 mix_q_c043_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_11 (mix_i_src_c043_0_11 0 bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_0_11 (mix_i_src_c043_0_11 mix_i_c043_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_11 (mix_q_src_c043_0_11 0 bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_0_11 (mix_q_src_c043_0_11 mix_q_c043_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_12 (mix_i_src_c043_0_12 0 bpf_c043_0 0) vcvs gain=1.950903220161e-01
SMIXI_c043_0_12 (mix_i_src_c043_0_12 mix_i_c043_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_12 (mix_q_src_c043_0_12 0 bpf_c043_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_0_12 (mix_q_src_c043_0_12 mix_q_c043_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_13 (mix_i_src_c043_0_13 0 bpf_c043_0 0) vcvs gain=5.555702330196e-01
SMIXI_c043_0_13 (mix_i_src_c043_0_13 mix_i_c043_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_13 (mix_q_src_c043_0_13 0 bpf_c043_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_0_13 (mix_q_src_c043_0_13 mix_q_c043_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_14 (mix_i_src_c043_0_14 0 bpf_c043_0 0) vcvs gain=8.314696123025e-01
SMIXI_c043_0_14 (mix_i_src_c043_0_14 mix_i_c043_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_14 (mix_q_src_c043_0_14 0 bpf_c043_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_0_14 (mix_q_src_c043_0_14 mix_q_c043_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_0_15 (mix_i_src_c043_0_15 0 bpf_c043_0 0) vcvs gain=9.807852804032e-01
SMIXI_c043_0_15 (mix_i_src_c043_0_15 mix_i_c043_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_0_15 (mix_q_src_c043_0_15 0 bpf_c043_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_0_15 (mix_q_src_c043_0_15 mix_q_c043_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c043_0 (mix_i_c043_0 0) resistor r=1G
RMIXQ_c043_0 (mix_q_c043_0 0) resistor r=1G
RINTI_c043_0 (mix_i_c043_0 Icar_c043_0) resistor r=1k
CINTI_c043_0 (Icar_c043_0 0) capacitor c=80p
RINTQ_c043_0 (mix_q_c043_0 Qcar_c043_0) resistor r=1k
CINTQ_c043_0 (Qcar_c043_0 0) capacitor c=80p

// bl043, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c043_1 (bl043 n_cbpf_c043_1) capacitor c=1.013211836423e-13
LBPF_c043_1 (n_cbpf_c043_1 bpf_c043_1) inductor l=1.000000000000e-06
RBPF_c043_1 (bpf_c043_1 0) resistor r=1.570796326795e+02
EMIXI_c043_1_00 (mix_i_src_c043_1_00 0 bpf_c043_1 0) vcvs gain=9.807852804032e-01
SMIXI_c043_1_00 (mix_i_src_c043_1_00 mix_i_c043_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_00 (mix_q_src_c043_1_00 0 bpf_c043_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_1_00 (mix_q_src_c043_1_00 mix_q_c043_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_01 (mix_i_src_c043_1_01 0 bpf_c043_1 0) vcvs gain=8.314696123025e-01
SMIXI_c043_1_01 (mix_i_src_c043_1_01 mix_i_c043_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_01 (mix_q_src_c043_1_01 0 bpf_c043_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_1_01 (mix_q_src_c043_1_01 mix_q_c043_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_02 (mix_i_src_c043_1_02 0 bpf_c043_1 0) vcvs gain=5.555702330196e-01
SMIXI_c043_1_02 (mix_i_src_c043_1_02 mix_i_c043_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_02 (mix_q_src_c043_1_02 0 bpf_c043_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_1_02 (mix_q_src_c043_1_02 mix_q_c043_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_03 (mix_i_src_c043_1_03 0 bpf_c043_1 0) vcvs gain=1.950903220161e-01
SMIXI_c043_1_03 (mix_i_src_c043_1_03 mix_i_c043_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_03 (mix_q_src_c043_1_03 0 bpf_c043_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_1_03 (mix_q_src_c043_1_03 mix_q_c043_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_04 (mix_i_src_c043_1_04 0 bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_1_04 (mix_i_src_c043_1_04 mix_i_c043_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_04 (mix_q_src_c043_1_04 0 bpf_c043_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_1_04 (mix_q_src_c043_1_04 mix_q_c043_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_05 (mix_i_src_c043_1_05 0 bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_1_05 (mix_i_src_c043_1_05 mix_i_c043_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_05 (mix_q_src_c043_1_05 0 bpf_c043_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_1_05 (mix_q_src_c043_1_05 mix_q_c043_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_06 (mix_i_src_c043_1_06 0 bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_1_06 (mix_i_src_c043_1_06 mix_i_c043_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_06 (mix_q_src_c043_1_06 0 bpf_c043_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_1_06 (mix_q_src_c043_1_06 mix_q_c043_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_07 (mix_i_src_c043_1_07 0 bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_1_07 (mix_i_src_c043_1_07 mix_i_c043_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_07 (mix_q_src_c043_1_07 0 bpf_c043_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_1_07 (mix_q_src_c043_1_07 mix_q_c043_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_08 (mix_i_src_c043_1_08 0 bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_1_08 (mix_i_src_c043_1_08 mix_i_c043_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_08 (mix_q_src_c043_1_08 0 bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_1_08 (mix_q_src_c043_1_08 mix_q_c043_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_09 (mix_i_src_c043_1_09 0 bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_1_09 (mix_i_src_c043_1_09 mix_i_c043_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_09 (mix_q_src_c043_1_09 0 bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_1_09 (mix_q_src_c043_1_09 mix_q_c043_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_10 (mix_i_src_c043_1_10 0 bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_1_10 (mix_i_src_c043_1_10 mix_i_c043_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_10 (mix_q_src_c043_1_10 0 bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_1_10 (mix_q_src_c043_1_10 mix_q_c043_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_11 (mix_i_src_c043_1_11 0 bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_1_11 (mix_i_src_c043_1_11 mix_i_c043_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_11 (mix_q_src_c043_1_11 0 bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_1_11 (mix_q_src_c043_1_11 mix_q_c043_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_12 (mix_i_src_c043_1_12 0 bpf_c043_1 0) vcvs gain=1.950903220161e-01
SMIXI_c043_1_12 (mix_i_src_c043_1_12 mix_i_c043_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_12 (mix_q_src_c043_1_12 0 bpf_c043_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_1_12 (mix_q_src_c043_1_12 mix_q_c043_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_13 (mix_i_src_c043_1_13 0 bpf_c043_1 0) vcvs gain=5.555702330196e-01
SMIXI_c043_1_13 (mix_i_src_c043_1_13 mix_i_c043_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_13 (mix_q_src_c043_1_13 0 bpf_c043_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_1_13 (mix_q_src_c043_1_13 mix_q_c043_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_14 (mix_i_src_c043_1_14 0 bpf_c043_1 0) vcvs gain=8.314696123025e-01
SMIXI_c043_1_14 (mix_i_src_c043_1_14 mix_i_c043_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_14 (mix_q_src_c043_1_14 0 bpf_c043_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_1_14 (mix_q_src_c043_1_14 mix_q_c043_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_1_15 (mix_i_src_c043_1_15 0 bpf_c043_1 0) vcvs gain=9.807852804032e-01
SMIXI_c043_1_15 (mix_i_src_c043_1_15 mix_i_c043_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_1_15 (mix_q_src_c043_1_15 0 bpf_c043_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_1_15 (mix_q_src_c043_1_15 mix_q_c043_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c043_1 (mix_i_c043_1 0) resistor r=1G
RMIXQ_c043_1 (mix_q_c043_1 0) resistor r=1G
RINTI_c043_1 (mix_i_c043_1 Icar_c043_1) resistor r=1k
CINTI_c043_1 (Icar_c043_1 0) capacitor c=80p
RINTQ_c043_1 (mix_q_c043_1 Qcar_c043_1) resistor r=1k
CINTQ_c043_1 (Qcar_c043_1 0) capacitor c=80p

// bl043, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c043_2 (bl043 n_cbpf_c043_2) capacitor c=4.503163717437e-14
LBPF_c043_2 (n_cbpf_c043_2 bpf_c043_2) inductor l=1.000000000000e-06
RBPF_c043_2 (bpf_c043_2 0) resistor r=2.356194490192e+02
EMIXI_c043_2_00 (mix_i_src_c043_2_00 0 bpf_c043_2 0) vcvs gain=9.807852804032e-01
SMIXI_c043_2_00 (mix_i_src_c043_2_00 mix_i_c043_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_00 (mix_q_src_c043_2_00 0 bpf_c043_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_2_00 (mix_q_src_c043_2_00 mix_q_c043_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_01 (mix_i_src_c043_2_01 0 bpf_c043_2 0) vcvs gain=8.314696123025e-01
SMIXI_c043_2_01 (mix_i_src_c043_2_01 mix_i_c043_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_01 (mix_q_src_c043_2_01 0 bpf_c043_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_2_01 (mix_q_src_c043_2_01 mix_q_c043_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_02 (mix_i_src_c043_2_02 0 bpf_c043_2 0) vcvs gain=5.555702330196e-01
SMIXI_c043_2_02 (mix_i_src_c043_2_02 mix_i_c043_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_02 (mix_q_src_c043_2_02 0 bpf_c043_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_2_02 (mix_q_src_c043_2_02 mix_q_c043_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_03 (mix_i_src_c043_2_03 0 bpf_c043_2 0) vcvs gain=1.950903220161e-01
SMIXI_c043_2_03 (mix_i_src_c043_2_03 mix_i_c043_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_03 (mix_q_src_c043_2_03 0 bpf_c043_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_2_03 (mix_q_src_c043_2_03 mix_q_c043_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_04 (mix_i_src_c043_2_04 0 bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_2_04 (mix_i_src_c043_2_04 mix_i_c043_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_04 (mix_q_src_c043_2_04 0 bpf_c043_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_2_04 (mix_q_src_c043_2_04 mix_q_c043_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_05 (mix_i_src_c043_2_05 0 bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_2_05 (mix_i_src_c043_2_05 mix_i_c043_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_05 (mix_q_src_c043_2_05 0 bpf_c043_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_2_05 (mix_q_src_c043_2_05 mix_q_c043_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_06 (mix_i_src_c043_2_06 0 bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_2_06 (mix_i_src_c043_2_06 mix_i_c043_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_06 (mix_q_src_c043_2_06 0 bpf_c043_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_2_06 (mix_q_src_c043_2_06 mix_q_c043_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_07 (mix_i_src_c043_2_07 0 bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_2_07 (mix_i_src_c043_2_07 mix_i_c043_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_07 (mix_q_src_c043_2_07 0 bpf_c043_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_2_07 (mix_q_src_c043_2_07 mix_q_c043_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_08 (mix_i_src_c043_2_08 0 bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_2_08 (mix_i_src_c043_2_08 mix_i_c043_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_08 (mix_q_src_c043_2_08 0 bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_2_08 (mix_q_src_c043_2_08 mix_q_c043_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_09 (mix_i_src_c043_2_09 0 bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_2_09 (mix_i_src_c043_2_09 mix_i_c043_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_09 (mix_q_src_c043_2_09 0 bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_2_09 (mix_q_src_c043_2_09 mix_q_c043_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_10 (mix_i_src_c043_2_10 0 bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_2_10 (mix_i_src_c043_2_10 mix_i_c043_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_10 (mix_q_src_c043_2_10 0 bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_2_10 (mix_q_src_c043_2_10 mix_q_c043_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_11 (mix_i_src_c043_2_11 0 bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_2_11 (mix_i_src_c043_2_11 mix_i_c043_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_11 (mix_q_src_c043_2_11 0 bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_2_11 (mix_q_src_c043_2_11 mix_q_c043_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_12 (mix_i_src_c043_2_12 0 bpf_c043_2 0) vcvs gain=1.950903220161e-01
SMIXI_c043_2_12 (mix_i_src_c043_2_12 mix_i_c043_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_12 (mix_q_src_c043_2_12 0 bpf_c043_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_2_12 (mix_q_src_c043_2_12 mix_q_c043_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_13 (mix_i_src_c043_2_13 0 bpf_c043_2 0) vcvs gain=5.555702330196e-01
SMIXI_c043_2_13 (mix_i_src_c043_2_13 mix_i_c043_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_13 (mix_q_src_c043_2_13 0 bpf_c043_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_2_13 (mix_q_src_c043_2_13 mix_q_c043_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_14 (mix_i_src_c043_2_14 0 bpf_c043_2 0) vcvs gain=8.314696123025e-01
SMIXI_c043_2_14 (mix_i_src_c043_2_14 mix_i_c043_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_14 (mix_q_src_c043_2_14 0 bpf_c043_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_2_14 (mix_q_src_c043_2_14 mix_q_c043_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_2_15 (mix_i_src_c043_2_15 0 bpf_c043_2 0) vcvs gain=9.807852804032e-01
SMIXI_c043_2_15 (mix_i_src_c043_2_15 mix_i_c043_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_2_15 (mix_q_src_c043_2_15 0 bpf_c043_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_2_15 (mix_q_src_c043_2_15 mix_q_c043_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c043_2 (mix_i_c043_2 0) resistor r=1G
RMIXQ_c043_2 (mix_q_c043_2 0) resistor r=1G
RINTI_c043_2 (mix_i_c043_2 Icar_c043_2) resistor r=1k
CINTI_c043_2 (Icar_c043_2 0) capacitor c=80p
RINTQ_c043_2 (mix_q_c043_2 Qcar_c043_2) resistor r=1k
CINTQ_c043_2 (Qcar_c043_2 0) capacitor c=80p

// bl043, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c043_3 (bl043 n_cbpf_c043_3) capacitor c=2.533029591058e-14
LBPF_c043_3 (n_cbpf_c043_3 bpf_c043_3) inductor l=1.000000000000e-06
RBPF_c043_3 (bpf_c043_3 0) resistor r=3.141592653590e+02
EMIXI_c043_3_00 (mix_i_src_c043_3_00 0 bpf_c043_3 0) vcvs gain=9.807852804032e-01
SMIXI_c043_3_00 (mix_i_src_c043_3_00 mix_i_c043_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_00 (mix_q_src_c043_3_00 0 bpf_c043_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_3_00 (mix_q_src_c043_3_00 mix_q_c043_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_01 (mix_i_src_c043_3_01 0 bpf_c043_3 0) vcvs gain=8.314696123025e-01
SMIXI_c043_3_01 (mix_i_src_c043_3_01 mix_i_c043_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_01 (mix_q_src_c043_3_01 0 bpf_c043_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_3_01 (mix_q_src_c043_3_01 mix_q_c043_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_02 (mix_i_src_c043_3_02 0 bpf_c043_3 0) vcvs gain=5.555702330196e-01
SMIXI_c043_3_02 (mix_i_src_c043_3_02 mix_i_c043_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_02 (mix_q_src_c043_3_02 0 bpf_c043_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_3_02 (mix_q_src_c043_3_02 mix_q_c043_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_03 (mix_i_src_c043_3_03 0 bpf_c043_3 0) vcvs gain=1.950903220161e-01
SMIXI_c043_3_03 (mix_i_src_c043_3_03 mix_i_c043_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_03 (mix_q_src_c043_3_03 0 bpf_c043_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_3_03 (mix_q_src_c043_3_03 mix_q_c043_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_04 (mix_i_src_c043_3_04 0 bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_3_04 (mix_i_src_c043_3_04 mix_i_c043_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_04 (mix_q_src_c043_3_04 0 bpf_c043_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c043_3_04 (mix_q_src_c043_3_04 mix_q_c043_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_05 (mix_i_src_c043_3_05 0 bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_3_05 (mix_i_src_c043_3_05 mix_i_c043_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_05 (mix_q_src_c043_3_05 0 bpf_c043_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c043_3_05 (mix_q_src_c043_3_05 mix_q_c043_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_06 (mix_i_src_c043_3_06 0 bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_3_06 (mix_i_src_c043_3_06 mix_i_c043_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_06 (mix_q_src_c043_3_06 0 bpf_c043_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c043_3_06 (mix_q_src_c043_3_06 mix_q_c043_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_07 (mix_i_src_c043_3_07 0 bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_3_07 (mix_i_src_c043_3_07 mix_i_c043_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_07 (mix_q_src_c043_3_07 0 bpf_c043_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c043_3_07 (mix_q_src_c043_3_07 mix_q_c043_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_08 (mix_i_src_c043_3_08 0 bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c043_3_08 (mix_i_src_c043_3_08 mix_i_c043_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_08 (mix_q_src_c043_3_08 0 bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_3_08 (mix_q_src_c043_3_08 mix_q_c043_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_09 (mix_i_src_c043_3_09 0 bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c043_3_09 (mix_i_src_c043_3_09 mix_i_c043_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_09 (mix_q_src_c043_3_09 0 bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_3_09 (mix_q_src_c043_3_09 mix_q_c043_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_10 (mix_i_src_c043_3_10 0 bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c043_3_10 (mix_i_src_c043_3_10 mix_i_c043_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_10 (mix_q_src_c043_3_10 0 bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_3_10 (mix_q_src_c043_3_10 mix_q_c043_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_11 (mix_i_src_c043_3_11 0 bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c043_3_11 (mix_i_src_c043_3_11 mix_i_c043_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_11 (mix_q_src_c043_3_11 0 bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_3_11 (mix_q_src_c043_3_11 mix_q_c043_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_12 (mix_i_src_c043_3_12 0 bpf_c043_3 0) vcvs gain=1.950903220161e-01
SMIXI_c043_3_12 (mix_i_src_c043_3_12 mix_i_c043_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_12 (mix_q_src_c043_3_12 0 bpf_c043_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c043_3_12 (mix_q_src_c043_3_12 mix_q_c043_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_13 (mix_i_src_c043_3_13 0 bpf_c043_3 0) vcvs gain=5.555702330196e-01
SMIXI_c043_3_13 (mix_i_src_c043_3_13 mix_i_c043_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_13 (mix_q_src_c043_3_13 0 bpf_c043_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c043_3_13 (mix_q_src_c043_3_13 mix_q_c043_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_14 (mix_i_src_c043_3_14 0 bpf_c043_3 0) vcvs gain=8.314696123025e-01
SMIXI_c043_3_14 (mix_i_src_c043_3_14 mix_i_c043_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_14 (mix_q_src_c043_3_14 0 bpf_c043_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c043_3_14 (mix_q_src_c043_3_14 mix_q_c043_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c043_3_15 (mix_i_src_c043_3_15 0 bpf_c043_3 0) vcvs gain=9.807852804032e-01
SMIXI_c043_3_15 (mix_i_src_c043_3_15 mix_i_c043_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c043_3_15 (mix_q_src_c043_3_15 0 bpf_c043_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c043_3_15 (mix_q_src_c043_3_15 mix_q_c043_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c043_3 (mix_i_c043_3 0) resistor r=1G
RMIXQ_c043_3 (mix_q_c043_3 0) resistor r=1G
RINTI_c043_3 (mix_i_c043_3 Icar_c043_3) resistor r=1k
CINTI_c043_3 (Icar_c043_3 0) capacitor c=80p
RINTQ_c043_3 (mix_q_c043_3 Qcar_c043_3) resistor r=1k
CINTQ_c043_3 (Qcar_c043_3 0) capacitor c=80p

// bl044, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c044_0 (bl044 n_cbpf_c044_0) capacitor c=4.052847345694e-13
LBPF_c044_0 (n_cbpf_c044_0 bpf_c044_0) inductor l=1.000000000000e-06
RBPF_c044_0 (bpf_c044_0 0) resistor r=7.853981633974e+01
EMIXI_c044_0_00 (mix_i_src_c044_0_00 0 bpf_c044_0 0) vcvs gain=9.807852804032e-01
SMIXI_c044_0_00 (mix_i_src_c044_0_00 mix_i_c044_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_00 (mix_q_src_c044_0_00 0 bpf_c044_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_0_00 (mix_q_src_c044_0_00 mix_q_c044_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_01 (mix_i_src_c044_0_01 0 bpf_c044_0 0) vcvs gain=8.314696123025e-01
SMIXI_c044_0_01 (mix_i_src_c044_0_01 mix_i_c044_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_01 (mix_q_src_c044_0_01 0 bpf_c044_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_0_01 (mix_q_src_c044_0_01 mix_q_c044_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_02 (mix_i_src_c044_0_02 0 bpf_c044_0 0) vcvs gain=5.555702330196e-01
SMIXI_c044_0_02 (mix_i_src_c044_0_02 mix_i_c044_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_02 (mix_q_src_c044_0_02 0 bpf_c044_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_0_02 (mix_q_src_c044_0_02 mix_q_c044_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_03 (mix_i_src_c044_0_03 0 bpf_c044_0 0) vcvs gain=1.950903220161e-01
SMIXI_c044_0_03 (mix_i_src_c044_0_03 mix_i_c044_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_03 (mix_q_src_c044_0_03 0 bpf_c044_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_0_03 (mix_q_src_c044_0_03 mix_q_c044_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_04 (mix_i_src_c044_0_04 0 bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_0_04 (mix_i_src_c044_0_04 mix_i_c044_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_04 (mix_q_src_c044_0_04 0 bpf_c044_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_0_04 (mix_q_src_c044_0_04 mix_q_c044_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_05 (mix_i_src_c044_0_05 0 bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_0_05 (mix_i_src_c044_0_05 mix_i_c044_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_05 (mix_q_src_c044_0_05 0 bpf_c044_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_0_05 (mix_q_src_c044_0_05 mix_q_c044_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_06 (mix_i_src_c044_0_06 0 bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_0_06 (mix_i_src_c044_0_06 mix_i_c044_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_06 (mix_q_src_c044_0_06 0 bpf_c044_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_0_06 (mix_q_src_c044_0_06 mix_q_c044_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_07 (mix_i_src_c044_0_07 0 bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_0_07 (mix_i_src_c044_0_07 mix_i_c044_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_07 (mix_q_src_c044_0_07 0 bpf_c044_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_0_07 (mix_q_src_c044_0_07 mix_q_c044_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_08 (mix_i_src_c044_0_08 0 bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_0_08 (mix_i_src_c044_0_08 mix_i_c044_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_08 (mix_q_src_c044_0_08 0 bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_0_08 (mix_q_src_c044_0_08 mix_q_c044_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_09 (mix_i_src_c044_0_09 0 bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_0_09 (mix_i_src_c044_0_09 mix_i_c044_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_09 (mix_q_src_c044_0_09 0 bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_0_09 (mix_q_src_c044_0_09 mix_q_c044_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_10 (mix_i_src_c044_0_10 0 bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_0_10 (mix_i_src_c044_0_10 mix_i_c044_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_10 (mix_q_src_c044_0_10 0 bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_0_10 (mix_q_src_c044_0_10 mix_q_c044_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_11 (mix_i_src_c044_0_11 0 bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_0_11 (mix_i_src_c044_0_11 mix_i_c044_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_11 (mix_q_src_c044_0_11 0 bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_0_11 (mix_q_src_c044_0_11 mix_q_c044_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_12 (mix_i_src_c044_0_12 0 bpf_c044_0 0) vcvs gain=1.950903220161e-01
SMIXI_c044_0_12 (mix_i_src_c044_0_12 mix_i_c044_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_12 (mix_q_src_c044_0_12 0 bpf_c044_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_0_12 (mix_q_src_c044_0_12 mix_q_c044_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_13 (mix_i_src_c044_0_13 0 bpf_c044_0 0) vcvs gain=5.555702330196e-01
SMIXI_c044_0_13 (mix_i_src_c044_0_13 mix_i_c044_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_13 (mix_q_src_c044_0_13 0 bpf_c044_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_0_13 (mix_q_src_c044_0_13 mix_q_c044_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_14 (mix_i_src_c044_0_14 0 bpf_c044_0 0) vcvs gain=8.314696123025e-01
SMIXI_c044_0_14 (mix_i_src_c044_0_14 mix_i_c044_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_14 (mix_q_src_c044_0_14 0 bpf_c044_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_0_14 (mix_q_src_c044_0_14 mix_q_c044_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_0_15 (mix_i_src_c044_0_15 0 bpf_c044_0 0) vcvs gain=9.807852804032e-01
SMIXI_c044_0_15 (mix_i_src_c044_0_15 mix_i_c044_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_0_15 (mix_q_src_c044_0_15 0 bpf_c044_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_0_15 (mix_q_src_c044_0_15 mix_q_c044_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c044_0 (mix_i_c044_0 0) resistor r=1G
RMIXQ_c044_0 (mix_q_c044_0 0) resistor r=1G
RINTI_c044_0 (mix_i_c044_0 Icar_c044_0) resistor r=1k
CINTI_c044_0 (Icar_c044_0 0) capacitor c=80p
RINTQ_c044_0 (mix_q_c044_0 Qcar_c044_0) resistor r=1k
CINTQ_c044_0 (Qcar_c044_0 0) capacitor c=80p

// bl044, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c044_1 (bl044 n_cbpf_c044_1) capacitor c=1.013211836423e-13
LBPF_c044_1 (n_cbpf_c044_1 bpf_c044_1) inductor l=1.000000000000e-06
RBPF_c044_1 (bpf_c044_1 0) resistor r=1.570796326795e+02
EMIXI_c044_1_00 (mix_i_src_c044_1_00 0 bpf_c044_1 0) vcvs gain=9.807852804032e-01
SMIXI_c044_1_00 (mix_i_src_c044_1_00 mix_i_c044_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_00 (mix_q_src_c044_1_00 0 bpf_c044_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_1_00 (mix_q_src_c044_1_00 mix_q_c044_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_01 (mix_i_src_c044_1_01 0 bpf_c044_1 0) vcvs gain=8.314696123025e-01
SMIXI_c044_1_01 (mix_i_src_c044_1_01 mix_i_c044_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_01 (mix_q_src_c044_1_01 0 bpf_c044_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_1_01 (mix_q_src_c044_1_01 mix_q_c044_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_02 (mix_i_src_c044_1_02 0 bpf_c044_1 0) vcvs gain=5.555702330196e-01
SMIXI_c044_1_02 (mix_i_src_c044_1_02 mix_i_c044_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_02 (mix_q_src_c044_1_02 0 bpf_c044_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_1_02 (mix_q_src_c044_1_02 mix_q_c044_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_03 (mix_i_src_c044_1_03 0 bpf_c044_1 0) vcvs gain=1.950903220161e-01
SMIXI_c044_1_03 (mix_i_src_c044_1_03 mix_i_c044_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_03 (mix_q_src_c044_1_03 0 bpf_c044_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_1_03 (mix_q_src_c044_1_03 mix_q_c044_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_04 (mix_i_src_c044_1_04 0 bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_1_04 (mix_i_src_c044_1_04 mix_i_c044_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_04 (mix_q_src_c044_1_04 0 bpf_c044_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_1_04 (mix_q_src_c044_1_04 mix_q_c044_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_05 (mix_i_src_c044_1_05 0 bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_1_05 (mix_i_src_c044_1_05 mix_i_c044_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_05 (mix_q_src_c044_1_05 0 bpf_c044_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_1_05 (mix_q_src_c044_1_05 mix_q_c044_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_06 (mix_i_src_c044_1_06 0 bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_1_06 (mix_i_src_c044_1_06 mix_i_c044_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_06 (mix_q_src_c044_1_06 0 bpf_c044_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_1_06 (mix_q_src_c044_1_06 mix_q_c044_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_07 (mix_i_src_c044_1_07 0 bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_1_07 (mix_i_src_c044_1_07 mix_i_c044_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_07 (mix_q_src_c044_1_07 0 bpf_c044_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_1_07 (mix_q_src_c044_1_07 mix_q_c044_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_08 (mix_i_src_c044_1_08 0 bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_1_08 (mix_i_src_c044_1_08 mix_i_c044_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_08 (mix_q_src_c044_1_08 0 bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_1_08 (mix_q_src_c044_1_08 mix_q_c044_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_09 (mix_i_src_c044_1_09 0 bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_1_09 (mix_i_src_c044_1_09 mix_i_c044_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_09 (mix_q_src_c044_1_09 0 bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_1_09 (mix_q_src_c044_1_09 mix_q_c044_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_10 (mix_i_src_c044_1_10 0 bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_1_10 (mix_i_src_c044_1_10 mix_i_c044_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_10 (mix_q_src_c044_1_10 0 bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_1_10 (mix_q_src_c044_1_10 mix_q_c044_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_11 (mix_i_src_c044_1_11 0 bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_1_11 (mix_i_src_c044_1_11 mix_i_c044_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_11 (mix_q_src_c044_1_11 0 bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_1_11 (mix_q_src_c044_1_11 mix_q_c044_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_12 (mix_i_src_c044_1_12 0 bpf_c044_1 0) vcvs gain=1.950903220161e-01
SMIXI_c044_1_12 (mix_i_src_c044_1_12 mix_i_c044_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_12 (mix_q_src_c044_1_12 0 bpf_c044_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_1_12 (mix_q_src_c044_1_12 mix_q_c044_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_13 (mix_i_src_c044_1_13 0 bpf_c044_1 0) vcvs gain=5.555702330196e-01
SMIXI_c044_1_13 (mix_i_src_c044_1_13 mix_i_c044_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_13 (mix_q_src_c044_1_13 0 bpf_c044_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_1_13 (mix_q_src_c044_1_13 mix_q_c044_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_14 (mix_i_src_c044_1_14 0 bpf_c044_1 0) vcvs gain=8.314696123025e-01
SMIXI_c044_1_14 (mix_i_src_c044_1_14 mix_i_c044_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_14 (mix_q_src_c044_1_14 0 bpf_c044_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_1_14 (mix_q_src_c044_1_14 mix_q_c044_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_1_15 (mix_i_src_c044_1_15 0 bpf_c044_1 0) vcvs gain=9.807852804032e-01
SMIXI_c044_1_15 (mix_i_src_c044_1_15 mix_i_c044_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_1_15 (mix_q_src_c044_1_15 0 bpf_c044_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_1_15 (mix_q_src_c044_1_15 mix_q_c044_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c044_1 (mix_i_c044_1 0) resistor r=1G
RMIXQ_c044_1 (mix_q_c044_1 0) resistor r=1G
RINTI_c044_1 (mix_i_c044_1 Icar_c044_1) resistor r=1k
CINTI_c044_1 (Icar_c044_1 0) capacitor c=80p
RINTQ_c044_1 (mix_q_c044_1 Qcar_c044_1) resistor r=1k
CINTQ_c044_1 (Qcar_c044_1 0) capacitor c=80p

// bl044, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c044_2 (bl044 n_cbpf_c044_2) capacitor c=4.503163717437e-14
LBPF_c044_2 (n_cbpf_c044_2 bpf_c044_2) inductor l=1.000000000000e-06
RBPF_c044_2 (bpf_c044_2 0) resistor r=2.356194490192e+02
EMIXI_c044_2_00 (mix_i_src_c044_2_00 0 bpf_c044_2 0) vcvs gain=9.807852804032e-01
SMIXI_c044_2_00 (mix_i_src_c044_2_00 mix_i_c044_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_00 (mix_q_src_c044_2_00 0 bpf_c044_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_2_00 (mix_q_src_c044_2_00 mix_q_c044_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_01 (mix_i_src_c044_2_01 0 bpf_c044_2 0) vcvs gain=8.314696123025e-01
SMIXI_c044_2_01 (mix_i_src_c044_2_01 mix_i_c044_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_01 (mix_q_src_c044_2_01 0 bpf_c044_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_2_01 (mix_q_src_c044_2_01 mix_q_c044_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_02 (mix_i_src_c044_2_02 0 bpf_c044_2 0) vcvs gain=5.555702330196e-01
SMIXI_c044_2_02 (mix_i_src_c044_2_02 mix_i_c044_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_02 (mix_q_src_c044_2_02 0 bpf_c044_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_2_02 (mix_q_src_c044_2_02 mix_q_c044_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_03 (mix_i_src_c044_2_03 0 bpf_c044_2 0) vcvs gain=1.950903220161e-01
SMIXI_c044_2_03 (mix_i_src_c044_2_03 mix_i_c044_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_03 (mix_q_src_c044_2_03 0 bpf_c044_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_2_03 (mix_q_src_c044_2_03 mix_q_c044_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_04 (mix_i_src_c044_2_04 0 bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_2_04 (mix_i_src_c044_2_04 mix_i_c044_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_04 (mix_q_src_c044_2_04 0 bpf_c044_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_2_04 (mix_q_src_c044_2_04 mix_q_c044_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_05 (mix_i_src_c044_2_05 0 bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_2_05 (mix_i_src_c044_2_05 mix_i_c044_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_05 (mix_q_src_c044_2_05 0 bpf_c044_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_2_05 (mix_q_src_c044_2_05 mix_q_c044_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_06 (mix_i_src_c044_2_06 0 bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_2_06 (mix_i_src_c044_2_06 mix_i_c044_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_06 (mix_q_src_c044_2_06 0 bpf_c044_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_2_06 (mix_q_src_c044_2_06 mix_q_c044_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_07 (mix_i_src_c044_2_07 0 bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_2_07 (mix_i_src_c044_2_07 mix_i_c044_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_07 (mix_q_src_c044_2_07 0 bpf_c044_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_2_07 (mix_q_src_c044_2_07 mix_q_c044_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_08 (mix_i_src_c044_2_08 0 bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_2_08 (mix_i_src_c044_2_08 mix_i_c044_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_08 (mix_q_src_c044_2_08 0 bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_2_08 (mix_q_src_c044_2_08 mix_q_c044_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_09 (mix_i_src_c044_2_09 0 bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_2_09 (mix_i_src_c044_2_09 mix_i_c044_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_09 (mix_q_src_c044_2_09 0 bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_2_09 (mix_q_src_c044_2_09 mix_q_c044_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_10 (mix_i_src_c044_2_10 0 bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_2_10 (mix_i_src_c044_2_10 mix_i_c044_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_10 (mix_q_src_c044_2_10 0 bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_2_10 (mix_q_src_c044_2_10 mix_q_c044_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_11 (mix_i_src_c044_2_11 0 bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_2_11 (mix_i_src_c044_2_11 mix_i_c044_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_11 (mix_q_src_c044_2_11 0 bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_2_11 (mix_q_src_c044_2_11 mix_q_c044_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_12 (mix_i_src_c044_2_12 0 bpf_c044_2 0) vcvs gain=1.950903220161e-01
SMIXI_c044_2_12 (mix_i_src_c044_2_12 mix_i_c044_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_12 (mix_q_src_c044_2_12 0 bpf_c044_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_2_12 (mix_q_src_c044_2_12 mix_q_c044_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_13 (mix_i_src_c044_2_13 0 bpf_c044_2 0) vcvs gain=5.555702330196e-01
SMIXI_c044_2_13 (mix_i_src_c044_2_13 mix_i_c044_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_13 (mix_q_src_c044_2_13 0 bpf_c044_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_2_13 (mix_q_src_c044_2_13 mix_q_c044_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_14 (mix_i_src_c044_2_14 0 bpf_c044_2 0) vcvs gain=8.314696123025e-01
SMIXI_c044_2_14 (mix_i_src_c044_2_14 mix_i_c044_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_14 (mix_q_src_c044_2_14 0 bpf_c044_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_2_14 (mix_q_src_c044_2_14 mix_q_c044_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_2_15 (mix_i_src_c044_2_15 0 bpf_c044_2 0) vcvs gain=9.807852804032e-01
SMIXI_c044_2_15 (mix_i_src_c044_2_15 mix_i_c044_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_2_15 (mix_q_src_c044_2_15 0 bpf_c044_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_2_15 (mix_q_src_c044_2_15 mix_q_c044_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c044_2 (mix_i_c044_2 0) resistor r=1G
RMIXQ_c044_2 (mix_q_c044_2 0) resistor r=1G
RINTI_c044_2 (mix_i_c044_2 Icar_c044_2) resistor r=1k
CINTI_c044_2 (Icar_c044_2 0) capacitor c=80p
RINTQ_c044_2 (mix_q_c044_2 Qcar_c044_2) resistor r=1k
CINTQ_c044_2 (Qcar_c044_2 0) capacitor c=80p

// bl044, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c044_3 (bl044 n_cbpf_c044_3) capacitor c=2.533029591058e-14
LBPF_c044_3 (n_cbpf_c044_3 bpf_c044_3) inductor l=1.000000000000e-06
RBPF_c044_3 (bpf_c044_3 0) resistor r=3.141592653590e+02
EMIXI_c044_3_00 (mix_i_src_c044_3_00 0 bpf_c044_3 0) vcvs gain=9.807852804032e-01
SMIXI_c044_3_00 (mix_i_src_c044_3_00 mix_i_c044_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_00 (mix_q_src_c044_3_00 0 bpf_c044_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_3_00 (mix_q_src_c044_3_00 mix_q_c044_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_01 (mix_i_src_c044_3_01 0 bpf_c044_3 0) vcvs gain=8.314696123025e-01
SMIXI_c044_3_01 (mix_i_src_c044_3_01 mix_i_c044_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_01 (mix_q_src_c044_3_01 0 bpf_c044_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_3_01 (mix_q_src_c044_3_01 mix_q_c044_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_02 (mix_i_src_c044_3_02 0 bpf_c044_3 0) vcvs gain=5.555702330196e-01
SMIXI_c044_3_02 (mix_i_src_c044_3_02 mix_i_c044_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_02 (mix_q_src_c044_3_02 0 bpf_c044_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_3_02 (mix_q_src_c044_3_02 mix_q_c044_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_03 (mix_i_src_c044_3_03 0 bpf_c044_3 0) vcvs gain=1.950903220161e-01
SMIXI_c044_3_03 (mix_i_src_c044_3_03 mix_i_c044_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_03 (mix_q_src_c044_3_03 0 bpf_c044_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_3_03 (mix_q_src_c044_3_03 mix_q_c044_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_04 (mix_i_src_c044_3_04 0 bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_3_04 (mix_i_src_c044_3_04 mix_i_c044_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_04 (mix_q_src_c044_3_04 0 bpf_c044_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c044_3_04 (mix_q_src_c044_3_04 mix_q_c044_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_05 (mix_i_src_c044_3_05 0 bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_3_05 (mix_i_src_c044_3_05 mix_i_c044_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_05 (mix_q_src_c044_3_05 0 bpf_c044_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c044_3_05 (mix_q_src_c044_3_05 mix_q_c044_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_06 (mix_i_src_c044_3_06 0 bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_3_06 (mix_i_src_c044_3_06 mix_i_c044_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_06 (mix_q_src_c044_3_06 0 bpf_c044_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c044_3_06 (mix_q_src_c044_3_06 mix_q_c044_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_07 (mix_i_src_c044_3_07 0 bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_3_07 (mix_i_src_c044_3_07 mix_i_c044_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_07 (mix_q_src_c044_3_07 0 bpf_c044_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c044_3_07 (mix_q_src_c044_3_07 mix_q_c044_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_08 (mix_i_src_c044_3_08 0 bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c044_3_08 (mix_i_src_c044_3_08 mix_i_c044_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_08 (mix_q_src_c044_3_08 0 bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_3_08 (mix_q_src_c044_3_08 mix_q_c044_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_09 (mix_i_src_c044_3_09 0 bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c044_3_09 (mix_i_src_c044_3_09 mix_i_c044_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_09 (mix_q_src_c044_3_09 0 bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_3_09 (mix_q_src_c044_3_09 mix_q_c044_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_10 (mix_i_src_c044_3_10 0 bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c044_3_10 (mix_i_src_c044_3_10 mix_i_c044_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_10 (mix_q_src_c044_3_10 0 bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_3_10 (mix_q_src_c044_3_10 mix_q_c044_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_11 (mix_i_src_c044_3_11 0 bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c044_3_11 (mix_i_src_c044_3_11 mix_i_c044_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_11 (mix_q_src_c044_3_11 0 bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_3_11 (mix_q_src_c044_3_11 mix_q_c044_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_12 (mix_i_src_c044_3_12 0 bpf_c044_3 0) vcvs gain=1.950903220161e-01
SMIXI_c044_3_12 (mix_i_src_c044_3_12 mix_i_c044_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_12 (mix_q_src_c044_3_12 0 bpf_c044_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c044_3_12 (mix_q_src_c044_3_12 mix_q_c044_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_13 (mix_i_src_c044_3_13 0 bpf_c044_3 0) vcvs gain=5.555702330196e-01
SMIXI_c044_3_13 (mix_i_src_c044_3_13 mix_i_c044_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_13 (mix_q_src_c044_3_13 0 bpf_c044_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c044_3_13 (mix_q_src_c044_3_13 mix_q_c044_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_14 (mix_i_src_c044_3_14 0 bpf_c044_3 0) vcvs gain=8.314696123025e-01
SMIXI_c044_3_14 (mix_i_src_c044_3_14 mix_i_c044_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_14 (mix_q_src_c044_3_14 0 bpf_c044_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c044_3_14 (mix_q_src_c044_3_14 mix_q_c044_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c044_3_15 (mix_i_src_c044_3_15 0 bpf_c044_3 0) vcvs gain=9.807852804032e-01
SMIXI_c044_3_15 (mix_i_src_c044_3_15 mix_i_c044_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c044_3_15 (mix_q_src_c044_3_15 0 bpf_c044_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c044_3_15 (mix_q_src_c044_3_15 mix_q_c044_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c044_3 (mix_i_c044_3 0) resistor r=1G
RMIXQ_c044_3 (mix_q_c044_3 0) resistor r=1G
RINTI_c044_3 (mix_i_c044_3 Icar_c044_3) resistor r=1k
CINTI_c044_3 (Icar_c044_3 0) capacitor c=80p
RINTQ_c044_3 (mix_q_c044_3 Qcar_c044_3) resistor r=1k
CINTQ_c044_3 (Qcar_c044_3 0) capacitor c=80p

// bl045, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c045_0 (bl045 n_cbpf_c045_0) capacitor c=4.052847345694e-13
LBPF_c045_0 (n_cbpf_c045_0 bpf_c045_0) inductor l=1.000000000000e-06
RBPF_c045_0 (bpf_c045_0 0) resistor r=7.853981633974e+01
EMIXI_c045_0_00 (mix_i_src_c045_0_00 0 bpf_c045_0 0) vcvs gain=9.807852804032e-01
SMIXI_c045_0_00 (mix_i_src_c045_0_00 mix_i_c045_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_00 (mix_q_src_c045_0_00 0 bpf_c045_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_0_00 (mix_q_src_c045_0_00 mix_q_c045_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_01 (mix_i_src_c045_0_01 0 bpf_c045_0 0) vcvs gain=8.314696123025e-01
SMIXI_c045_0_01 (mix_i_src_c045_0_01 mix_i_c045_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_01 (mix_q_src_c045_0_01 0 bpf_c045_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_0_01 (mix_q_src_c045_0_01 mix_q_c045_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_02 (mix_i_src_c045_0_02 0 bpf_c045_0 0) vcvs gain=5.555702330196e-01
SMIXI_c045_0_02 (mix_i_src_c045_0_02 mix_i_c045_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_02 (mix_q_src_c045_0_02 0 bpf_c045_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_0_02 (mix_q_src_c045_0_02 mix_q_c045_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_03 (mix_i_src_c045_0_03 0 bpf_c045_0 0) vcvs gain=1.950903220161e-01
SMIXI_c045_0_03 (mix_i_src_c045_0_03 mix_i_c045_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_03 (mix_q_src_c045_0_03 0 bpf_c045_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_0_03 (mix_q_src_c045_0_03 mix_q_c045_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_04 (mix_i_src_c045_0_04 0 bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_0_04 (mix_i_src_c045_0_04 mix_i_c045_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_04 (mix_q_src_c045_0_04 0 bpf_c045_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_0_04 (mix_q_src_c045_0_04 mix_q_c045_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_05 (mix_i_src_c045_0_05 0 bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_0_05 (mix_i_src_c045_0_05 mix_i_c045_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_05 (mix_q_src_c045_0_05 0 bpf_c045_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_0_05 (mix_q_src_c045_0_05 mix_q_c045_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_06 (mix_i_src_c045_0_06 0 bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_0_06 (mix_i_src_c045_0_06 mix_i_c045_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_06 (mix_q_src_c045_0_06 0 bpf_c045_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_0_06 (mix_q_src_c045_0_06 mix_q_c045_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_07 (mix_i_src_c045_0_07 0 bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_0_07 (mix_i_src_c045_0_07 mix_i_c045_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_07 (mix_q_src_c045_0_07 0 bpf_c045_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_0_07 (mix_q_src_c045_0_07 mix_q_c045_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_08 (mix_i_src_c045_0_08 0 bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_0_08 (mix_i_src_c045_0_08 mix_i_c045_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_08 (mix_q_src_c045_0_08 0 bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_0_08 (mix_q_src_c045_0_08 mix_q_c045_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_09 (mix_i_src_c045_0_09 0 bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_0_09 (mix_i_src_c045_0_09 mix_i_c045_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_09 (mix_q_src_c045_0_09 0 bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_0_09 (mix_q_src_c045_0_09 mix_q_c045_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_10 (mix_i_src_c045_0_10 0 bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_0_10 (mix_i_src_c045_0_10 mix_i_c045_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_10 (mix_q_src_c045_0_10 0 bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_0_10 (mix_q_src_c045_0_10 mix_q_c045_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_11 (mix_i_src_c045_0_11 0 bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_0_11 (mix_i_src_c045_0_11 mix_i_c045_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_11 (mix_q_src_c045_0_11 0 bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_0_11 (mix_q_src_c045_0_11 mix_q_c045_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_12 (mix_i_src_c045_0_12 0 bpf_c045_0 0) vcvs gain=1.950903220161e-01
SMIXI_c045_0_12 (mix_i_src_c045_0_12 mix_i_c045_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_12 (mix_q_src_c045_0_12 0 bpf_c045_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_0_12 (mix_q_src_c045_0_12 mix_q_c045_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_13 (mix_i_src_c045_0_13 0 bpf_c045_0 0) vcvs gain=5.555702330196e-01
SMIXI_c045_0_13 (mix_i_src_c045_0_13 mix_i_c045_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_13 (mix_q_src_c045_0_13 0 bpf_c045_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_0_13 (mix_q_src_c045_0_13 mix_q_c045_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_14 (mix_i_src_c045_0_14 0 bpf_c045_0 0) vcvs gain=8.314696123025e-01
SMIXI_c045_0_14 (mix_i_src_c045_0_14 mix_i_c045_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_14 (mix_q_src_c045_0_14 0 bpf_c045_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_0_14 (mix_q_src_c045_0_14 mix_q_c045_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_0_15 (mix_i_src_c045_0_15 0 bpf_c045_0 0) vcvs gain=9.807852804032e-01
SMIXI_c045_0_15 (mix_i_src_c045_0_15 mix_i_c045_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_0_15 (mix_q_src_c045_0_15 0 bpf_c045_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_0_15 (mix_q_src_c045_0_15 mix_q_c045_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c045_0 (mix_i_c045_0 0) resistor r=1G
RMIXQ_c045_0 (mix_q_c045_0 0) resistor r=1G
RINTI_c045_0 (mix_i_c045_0 Icar_c045_0) resistor r=1k
CINTI_c045_0 (Icar_c045_0 0) capacitor c=80p
RINTQ_c045_0 (mix_q_c045_0 Qcar_c045_0) resistor r=1k
CINTQ_c045_0 (Qcar_c045_0 0) capacitor c=80p

// bl045, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c045_1 (bl045 n_cbpf_c045_1) capacitor c=1.013211836423e-13
LBPF_c045_1 (n_cbpf_c045_1 bpf_c045_1) inductor l=1.000000000000e-06
RBPF_c045_1 (bpf_c045_1 0) resistor r=1.570796326795e+02
EMIXI_c045_1_00 (mix_i_src_c045_1_00 0 bpf_c045_1 0) vcvs gain=9.807852804032e-01
SMIXI_c045_1_00 (mix_i_src_c045_1_00 mix_i_c045_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_00 (mix_q_src_c045_1_00 0 bpf_c045_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_1_00 (mix_q_src_c045_1_00 mix_q_c045_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_01 (mix_i_src_c045_1_01 0 bpf_c045_1 0) vcvs gain=8.314696123025e-01
SMIXI_c045_1_01 (mix_i_src_c045_1_01 mix_i_c045_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_01 (mix_q_src_c045_1_01 0 bpf_c045_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_1_01 (mix_q_src_c045_1_01 mix_q_c045_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_02 (mix_i_src_c045_1_02 0 bpf_c045_1 0) vcvs gain=5.555702330196e-01
SMIXI_c045_1_02 (mix_i_src_c045_1_02 mix_i_c045_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_02 (mix_q_src_c045_1_02 0 bpf_c045_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_1_02 (mix_q_src_c045_1_02 mix_q_c045_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_03 (mix_i_src_c045_1_03 0 bpf_c045_1 0) vcvs gain=1.950903220161e-01
SMIXI_c045_1_03 (mix_i_src_c045_1_03 mix_i_c045_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_03 (mix_q_src_c045_1_03 0 bpf_c045_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_1_03 (mix_q_src_c045_1_03 mix_q_c045_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_04 (mix_i_src_c045_1_04 0 bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_1_04 (mix_i_src_c045_1_04 mix_i_c045_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_04 (mix_q_src_c045_1_04 0 bpf_c045_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_1_04 (mix_q_src_c045_1_04 mix_q_c045_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_05 (mix_i_src_c045_1_05 0 bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_1_05 (mix_i_src_c045_1_05 mix_i_c045_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_05 (mix_q_src_c045_1_05 0 bpf_c045_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_1_05 (mix_q_src_c045_1_05 mix_q_c045_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_06 (mix_i_src_c045_1_06 0 bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_1_06 (mix_i_src_c045_1_06 mix_i_c045_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_06 (mix_q_src_c045_1_06 0 bpf_c045_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_1_06 (mix_q_src_c045_1_06 mix_q_c045_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_07 (mix_i_src_c045_1_07 0 bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_1_07 (mix_i_src_c045_1_07 mix_i_c045_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_07 (mix_q_src_c045_1_07 0 bpf_c045_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_1_07 (mix_q_src_c045_1_07 mix_q_c045_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_08 (mix_i_src_c045_1_08 0 bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_1_08 (mix_i_src_c045_1_08 mix_i_c045_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_08 (mix_q_src_c045_1_08 0 bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_1_08 (mix_q_src_c045_1_08 mix_q_c045_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_09 (mix_i_src_c045_1_09 0 bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_1_09 (mix_i_src_c045_1_09 mix_i_c045_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_09 (mix_q_src_c045_1_09 0 bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_1_09 (mix_q_src_c045_1_09 mix_q_c045_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_10 (mix_i_src_c045_1_10 0 bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_1_10 (mix_i_src_c045_1_10 mix_i_c045_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_10 (mix_q_src_c045_1_10 0 bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_1_10 (mix_q_src_c045_1_10 mix_q_c045_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_11 (mix_i_src_c045_1_11 0 bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_1_11 (mix_i_src_c045_1_11 mix_i_c045_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_11 (mix_q_src_c045_1_11 0 bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_1_11 (mix_q_src_c045_1_11 mix_q_c045_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_12 (mix_i_src_c045_1_12 0 bpf_c045_1 0) vcvs gain=1.950903220161e-01
SMIXI_c045_1_12 (mix_i_src_c045_1_12 mix_i_c045_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_12 (mix_q_src_c045_1_12 0 bpf_c045_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_1_12 (mix_q_src_c045_1_12 mix_q_c045_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_13 (mix_i_src_c045_1_13 0 bpf_c045_1 0) vcvs gain=5.555702330196e-01
SMIXI_c045_1_13 (mix_i_src_c045_1_13 mix_i_c045_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_13 (mix_q_src_c045_1_13 0 bpf_c045_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_1_13 (mix_q_src_c045_1_13 mix_q_c045_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_14 (mix_i_src_c045_1_14 0 bpf_c045_1 0) vcvs gain=8.314696123025e-01
SMIXI_c045_1_14 (mix_i_src_c045_1_14 mix_i_c045_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_14 (mix_q_src_c045_1_14 0 bpf_c045_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_1_14 (mix_q_src_c045_1_14 mix_q_c045_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_1_15 (mix_i_src_c045_1_15 0 bpf_c045_1 0) vcvs gain=9.807852804032e-01
SMIXI_c045_1_15 (mix_i_src_c045_1_15 mix_i_c045_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_1_15 (mix_q_src_c045_1_15 0 bpf_c045_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_1_15 (mix_q_src_c045_1_15 mix_q_c045_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c045_1 (mix_i_c045_1 0) resistor r=1G
RMIXQ_c045_1 (mix_q_c045_1 0) resistor r=1G
RINTI_c045_1 (mix_i_c045_1 Icar_c045_1) resistor r=1k
CINTI_c045_1 (Icar_c045_1 0) capacitor c=80p
RINTQ_c045_1 (mix_q_c045_1 Qcar_c045_1) resistor r=1k
CINTQ_c045_1 (Qcar_c045_1 0) capacitor c=80p

// bl045, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c045_2 (bl045 n_cbpf_c045_2) capacitor c=4.503163717437e-14
LBPF_c045_2 (n_cbpf_c045_2 bpf_c045_2) inductor l=1.000000000000e-06
RBPF_c045_2 (bpf_c045_2 0) resistor r=2.356194490192e+02
EMIXI_c045_2_00 (mix_i_src_c045_2_00 0 bpf_c045_2 0) vcvs gain=9.807852804032e-01
SMIXI_c045_2_00 (mix_i_src_c045_2_00 mix_i_c045_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_00 (mix_q_src_c045_2_00 0 bpf_c045_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_2_00 (mix_q_src_c045_2_00 mix_q_c045_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_01 (mix_i_src_c045_2_01 0 bpf_c045_2 0) vcvs gain=8.314696123025e-01
SMIXI_c045_2_01 (mix_i_src_c045_2_01 mix_i_c045_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_01 (mix_q_src_c045_2_01 0 bpf_c045_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_2_01 (mix_q_src_c045_2_01 mix_q_c045_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_02 (mix_i_src_c045_2_02 0 bpf_c045_2 0) vcvs gain=5.555702330196e-01
SMIXI_c045_2_02 (mix_i_src_c045_2_02 mix_i_c045_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_02 (mix_q_src_c045_2_02 0 bpf_c045_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_2_02 (mix_q_src_c045_2_02 mix_q_c045_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_03 (mix_i_src_c045_2_03 0 bpf_c045_2 0) vcvs gain=1.950903220161e-01
SMIXI_c045_2_03 (mix_i_src_c045_2_03 mix_i_c045_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_03 (mix_q_src_c045_2_03 0 bpf_c045_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_2_03 (mix_q_src_c045_2_03 mix_q_c045_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_04 (mix_i_src_c045_2_04 0 bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_2_04 (mix_i_src_c045_2_04 mix_i_c045_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_04 (mix_q_src_c045_2_04 0 bpf_c045_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_2_04 (mix_q_src_c045_2_04 mix_q_c045_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_05 (mix_i_src_c045_2_05 0 bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_2_05 (mix_i_src_c045_2_05 mix_i_c045_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_05 (mix_q_src_c045_2_05 0 bpf_c045_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_2_05 (mix_q_src_c045_2_05 mix_q_c045_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_06 (mix_i_src_c045_2_06 0 bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_2_06 (mix_i_src_c045_2_06 mix_i_c045_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_06 (mix_q_src_c045_2_06 0 bpf_c045_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_2_06 (mix_q_src_c045_2_06 mix_q_c045_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_07 (mix_i_src_c045_2_07 0 bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_2_07 (mix_i_src_c045_2_07 mix_i_c045_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_07 (mix_q_src_c045_2_07 0 bpf_c045_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_2_07 (mix_q_src_c045_2_07 mix_q_c045_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_08 (mix_i_src_c045_2_08 0 bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_2_08 (mix_i_src_c045_2_08 mix_i_c045_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_08 (mix_q_src_c045_2_08 0 bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_2_08 (mix_q_src_c045_2_08 mix_q_c045_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_09 (mix_i_src_c045_2_09 0 bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_2_09 (mix_i_src_c045_2_09 mix_i_c045_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_09 (mix_q_src_c045_2_09 0 bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_2_09 (mix_q_src_c045_2_09 mix_q_c045_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_10 (mix_i_src_c045_2_10 0 bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_2_10 (mix_i_src_c045_2_10 mix_i_c045_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_10 (mix_q_src_c045_2_10 0 bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_2_10 (mix_q_src_c045_2_10 mix_q_c045_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_11 (mix_i_src_c045_2_11 0 bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_2_11 (mix_i_src_c045_2_11 mix_i_c045_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_11 (mix_q_src_c045_2_11 0 bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_2_11 (mix_q_src_c045_2_11 mix_q_c045_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_12 (mix_i_src_c045_2_12 0 bpf_c045_2 0) vcvs gain=1.950903220161e-01
SMIXI_c045_2_12 (mix_i_src_c045_2_12 mix_i_c045_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_12 (mix_q_src_c045_2_12 0 bpf_c045_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_2_12 (mix_q_src_c045_2_12 mix_q_c045_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_13 (mix_i_src_c045_2_13 0 bpf_c045_2 0) vcvs gain=5.555702330196e-01
SMIXI_c045_2_13 (mix_i_src_c045_2_13 mix_i_c045_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_13 (mix_q_src_c045_2_13 0 bpf_c045_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_2_13 (mix_q_src_c045_2_13 mix_q_c045_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_14 (mix_i_src_c045_2_14 0 bpf_c045_2 0) vcvs gain=8.314696123025e-01
SMIXI_c045_2_14 (mix_i_src_c045_2_14 mix_i_c045_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_14 (mix_q_src_c045_2_14 0 bpf_c045_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_2_14 (mix_q_src_c045_2_14 mix_q_c045_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_2_15 (mix_i_src_c045_2_15 0 bpf_c045_2 0) vcvs gain=9.807852804032e-01
SMIXI_c045_2_15 (mix_i_src_c045_2_15 mix_i_c045_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_2_15 (mix_q_src_c045_2_15 0 bpf_c045_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_2_15 (mix_q_src_c045_2_15 mix_q_c045_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c045_2 (mix_i_c045_2 0) resistor r=1G
RMIXQ_c045_2 (mix_q_c045_2 0) resistor r=1G
RINTI_c045_2 (mix_i_c045_2 Icar_c045_2) resistor r=1k
CINTI_c045_2 (Icar_c045_2 0) capacitor c=80p
RINTQ_c045_2 (mix_q_c045_2 Qcar_c045_2) resistor r=1k
CINTQ_c045_2 (Qcar_c045_2 0) capacitor c=80p

// bl045, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c045_3 (bl045 n_cbpf_c045_3) capacitor c=2.533029591058e-14
LBPF_c045_3 (n_cbpf_c045_3 bpf_c045_3) inductor l=1.000000000000e-06
RBPF_c045_3 (bpf_c045_3 0) resistor r=3.141592653590e+02
EMIXI_c045_3_00 (mix_i_src_c045_3_00 0 bpf_c045_3 0) vcvs gain=9.807852804032e-01
SMIXI_c045_3_00 (mix_i_src_c045_3_00 mix_i_c045_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_00 (mix_q_src_c045_3_00 0 bpf_c045_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_3_00 (mix_q_src_c045_3_00 mix_q_c045_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_01 (mix_i_src_c045_3_01 0 bpf_c045_3 0) vcvs gain=8.314696123025e-01
SMIXI_c045_3_01 (mix_i_src_c045_3_01 mix_i_c045_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_01 (mix_q_src_c045_3_01 0 bpf_c045_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_3_01 (mix_q_src_c045_3_01 mix_q_c045_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_02 (mix_i_src_c045_3_02 0 bpf_c045_3 0) vcvs gain=5.555702330196e-01
SMIXI_c045_3_02 (mix_i_src_c045_3_02 mix_i_c045_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_02 (mix_q_src_c045_3_02 0 bpf_c045_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_3_02 (mix_q_src_c045_3_02 mix_q_c045_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_03 (mix_i_src_c045_3_03 0 bpf_c045_3 0) vcvs gain=1.950903220161e-01
SMIXI_c045_3_03 (mix_i_src_c045_3_03 mix_i_c045_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_03 (mix_q_src_c045_3_03 0 bpf_c045_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_3_03 (mix_q_src_c045_3_03 mix_q_c045_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_04 (mix_i_src_c045_3_04 0 bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_3_04 (mix_i_src_c045_3_04 mix_i_c045_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_04 (mix_q_src_c045_3_04 0 bpf_c045_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c045_3_04 (mix_q_src_c045_3_04 mix_q_c045_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_05 (mix_i_src_c045_3_05 0 bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_3_05 (mix_i_src_c045_3_05 mix_i_c045_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_05 (mix_q_src_c045_3_05 0 bpf_c045_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c045_3_05 (mix_q_src_c045_3_05 mix_q_c045_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_06 (mix_i_src_c045_3_06 0 bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_3_06 (mix_i_src_c045_3_06 mix_i_c045_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_06 (mix_q_src_c045_3_06 0 bpf_c045_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c045_3_06 (mix_q_src_c045_3_06 mix_q_c045_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_07 (mix_i_src_c045_3_07 0 bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_3_07 (mix_i_src_c045_3_07 mix_i_c045_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_07 (mix_q_src_c045_3_07 0 bpf_c045_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c045_3_07 (mix_q_src_c045_3_07 mix_q_c045_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_08 (mix_i_src_c045_3_08 0 bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c045_3_08 (mix_i_src_c045_3_08 mix_i_c045_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_08 (mix_q_src_c045_3_08 0 bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_3_08 (mix_q_src_c045_3_08 mix_q_c045_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_09 (mix_i_src_c045_3_09 0 bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c045_3_09 (mix_i_src_c045_3_09 mix_i_c045_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_09 (mix_q_src_c045_3_09 0 bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_3_09 (mix_q_src_c045_3_09 mix_q_c045_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_10 (mix_i_src_c045_3_10 0 bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c045_3_10 (mix_i_src_c045_3_10 mix_i_c045_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_10 (mix_q_src_c045_3_10 0 bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_3_10 (mix_q_src_c045_3_10 mix_q_c045_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_11 (mix_i_src_c045_3_11 0 bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c045_3_11 (mix_i_src_c045_3_11 mix_i_c045_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_11 (mix_q_src_c045_3_11 0 bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_3_11 (mix_q_src_c045_3_11 mix_q_c045_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_12 (mix_i_src_c045_3_12 0 bpf_c045_3 0) vcvs gain=1.950903220161e-01
SMIXI_c045_3_12 (mix_i_src_c045_3_12 mix_i_c045_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_12 (mix_q_src_c045_3_12 0 bpf_c045_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c045_3_12 (mix_q_src_c045_3_12 mix_q_c045_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_13 (mix_i_src_c045_3_13 0 bpf_c045_3 0) vcvs gain=5.555702330196e-01
SMIXI_c045_3_13 (mix_i_src_c045_3_13 mix_i_c045_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_13 (mix_q_src_c045_3_13 0 bpf_c045_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c045_3_13 (mix_q_src_c045_3_13 mix_q_c045_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_14 (mix_i_src_c045_3_14 0 bpf_c045_3 0) vcvs gain=8.314696123025e-01
SMIXI_c045_3_14 (mix_i_src_c045_3_14 mix_i_c045_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_14 (mix_q_src_c045_3_14 0 bpf_c045_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c045_3_14 (mix_q_src_c045_3_14 mix_q_c045_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c045_3_15 (mix_i_src_c045_3_15 0 bpf_c045_3 0) vcvs gain=9.807852804032e-01
SMIXI_c045_3_15 (mix_i_src_c045_3_15 mix_i_c045_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c045_3_15 (mix_q_src_c045_3_15 0 bpf_c045_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c045_3_15 (mix_q_src_c045_3_15 mix_q_c045_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c045_3 (mix_i_c045_3 0) resistor r=1G
RMIXQ_c045_3 (mix_q_c045_3 0) resistor r=1G
RINTI_c045_3 (mix_i_c045_3 Icar_c045_3) resistor r=1k
CINTI_c045_3 (Icar_c045_3 0) capacitor c=80p
RINTQ_c045_3 (mix_q_c045_3 Qcar_c045_3) resistor r=1k
CINTQ_c045_3 (Qcar_c045_3 0) capacitor c=80p

// bl046, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c046_0 (bl046 n_cbpf_c046_0) capacitor c=4.052847345694e-13
LBPF_c046_0 (n_cbpf_c046_0 bpf_c046_0) inductor l=1.000000000000e-06
RBPF_c046_0 (bpf_c046_0 0) resistor r=7.853981633974e+01
EMIXI_c046_0_00 (mix_i_src_c046_0_00 0 bpf_c046_0 0) vcvs gain=9.807852804032e-01
SMIXI_c046_0_00 (mix_i_src_c046_0_00 mix_i_c046_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_00 (mix_q_src_c046_0_00 0 bpf_c046_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_0_00 (mix_q_src_c046_0_00 mix_q_c046_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_01 (mix_i_src_c046_0_01 0 bpf_c046_0 0) vcvs gain=8.314696123025e-01
SMIXI_c046_0_01 (mix_i_src_c046_0_01 mix_i_c046_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_01 (mix_q_src_c046_0_01 0 bpf_c046_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_0_01 (mix_q_src_c046_0_01 mix_q_c046_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_02 (mix_i_src_c046_0_02 0 bpf_c046_0 0) vcvs gain=5.555702330196e-01
SMIXI_c046_0_02 (mix_i_src_c046_0_02 mix_i_c046_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_02 (mix_q_src_c046_0_02 0 bpf_c046_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_0_02 (mix_q_src_c046_0_02 mix_q_c046_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_03 (mix_i_src_c046_0_03 0 bpf_c046_0 0) vcvs gain=1.950903220161e-01
SMIXI_c046_0_03 (mix_i_src_c046_0_03 mix_i_c046_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_03 (mix_q_src_c046_0_03 0 bpf_c046_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_0_03 (mix_q_src_c046_0_03 mix_q_c046_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_04 (mix_i_src_c046_0_04 0 bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_0_04 (mix_i_src_c046_0_04 mix_i_c046_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_04 (mix_q_src_c046_0_04 0 bpf_c046_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_0_04 (mix_q_src_c046_0_04 mix_q_c046_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_05 (mix_i_src_c046_0_05 0 bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_0_05 (mix_i_src_c046_0_05 mix_i_c046_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_05 (mix_q_src_c046_0_05 0 bpf_c046_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_0_05 (mix_q_src_c046_0_05 mix_q_c046_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_06 (mix_i_src_c046_0_06 0 bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_0_06 (mix_i_src_c046_0_06 mix_i_c046_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_06 (mix_q_src_c046_0_06 0 bpf_c046_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_0_06 (mix_q_src_c046_0_06 mix_q_c046_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_07 (mix_i_src_c046_0_07 0 bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_0_07 (mix_i_src_c046_0_07 mix_i_c046_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_07 (mix_q_src_c046_0_07 0 bpf_c046_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_0_07 (mix_q_src_c046_0_07 mix_q_c046_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_08 (mix_i_src_c046_0_08 0 bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_0_08 (mix_i_src_c046_0_08 mix_i_c046_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_08 (mix_q_src_c046_0_08 0 bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_0_08 (mix_q_src_c046_0_08 mix_q_c046_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_09 (mix_i_src_c046_0_09 0 bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_0_09 (mix_i_src_c046_0_09 mix_i_c046_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_09 (mix_q_src_c046_0_09 0 bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_0_09 (mix_q_src_c046_0_09 mix_q_c046_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_10 (mix_i_src_c046_0_10 0 bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_0_10 (mix_i_src_c046_0_10 mix_i_c046_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_10 (mix_q_src_c046_0_10 0 bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_0_10 (mix_q_src_c046_0_10 mix_q_c046_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_11 (mix_i_src_c046_0_11 0 bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_0_11 (mix_i_src_c046_0_11 mix_i_c046_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_11 (mix_q_src_c046_0_11 0 bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_0_11 (mix_q_src_c046_0_11 mix_q_c046_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_12 (mix_i_src_c046_0_12 0 bpf_c046_0 0) vcvs gain=1.950903220161e-01
SMIXI_c046_0_12 (mix_i_src_c046_0_12 mix_i_c046_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_12 (mix_q_src_c046_0_12 0 bpf_c046_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_0_12 (mix_q_src_c046_0_12 mix_q_c046_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_13 (mix_i_src_c046_0_13 0 bpf_c046_0 0) vcvs gain=5.555702330196e-01
SMIXI_c046_0_13 (mix_i_src_c046_0_13 mix_i_c046_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_13 (mix_q_src_c046_0_13 0 bpf_c046_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_0_13 (mix_q_src_c046_0_13 mix_q_c046_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_14 (mix_i_src_c046_0_14 0 bpf_c046_0 0) vcvs gain=8.314696123025e-01
SMIXI_c046_0_14 (mix_i_src_c046_0_14 mix_i_c046_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_14 (mix_q_src_c046_0_14 0 bpf_c046_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_0_14 (mix_q_src_c046_0_14 mix_q_c046_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_0_15 (mix_i_src_c046_0_15 0 bpf_c046_0 0) vcvs gain=9.807852804032e-01
SMIXI_c046_0_15 (mix_i_src_c046_0_15 mix_i_c046_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_0_15 (mix_q_src_c046_0_15 0 bpf_c046_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_0_15 (mix_q_src_c046_0_15 mix_q_c046_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c046_0 (mix_i_c046_0 0) resistor r=1G
RMIXQ_c046_0 (mix_q_c046_0 0) resistor r=1G
RINTI_c046_0 (mix_i_c046_0 Icar_c046_0) resistor r=1k
CINTI_c046_0 (Icar_c046_0 0) capacitor c=80p
RINTQ_c046_0 (mix_q_c046_0 Qcar_c046_0) resistor r=1k
CINTQ_c046_0 (Qcar_c046_0 0) capacitor c=80p

// bl046, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c046_1 (bl046 n_cbpf_c046_1) capacitor c=1.013211836423e-13
LBPF_c046_1 (n_cbpf_c046_1 bpf_c046_1) inductor l=1.000000000000e-06
RBPF_c046_1 (bpf_c046_1 0) resistor r=1.570796326795e+02
EMIXI_c046_1_00 (mix_i_src_c046_1_00 0 bpf_c046_1 0) vcvs gain=9.807852804032e-01
SMIXI_c046_1_00 (mix_i_src_c046_1_00 mix_i_c046_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_00 (mix_q_src_c046_1_00 0 bpf_c046_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_1_00 (mix_q_src_c046_1_00 mix_q_c046_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_01 (mix_i_src_c046_1_01 0 bpf_c046_1 0) vcvs gain=8.314696123025e-01
SMIXI_c046_1_01 (mix_i_src_c046_1_01 mix_i_c046_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_01 (mix_q_src_c046_1_01 0 bpf_c046_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_1_01 (mix_q_src_c046_1_01 mix_q_c046_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_02 (mix_i_src_c046_1_02 0 bpf_c046_1 0) vcvs gain=5.555702330196e-01
SMIXI_c046_1_02 (mix_i_src_c046_1_02 mix_i_c046_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_02 (mix_q_src_c046_1_02 0 bpf_c046_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_1_02 (mix_q_src_c046_1_02 mix_q_c046_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_03 (mix_i_src_c046_1_03 0 bpf_c046_1 0) vcvs gain=1.950903220161e-01
SMIXI_c046_1_03 (mix_i_src_c046_1_03 mix_i_c046_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_03 (mix_q_src_c046_1_03 0 bpf_c046_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_1_03 (mix_q_src_c046_1_03 mix_q_c046_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_04 (mix_i_src_c046_1_04 0 bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_1_04 (mix_i_src_c046_1_04 mix_i_c046_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_04 (mix_q_src_c046_1_04 0 bpf_c046_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_1_04 (mix_q_src_c046_1_04 mix_q_c046_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_05 (mix_i_src_c046_1_05 0 bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_1_05 (mix_i_src_c046_1_05 mix_i_c046_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_05 (mix_q_src_c046_1_05 0 bpf_c046_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_1_05 (mix_q_src_c046_1_05 mix_q_c046_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_06 (mix_i_src_c046_1_06 0 bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_1_06 (mix_i_src_c046_1_06 mix_i_c046_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_06 (mix_q_src_c046_1_06 0 bpf_c046_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_1_06 (mix_q_src_c046_1_06 mix_q_c046_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_07 (mix_i_src_c046_1_07 0 bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_1_07 (mix_i_src_c046_1_07 mix_i_c046_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_07 (mix_q_src_c046_1_07 0 bpf_c046_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_1_07 (mix_q_src_c046_1_07 mix_q_c046_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_08 (mix_i_src_c046_1_08 0 bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_1_08 (mix_i_src_c046_1_08 mix_i_c046_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_08 (mix_q_src_c046_1_08 0 bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_1_08 (mix_q_src_c046_1_08 mix_q_c046_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_09 (mix_i_src_c046_1_09 0 bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_1_09 (mix_i_src_c046_1_09 mix_i_c046_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_09 (mix_q_src_c046_1_09 0 bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_1_09 (mix_q_src_c046_1_09 mix_q_c046_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_10 (mix_i_src_c046_1_10 0 bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_1_10 (mix_i_src_c046_1_10 mix_i_c046_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_10 (mix_q_src_c046_1_10 0 bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_1_10 (mix_q_src_c046_1_10 mix_q_c046_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_11 (mix_i_src_c046_1_11 0 bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_1_11 (mix_i_src_c046_1_11 mix_i_c046_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_11 (mix_q_src_c046_1_11 0 bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_1_11 (mix_q_src_c046_1_11 mix_q_c046_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_12 (mix_i_src_c046_1_12 0 bpf_c046_1 0) vcvs gain=1.950903220161e-01
SMIXI_c046_1_12 (mix_i_src_c046_1_12 mix_i_c046_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_12 (mix_q_src_c046_1_12 0 bpf_c046_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_1_12 (mix_q_src_c046_1_12 mix_q_c046_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_13 (mix_i_src_c046_1_13 0 bpf_c046_1 0) vcvs gain=5.555702330196e-01
SMIXI_c046_1_13 (mix_i_src_c046_1_13 mix_i_c046_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_13 (mix_q_src_c046_1_13 0 bpf_c046_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_1_13 (mix_q_src_c046_1_13 mix_q_c046_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_14 (mix_i_src_c046_1_14 0 bpf_c046_1 0) vcvs gain=8.314696123025e-01
SMIXI_c046_1_14 (mix_i_src_c046_1_14 mix_i_c046_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_14 (mix_q_src_c046_1_14 0 bpf_c046_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_1_14 (mix_q_src_c046_1_14 mix_q_c046_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_1_15 (mix_i_src_c046_1_15 0 bpf_c046_1 0) vcvs gain=9.807852804032e-01
SMIXI_c046_1_15 (mix_i_src_c046_1_15 mix_i_c046_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_1_15 (mix_q_src_c046_1_15 0 bpf_c046_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_1_15 (mix_q_src_c046_1_15 mix_q_c046_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c046_1 (mix_i_c046_1 0) resistor r=1G
RMIXQ_c046_1 (mix_q_c046_1 0) resistor r=1G
RINTI_c046_1 (mix_i_c046_1 Icar_c046_1) resistor r=1k
CINTI_c046_1 (Icar_c046_1 0) capacitor c=80p
RINTQ_c046_1 (mix_q_c046_1 Qcar_c046_1) resistor r=1k
CINTQ_c046_1 (Qcar_c046_1 0) capacitor c=80p

// bl046, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c046_2 (bl046 n_cbpf_c046_2) capacitor c=4.503163717437e-14
LBPF_c046_2 (n_cbpf_c046_2 bpf_c046_2) inductor l=1.000000000000e-06
RBPF_c046_2 (bpf_c046_2 0) resistor r=2.356194490192e+02
EMIXI_c046_2_00 (mix_i_src_c046_2_00 0 bpf_c046_2 0) vcvs gain=9.807852804032e-01
SMIXI_c046_2_00 (mix_i_src_c046_2_00 mix_i_c046_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_00 (mix_q_src_c046_2_00 0 bpf_c046_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_2_00 (mix_q_src_c046_2_00 mix_q_c046_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_01 (mix_i_src_c046_2_01 0 bpf_c046_2 0) vcvs gain=8.314696123025e-01
SMIXI_c046_2_01 (mix_i_src_c046_2_01 mix_i_c046_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_01 (mix_q_src_c046_2_01 0 bpf_c046_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_2_01 (mix_q_src_c046_2_01 mix_q_c046_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_02 (mix_i_src_c046_2_02 0 bpf_c046_2 0) vcvs gain=5.555702330196e-01
SMIXI_c046_2_02 (mix_i_src_c046_2_02 mix_i_c046_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_02 (mix_q_src_c046_2_02 0 bpf_c046_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_2_02 (mix_q_src_c046_2_02 mix_q_c046_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_03 (mix_i_src_c046_2_03 0 bpf_c046_2 0) vcvs gain=1.950903220161e-01
SMIXI_c046_2_03 (mix_i_src_c046_2_03 mix_i_c046_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_03 (mix_q_src_c046_2_03 0 bpf_c046_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_2_03 (mix_q_src_c046_2_03 mix_q_c046_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_04 (mix_i_src_c046_2_04 0 bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_2_04 (mix_i_src_c046_2_04 mix_i_c046_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_04 (mix_q_src_c046_2_04 0 bpf_c046_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_2_04 (mix_q_src_c046_2_04 mix_q_c046_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_05 (mix_i_src_c046_2_05 0 bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_2_05 (mix_i_src_c046_2_05 mix_i_c046_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_05 (mix_q_src_c046_2_05 0 bpf_c046_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_2_05 (mix_q_src_c046_2_05 mix_q_c046_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_06 (mix_i_src_c046_2_06 0 bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_2_06 (mix_i_src_c046_2_06 mix_i_c046_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_06 (mix_q_src_c046_2_06 0 bpf_c046_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_2_06 (mix_q_src_c046_2_06 mix_q_c046_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_07 (mix_i_src_c046_2_07 0 bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_2_07 (mix_i_src_c046_2_07 mix_i_c046_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_07 (mix_q_src_c046_2_07 0 bpf_c046_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_2_07 (mix_q_src_c046_2_07 mix_q_c046_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_08 (mix_i_src_c046_2_08 0 bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_2_08 (mix_i_src_c046_2_08 mix_i_c046_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_08 (mix_q_src_c046_2_08 0 bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_2_08 (mix_q_src_c046_2_08 mix_q_c046_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_09 (mix_i_src_c046_2_09 0 bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_2_09 (mix_i_src_c046_2_09 mix_i_c046_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_09 (mix_q_src_c046_2_09 0 bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_2_09 (mix_q_src_c046_2_09 mix_q_c046_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_10 (mix_i_src_c046_2_10 0 bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_2_10 (mix_i_src_c046_2_10 mix_i_c046_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_10 (mix_q_src_c046_2_10 0 bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_2_10 (mix_q_src_c046_2_10 mix_q_c046_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_11 (mix_i_src_c046_2_11 0 bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_2_11 (mix_i_src_c046_2_11 mix_i_c046_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_11 (mix_q_src_c046_2_11 0 bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_2_11 (mix_q_src_c046_2_11 mix_q_c046_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_12 (mix_i_src_c046_2_12 0 bpf_c046_2 0) vcvs gain=1.950903220161e-01
SMIXI_c046_2_12 (mix_i_src_c046_2_12 mix_i_c046_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_12 (mix_q_src_c046_2_12 0 bpf_c046_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_2_12 (mix_q_src_c046_2_12 mix_q_c046_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_13 (mix_i_src_c046_2_13 0 bpf_c046_2 0) vcvs gain=5.555702330196e-01
SMIXI_c046_2_13 (mix_i_src_c046_2_13 mix_i_c046_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_13 (mix_q_src_c046_2_13 0 bpf_c046_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_2_13 (mix_q_src_c046_2_13 mix_q_c046_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_14 (mix_i_src_c046_2_14 0 bpf_c046_2 0) vcvs gain=8.314696123025e-01
SMIXI_c046_2_14 (mix_i_src_c046_2_14 mix_i_c046_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_14 (mix_q_src_c046_2_14 0 bpf_c046_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_2_14 (mix_q_src_c046_2_14 mix_q_c046_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_2_15 (mix_i_src_c046_2_15 0 bpf_c046_2 0) vcvs gain=9.807852804032e-01
SMIXI_c046_2_15 (mix_i_src_c046_2_15 mix_i_c046_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_2_15 (mix_q_src_c046_2_15 0 bpf_c046_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_2_15 (mix_q_src_c046_2_15 mix_q_c046_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c046_2 (mix_i_c046_2 0) resistor r=1G
RMIXQ_c046_2 (mix_q_c046_2 0) resistor r=1G
RINTI_c046_2 (mix_i_c046_2 Icar_c046_2) resistor r=1k
CINTI_c046_2 (Icar_c046_2 0) capacitor c=80p
RINTQ_c046_2 (mix_q_c046_2 Qcar_c046_2) resistor r=1k
CINTQ_c046_2 (Qcar_c046_2 0) capacitor c=80p

// bl046, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c046_3 (bl046 n_cbpf_c046_3) capacitor c=2.533029591058e-14
LBPF_c046_3 (n_cbpf_c046_3 bpf_c046_3) inductor l=1.000000000000e-06
RBPF_c046_3 (bpf_c046_3 0) resistor r=3.141592653590e+02
EMIXI_c046_3_00 (mix_i_src_c046_3_00 0 bpf_c046_3 0) vcvs gain=9.807852804032e-01
SMIXI_c046_3_00 (mix_i_src_c046_3_00 mix_i_c046_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_00 (mix_q_src_c046_3_00 0 bpf_c046_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_3_00 (mix_q_src_c046_3_00 mix_q_c046_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_01 (mix_i_src_c046_3_01 0 bpf_c046_3 0) vcvs gain=8.314696123025e-01
SMIXI_c046_3_01 (mix_i_src_c046_3_01 mix_i_c046_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_01 (mix_q_src_c046_3_01 0 bpf_c046_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_3_01 (mix_q_src_c046_3_01 mix_q_c046_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_02 (mix_i_src_c046_3_02 0 bpf_c046_3 0) vcvs gain=5.555702330196e-01
SMIXI_c046_3_02 (mix_i_src_c046_3_02 mix_i_c046_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_02 (mix_q_src_c046_3_02 0 bpf_c046_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_3_02 (mix_q_src_c046_3_02 mix_q_c046_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_03 (mix_i_src_c046_3_03 0 bpf_c046_3 0) vcvs gain=1.950903220161e-01
SMIXI_c046_3_03 (mix_i_src_c046_3_03 mix_i_c046_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_03 (mix_q_src_c046_3_03 0 bpf_c046_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_3_03 (mix_q_src_c046_3_03 mix_q_c046_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_04 (mix_i_src_c046_3_04 0 bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_3_04 (mix_i_src_c046_3_04 mix_i_c046_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_04 (mix_q_src_c046_3_04 0 bpf_c046_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c046_3_04 (mix_q_src_c046_3_04 mix_q_c046_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_05 (mix_i_src_c046_3_05 0 bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_3_05 (mix_i_src_c046_3_05 mix_i_c046_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_05 (mix_q_src_c046_3_05 0 bpf_c046_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c046_3_05 (mix_q_src_c046_3_05 mix_q_c046_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_06 (mix_i_src_c046_3_06 0 bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_3_06 (mix_i_src_c046_3_06 mix_i_c046_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_06 (mix_q_src_c046_3_06 0 bpf_c046_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c046_3_06 (mix_q_src_c046_3_06 mix_q_c046_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_07 (mix_i_src_c046_3_07 0 bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_3_07 (mix_i_src_c046_3_07 mix_i_c046_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_07 (mix_q_src_c046_3_07 0 bpf_c046_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c046_3_07 (mix_q_src_c046_3_07 mix_q_c046_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_08 (mix_i_src_c046_3_08 0 bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c046_3_08 (mix_i_src_c046_3_08 mix_i_c046_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_08 (mix_q_src_c046_3_08 0 bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_3_08 (mix_q_src_c046_3_08 mix_q_c046_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_09 (mix_i_src_c046_3_09 0 bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c046_3_09 (mix_i_src_c046_3_09 mix_i_c046_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_09 (mix_q_src_c046_3_09 0 bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_3_09 (mix_q_src_c046_3_09 mix_q_c046_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_10 (mix_i_src_c046_3_10 0 bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c046_3_10 (mix_i_src_c046_3_10 mix_i_c046_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_10 (mix_q_src_c046_3_10 0 bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_3_10 (mix_q_src_c046_3_10 mix_q_c046_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_11 (mix_i_src_c046_3_11 0 bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c046_3_11 (mix_i_src_c046_3_11 mix_i_c046_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_11 (mix_q_src_c046_3_11 0 bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_3_11 (mix_q_src_c046_3_11 mix_q_c046_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_12 (mix_i_src_c046_3_12 0 bpf_c046_3 0) vcvs gain=1.950903220161e-01
SMIXI_c046_3_12 (mix_i_src_c046_3_12 mix_i_c046_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_12 (mix_q_src_c046_3_12 0 bpf_c046_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c046_3_12 (mix_q_src_c046_3_12 mix_q_c046_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_13 (mix_i_src_c046_3_13 0 bpf_c046_3 0) vcvs gain=5.555702330196e-01
SMIXI_c046_3_13 (mix_i_src_c046_3_13 mix_i_c046_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_13 (mix_q_src_c046_3_13 0 bpf_c046_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c046_3_13 (mix_q_src_c046_3_13 mix_q_c046_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_14 (mix_i_src_c046_3_14 0 bpf_c046_3 0) vcvs gain=8.314696123025e-01
SMIXI_c046_3_14 (mix_i_src_c046_3_14 mix_i_c046_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_14 (mix_q_src_c046_3_14 0 bpf_c046_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c046_3_14 (mix_q_src_c046_3_14 mix_q_c046_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c046_3_15 (mix_i_src_c046_3_15 0 bpf_c046_3 0) vcvs gain=9.807852804032e-01
SMIXI_c046_3_15 (mix_i_src_c046_3_15 mix_i_c046_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c046_3_15 (mix_q_src_c046_3_15 0 bpf_c046_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c046_3_15 (mix_q_src_c046_3_15 mix_q_c046_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c046_3 (mix_i_c046_3 0) resistor r=1G
RMIXQ_c046_3 (mix_q_c046_3 0) resistor r=1G
RINTI_c046_3 (mix_i_c046_3 Icar_c046_3) resistor r=1k
CINTI_c046_3 (Icar_c046_3 0) capacitor c=80p
RINTQ_c046_3 (mix_q_c046_3 Qcar_c046_3) resistor r=1k
CINTQ_c046_3 (Qcar_c046_3 0) capacitor c=80p

// bl047, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c047_0 (bl047 n_cbpf_c047_0) capacitor c=4.052847345694e-13
LBPF_c047_0 (n_cbpf_c047_0 bpf_c047_0) inductor l=1.000000000000e-06
RBPF_c047_0 (bpf_c047_0 0) resistor r=7.853981633974e+01
EMIXI_c047_0_00 (mix_i_src_c047_0_00 0 bpf_c047_0 0) vcvs gain=9.807852804032e-01
SMIXI_c047_0_00 (mix_i_src_c047_0_00 mix_i_c047_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_00 (mix_q_src_c047_0_00 0 bpf_c047_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_0_00 (mix_q_src_c047_0_00 mix_q_c047_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_01 (mix_i_src_c047_0_01 0 bpf_c047_0 0) vcvs gain=8.314696123025e-01
SMIXI_c047_0_01 (mix_i_src_c047_0_01 mix_i_c047_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_01 (mix_q_src_c047_0_01 0 bpf_c047_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_0_01 (mix_q_src_c047_0_01 mix_q_c047_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_02 (mix_i_src_c047_0_02 0 bpf_c047_0 0) vcvs gain=5.555702330196e-01
SMIXI_c047_0_02 (mix_i_src_c047_0_02 mix_i_c047_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_02 (mix_q_src_c047_0_02 0 bpf_c047_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_0_02 (mix_q_src_c047_0_02 mix_q_c047_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_03 (mix_i_src_c047_0_03 0 bpf_c047_0 0) vcvs gain=1.950903220161e-01
SMIXI_c047_0_03 (mix_i_src_c047_0_03 mix_i_c047_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_03 (mix_q_src_c047_0_03 0 bpf_c047_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_0_03 (mix_q_src_c047_0_03 mix_q_c047_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_04 (mix_i_src_c047_0_04 0 bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_0_04 (mix_i_src_c047_0_04 mix_i_c047_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_04 (mix_q_src_c047_0_04 0 bpf_c047_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_0_04 (mix_q_src_c047_0_04 mix_q_c047_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_05 (mix_i_src_c047_0_05 0 bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_0_05 (mix_i_src_c047_0_05 mix_i_c047_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_05 (mix_q_src_c047_0_05 0 bpf_c047_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_0_05 (mix_q_src_c047_0_05 mix_q_c047_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_06 (mix_i_src_c047_0_06 0 bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_0_06 (mix_i_src_c047_0_06 mix_i_c047_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_06 (mix_q_src_c047_0_06 0 bpf_c047_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_0_06 (mix_q_src_c047_0_06 mix_q_c047_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_07 (mix_i_src_c047_0_07 0 bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_0_07 (mix_i_src_c047_0_07 mix_i_c047_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_07 (mix_q_src_c047_0_07 0 bpf_c047_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_0_07 (mix_q_src_c047_0_07 mix_q_c047_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_08 (mix_i_src_c047_0_08 0 bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_0_08 (mix_i_src_c047_0_08 mix_i_c047_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_08 (mix_q_src_c047_0_08 0 bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_0_08 (mix_q_src_c047_0_08 mix_q_c047_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_09 (mix_i_src_c047_0_09 0 bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_0_09 (mix_i_src_c047_0_09 mix_i_c047_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_09 (mix_q_src_c047_0_09 0 bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_0_09 (mix_q_src_c047_0_09 mix_q_c047_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_10 (mix_i_src_c047_0_10 0 bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_0_10 (mix_i_src_c047_0_10 mix_i_c047_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_10 (mix_q_src_c047_0_10 0 bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_0_10 (mix_q_src_c047_0_10 mix_q_c047_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_11 (mix_i_src_c047_0_11 0 bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_0_11 (mix_i_src_c047_0_11 mix_i_c047_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_11 (mix_q_src_c047_0_11 0 bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_0_11 (mix_q_src_c047_0_11 mix_q_c047_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_12 (mix_i_src_c047_0_12 0 bpf_c047_0 0) vcvs gain=1.950903220161e-01
SMIXI_c047_0_12 (mix_i_src_c047_0_12 mix_i_c047_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_12 (mix_q_src_c047_0_12 0 bpf_c047_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_0_12 (mix_q_src_c047_0_12 mix_q_c047_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_13 (mix_i_src_c047_0_13 0 bpf_c047_0 0) vcvs gain=5.555702330196e-01
SMIXI_c047_0_13 (mix_i_src_c047_0_13 mix_i_c047_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_13 (mix_q_src_c047_0_13 0 bpf_c047_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_0_13 (mix_q_src_c047_0_13 mix_q_c047_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_14 (mix_i_src_c047_0_14 0 bpf_c047_0 0) vcvs gain=8.314696123025e-01
SMIXI_c047_0_14 (mix_i_src_c047_0_14 mix_i_c047_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_14 (mix_q_src_c047_0_14 0 bpf_c047_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_0_14 (mix_q_src_c047_0_14 mix_q_c047_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_0_15 (mix_i_src_c047_0_15 0 bpf_c047_0 0) vcvs gain=9.807852804032e-01
SMIXI_c047_0_15 (mix_i_src_c047_0_15 mix_i_c047_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_0_15 (mix_q_src_c047_0_15 0 bpf_c047_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_0_15 (mix_q_src_c047_0_15 mix_q_c047_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c047_0 (mix_i_c047_0 0) resistor r=1G
RMIXQ_c047_0 (mix_q_c047_0 0) resistor r=1G
RINTI_c047_0 (mix_i_c047_0 Icar_c047_0) resistor r=1k
CINTI_c047_0 (Icar_c047_0 0) capacitor c=80p
RINTQ_c047_0 (mix_q_c047_0 Qcar_c047_0) resistor r=1k
CINTQ_c047_0 (Qcar_c047_0 0) capacitor c=80p

// bl047, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c047_1 (bl047 n_cbpf_c047_1) capacitor c=1.013211836423e-13
LBPF_c047_1 (n_cbpf_c047_1 bpf_c047_1) inductor l=1.000000000000e-06
RBPF_c047_1 (bpf_c047_1 0) resistor r=1.570796326795e+02
EMIXI_c047_1_00 (mix_i_src_c047_1_00 0 bpf_c047_1 0) vcvs gain=9.807852804032e-01
SMIXI_c047_1_00 (mix_i_src_c047_1_00 mix_i_c047_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_00 (mix_q_src_c047_1_00 0 bpf_c047_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_1_00 (mix_q_src_c047_1_00 mix_q_c047_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_01 (mix_i_src_c047_1_01 0 bpf_c047_1 0) vcvs gain=8.314696123025e-01
SMIXI_c047_1_01 (mix_i_src_c047_1_01 mix_i_c047_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_01 (mix_q_src_c047_1_01 0 bpf_c047_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_1_01 (mix_q_src_c047_1_01 mix_q_c047_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_02 (mix_i_src_c047_1_02 0 bpf_c047_1 0) vcvs gain=5.555702330196e-01
SMIXI_c047_1_02 (mix_i_src_c047_1_02 mix_i_c047_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_02 (mix_q_src_c047_1_02 0 bpf_c047_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_1_02 (mix_q_src_c047_1_02 mix_q_c047_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_03 (mix_i_src_c047_1_03 0 bpf_c047_1 0) vcvs gain=1.950903220161e-01
SMIXI_c047_1_03 (mix_i_src_c047_1_03 mix_i_c047_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_03 (mix_q_src_c047_1_03 0 bpf_c047_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_1_03 (mix_q_src_c047_1_03 mix_q_c047_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_04 (mix_i_src_c047_1_04 0 bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_1_04 (mix_i_src_c047_1_04 mix_i_c047_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_04 (mix_q_src_c047_1_04 0 bpf_c047_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_1_04 (mix_q_src_c047_1_04 mix_q_c047_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_05 (mix_i_src_c047_1_05 0 bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_1_05 (mix_i_src_c047_1_05 mix_i_c047_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_05 (mix_q_src_c047_1_05 0 bpf_c047_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_1_05 (mix_q_src_c047_1_05 mix_q_c047_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_06 (mix_i_src_c047_1_06 0 bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_1_06 (mix_i_src_c047_1_06 mix_i_c047_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_06 (mix_q_src_c047_1_06 0 bpf_c047_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_1_06 (mix_q_src_c047_1_06 mix_q_c047_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_07 (mix_i_src_c047_1_07 0 bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_1_07 (mix_i_src_c047_1_07 mix_i_c047_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_07 (mix_q_src_c047_1_07 0 bpf_c047_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_1_07 (mix_q_src_c047_1_07 mix_q_c047_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_08 (mix_i_src_c047_1_08 0 bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_1_08 (mix_i_src_c047_1_08 mix_i_c047_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_08 (mix_q_src_c047_1_08 0 bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_1_08 (mix_q_src_c047_1_08 mix_q_c047_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_09 (mix_i_src_c047_1_09 0 bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_1_09 (mix_i_src_c047_1_09 mix_i_c047_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_09 (mix_q_src_c047_1_09 0 bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_1_09 (mix_q_src_c047_1_09 mix_q_c047_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_10 (mix_i_src_c047_1_10 0 bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_1_10 (mix_i_src_c047_1_10 mix_i_c047_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_10 (mix_q_src_c047_1_10 0 bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_1_10 (mix_q_src_c047_1_10 mix_q_c047_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_11 (mix_i_src_c047_1_11 0 bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_1_11 (mix_i_src_c047_1_11 mix_i_c047_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_11 (mix_q_src_c047_1_11 0 bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_1_11 (mix_q_src_c047_1_11 mix_q_c047_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_12 (mix_i_src_c047_1_12 0 bpf_c047_1 0) vcvs gain=1.950903220161e-01
SMIXI_c047_1_12 (mix_i_src_c047_1_12 mix_i_c047_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_12 (mix_q_src_c047_1_12 0 bpf_c047_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_1_12 (mix_q_src_c047_1_12 mix_q_c047_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_13 (mix_i_src_c047_1_13 0 bpf_c047_1 0) vcvs gain=5.555702330196e-01
SMIXI_c047_1_13 (mix_i_src_c047_1_13 mix_i_c047_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_13 (mix_q_src_c047_1_13 0 bpf_c047_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_1_13 (mix_q_src_c047_1_13 mix_q_c047_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_14 (mix_i_src_c047_1_14 0 bpf_c047_1 0) vcvs gain=8.314696123025e-01
SMIXI_c047_1_14 (mix_i_src_c047_1_14 mix_i_c047_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_14 (mix_q_src_c047_1_14 0 bpf_c047_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_1_14 (mix_q_src_c047_1_14 mix_q_c047_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_1_15 (mix_i_src_c047_1_15 0 bpf_c047_1 0) vcvs gain=9.807852804032e-01
SMIXI_c047_1_15 (mix_i_src_c047_1_15 mix_i_c047_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_1_15 (mix_q_src_c047_1_15 0 bpf_c047_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_1_15 (mix_q_src_c047_1_15 mix_q_c047_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c047_1 (mix_i_c047_1 0) resistor r=1G
RMIXQ_c047_1 (mix_q_c047_1 0) resistor r=1G
RINTI_c047_1 (mix_i_c047_1 Icar_c047_1) resistor r=1k
CINTI_c047_1 (Icar_c047_1 0) capacitor c=80p
RINTQ_c047_1 (mix_q_c047_1 Qcar_c047_1) resistor r=1k
CINTQ_c047_1 (Qcar_c047_1 0) capacitor c=80p

// bl047, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c047_2 (bl047 n_cbpf_c047_2) capacitor c=4.503163717437e-14
LBPF_c047_2 (n_cbpf_c047_2 bpf_c047_2) inductor l=1.000000000000e-06
RBPF_c047_2 (bpf_c047_2 0) resistor r=2.356194490192e+02
EMIXI_c047_2_00 (mix_i_src_c047_2_00 0 bpf_c047_2 0) vcvs gain=9.807852804032e-01
SMIXI_c047_2_00 (mix_i_src_c047_2_00 mix_i_c047_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_00 (mix_q_src_c047_2_00 0 bpf_c047_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_2_00 (mix_q_src_c047_2_00 mix_q_c047_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_01 (mix_i_src_c047_2_01 0 bpf_c047_2 0) vcvs gain=8.314696123025e-01
SMIXI_c047_2_01 (mix_i_src_c047_2_01 mix_i_c047_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_01 (mix_q_src_c047_2_01 0 bpf_c047_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_2_01 (mix_q_src_c047_2_01 mix_q_c047_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_02 (mix_i_src_c047_2_02 0 bpf_c047_2 0) vcvs gain=5.555702330196e-01
SMIXI_c047_2_02 (mix_i_src_c047_2_02 mix_i_c047_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_02 (mix_q_src_c047_2_02 0 bpf_c047_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_2_02 (mix_q_src_c047_2_02 mix_q_c047_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_03 (mix_i_src_c047_2_03 0 bpf_c047_2 0) vcvs gain=1.950903220161e-01
SMIXI_c047_2_03 (mix_i_src_c047_2_03 mix_i_c047_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_03 (mix_q_src_c047_2_03 0 bpf_c047_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_2_03 (mix_q_src_c047_2_03 mix_q_c047_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_04 (mix_i_src_c047_2_04 0 bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_2_04 (mix_i_src_c047_2_04 mix_i_c047_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_04 (mix_q_src_c047_2_04 0 bpf_c047_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_2_04 (mix_q_src_c047_2_04 mix_q_c047_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_05 (mix_i_src_c047_2_05 0 bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_2_05 (mix_i_src_c047_2_05 mix_i_c047_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_05 (mix_q_src_c047_2_05 0 bpf_c047_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_2_05 (mix_q_src_c047_2_05 mix_q_c047_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_06 (mix_i_src_c047_2_06 0 bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_2_06 (mix_i_src_c047_2_06 mix_i_c047_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_06 (mix_q_src_c047_2_06 0 bpf_c047_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_2_06 (mix_q_src_c047_2_06 mix_q_c047_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_07 (mix_i_src_c047_2_07 0 bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_2_07 (mix_i_src_c047_2_07 mix_i_c047_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_07 (mix_q_src_c047_2_07 0 bpf_c047_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_2_07 (mix_q_src_c047_2_07 mix_q_c047_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_08 (mix_i_src_c047_2_08 0 bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_2_08 (mix_i_src_c047_2_08 mix_i_c047_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_08 (mix_q_src_c047_2_08 0 bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_2_08 (mix_q_src_c047_2_08 mix_q_c047_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_09 (mix_i_src_c047_2_09 0 bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_2_09 (mix_i_src_c047_2_09 mix_i_c047_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_09 (mix_q_src_c047_2_09 0 bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_2_09 (mix_q_src_c047_2_09 mix_q_c047_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_10 (mix_i_src_c047_2_10 0 bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_2_10 (mix_i_src_c047_2_10 mix_i_c047_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_10 (mix_q_src_c047_2_10 0 bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_2_10 (mix_q_src_c047_2_10 mix_q_c047_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_11 (mix_i_src_c047_2_11 0 bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_2_11 (mix_i_src_c047_2_11 mix_i_c047_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_11 (mix_q_src_c047_2_11 0 bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_2_11 (mix_q_src_c047_2_11 mix_q_c047_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_12 (mix_i_src_c047_2_12 0 bpf_c047_2 0) vcvs gain=1.950903220161e-01
SMIXI_c047_2_12 (mix_i_src_c047_2_12 mix_i_c047_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_12 (mix_q_src_c047_2_12 0 bpf_c047_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_2_12 (mix_q_src_c047_2_12 mix_q_c047_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_13 (mix_i_src_c047_2_13 0 bpf_c047_2 0) vcvs gain=5.555702330196e-01
SMIXI_c047_2_13 (mix_i_src_c047_2_13 mix_i_c047_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_13 (mix_q_src_c047_2_13 0 bpf_c047_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_2_13 (mix_q_src_c047_2_13 mix_q_c047_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_14 (mix_i_src_c047_2_14 0 bpf_c047_2 0) vcvs gain=8.314696123025e-01
SMIXI_c047_2_14 (mix_i_src_c047_2_14 mix_i_c047_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_14 (mix_q_src_c047_2_14 0 bpf_c047_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_2_14 (mix_q_src_c047_2_14 mix_q_c047_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_2_15 (mix_i_src_c047_2_15 0 bpf_c047_2 0) vcvs gain=9.807852804032e-01
SMIXI_c047_2_15 (mix_i_src_c047_2_15 mix_i_c047_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_2_15 (mix_q_src_c047_2_15 0 bpf_c047_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_2_15 (mix_q_src_c047_2_15 mix_q_c047_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c047_2 (mix_i_c047_2 0) resistor r=1G
RMIXQ_c047_2 (mix_q_c047_2 0) resistor r=1G
RINTI_c047_2 (mix_i_c047_2 Icar_c047_2) resistor r=1k
CINTI_c047_2 (Icar_c047_2 0) capacitor c=80p
RINTQ_c047_2 (mix_q_c047_2 Qcar_c047_2) resistor r=1k
CINTQ_c047_2 (Qcar_c047_2 0) capacitor c=80p

// bl047, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c047_3 (bl047 n_cbpf_c047_3) capacitor c=2.533029591058e-14
LBPF_c047_3 (n_cbpf_c047_3 bpf_c047_3) inductor l=1.000000000000e-06
RBPF_c047_3 (bpf_c047_3 0) resistor r=3.141592653590e+02
EMIXI_c047_3_00 (mix_i_src_c047_3_00 0 bpf_c047_3 0) vcvs gain=9.807852804032e-01
SMIXI_c047_3_00 (mix_i_src_c047_3_00 mix_i_c047_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_00 (mix_q_src_c047_3_00 0 bpf_c047_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_3_00 (mix_q_src_c047_3_00 mix_q_c047_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_01 (mix_i_src_c047_3_01 0 bpf_c047_3 0) vcvs gain=8.314696123025e-01
SMIXI_c047_3_01 (mix_i_src_c047_3_01 mix_i_c047_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_01 (mix_q_src_c047_3_01 0 bpf_c047_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_3_01 (mix_q_src_c047_3_01 mix_q_c047_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_02 (mix_i_src_c047_3_02 0 bpf_c047_3 0) vcvs gain=5.555702330196e-01
SMIXI_c047_3_02 (mix_i_src_c047_3_02 mix_i_c047_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_02 (mix_q_src_c047_3_02 0 bpf_c047_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_3_02 (mix_q_src_c047_3_02 mix_q_c047_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_03 (mix_i_src_c047_3_03 0 bpf_c047_3 0) vcvs gain=1.950903220161e-01
SMIXI_c047_3_03 (mix_i_src_c047_3_03 mix_i_c047_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_03 (mix_q_src_c047_3_03 0 bpf_c047_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_3_03 (mix_q_src_c047_3_03 mix_q_c047_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_04 (mix_i_src_c047_3_04 0 bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_3_04 (mix_i_src_c047_3_04 mix_i_c047_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_04 (mix_q_src_c047_3_04 0 bpf_c047_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c047_3_04 (mix_q_src_c047_3_04 mix_q_c047_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_05 (mix_i_src_c047_3_05 0 bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_3_05 (mix_i_src_c047_3_05 mix_i_c047_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_05 (mix_q_src_c047_3_05 0 bpf_c047_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c047_3_05 (mix_q_src_c047_3_05 mix_q_c047_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_06 (mix_i_src_c047_3_06 0 bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_3_06 (mix_i_src_c047_3_06 mix_i_c047_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_06 (mix_q_src_c047_3_06 0 bpf_c047_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c047_3_06 (mix_q_src_c047_3_06 mix_q_c047_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_07 (mix_i_src_c047_3_07 0 bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_3_07 (mix_i_src_c047_3_07 mix_i_c047_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_07 (mix_q_src_c047_3_07 0 bpf_c047_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c047_3_07 (mix_q_src_c047_3_07 mix_q_c047_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_08 (mix_i_src_c047_3_08 0 bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c047_3_08 (mix_i_src_c047_3_08 mix_i_c047_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_08 (mix_q_src_c047_3_08 0 bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_3_08 (mix_q_src_c047_3_08 mix_q_c047_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_09 (mix_i_src_c047_3_09 0 bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c047_3_09 (mix_i_src_c047_3_09 mix_i_c047_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_09 (mix_q_src_c047_3_09 0 bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_3_09 (mix_q_src_c047_3_09 mix_q_c047_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_10 (mix_i_src_c047_3_10 0 bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c047_3_10 (mix_i_src_c047_3_10 mix_i_c047_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_10 (mix_q_src_c047_3_10 0 bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_3_10 (mix_q_src_c047_3_10 mix_q_c047_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_11 (mix_i_src_c047_3_11 0 bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c047_3_11 (mix_i_src_c047_3_11 mix_i_c047_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_11 (mix_q_src_c047_3_11 0 bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_3_11 (mix_q_src_c047_3_11 mix_q_c047_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_12 (mix_i_src_c047_3_12 0 bpf_c047_3 0) vcvs gain=1.950903220161e-01
SMIXI_c047_3_12 (mix_i_src_c047_3_12 mix_i_c047_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_12 (mix_q_src_c047_3_12 0 bpf_c047_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c047_3_12 (mix_q_src_c047_3_12 mix_q_c047_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_13 (mix_i_src_c047_3_13 0 bpf_c047_3 0) vcvs gain=5.555702330196e-01
SMIXI_c047_3_13 (mix_i_src_c047_3_13 mix_i_c047_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_13 (mix_q_src_c047_3_13 0 bpf_c047_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c047_3_13 (mix_q_src_c047_3_13 mix_q_c047_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_14 (mix_i_src_c047_3_14 0 bpf_c047_3 0) vcvs gain=8.314696123025e-01
SMIXI_c047_3_14 (mix_i_src_c047_3_14 mix_i_c047_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_14 (mix_q_src_c047_3_14 0 bpf_c047_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c047_3_14 (mix_q_src_c047_3_14 mix_q_c047_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c047_3_15 (mix_i_src_c047_3_15 0 bpf_c047_3 0) vcvs gain=9.807852804032e-01
SMIXI_c047_3_15 (mix_i_src_c047_3_15 mix_i_c047_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c047_3_15 (mix_q_src_c047_3_15 0 bpf_c047_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c047_3_15 (mix_q_src_c047_3_15 mix_q_c047_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c047_3 (mix_i_c047_3 0) resistor r=1G
RMIXQ_c047_3 (mix_q_c047_3 0) resistor r=1G
RINTI_c047_3 (mix_i_c047_3 Icar_c047_3) resistor r=1k
CINTI_c047_3 (Icar_c047_3 0) capacitor c=80p
RINTQ_c047_3 (mix_q_c047_3 Qcar_c047_3) resistor r=1k
CINTQ_c047_3 (Qcar_c047_3 0) capacitor c=80p

// bl048, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c048_0 (bl048 n_cbpf_c048_0) capacitor c=4.052847345694e-13
LBPF_c048_0 (n_cbpf_c048_0 bpf_c048_0) inductor l=1.000000000000e-06
RBPF_c048_0 (bpf_c048_0 0) resistor r=7.853981633974e+01
EMIXI_c048_0_00 (mix_i_src_c048_0_00 0 bpf_c048_0 0) vcvs gain=9.807852804032e-01
SMIXI_c048_0_00 (mix_i_src_c048_0_00 mix_i_c048_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_00 (mix_q_src_c048_0_00 0 bpf_c048_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_0_00 (mix_q_src_c048_0_00 mix_q_c048_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_01 (mix_i_src_c048_0_01 0 bpf_c048_0 0) vcvs gain=8.314696123025e-01
SMIXI_c048_0_01 (mix_i_src_c048_0_01 mix_i_c048_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_01 (mix_q_src_c048_0_01 0 bpf_c048_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_0_01 (mix_q_src_c048_0_01 mix_q_c048_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_02 (mix_i_src_c048_0_02 0 bpf_c048_0 0) vcvs gain=5.555702330196e-01
SMIXI_c048_0_02 (mix_i_src_c048_0_02 mix_i_c048_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_02 (mix_q_src_c048_0_02 0 bpf_c048_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_0_02 (mix_q_src_c048_0_02 mix_q_c048_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_03 (mix_i_src_c048_0_03 0 bpf_c048_0 0) vcvs gain=1.950903220161e-01
SMIXI_c048_0_03 (mix_i_src_c048_0_03 mix_i_c048_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_03 (mix_q_src_c048_0_03 0 bpf_c048_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_0_03 (mix_q_src_c048_0_03 mix_q_c048_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_04 (mix_i_src_c048_0_04 0 bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_0_04 (mix_i_src_c048_0_04 mix_i_c048_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_04 (mix_q_src_c048_0_04 0 bpf_c048_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_0_04 (mix_q_src_c048_0_04 mix_q_c048_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_05 (mix_i_src_c048_0_05 0 bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_0_05 (mix_i_src_c048_0_05 mix_i_c048_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_05 (mix_q_src_c048_0_05 0 bpf_c048_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_0_05 (mix_q_src_c048_0_05 mix_q_c048_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_06 (mix_i_src_c048_0_06 0 bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_0_06 (mix_i_src_c048_0_06 mix_i_c048_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_06 (mix_q_src_c048_0_06 0 bpf_c048_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_0_06 (mix_q_src_c048_0_06 mix_q_c048_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_07 (mix_i_src_c048_0_07 0 bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_0_07 (mix_i_src_c048_0_07 mix_i_c048_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_07 (mix_q_src_c048_0_07 0 bpf_c048_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_0_07 (mix_q_src_c048_0_07 mix_q_c048_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_08 (mix_i_src_c048_0_08 0 bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_0_08 (mix_i_src_c048_0_08 mix_i_c048_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_08 (mix_q_src_c048_0_08 0 bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_0_08 (mix_q_src_c048_0_08 mix_q_c048_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_09 (mix_i_src_c048_0_09 0 bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_0_09 (mix_i_src_c048_0_09 mix_i_c048_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_09 (mix_q_src_c048_0_09 0 bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_0_09 (mix_q_src_c048_0_09 mix_q_c048_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_10 (mix_i_src_c048_0_10 0 bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_0_10 (mix_i_src_c048_0_10 mix_i_c048_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_10 (mix_q_src_c048_0_10 0 bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_0_10 (mix_q_src_c048_0_10 mix_q_c048_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_11 (mix_i_src_c048_0_11 0 bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_0_11 (mix_i_src_c048_0_11 mix_i_c048_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_11 (mix_q_src_c048_0_11 0 bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_0_11 (mix_q_src_c048_0_11 mix_q_c048_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_12 (mix_i_src_c048_0_12 0 bpf_c048_0 0) vcvs gain=1.950903220161e-01
SMIXI_c048_0_12 (mix_i_src_c048_0_12 mix_i_c048_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_12 (mix_q_src_c048_0_12 0 bpf_c048_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_0_12 (mix_q_src_c048_0_12 mix_q_c048_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_13 (mix_i_src_c048_0_13 0 bpf_c048_0 0) vcvs gain=5.555702330196e-01
SMIXI_c048_0_13 (mix_i_src_c048_0_13 mix_i_c048_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_13 (mix_q_src_c048_0_13 0 bpf_c048_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_0_13 (mix_q_src_c048_0_13 mix_q_c048_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_14 (mix_i_src_c048_0_14 0 bpf_c048_0 0) vcvs gain=8.314696123025e-01
SMIXI_c048_0_14 (mix_i_src_c048_0_14 mix_i_c048_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_14 (mix_q_src_c048_0_14 0 bpf_c048_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_0_14 (mix_q_src_c048_0_14 mix_q_c048_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_0_15 (mix_i_src_c048_0_15 0 bpf_c048_0 0) vcvs gain=9.807852804032e-01
SMIXI_c048_0_15 (mix_i_src_c048_0_15 mix_i_c048_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_0_15 (mix_q_src_c048_0_15 0 bpf_c048_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_0_15 (mix_q_src_c048_0_15 mix_q_c048_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c048_0 (mix_i_c048_0 0) resistor r=1G
RMIXQ_c048_0 (mix_q_c048_0 0) resistor r=1G
RINTI_c048_0 (mix_i_c048_0 Icar_c048_0) resistor r=1k
CINTI_c048_0 (Icar_c048_0 0) capacitor c=80p
RINTQ_c048_0 (mix_q_c048_0 Qcar_c048_0) resistor r=1k
CINTQ_c048_0 (Qcar_c048_0 0) capacitor c=80p

// bl048, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c048_1 (bl048 n_cbpf_c048_1) capacitor c=1.013211836423e-13
LBPF_c048_1 (n_cbpf_c048_1 bpf_c048_1) inductor l=1.000000000000e-06
RBPF_c048_1 (bpf_c048_1 0) resistor r=1.570796326795e+02
EMIXI_c048_1_00 (mix_i_src_c048_1_00 0 bpf_c048_1 0) vcvs gain=9.807852804032e-01
SMIXI_c048_1_00 (mix_i_src_c048_1_00 mix_i_c048_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_00 (mix_q_src_c048_1_00 0 bpf_c048_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_1_00 (mix_q_src_c048_1_00 mix_q_c048_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_01 (mix_i_src_c048_1_01 0 bpf_c048_1 0) vcvs gain=8.314696123025e-01
SMIXI_c048_1_01 (mix_i_src_c048_1_01 mix_i_c048_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_01 (mix_q_src_c048_1_01 0 bpf_c048_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_1_01 (mix_q_src_c048_1_01 mix_q_c048_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_02 (mix_i_src_c048_1_02 0 bpf_c048_1 0) vcvs gain=5.555702330196e-01
SMIXI_c048_1_02 (mix_i_src_c048_1_02 mix_i_c048_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_02 (mix_q_src_c048_1_02 0 bpf_c048_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_1_02 (mix_q_src_c048_1_02 mix_q_c048_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_03 (mix_i_src_c048_1_03 0 bpf_c048_1 0) vcvs gain=1.950903220161e-01
SMIXI_c048_1_03 (mix_i_src_c048_1_03 mix_i_c048_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_03 (mix_q_src_c048_1_03 0 bpf_c048_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_1_03 (mix_q_src_c048_1_03 mix_q_c048_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_04 (mix_i_src_c048_1_04 0 bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_1_04 (mix_i_src_c048_1_04 mix_i_c048_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_04 (mix_q_src_c048_1_04 0 bpf_c048_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_1_04 (mix_q_src_c048_1_04 mix_q_c048_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_05 (mix_i_src_c048_1_05 0 bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_1_05 (mix_i_src_c048_1_05 mix_i_c048_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_05 (mix_q_src_c048_1_05 0 bpf_c048_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_1_05 (mix_q_src_c048_1_05 mix_q_c048_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_06 (mix_i_src_c048_1_06 0 bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_1_06 (mix_i_src_c048_1_06 mix_i_c048_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_06 (mix_q_src_c048_1_06 0 bpf_c048_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_1_06 (mix_q_src_c048_1_06 mix_q_c048_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_07 (mix_i_src_c048_1_07 0 bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_1_07 (mix_i_src_c048_1_07 mix_i_c048_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_07 (mix_q_src_c048_1_07 0 bpf_c048_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_1_07 (mix_q_src_c048_1_07 mix_q_c048_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_08 (mix_i_src_c048_1_08 0 bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_1_08 (mix_i_src_c048_1_08 mix_i_c048_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_08 (mix_q_src_c048_1_08 0 bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_1_08 (mix_q_src_c048_1_08 mix_q_c048_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_09 (mix_i_src_c048_1_09 0 bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_1_09 (mix_i_src_c048_1_09 mix_i_c048_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_09 (mix_q_src_c048_1_09 0 bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_1_09 (mix_q_src_c048_1_09 mix_q_c048_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_10 (mix_i_src_c048_1_10 0 bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_1_10 (mix_i_src_c048_1_10 mix_i_c048_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_10 (mix_q_src_c048_1_10 0 bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_1_10 (mix_q_src_c048_1_10 mix_q_c048_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_11 (mix_i_src_c048_1_11 0 bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_1_11 (mix_i_src_c048_1_11 mix_i_c048_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_11 (mix_q_src_c048_1_11 0 bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_1_11 (mix_q_src_c048_1_11 mix_q_c048_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_12 (mix_i_src_c048_1_12 0 bpf_c048_1 0) vcvs gain=1.950903220161e-01
SMIXI_c048_1_12 (mix_i_src_c048_1_12 mix_i_c048_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_12 (mix_q_src_c048_1_12 0 bpf_c048_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_1_12 (mix_q_src_c048_1_12 mix_q_c048_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_13 (mix_i_src_c048_1_13 0 bpf_c048_1 0) vcvs gain=5.555702330196e-01
SMIXI_c048_1_13 (mix_i_src_c048_1_13 mix_i_c048_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_13 (mix_q_src_c048_1_13 0 bpf_c048_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_1_13 (mix_q_src_c048_1_13 mix_q_c048_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_14 (mix_i_src_c048_1_14 0 bpf_c048_1 0) vcvs gain=8.314696123025e-01
SMIXI_c048_1_14 (mix_i_src_c048_1_14 mix_i_c048_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_14 (mix_q_src_c048_1_14 0 bpf_c048_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_1_14 (mix_q_src_c048_1_14 mix_q_c048_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_1_15 (mix_i_src_c048_1_15 0 bpf_c048_1 0) vcvs gain=9.807852804032e-01
SMIXI_c048_1_15 (mix_i_src_c048_1_15 mix_i_c048_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_1_15 (mix_q_src_c048_1_15 0 bpf_c048_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_1_15 (mix_q_src_c048_1_15 mix_q_c048_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c048_1 (mix_i_c048_1 0) resistor r=1G
RMIXQ_c048_1 (mix_q_c048_1 0) resistor r=1G
RINTI_c048_1 (mix_i_c048_1 Icar_c048_1) resistor r=1k
CINTI_c048_1 (Icar_c048_1 0) capacitor c=80p
RINTQ_c048_1 (mix_q_c048_1 Qcar_c048_1) resistor r=1k
CINTQ_c048_1 (Qcar_c048_1 0) capacitor c=80p

// bl048, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c048_2 (bl048 n_cbpf_c048_2) capacitor c=4.503163717437e-14
LBPF_c048_2 (n_cbpf_c048_2 bpf_c048_2) inductor l=1.000000000000e-06
RBPF_c048_2 (bpf_c048_2 0) resistor r=2.356194490192e+02
EMIXI_c048_2_00 (mix_i_src_c048_2_00 0 bpf_c048_2 0) vcvs gain=9.807852804032e-01
SMIXI_c048_2_00 (mix_i_src_c048_2_00 mix_i_c048_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_00 (mix_q_src_c048_2_00 0 bpf_c048_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_2_00 (mix_q_src_c048_2_00 mix_q_c048_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_01 (mix_i_src_c048_2_01 0 bpf_c048_2 0) vcvs gain=8.314696123025e-01
SMIXI_c048_2_01 (mix_i_src_c048_2_01 mix_i_c048_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_01 (mix_q_src_c048_2_01 0 bpf_c048_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_2_01 (mix_q_src_c048_2_01 mix_q_c048_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_02 (mix_i_src_c048_2_02 0 bpf_c048_2 0) vcvs gain=5.555702330196e-01
SMIXI_c048_2_02 (mix_i_src_c048_2_02 mix_i_c048_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_02 (mix_q_src_c048_2_02 0 bpf_c048_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_2_02 (mix_q_src_c048_2_02 mix_q_c048_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_03 (mix_i_src_c048_2_03 0 bpf_c048_2 0) vcvs gain=1.950903220161e-01
SMIXI_c048_2_03 (mix_i_src_c048_2_03 mix_i_c048_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_03 (mix_q_src_c048_2_03 0 bpf_c048_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_2_03 (mix_q_src_c048_2_03 mix_q_c048_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_04 (mix_i_src_c048_2_04 0 bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_2_04 (mix_i_src_c048_2_04 mix_i_c048_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_04 (mix_q_src_c048_2_04 0 bpf_c048_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_2_04 (mix_q_src_c048_2_04 mix_q_c048_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_05 (mix_i_src_c048_2_05 0 bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_2_05 (mix_i_src_c048_2_05 mix_i_c048_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_05 (mix_q_src_c048_2_05 0 bpf_c048_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_2_05 (mix_q_src_c048_2_05 mix_q_c048_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_06 (mix_i_src_c048_2_06 0 bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_2_06 (mix_i_src_c048_2_06 mix_i_c048_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_06 (mix_q_src_c048_2_06 0 bpf_c048_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_2_06 (mix_q_src_c048_2_06 mix_q_c048_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_07 (mix_i_src_c048_2_07 0 bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_2_07 (mix_i_src_c048_2_07 mix_i_c048_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_07 (mix_q_src_c048_2_07 0 bpf_c048_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_2_07 (mix_q_src_c048_2_07 mix_q_c048_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_08 (mix_i_src_c048_2_08 0 bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_2_08 (mix_i_src_c048_2_08 mix_i_c048_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_08 (mix_q_src_c048_2_08 0 bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_2_08 (mix_q_src_c048_2_08 mix_q_c048_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_09 (mix_i_src_c048_2_09 0 bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_2_09 (mix_i_src_c048_2_09 mix_i_c048_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_09 (mix_q_src_c048_2_09 0 bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_2_09 (mix_q_src_c048_2_09 mix_q_c048_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_10 (mix_i_src_c048_2_10 0 bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_2_10 (mix_i_src_c048_2_10 mix_i_c048_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_10 (mix_q_src_c048_2_10 0 bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_2_10 (mix_q_src_c048_2_10 mix_q_c048_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_11 (mix_i_src_c048_2_11 0 bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_2_11 (mix_i_src_c048_2_11 mix_i_c048_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_11 (mix_q_src_c048_2_11 0 bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_2_11 (mix_q_src_c048_2_11 mix_q_c048_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_12 (mix_i_src_c048_2_12 0 bpf_c048_2 0) vcvs gain=1.950903220161e-01
SMIXI_c048_2_12 (mix_i_src_c048_2_12 mix_i_c048_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_12 (mix_q_src_c048_2_12 0 bpf_c048_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_2_12 (mix_q_src_c048_2_12 mix_q_c048_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_13 (mix_i_src_c048_2_13 0 bpf_c048_2 0) vcvs gain=5.555702330196e-01
SMIXI_c048_2_13 (mix_i_src_c048_2_13 mix_i_c048_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_13 (mix_q_src_c048_2_13 0 bpf_c048_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_2_13 (mix_q_src_c048_2_13 mix_q_c048_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_14 (mix_i_src_c048_2_14 0 bpf_c048_2 0) vcvs gain=8.314696123025e-01
SMIXI_c048_2_14 (mix_i_src_c048_2_14 mix_i_c048_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_14 (mix_q_src_c048_2_14 0 bpf_c048_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_2_14 (mix_q_src_c048_2_14 mix_q_c048_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_2_15 (mix_i_src_c048_2_15 0 bpf_c048_2 0) vcvs gain=9.807852804032e-01
SMIXI_c048_2_15 (mix_i_src_c048_2_15 mix_i_c048_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_2_15 (mix_q_src_c048_2_15 0 bpf_c048_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_2_15 (mix_q_src_c048_2_15 mix_q_c048_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c048_2 (mix_i_c048_2 0) resistor r=1G
RMIXQ_c048_2 (mix_q_c048_2 0) resistor r=1G
RINTI_c048_2 (mix_i_c048_2 Icar_c048_2) resistor r=1k
CINTI_c048_2 (Icar_c048_2 0) capacitor c=80p
RINTQ_c048_2 (mix_q_c048_2 Qcar_c048_2) resistor r=1k
CINTQ_c048_2 (Qcar_c048_2 0) capacitor c=80p

// bl048, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c048_3 (bl048 n_cbpf_c048_3) capacitor c=2.533029591058e-14
LBPF_c048_3 (n_cbpf_c048_3 bpf_c048_3) inductor l=1.000000000000e-06
RBPF_c048_3 (bpf_c048_3 0) resistor r=3.141592653590e+02
EMIXI_c048_3_00 (mix_i_src_c048_3_00 0 bpf_c048_3 0) vcvs gain=9.807852804032e-01
SMIXI_c048_3_00 (mix_i_src_c048_3_00 mix_i_c048_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_00 (mix_q_src_c048_3_00 0 bpf_c048_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_3_00 (mix_q_src_c048_3_00 mix_q_c048_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_01 (mix_i_src_c048_3_01 0 bpf_c048_3 0) vcvs gain=8.314696123025e-01
SMIXI_c048_3_01 (mix_i_src_c048_3_01 mix_i_c048_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_01 (mix_q_src_c048_3_01 0 bpf_c048_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_3_01 (mix_q_src_c048_3_01 mix_q_c048_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_02 (mix_i_src_c048_3_02 0 bpf_c048_3 0) vcvs gain=5.555702330196e-01
SMIXI_c048_3_02 (mix_i_src_c048_3_02 mix_i_c048_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_02 (mix_q_src_c048_3_02 0 bpf_c048_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_3_02 (mix_q_src_c048_3_02 mix_q_c048_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_03 (mix_i_src_c048_3_03 0 bpf_c048_3 0) vcvs gain=1.950903220161e-01
SMIXI_c048_3_03 (mix_i_src_c048_3_03 mix_i_c048_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_03 (mix_q_src_c048_3_03 0 bpf_c048_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_3_03 (mix_q_src_c048_3_03 mix_q_c048_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_04 (mix_i_src_c048_3_04 0 bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_3_04 (mix_i_src_c048_3_04 mix_i_c048_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_04 (mix_q_src_c048_3_04 0 bpf_c048_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c048_3_04 (mix_q_src_c048_3_04 mix_q_c048_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_05 (mix_i_src_c048_3_05 0 bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_3_05 (mix_i_src_c048_3_05 mix_i_c048_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_05 (mix_q_src_c048_3_05 0 bpf_c048_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c048_3_05 (mix_q_src_c048_3_05 mix_q_c048_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_06 (mix_i_src_c048_3_06 0 bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_3_06 (mix_i_src_c048_3_06 mix_i_c048_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_06 (mix_q_src_c048_3_06 0 bpf_c048_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c048_3_06 (mix_q_src_c048_3_06 mix_q_c048_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_07 (mix_i_src_c048_3_07 0 bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_3_07 (mix_i_src_c048_3_07 mix_i_c048_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_07 (mix_q_src_c048_3_07 0 bpf_c048_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c048_3_07 (mix_q_src_c048_3_07 mix_q_c048_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_08 (mix_i_src_c048_3_08 0 bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c048_3_08 (mix_i_src_c048_3_08 mix_i_c048_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_08 (mix_q_src_c048_3_08 0 bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_3_08 (mix_q_src_c048_3_08 mix_q_c048_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_09 (mix_i_src_c048_3_09 0 bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c048_3_09 (mix_i_src_c048_3_09 mix_i_c048_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_09 (mix_q_src_c048_3_09 0 bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_3_09 (mix_q_src_c048_3_09 mix_q_c048_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_10 (mix_i_src_c048_3_10 0 bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c048_3_10 (mix_i_src_c048_3_10 mix_i_c048_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_10 (mix_q_src_c048_3_10 0 bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_3_10 (mix_q_src_c048_3_10 mix_q_c048_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_11 (mix_i_src_c048_3_11 0 bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c048_3_11 (mix_i_src_c048_3_11 mix_i_c048_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_11 (mix_q_src_c048_3_11 0 bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_3_11 (mix_q_src_c048_3_11 mix_q_c048_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_12 (mix_i_src_c048_3_12 0 bpf_c048_3 0) vcvs gain=1.950903220161e-01
SMIXI_c048_3_12 (mix_i_src_c048_3_12 mix_i_c048_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_12 (mix_q_src_c048_3_12 0 bpf_c048_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c048_3_12 (mix_q_src_c048_3_12 mix_q_c048_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_13 (mix_i_src_c048_3_13 0 bpf_c048_3 0) vcvs gain=5.555702330196e-01
SMIXI_c048_3_13 (mix_i_src_c048_3_13 mix_i_c048_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_13 (mix_q_src_c048_3_13 0 bpf_c048_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c048_3_13 (mix_q_src_c048_3_13 mix_q_c048_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_14 (mix_i_src_c048_3_14 0 bpf_c048_3 0) vcvs gain=8.314696123025e-01
SMIXI_c048_3_14 (mix_i_src_c048_3_14 mix_i_c048_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_14 (mix_q_src_c048_3_14 0 bpf_c048_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c048_3_14 (mix_q_src_c048_3_14 mix_q_c048_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c048_3_15 (mix_i_src_c048_3_15 0 bpf_c048_3 0) vcvs gain=9.807852804032e-01
SMIXI_c048_3_15 (mix_i_src_c048_3_15 mix_i_c048_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c048_3_15 (mix_q_src_c048_3_15 0 bpf_c048_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c048_3_15 (mix_q_src_c048_3_15 mix_q_c048_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c048_3 (mix_i_c048_3 0) resistor r=1G
RMIXQ_c048_3 (mix_q_c048_3 0) resistor r=1G
RINTI_c048_3 (mix_i_c048_3 Icar_c048_3) resistor r=1k
CINTI_c048_3 (Icar_c048_3 0) capacitor c=80p
RINTQ_c048_3 (mix_q_c048_3 Qcar_c048_3) resistor r=1k
CINTQ_c048_3 (Qcar_c048_3 0) capacitor c=80p

// bl049, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c049_0 (bl049 n_cbpf_c049_0) capacitor c=4.052847345694e-13
LBPF_c049_0 (n_cbpf_c049_0 bpf_c049_0) inductor l=1.000000000000e-06
RBPF_c049_0 (bpf_c049_0 0) resistor r=7.853981633974e+01
EMIXI_c049_0_00 (mix_i_src_c049_0_00 0 bpf_c049_0 0) vcvs gain=9.807852804032e-01
SMIXI_c049_0_00 (mix_i_src_c049_0_00 mix_i_c049_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_00 (mix_q_src_c049_0_00 0 bpf_c049_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_0_00 (mix_q_src_c049_0_00 mix_q_c049_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_01 (mix_i_src_c049_0_01 0 bpf_c049_0 0) vcvs gain=8.314696123025e-01
SMIXI_c049_0_01 (mix_i_src_c049_0_01 mix_i_c049_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_01 (mix_q_src_c049_0_01 0 bpf_c049_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_0_01 (mix_q_src_c049_0_01 mix_q_c049_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_02 (mix_i_src_c049_0_02 0 bpf_c049_0 0) vcvs gain=5.555702330196e-01
SMIXI_c049_0_02 (mix_i_src_c049_0_02 mix_i_c049_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_02 (mix_q_src_c049_0_02 0 bpf_c049_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_0_02 (mix_q_src_c049_0_02 mix_q_c049_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_03 (mix_i_src_c049_0_03 0 bpf_c049_0 0) vcvs gain=1.950903220161e-01
SMIXI_c049_0_03 (mix_i_src_c049_0_03 mix_i_c049_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_03 (mix_q_src_c049_0_03 0 bpf_c049_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_0_03 (mix_q_src_c049_0_03 mix_q_c049_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_04 (mix_i_src_c049_0_04 0 bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_0_04 (mix_i_src_c049_0_04 mix_i_c049_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_04 (mix_q_src_c049_0_04 0 bpf_c049_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_0_04 (mix_q_src_c049_0_04 mix_q_c049_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_05 (mix_i_src_c049_0_05 0 bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_0_05 (mix_i_src_c049_0_05 mix_i_c049_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_05 (mix_q_src_c049_0_05 0 bpf_c049_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_0_05 (mix_q_src_c049_0_05 mix_q_c049_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_06 (mix_i_src_c049_0_06 0 bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_0_06 (mix_i_src_c049_0_06 mix_i_c049_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_06 (mix_q_src_c049_0_06 0 bpf_c049_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_0_06 (mix_q_src_c049_0_06 mix_q_c049_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_07 (mix_i_src_c049_0_07 0 bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_0_07 (mix_i_src_c049_0_07 mix_i_c049_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_07 (mix_q_src_c049_0_07 0 bpf_c049_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_0_07 (mix_q_src_c049_0_07 mix_q_c049_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_08 (mix_i_src_c049_0_08 0 bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_0_08 (mix_i_src_c049_0_08 mix_i_c049_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_08 (mix_q_src_c049_0_08 0 bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_0_08 (mix_q_src_c049_0_08 mix_q_c049_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_09 (mix_i_src_c049_0_09 0 bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_0_09 (mix_i_src_c049_0_09 mix_i_c049_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_09 (mix_q_src_c049_0_09 0 bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_0_09 (mix_q_src_c049_0_09 mix_q_c049_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_10 (mix_i_src_c049_0_10 0 bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_0_10 (mix_i_src_c049_0_10 mix_i_c049_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_10 (mix_q_src_c049_0_10 0 bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_0_10 (mix_q_src_c049_0_10 mix_q_c049_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_11 (mix_i_src_c049_0_11 0 bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_0_11 (mix_i_src_c049_0_11 mix_i_c049_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_11 (mix_q_src_c049_0_11 0 bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_0_11 (mix_q_src_c049_0_11 mix_q_c049_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_12 (mix_i_src_c049_0_12 0 bpf_c049_0 0) vcvs gain=1.950903220161e-01
SMIXI_c049_0_12 (mix_i_src_c049_0_12 mix_i_c049_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_12 (mix_q_src_c049_0_12 0 bpf_c049_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_0_12 (mix_q_src_c049_0_12 mix_q_c049_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_13 (mix_i_src_c049_0_13 0 bpf_c049_0 0) vcvs gain=5.555702330196e-01
SMIXI_c049_0_13 (mix_i_src_c049_0_13 mix_i_c049_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_13 (mix_q_src_c049_0_13 0 bpf_c049_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_0_13 (mix_q_src_c049_0_13 mix_q_c049_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_14 (mix_i_src_c049_0_14 0 bpf_c049_0 0) vcvs gain=8.314696123025e-01
SMIXI_c049_0_14 (mix_i_src_c049_0_14 mix_i_c049_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_14 (mix_q_src_c049_0_14 0 bpf_c049_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_0_14 (mix_q_src_c049_0_14 mix_q_c049_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_0_15 (mix_i_src_c049_0_15 0 bpf_c049_0 0) vcvs gain=9.807852804032e-01
SMIXI_c049_0_15 (mix_i_src_c049_0_15 mix_i_c049_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_0_15 (mix_q_src_c049_0_15 0 bpf_c049_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_0_15 (mix_q_src_c049_0_15 mix_q_c049_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c049_0 (mix_i_c049_0 0) resistor r=1G
RMIXQ_c049_0 (mix_q_c049_0 0) resistor r=1G
RINTI_c049_0 (mix_i_c049_0 Icar_c049_0) resistor r=1k
CINTI_c049_0 (Icar_c049_0 0) capacitor c=80p
RINTQ_c049_0 (mix_q_c049_0 Qcar_c049_0) resistor r=1k
CINTQ_c049_0 (Qcar_c049_0 0) capacitor c=80p

// bl049, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c049_1 (bl049 n_cbpf_c049_1) capacitor c=1.013211836423e-13
LBPF_c049_1 (n_cbpf_c049_1 bpf_c049_1) inductor l=1.000000000000e-06
RBPF_c049_1 (bpf_c049_1 0) resistor r=1.570796326795e+02
EMIXI_c049_1_00 (mix_i_src_c049_1_00 0 bpf_c049_1 0) vcvs gain=9.807852804032e-01
SMIXI_c049_1_00 (mix_i_src_c049_1_00 mix_i_c049_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_00 (mix_q_src_c049_1_00 0 bpf_c049_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_1_00 (mix_q_src_c049_1_00 mix_q_c049_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_01 (mix_i_src_c049_1_01 0 bpf_c049_1 0) vcvs gain=8.314696123025e-01
SMIXI_c049_1_01 (mix_i_src_c049_1_01 mix_i_c049_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_01 (mix_q_src_c049_1_01 0 bpf_c049_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_1_01 (mix_q_src_c049_1_01 mix_q_c049_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_02 (mix_i_src_c049_1_02 0 bpf_c049_1 0) vcvs gain=5.555702330196e-01
SMIXI_c049_1_02 (mix_i_src_c049_1_02 mix_i_c049_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_02 (mix_q_src_c049_1_02 0 bpf_c049_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_1_02 (mix_q_src_c049_1_02 mix_q_c049_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_03 (mix_i_src_c049_1_03 0 bpf_c049_1 0) vcvs gain=1.950903220161e-01
SMIXI_c049_1_03 (mix_i_src_c049_1_03 mix_i_c049_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_03 (mix_q_src_c049_1_03 0 bpf_c049_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_1_03 (mix_q_src_c049_1_03 mix_q_c049_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_04 (mix_i_src_c049_1_04 0 bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_1_04 (mix_i_src_c049_1_04 mix_i_c049_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_04 (mix_q_src_c049_1_04 0 bpf_c049_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_1_04 (mix_q_src_c049_1_04 mix_q_c049_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_05 (mix_i_src_c049_1_05 0 bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_1_05 (mix_i_src_c049_1_05 mix_i_c049_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_05 (mix_q_src_c049_1_05 0 bpf_c049_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_1_05 (mix_q_src_c049_1_05 mix_q_c049_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_06 (mix_i_src_c049_1_06 0 bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_1_06 (mix_i_src_c049_1_06 mix_i_c049_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_06 (mix_q_src_c049_1_06 0 bpf_c049_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_1_06 (mix_q_src_c049_1_06 mix_q_c049_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_07 (mix_i_src_c049_1_07 0 bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_1_07 (mix_i_src_c049_1_07 mix_i_c049_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_07 (mix_q_src_c049_1_07 0 bpf_c049_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_1_07 (mix_q_src_c049_1_07 mix_q_c049_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_08 (mix_i_src_c049_1_08 0 bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_1_08 (mix_i_src_c049_1_08 mix_i_c049_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_08 (mix_q_src_c049_1_08 0 bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_1_08 (mix_q_src_c049_1_08 mix_q_c049_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_09 (mix_i_src_c049_1_09 0 bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_1_09 (mix_i_src_c049_1_09 mix_i_c049_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_09 (mix_q_src_c049_1_09 0 bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_1_09 (mix_q_src_c049_1_09 mix_q_c049_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_10 (mix_i_src_c049_1_10 0 bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_1_10 (mix_i_src_c049_1_10 mix_i_c049_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_10 (mix_q_src_c049_1_10 0 bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_1_10 (mix_q_src_c049_1_10 mix_q_c049_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_11 (mix_i_src_c049_1_11 0 bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_1_11 (mix_i_src_c049_1_11 mix_i_c049_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_11 (mix_q_src_c049_1_11 0 bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_1_11 (mix_q_src_c049_1_11 mix_q_c049_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_12 (mix_i_src_c049_1_12 0 bpf_c049_1 0) vcvs gain=1.950903220161e-01
SMIXI_c049_1_12 (mix_i_src_c049_1_12 mix_i_c049_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_12 (mix_q_src_c049_1_12 0 bpf_c049_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_1_12 (mix_q_src_c049_1_12 mix_q_c049_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_13 (mix_i_src_c049_1_13 0 bpf_c049_1 0) vcvs gain=5.555702330196e-01
SMIXI_c049_1_13 (mix_i_src_c049_1_13 mix_i_c049_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_13 (mix_q_src_c049_1_13 0 bpf_c049_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_1_13 (mix_q_src_c049_1_13 mix_q_c049_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_14 (mix_i_src_c049_1_14 0 bpf_c049_1 0) vcvs gain=8.314696123025e-01
SMIXI_c049_1_14 (mix_i_src_c049_1_14 mix_i_c049_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_14 (mix_q_src_c049_1_14 0 bpf_c049_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_1_14 (mix_q_src_c049_1_14 mix_q_c049_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_1_15 (mix_i_src_c049_1_15 0 bpf_c049_1 0) vcvs gain=9.807852804032e-01
SMIXI_c049_1_15 (mix_i_src_c049_1_15 mix_i_c049_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_1_15 (mix_q_src_c049_1_15 0 bpf_c049_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_1_15 (mix_q_src_c049_1_15 mix_q_c049_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c049_1 (mix_i_c049_1 0) resistor r=1G
RMIXQ_c049_1 (mix_q_c049_1 0) resistor r=1G
RINTI_c049_1 (mix_i_c049_1 Icar_c049_1) resistor r=1k
CINTI_c049_1 (Icar_c049_1 0) capacitor c=80p
RINTQ_c049_1 (mix_q_c049_1 Qcar_c049_1) resistor r=1k
CINTQ_c049_1 (Qcar_c049_1 0) capacitor c=80p

// bl049, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c049_2 (bl049 n_cbpf_c049_2) capacitor c=4.503163717437e-14
LBPF_c049_2 (n_cbpf_c049_2 bpf_c049_2) inductor l=1.000000000000e-06
RBPF_c049_2 (bpf_c049_2 0) resistor r=2.356194490192e+02
EMIXI_c049_2_00 (mix_i_src_c049_2_00 0 bpf_c049_2 0) vcvs gain=9.807852804032e-01
SMIXI_c049_2_00 (mix_i_src_c049_2_00 mix_i_c049_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_00 (mix_q_src_c049_2_00 0 bpf_c049_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_2_00 (mix_q_src_c049_2_00 mix_q_c049_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_01 (mix_i_src_c049_2_01 0 bpf_c049_2 0) vcvs gain=8.314696123025e-01
SMIXI_c049_2_01 (mix_i_src_c049_2_01 mix_i_c049_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_01 (mix_q_src_c049_2_01 0 bpf_c049_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_2_01 (mix_q_src_c049_2_01 mix_q_c049_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_02 (mix_i_src_c049_2_02 0 bpf_c049_2 0) vcvs gain=5.555702330196e-01
SMIXI_c049_2_02 (mix_i_src_c049_2_02 mix_i_c049_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_02 (mix_q_src_c049_2_02 0 bpf_c049_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_2_02 (mix_q_src_c049_2_02 mix_q_c049_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_03 (mix_i_src_c049_2_03 0 bpf_c049_2 0) vcvs gain=1.950903220161e-01
SMIXI_c049_2_03 (mix_i_src_c049_2_03 mix_i_c049_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_03 (mix_q_src_c049_2_03 0 bpf_c049_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_2_03 (mix_q_src_c049_2_03 mix_q_c049_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_04 (mix_i_src_c049_2_04 0 bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_2_04 (mix_i_src_c049_2_04 mix_i_c049_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_04 (mix_q_src_c049_2_04 0 bpf_c049_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_2_04 (mix_q_src_c049_2_04 mix_q_c049_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_05 (mix_i_src_c049_2_05 0 bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_2_05 (mix_i_src_c049_2_05 mix_i_c049_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_05 (mix_q_src_c049_2_05 0 bpf_c049_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_2_05 (mix_q_src_c049_2_05 mix_q_c049_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_06 (mix_i_src_c049_2_06 0 bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_2_06 (mix_i_src_c049_2_06 mix_i_c049_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_06 (mix_q_src_c049_2_06 0 bpf_c049_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_2_06 (mix_q_src_c049_2_06 mix_q_c049_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_07 (mix_i_src_c049_2_07 0 bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_2_07 (mix_i_src_c049_2_07 mix_i_c049_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_07 (mix_q_src_c049_2_07 0 bpf_c049_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_2_07 (mix_q_src_c049_2_07 mix_q_c049_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_08 (mix_i_src_c049_2_08 0 bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_2_08 (mix_i_src_c049_2_08 mix_i_c049_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_08 (mix_q_src_c049_2_08 0 bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_2_08 (mix_q_src_c049_2_08 mix_q_c049_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_09 (mix_i_src_c049_2_09 0 bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_2_09 (mix_i_src_c049_2_09 mix_i_c049_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_09 (mix_q_src_c049_2_09 0 bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_2_09 (mix_q_src_c049_2_09 mix_q_c049_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_10 (mix_i_src_c049_2_10 0 bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_2_10 (mix_i_src_c049_2_10 mix_i_c049_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_10 (mix_q_src_c049_2_10 0 bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_2_10 (mix_q_src_c049_2_10 mix_q_c049_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_11 (mix_i_src_c049_2_11 0 bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_2_11 (mix_i_src_c049_2_11 mix_i_c049_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_11 (mix_q_src_c049_2_11 0 bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_2_11 (mix_q_src_c049_2_11 mix_q_c049_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_12 (mix_i_src_c049_2_12 0 bpf_c049_2 0) vcvs gain=1.950903220161e-01
SMIXI_c049_2_12 (mix_i_src_c049_2_12 mix_i_c049_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_12 (mix_q_src_c049_2_12 0 bpf_c049_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_2_12 (mix_q_src_c049_2_12 mix_q_c049_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_13 (mix_i_src_c049_2_13 0 bpf_c049_2 0) vcvs gain=5.555702330196e-01
SMIXI_c049_2_13 (mix_i_src_c049_2_13 mix_i_c049_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_13 (mix_q_src_c049_2_13 0 bpf_c049_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_2_13 (mix_q_src_c049_2_13 mix_q_c049_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_14 (mix_i_src_c049_2_14 0 bpf_c049_2 0) vcvs gain=8.314696123025e-01
SMIXI_c049_2_14 (mix_i_src_c049_2_14 mix_i_c049_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_14 (mix_q_src_c049_2_14 0 bpf_c049_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_2_14 (mix_q_src_c049_2_14 mix_q_c049_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_2_15 (mix_i_src_c049_2_15 0 bpf_c049_2 0) vcvs gain=9.807852804032e-01
SMIXI_c049_2_15 (mix_i_src_c049_2_15 mix_i_c049_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_2_15 (mix_q_src_c049_2_15 0 bpf_c049_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_2_15 (mix_q_src_c049_2_15 mix_q_c049_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c049_2 (mix_i_c049_2 0) resistor r=1G
RMIXQ_c049_2 (mix_q_c049_2 0) resistor r=1G
RINTI_c049_2 (mix_i_c049_2 Icar_c049_2) resistor r=1k
CINTI_c049_2 (Icar_c049_2 0) capacitor c=80p
RINTQ_c049_2 (mix_q_c049_2 Qcar_c049_2) resistor r=1k
CINTQ_c049_2 (Qcar_c049_2 0) capacitor c=80p

// bl049, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c049_3 (bl049 n_cbpf_c049_3) capacitor c=2.533029591058e-14
LBPF_c049_3 (n_cbpf_c049_3 bpf_c049_3) inductor l=1.000000000000e-06
RBPF_c049_3 (bpf_c049_3 0) resistor r=3.141592653590e+02
EMIXI_c049_3_00 (mix_i_src_c049_3_00 0 bpf_c049_3 0) vcvs gain=9.807852804032e-01
SMIXI_c049_3_00 (mix_i_src_c049_3_00 mix_i_c049_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_00 (mix_q_src_c049_3_00 0 bpf_c049_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_3_00 (mix_q_src_c049_3_00 mix_q_c049_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_01 (mix_i_src_c049_3_01 0 bpf_c049_3 0) vcvs gain=8.314696123025e-01
SMIXI_c049_3_01 (mix_i_src_c049_3_01 mix_i_c049_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_01 (mix_q_src_c049_3_01 0 bpf_c049_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_3_01 (mix_q_src_c049_3_01 mix_q_c049_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_02 (mix_i_src_c049_3_02 0 bpf_c049_3 0) vcvs gain=5.555702330196e-01
SMIXI_c049_3_02 (mix_i_src_c049_3_02 mix_i_c049_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_02 (mix_q_src_c049_3_02 0 bpf_c049_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_3_02 (mix_q_src_c049_3_02 mix_q_c049_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_03 (mix_i_src_c049_3_03 0 bpf_c049_3 0) vcvs gain=1.950903220161e-01
SMIXI_c049_3_03 (mix_i_src_c049_3_03 mix_i_c049_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_03 (mix_q_src_c049_3_03 0 bpf_c049_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_3_03 (mix_q_src_c049_3_03 mix_q_c049_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_04 (mix_i_src_c049_3_04 0 bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_3_04 (mix_i_src_c049_3_04 mix_i_c049_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_04 (mix_q_src_c049_3_04 0 bpf_c049_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c049_3_04 (mix_q_src_c049_3_04 mix_q_c049_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_05 (mix_i_src_c049_3_05 0 bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_3_05 (mix_i_src_c049_3_05 mix_i_c049_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_05 (mix_q_src_c049_3_05 0 bpf_c049_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c049_3_05 (mix_q_src_c049_3_05 mix_q_c049_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_06 (mix_i_src_c049_3_06 0 bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_3_06 (mix_i_src_c049_3_06 mix_i_c049_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_06 (mix_q_src_c049_3_06 0 bpf_c049_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c049_3_06 (mix_q_src_c049_3_06 mix_q_c049_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_07 (mix_i_src_c049_3_07 0 bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_3_07 (mix_i_src_c049_3_07 mix_i_c049_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_07 (mix_q_src_c049_3_07 0 bpf_c049_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c049_3_07 (mix_q_src_c049_3_07 mix_q_c049_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_08 (mix_i_src_c049_3_08 0 bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c049_3_08 (mix_i_src_c049_3_08 mix_i_c049_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_08 (mix_q_src_c049_3_08 0 bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_3_08 (mix_q_src_c049_3_08 mix_q_c049_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_09 (mix_i_src_c049_3_09 0 bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c049_3_09 (mix_i_src_c049_3_09 mix_i_c049_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_09 (mix_q_src_c049_3_09 0 bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_3_09 (mix_q_src_c049_3_09 mix_q_c049_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_10 (mix_i_src_c049_3_10 0 bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c049_3_10 (mix_i_src_c049_3_10 mix_i_c049_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_10 (mix_q_src_c049_3_10 0 bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_3_10 (mix_q_src_c049_3_10 mix_q_c049_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_11 (mix_i_src_c049_3_11 0 bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c049_3_11 (mix_i_src_c049_3_11 mix_i_c049_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_11 (mix_q_src_c049_3_11 0 bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_3_11 (mix_q_src_c049_3_11 mix_q_c049_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_12 (mix_i_src_c049_3_12 0 bpf_c049_3 0) vcvs gain=1.950903220161e-01
SMIXI_c049_3_12 (mix_i_src_c049_3_12 mix_i_c049_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_12 (mix_q_src_c049_3_12 0 bpf_c049_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c049_3_12 (mix_q_src_c049_3_12 mix_q_c049_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_13 (mix_i_src_c049_3_13 0 bpf_c049_3 0) vcvs gain=5.555702330196e-01
SMIXI_c049_3_13 (mix_i_src_c049_3_13 mix_i_c049_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_13 (mix_q_src_c049_3_13 0 bpf_c049_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c049_3_13 (mix_q_src_c049_3_13 mix_q_c049_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_14 (mix_i_src_c049_3_14 0 bpf_c049_3 0) vcvs gain=8.314696123025e-01
SMIXI_c049_3_14 (mix_i_src_c049_3_14 mix_i_c049_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_14 (mix_q_src_c049_3_14 0 bpf_c049_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c049_3_14 (mix_q_src_c049_3_14 mix_q_c049_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c049_3_15 (mix_i_src_c049_3_15 0 bpf_c049_3 0) vcvs gain=9.807852804032e-01
SMIXI_c049_3_15 (mix_i_src_c049_3_15 mix_i_c049_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c049_3_15 (mix_q_src_c049_3_15 0 bpf_c049_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c049_3_15 (mix_q_src_c049_3_15 mix_q_c049_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c049_3 (mix_i_c049_3 0) resistor r=1G
RMIXQ_c049_3 (mix_q_c049_3 0) resistor r=1G
RINTI_c049_3 (mix_i_c049_3 Icar_c049_3) resistor r=1k
CINTI_c049_3 (Icar_c049_3 0) capacitor c=80p
RINTQ_c049_3 (mix_q_c049_3 Qcar_c049_3) resistor r=1k
CINTQ_c049_3 (Qcar_c049_3 0) capacitor c=80p

// bl050, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c050_0 (bl050 n_cbpf_c050_0) capacitor c=4.052847345694e-13
LBPF_c050_0 (n_cbpf_c050_0 bpf_c050_0) inductor l=1.000000000000e-06
RBPF_c050_0 (bpf_c050_0 0) resistor r=7.853981633974e+01
EMIXI_c050_0_00 (mix_i_src_c050_0_00 0 bpf_c050_0 0) vcvs gain=9.807852804032e-01
SMIXI_c050_0_00 (mix_i_src_c050_0_00 mix_i_c050_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_00 (mix_q_src_c050_0_00 0 bpf_c050_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_0_00 (mix_q_src_c050_0_00 mix_q_c050_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_01 (mix_i_src_c050_0_01 0 bpf_c050_0 0) vcvs gain=8.314696123025e-01
SMIXI_c050_0_01 (mix_i_src_c050_0_01 mix_i_c050_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_01 (mix_q_src_c050_0_01 0 bpf_c050_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_0_01 (mix_q_src_c050_0_01 mix_q_c050_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_02 (mix_i_src_c050_0_02 0 bpf_c050_0 0) vcvs gain=5.555702330196e-01
SMIXI_c050_0_02 (mix_i_src_c050_0_02 mix_i_c050_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_02 (mix_q_src_c050_0_02 0 bpf_c050_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_0_02 (mix_q_src_c050_0_02 mix_q_c050_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_03 (mix_i_src_c050_0_03 0 bpf_c050_0 0) vcvs gain=1.950903220161e-01
SMIXI_c050_0_03 (mix_i_src_c050_0_03 mix_i_c050_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_03 (mix_q_src_c050_0_03 0 bpf_c050_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_0_03 (mix_q_src_c050_0_03 mix_q_c050_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_04 (mix_i_src_c050_0_04 0 bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_0_04 (mix_i_src_c050_0_04 mix_i_c050_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_04 (mix_q_src_c050_0_04 0 bpf_c050_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_0_04 (mix_q_src_c050_0_04 mix_q_c050_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_05 (mix_i_src_c050_0_05 0 bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_0_05 (mix_i_src_c050_0_05 mix_i_c050_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_05 (mix_q_src_c050_0_05 0 bpf_c050_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_0_05 (mix_q_src_c050_0_05 mix_q_c050_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_06 (mix_i_src_c050_0_06 0 bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_0_06 (mix_i_src_c050_0_06 mix_i_c050_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_06 (mix_q_src_c050_0_06 0 bpf_c050_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_0_06 (mix_q_src_c050_0_06 mix_q_c050_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_07 (mix_i_src_c050_0_07 0 bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_0_07 (mix_i_src_c050_0_07 mix_i_c050_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_07 (mix_q_src_c050_0_07 0 bpf_c050_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_0_07 (mix_q_src_c050_0_07 mix_q_c050_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_08 (mix_i_src_c050_0_08 0 bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_0_08 (mix_i_src_c050_0_08 mix_i_c050_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_08 (mix_q_src_c050_0_08 0 bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_0_08 (mix_q_src_c050_0_08 mix_q_c050_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_09 (mix_i_src_c050_0_09 0 bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_0_09 (mix_i_src_c050_0_09 mix_i_c050_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_09 (mix_q_src_c050_0_09 0 bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_0_09 (mix_q_src_c050_0_09 mix_q_c050_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_10 (mix_i_src_c050_0_10 0 bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_0_10 (mix_i_src_c050_0_10 mix_i_c050_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_10 (mix_q_src_c050_0_10 0 bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_0_10 (mix_q_src_c050_0_10 mix_q_c050_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_11 (mix_i_src_c050_0_11 0 bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_0_11 (mix_i_src_c050_0_11 mix_i_c050_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_11 (mix_q_src_c050_0_11 0 bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_0_11 (mix_q_src_c050_0_11 mix_q_c050_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_12 (mix_i_src_c050_0_12 0 bpf_c050_0 0) vcvs gain=1.950903220161e-01
SMIXI_c050_0_12 (mix_i_src_c050_0_12 mix_i_c050_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_12 (mix_q_src_c050_0_12 0 bpf_c050_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_0_12 (mix_q_src_c050_0_12 mix_q_c050_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_13 (mix_i_src_c050_0_13 0 bpf_c050_0 0) vcvs gain=5.555702330196e-01
SMIXI_c050_0_13 (mix_i_src_c050_0_13 mix_i_c050_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_13 (mix_q_src_c050_0_13 0 bpf_c050_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_0_13 (mix_q_src_c050_0_13 mix_q_c050_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_14 (mix_i_src_c050_0_14 0 bpf_c050_0 0) vcvs gain=8.314696123025e-01
SMIXI_c050_0_14 (mix_i_src_c050_0_14 mix_i_c050_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_14 (mix_q_src_c050_0_14 0 bpf_c050_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_0_14 (mix_q_src_c050_0_14 mix_q_c050_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_0_15 (mix_i_src_c050_0_15 0 bpf_c050_0 0) vcvs gain=9.807852804032e-01
SMIXI_c050_0_15 (mix_i_src_c050_0_15 mix_i_c050_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_0_15 (mix_q_src_c050_0_15 0 bpf_c050_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_0_15 (mix_q_src_c050_0_15 mix_q_c050_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c050_0 (mix_i_c050_0 0) resistor r=1G
RMIXQ_c050_0 (mix_q_c050_0 0) resistor r=1G
RINTI_c050_0 (mix_i_c050_0 Icar_c050_0) resistor r=1k
CINTI_c050_0 (Icar_c050_0 0) capacitor c=80p
RINTQ_c050_0 (mix_q_c050_0 Qcar_c050_0) resistor r=1k
CINTQ_c050_0 (Qcar_c050_0 0) capacitor c=80p

// bl050, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c050_1 (bl050 n_cbpf_c050_1) capacitor c=1.013211836423e-13
LBPF_c050_1 (n_cbpf_c050_1 bpf_c050_1) inductor l=1.000000000000e-06
RBPF_c050_1 (bpf_c050_1 0) resistor r=1.570796326795e+02
EMIXI_c050_1_00 (mix_i_src_c050_1_00 0 bpf_c050_1 0) vcvs gain=9.807852804032e-01
SMIXI_c050_1_00 (mix_i_src_c050_1_00 mix_i_c050_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_00 (mix_q_src_c050_1_00 0 bpf_c050_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_1_00 (mix_q_src_c050_1_00 mix_q_c050_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_01 (mix_i_src_c050_1_01 0 bpf_c050_1 0) vcvs gain=8.314696123025e-01
SMIXI_c050_1_01 (mix_i_src_c050_1_01 mix_i_c050_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_01 (mix_q_src_c050_1_01 0 bpf_c050_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_1_01 (mix_q_src_c050_1_01 mix_q_c050_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_02 (mix_i_src_c050_1_02 0 bpf_c050_1 0) vcvs gain=5.555702330196e-01
SMIXI_c050_1_02 (mix_i_src_c050_1_02 mix_i_c050_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_02 (mix_q_src_c050_1_02 0 bpf_c050_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_1_02 (mix_q_src_c050_1_02 mix_q_c050_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_03 (mix_i_src_c050_1_03 0 bpf_c050_1 0) vcvs gain=1.950903220161e-01
SMIXI_c050_1_03 (mix_i_src_c050_1_03 mix_i_c050_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_03 (mix_q_src_c050_1_03 0 bpf_c050_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_1_03 (mix_q_src_c050_1_03 mix_q_c050_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_04 (mix_i_src_c050_1_04 0 bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_1_04 (mix_i_src_c050_1_04 mix_i_c050_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_04 (mix_q_src_c050_1_04 0 bpf_c050_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_1_04 (mix_q_src_c050_1_04 mix_q_c050_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_05 (mix_i_src_c050_1_05 0 bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_1_05 (mix_i_src_c050_1_05 mix_i_c050_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_05 (mix_q_src_c050_1_05 0 bpf_c050_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_1_05 (mix_q_src_c050_1_05 mix_q_c050_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_06 (mix_i_src_c050_1_06 0 bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_1_06 (mix_i_src_c050_1_06 mix_i_c050_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_06 (mix_q_src_c050_1_06 0 bpf_c050_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_1_06 (mix_q_src_c050_1_06 mix_q_c050_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_07 (mix_i_src_c050_1_07 0 bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_1_07 (mix_i_src_c050_1_07 mix_i_c050_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_07 (mix_q_src_c050_1_07 0 bpf_c050_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_1_07 (mix_q_src_c050_1_07 mix_q_c050_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_08 (mix_i_src_c050_1_08 0 bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_1_08 (mix_i_src_c050_1_08 mix_i_c050_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_08 (mix_q_src_c050_1_08 0 bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_1_08 (mix_q_src_c050_1_08 mix_q_c050_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_09 (mix_i_src_c050_1_09 0 bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_1_09 (mix_i_src_c050_1_09 mix_i_c050_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_09 (mix_q_src_c050_1_09 0 bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_1_09 (mix_q_src_c050_1_09 mix_q_c050_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_10 (mix_i_src_c050_1_10 0 bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_1_10 (mix_i_src_c050_1_10 mix_i_c050_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_10 (mix_q_src_c050_1_10 0 bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_1_10 (mix_q_src_c050_1_10 mix_q_c050_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_11 (mix_i_src_c050_1_11 0 bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_1_11 (mix_i_src_c050_1_11 mix_i_c050_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_11 (mix_q_src_c050_1_11 0 bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_1_11 (mix_q_src_c050_1_11 mix_q_c050_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_12 (mix_i_src_c050_1_12 0 bpf_c050_1 0) vcvs gain=1.950903220161e-01
SMIXI_c050_1_12 (mix_i_src_c050_1_12 mix_i_c050_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_12 (mix_q_src_c050_1_12 0 bpf_c050_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_1_12 (mix_q_src_c050_1_12 mix_q_c050_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_13 (mix_i_src_c050_1_13 0 bpf_c050_1 0) vcvs gain=5.555702330196e-01
SMIXI_c050_1_13 (mix_i_src_c050_1_13 mix_i_c050_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_13 (mix_q_src_c050_1_13 0 bpf_c050_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_1_13 (mix_q_src_c050_1_13 mix_q_c050_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_14 (mix_i_src_c050_1_14 0 bpf_c050_1 0) vcvs gain=8.314696123025e-01
SMIXI_c050_1_14 (mix_i_src_c050_1_14 mix_i_c050_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_14 (mix_q_src_c050_1_14 0 bpf_c050_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_1_14 (mix_q_src_c050_1_14 mix_q_c050_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_1_15 (mix_i_src_c050_1_15 0 bpf_c050_1 0) vcvs gain=9.807852804032e-01
SMIXI_c050_1_15 (mix_i_src_c050_1_15 mix_i_c050_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_1_15 (mix_q_src_c050_1_15 0 bpf_c050_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_1_15 (mix_q_src_c050_1_15 mix_q_c050_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c050_1 (mix_i_c050_1 0) resistor r=1G
RMIXQ_c050_1 (mix_q_c050_1 0) resistor r=1G
RINTI_c050_1 (mix_i_c050_1 Icar_c050_1) resistor r=1k
CINTI_c050_1 (Icar_c050_1 0) capacitor c=80p
RINTQ_c050_1 (mix_q_c050_1 Qcar_c050_1) resistor r=1k
CINTQ_c050_1 (Qcar_c050_1 0) capacitor c=80p

// bl050, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c050_2 (bl050 n_cbpf_c050_2) capacitor c=4.503163717437e-14
LBPF_c050_2 (n_cbpf_c050_2 bpf_c050_2) inductor l=1.000000000000e-06
RBPF_c050_2 (bpf_c050_2 0) resistor r=2.356194490192e+02
EMIXI_c050_2_00 (mix_i_src_c050_2_00 0 bpf_c050_2 0) vcvs gain=9.807852804032e-01
SMIXI_c050_2_00 (mix_i_src_c050_2_00 mix_i_c050_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_00 (mix_q_src_c050_2_00 0 bpf_c050_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_2_00 (mix_q_src_c050_2_00 mix_q_c050_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_01 (mix_i_src_c050_2_01 0 bpf_c050_2 0) vcvs gain=8.314696123025e-01
SMIXI_c050_2_01 (mix_i_src_c050_2_01 mix_i_c050_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_01 (mix_q_src_c050_2_01 0 bpf_c050_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_2_01 (mix_q_src_c050_2_01 mix_q_c050_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_02 (mix_i_src_c050_2_02 0 bpf_c050_2 0) vcvs gain=5.555702330196e-01
SMIXI_c050_2_02 (mix_i_src_c050_2_02 mix_i_c050_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_02 (mix_q_src_c050_2_02 0 bpf_c050_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_2_02 (mix_q_src_c050_2_02 mix_q_c050_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_03 (mix_i_src_c050_2_03 0 bpf_c050_2 0) vcvs gain=1.950903220161e-01
SMIXI_c050_2_03 (mix_i_src_c050_2_03 mix_i_c050_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_03 (mix_q_src_c050_2_03 0 bpf_c050_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_2_03 (mix_q_src_c050_2_03 mix_q_c050_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_04 (mix_i_src_c050_2_04 0 bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_2_04 (mix_i_src_c050_2_04 mix_i_c050_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_04 (mix_q_src_c050_2_04 0 bpf_c050_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_2_04 (mix_q_src_c050_2_04 mix_q_c050_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_05 (mix_i_src_c050_2_05 0 bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_2_05 (mix_i_src_c050_2_05 mix_i_c050_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_05 (mix_q_src_c050_2_05 0 bpf_c050_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_2_05 (mix_q_src_c050_2_05 mix_q_c050_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_06 (mix_i_src_c050_2_06 0 bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_2_06 (mix_i_src_c050_2_06 mix_i_c050_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_06 (mix_q_src_c050_2_06 0 bpf_c050_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_2_06 (mix_q_src_c050_2_06 mix_q_c050_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_07 (mix_i_src_c050_2_07 0 bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_2_07 (mix_i_src_c050_2_07 mix_i_c050_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_07 (mix_q_src_c050_2_07 0 bpf_c050_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_2_07 (mix_q_src_c050_2_07 mix_q_c050_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_08 (mix_i_src_c050_2_08 0 bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_2_08 (mix_i_src_c050_2_08 mix_i_c050_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_08 (mix_q_src_c050_2_08 0 bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_2_08 (mix_q_src_c050_2_08 mix_q_c050_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_09 (mix_i_src_c050_2_09 0 bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_2_09 (mix_i_src_c050_2_09 mix_i_c050_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_09 (mix_q_src_c050_2_09 0 bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_2_09 (mix_q_src_c050_2_09 mix_q_c050_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_10 (mix_i_src_c050_2_10 0 bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_2_10 (mix_i_src_c050_2_10 mix_i_c050_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_10 (mix_q_src_c050_2_10 0 bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_2_10 (mix_q_src_c050_2_10 mix_q_c050_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_11 (mix_i_src_c050_2_11 0 bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_2_11 (mix_i_src_c050_2_11 mix_i_c050_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_11 (mix_q_src_c050_2_11 0 bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_2_11 (mix_q_src_c050_2_11 mix_q_c050_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_12 (mix_i_src_c050_2_12 0 bpf_c050_2 0) vcvs gain=1.950903220161e-01
SMIXI_c050_2_12 (mix_i_src_c050_2_12 mix_i_c050_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_12 (mix_q_src_c050_2_12 0 bpf_c050_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_2_12 (mix_q_src_c050_2_12 mix_q_c050_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_13 (mix_i_src_c050_2_13 0 bpf_c050_2 0) vcvs gain=5.555702330196e-01
SMIXI_c050_2_13 (mix_i_src_c050_2_13 mix_i_c050_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_13 (mix_q_src_c050_2_13 0 bpf_c050_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_2_13 (mix_q_src_c050_2_13 mix_q_c050_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_14 (mix_i_src_c050_2_14 0 bpf_c050_2 0) vcvs gain=8.314696123025e-01
SMIXI_c050_2_14 (mix_i_src_c050_2_14 mix_i_c050_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_14 (mix_q_src_c050_2_14 0 bpf_c050_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_2_14 (mix_q_src_c050_2_14 mix_q_c050_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_2_15 (mix_i_src_c050_2_15 0 bpf_c050_2 0) vcvs gain=9.807852804032e-01
SMIXI_c050_2_15 (mix_i_src_c050_2_15 mix_i_c050_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_2_15 (mix_q_src_c050_2_15 0 bpf_c050_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_2_15 (mix_q_src_c050_2_15 mix_q_c050_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c050_2 (mix_i_c050_2 0) resistor r=1G
RMIXQ_c050_2 (mix_q_c050_2 0) resistor r=1G
RINTI_c050_2 (mix_i_c050_2 Icar_c050_2) resistor r=1k
CINTI_c050_2 (Icar_c050_2 0) capacitor c=80p
RINTQ_c050_2 (mix_q_c050_2 Qcar_c050_2) resistor r=1k
CINTQ_c050_2 (Qcar_c050_2 0) capacitor c=80p

// bl050, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c050_3 (bl050 n_cbpf_c050_3) capacitor c=2.533029591058e-14
LBPF_c050_3 (n_cbpf_c050_3 bpf_c050_3) inductor l=1.000000000000e-06
RBPF_c050_3 (bpf_c050_3 0) resistor r=3.141592653590e+02
EMIXI_c050_3_00 (mix_i_src_c050_3_00 0 bpf_c050_3 0) vcvs gain=9.807852804032e-01
SMIXI_c050_3_00 (mix_i_src_c050_3_00 mix_i_c050_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_00 (mix_q_src_c050_3_00 0 bpf_c050_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_3_00 (mix_q_src_c050_3_00 mix_q_c050_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_01 (mix_i_src_c050_3_01 0 bpf_c050_3 0) vcvs gain=8.314696123025e-01
SMIXI_c050_3_01 (mix_i_src_c050_3_01 mix_i_c050_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_01 (mix_q_src_c050_3_01 0 bpf_c050_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_3_01 (mix_q_src_c050_3_01 mix_q_c050_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_02 (mix_i_src_c050_3_02 0 bpf_c050_3 0) vcvs gain=5.555702330196e-01
SMIXI_c050_3_02 (mix_i_src_c050_3_02 mix_i_c050_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_02 (mix_q_src_c050_3_02 0 bpf_c050_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_3_02 (mix_q_src_c050_3_02 mix_q_c050_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_03 (mix_i_src_c050_3_03 0 bpf_c050_3 0) vcvs gain=1.950903220161e-01
SMIXI_c050_3_03 (mix_i_src_c050_3_03 mix_i_c050_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_03 (mix_q_src_c050_3_03 0 bpf_c050_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_3_03 (mix_q_src_c050_3_03 mix_q_c050_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_04 (mix_i_src_c050_3_04 0 bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_3_04 (mix_i_src_c050_3_04 mix_i_c050_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_04 (mix_q_src_c050_3_04 0 bpf_c050_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c050_3_04 (mix_q_src_c050_3_04 mix_q_c050_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_05 (mix_i_src_c050_3_05 0 bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_3_05 (mix_i_src_c050_3_05 mix_i_c050_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_05 (mix_q_src_c050_3_05 0 bpf_c050_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c050_3_05 (mix_q_src_c050_3_05 mix_q_c050_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_06 (mix_i_src_c050_3_06 0 bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_3_06 (mix_i_src_c050_3_06 mix_i_c050_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_06 (mix_q_src_c050_3_06 0 bpf_c050_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c050_3_06 (mix_q_src_c050_3_06 mix_q_c050_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_07 (mix_i_src_c050_3_07 0 bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_3_07 (mix_i_src_c050_3_07 mix_i_c050_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_07 (mix_q_src_c050_3_07 0 bpf_c050_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c050_3_07 (mix_q_src_c050_3_07 mix_q_c050_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_08 (mix_i_src_c050_3_08 0 bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c050_3_08 (mix_i_src_c050_3_08 mix_i_c050_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_08 (mix_q_src_c050_3_08 0 bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_3_08 (mix_q_src_c050_3_08 mix_q_c050_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_09 (mix_i_src_c050_3_09 0 bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c050_3_09 (mix_i_src_c050_3_09 mix_i_c050_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_09 (mix_q_src_c050_3_09 0 bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_3_09 (mix_q_src_c050_3_09 mix_q_c050_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_10 (mix_i_src_c050_3_10 0 bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c050_3_10 (mix_i_src_c050_3_10 mix_i_c050_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_10 (mix_q_src_c050_3_10 0 bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_3_10 (mix_q_src_c050_3_10 mix_q_c050_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_11 (mix_i_src_c050_3_11 0 bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c050_3_11 (mix_i_src_c050_3_11 mix_i_c050_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_11 (mix_q_src_c050_3_11 0 bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_3_11 (mix_q_src_c050_3_11 mix_q_c050_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_12 (mix_i_src_c050_3_12 0 bpf_c050_3 0) vcvs gain=1.950903220161e-01
SMIXI_c050_3_12 (mix_i_src_c050_3_12 mix_i_c050_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_12 (mix_q_src_c050_3_12 0 bpf_c050_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c050_3_12 (mix_q_src_c050_3_12 mix_q_c050_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_13 (mix_i_src_c050_3_13 0 bpf_c050_3 0) vcvs gain=5.555702330196e-01
SMIXI_c050_3_13 (mix_i_src_c050_3_13 mix_i_c050_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_13 (mix_q_src_c050_3_13 0 bpf_c050_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c050_3_13 (mix_q_src_c050_3_13 mix_q_c050_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_14 (mix_i_src_c050_3_14 0 bpf_c050_3 0) vcvs gain=8.314696123025e-01
SMIXI_c050_3_14 (mix_i_src_c050_3_14 mix_i_c050_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_14 (mix_q_src_c050_3_14 0 bpf_c050_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c050_3_14 (mix_q_src_c050_3_14 mix_q_c050_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c050_3_15 (mix_i_src_c050_3_15 0 bpf_c050_3 0) vcvs gain=9.807852804032e-01
SMIXI_c050_3_15 (mix_i_src_c050_3_15 mix_i_c050_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c050_3_15 (mix_q_src_c050_3_15 0 bpf_c050_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c050_3_15 (mix_q_src_c050_3_15 mix_q_c050_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c050_3 (mix_i_c050_3 0) resistor r=1G
RMIXQ_c050_3 (mix_q_c050_3 0) resistor r=1G
RINTI_c050_3 (mix_i_c050_3 Icar_c050_3) resistor r=1k
CINTI_c050_3 (Icar_c050_3 0) capacitor c=80p
RINTQ_c050_3 (mix_q_c050_3 Qcar_c050_3) resistor r=1k
CINTQ_c050_3 (Qcar_c050_3 0) capacitor c=80p

// bl051, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c051_0 (bl051 n_cbpf_c051_0) capacitor c=4.052847345694e-13
LBPF_c051_0 (n_cbpf_c051_0 bpf_c051_0) inductor l=1.000000000000e-06
RBPF_c051_0 (bpf_c051_0 0) resistor r=7.853981633974e+01
EMIXI_c051_0_00 (mix_i_src_c051_0_00 0 bpf_c051_0 0) vcvs gain=9.807852804032e-01
SMIXI_c051_0_00 (mix_i_src_c051_0_00 mix_i_c051_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_00 (mix_q_src_c051_0_00 0 bpf_c051_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_0_00 (mix_q_src_c051_0_00 mix_q_c051_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_01 (mix_i_src_c051_0_01 0 bpf_c051_0 0) vcvs gain=8.314696123025e-01
SMIXI_c051_0_01 (mix_i_src_c051_0_01 mix_i_c051_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_01 (mix_q_src_c051_0_01 0 bpf_c051_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_0_01 (mix_q_src_c051_0_01 mix_q_c051_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_02 (mix_i_src_c051_0_02 0 bpf_c051_0 0) vcvs gain=5.555702330196e-01
SMIXI_c051_0_02 (mix_i_src_c051_0_02 mix_i_c051_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_02 (mix_q_src_c051_0_02 0 bpf_c051_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_0_02 (mix_q_src_c051_0_02 mix_q_c051_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_03 (mix_i_src_c051_0_03 0 bpf_c051_0 0) vcvs gain=1.950903220161e-01
SMIXI_c051_0_03 (mix_i_src_c051_0_03 mix_i_c051_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_03 (mix_q_src_c051_0_03 0 bpf_c051_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_0_03 (mix_q_src_c051_0_03 mix_q_c051_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_04 (mix_i_src_c051_0_04 0 bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_0_04 (mix_i_src_c051_0_04 mix_i_c051_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_04 (mix_q_src_c051_0_04 0 bpf_c051_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_0_04 (mix_q_src_c051_0_04 mix_q_c051_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_05 (mix_i_src_c051_0_05 0 bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_0_05 (mix_i_src_c051_0_05 mix_i_c051_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_05 (mix_q_src_c051_0_05 0 bpf_c051_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_0_05 (mix_q_src_c051_0_05 mix_q_c051_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_06 (mix_i_src_c051_0_06 0 bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_0_06 (mix_i_src_c051_0_06 mix_i_c051_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_06 (mix_q_src_c051_0_06 0 bpf_c051_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_0_06 (mix_q_src_c051_0_06 mix_q_c051_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_07 (mix_i_src_c051_0_07 0 bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_0_07 (mix_i_src_c051_0_07 mix_i_c051_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_07 (mix_q_src_c051_0_07 0 bpf_c051_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_0_07 (mix_q_src_c051_0_07 mix_q_c051_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_08 (mix_i_src_c051_0_08 0 bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_0_08 (mix_i_src_c051_0_08 mix_i_c051_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_08 (mix_q_src_c051_0_08 0 bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_0_08 (mix_q_src_c051_0_08 mix_q_c051_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_09 (mix_i_src_c051_0_09 0 bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_0_09 (mix_i_src_c051_0_09 mix_i_c051_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_09 (mix_q_src_c051_0_09 0 bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_0_09 (mix_q_src_c051_0_09 mix_q_c051_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_10 (mix_i_src_c051_0_10 0 bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_0_10 (mix_i_src_c051_0_10 mix_i_c051_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_10 (mix_q_src_c051_0_10 0 bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_0_10 (mix_q_src_c051_0_10 mix_q_c051_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_11 (mix_i_src_c051_0_11 0 bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_0_11 (mix_i_src_c051_0_11 mix_i_c051_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_11 (mix_q_src_c051_0_11 0 bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_0_11 (mix_q_src_c051_0_11 mix_q_c051_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_12 (mix_i_src_c051_0_12 0 bpf_c051_0 0) vcvs gain=1.950903220161e-01
SMIXI_c051_0_12 (mix_i_src_c051_0_12 mix_i_c051_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_12 (mix_q_src_c051_0_12 0 bpf_c051_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_0_12 (mix_q_src_c051_0_12 mix_q_c051_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_13 (mix_i_src_c051_0_13 0 bpf_c051_0 0) vcvs gain=5.555702330196e-01
SMIXI_c051_0_13 (mix_i_src_c051_0_13 mix_i_c051_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_13 (mix_q_src_c051_0_13 0 bpf_c051_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_0_13 (mix_q_src_c051_0_13 mix_q_c051_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_14 (mix_i_src_c051_0_14 0 bpf_c051_0 0) vcvs gain=8.314696123025e-01
SMIXI_c051_0_14 (mix_i_src_c051_0_14 mix_i_c051_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_14 (mix_q_src_c051_0_14 0 bpf_c051_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_0_14 (mix_q_src_c051_0_14 mix_q_c051_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_0_15 (mix_i_src_c051_0_15 0 bpf_c051_0 0) vcvs gain=9.807852804032e-01
SMIXI_c051_0_15 (mix_i_src_c051_0_15 mix_i_c051_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_0_15 (mix_q_src_c051_0_15 0 bpf_c051_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_0_15 (mix_q_src_c051_0_15 mix_q_c051_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c051_0 (mix_i_c051_0 0) resistor r=1G
RMIXQ_c051_0 (mix_q_c051_0 0) resistor r=1G
RINTI_c051_0 (mix_i_c051_0 Icar_c051_0) resistor r=1k
CINTI_c051_0 (Icar_c051_0 0) capacitor c=80p
RINTQ_c051_0 (mix_q_c051_0 Qcar_c051_0) resistor r=1k
CINTQ_c051_0 (Qcar_c051_0 0) capacitor c=80p

// bl051, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c051_1 (bl051 n_cbpf_c051_1) capacitor c=1.013211836423e-13
LBPF_c051_1 (n_cbpf_c051_1 bpf_c051_1) inductor l=1.000000000000e-06
RBPF_c051_1 (bpf_c051_1 0) resistor r=1.570796326795e+02
EMIXI_c051_1_00 (mix_i_src_c051_1_00 0 bpf_c051_1 0) vcvs gain=9.807852804032e-01
SMIXI_c051_1_00 (mix_i_src_c051_1_00 mix_i_c051_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_00 (mix_q_src_c051_1_00 0 bpf_c051_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_1_00 (mix_q_src_c051_1_00 mix_q_c051_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_01 (mix_i_src_c051_1_01 0 bpf_c051_1 0) vcvs gain=8.314696123025e-01
SMIXI_c051_1_01 (mix_i_src_c051_1_01 mix_i_c051_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_01 (mix_q_src_c051_1_01 0 bpf_c051_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_1_01 (mix_q_src_c051_1_01 mix_q_c051_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_02 (mix_i_src_c051_1_02 0 bpf_c051_1 0) vcvs gain=5.555702330196e-01
SMIXI_c051_1_02 (mix_i_src_c051_1_02 mix_i_c051_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_02 (mix_q_src_c051_1_02 0 bpf_c051_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_1_02 (mix_q_src_c051_1_02 mix_q_c051_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_03 (mix_i_src_c051_1_03 0 bpf_c051_1 0) vcvs gain=1.950903220161e-01
SMIXI_c051_1_03 (mix_i_src_c051_1_03 mix_i_c051_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_03 (mix_q_src_c051_1_03 0 bpf_c051_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_1_03 (mix_q_src_c051_1_03 mix_q_c051_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_04 (mix_i_src_c051_1_04 0 bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_1_04 (mix_i_src_c051_1_04 mix_i_c051_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_04 (mix_q_src_c051_1_04 0 bpf_c051_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_1_04 (mix_q_src_c051_1_04 mix_q_c051_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_05 (mix_i_src_c051_1_05 0 bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_1_05 (mix_i_src_c051_1_05 mix_i_c051_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_05 (mix_q_src_c051_1_05 0 bpf_c051_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_1_05 (mix_q_src_c051_1_05 mix_q_c051_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_06 (mix_i_src_c051_1_06 0 bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_1_06 (mix_i_src_c051_1_06 mix_i_c051_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_06 (mix_q_src_c051_1_06 0 bpf_c051_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_1_06 (mix_q_src_c051_1_06 mix_q_c051_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_07 (mix_i_src_c051_1_07 0 bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_1_07 (mix_i_src_c051_1_07 mix_i_c051_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_07 (mix_q_src_c051_1_07 0 bpf_c051_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_1_07 (mix_q_src_c051_1_07 mix_q_c051_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_08 (mix_i_src_c051_1_08 0 bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_1_08 (mix_i_src_c051_1_08 mix_i_c051_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_08 (mix_q_src_c051_1_08 0 bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_1_08 (mix_q_src_c051_1_08 mix_q_c051_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_09 (mix_i_src_c051_1_09 0 bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_1_09 (mix_i_src_c051_1_09 mix_i_c051_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_09 (mix_q_src_c051_1_09 0 bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_1_09 (mix_q_src_c051_1_09 mix_q_c051_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_10 (mix_i_src_c051_1_10 0 bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_1_10 (mix_i_src_c051_1_10 mix_i_c051_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_10 (mix_q_src_c051_1_10 0 bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_1_10 (mix_q_src_c051_1_10 mix_q_c051_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_11 (mix_i_src_c051_1_11 0 bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_1_11 (mix_i_src_c051_1_11 mix_i_c051_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_11 (mix_q_src_c051_1_11 0 bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_1_11 (mix_q_src_c051_1_11 mix_q_c051_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_12 (mix_i_src_c051_1_12 0 bpf_c051_1 0) vcvs gain=1.950903220161e-01
SMIXI_c051_1_12 (mix_i_src_c051_1_12 mix_i_c051_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_12 (mix_q_src_c051_1_12 0 bpf_c051_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_1_12 (mix_q_src_c051_1_12 mix_q_c051_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_13 (mix_i_src_c051_1_13 0 bpf_c051_1 0) vcvs gain=5.555702330196e-01
SMIXI_c051_1_13 (mix_i_src_c051_1_13 mix_i_c051_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_13 (mix_q_src_c051_1_13 0 bpf_c051_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_1_13 (mix_q_src_c051_1_13 mix_q_c051_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_14 (mix_i_src_c051_1_14 0 bpf_c051_1 0) vcvs gain=8.314696123025e-01
SMIXI_c051_1_14 (mix_i_src_c051_1_14 mix_i_c051_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_14 (mix_q_src_c051_1_14 0 bpf_c051_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_1_14 (mix_q_src_c051_1_14 mix_q_c051_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_1_15 (mix_i_src_c051_1_15 0 bpf_c051_1 0) vcvs gain=9.807852804032e-01
SMIXI_c051_1_15 (mix_i_src_c051_1_15 mix_i_c051_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_1_15 (mix_q_src_c051_1_15 0 bpf_c051_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_1_15 (mix_q_src_c051_1_15 mix_q_c051_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c051_1 (mix_i_c051_1 0) resistor r=1G
RMIXQ_c051_1 (mix_q_c051_1 0) resistor r=1G
RINTI_c051_1 (mix_i_c051_1 Icar_c051_1) resistor r=1k
CINTI_c051_1 (Icar_c051_1 0) capacitor c=80p
RINTQ_c051_1 (mix_q_c051_1 Qcar_c051_1) resistor r=1k
CINTQ_c051_1 (Qcar_c051_1 0) capacitor c=80p

// bl051, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c051_2 (bl051 n_cbpf_c051_2) capacitor c=4.503163717437e-14
LBPF_c051_2 (n_cbpf_c051_2 bpf_c051_2) inductor l=1.000000000000e-06
RBPF_c051_2 (bpf_c051_2 0) resistor r=2.356194490192e+02
EMIXI_c051_2_00 (mix_i_src_c051_2_00 0 bpf_c051_2 0) vcvs gain=9.807852804032e-01
SMIXI_c051_2_00 (mix_i_src_c051_2_00 mix_i_c051_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_00 (mix_q_src_c051_2_00 0 bpf_c051_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_2_00 (mix_q_src_c051_2_00 mix_q_c051_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_01 (mix_i_src_c051_2_01 0 bpf_c051_2 0) vcvs gain=8.314696123025e-01
SMIXI_c051_2_01 (mix_i_src_c051_2_01 mix_i_c051_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_01 (mix_q_src_c051_2_01 0 bpf_c051_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_2_01 (mix_q_src_c051_2_01 mix_q_c051_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_02 (mix_i_src_c051_2_02 0 bpf_c051_2 0) vcvs gain=5.555702330196e-01
SMIXI_c051_2_02 (mix_i_src_c051_2_02 mix_i_c051_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_02 (mix_q_src_c051_2_02 0 bpf_c051_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_2_02 (mix_q_src_c051_2_02 mix_q_c051_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_03 (mix_i_src_c051_2_03 0 bpf_c051_2 0) vcvs gain=1.950903220161e-01
SMIXI_c051_2_03 (mix_i_src_c051_2_03 mix_i_c051_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_03 (mix_q_src_c051_2_03 0 bpf_c051_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_2_03 (mix_q_src_c051_2_03 mix_q_c051_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_04 (mix_i_src_c051_2_04 0 bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_2_04 (mix_i_src_c051_2_04 mix_i_c051_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_04 (mix_q_src_c051_2_04 0 bpf_c051_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_2_04 (mix_q_src_c051_2_04 mix_q_c051_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_05 (mix_i_src_c051_2_05 0 bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_2_05 (mix_i_src_c051_2_05 mix_i_c051_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_05 (mix_q_src_c051_2_05 0 bpf_c051_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_2_05 (mix_q_src_c051_2_05 mix_q_c051_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_06 (mix_i_src_c051_2_06 0 bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_2_06 (mix_i_src_c051_2_06 mix_i_c051_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_06 (mix_q_src_c051_2_06 0 bpf_c051_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_2_06 (mix_q_src_c051_2_06 mix_q_c051_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_07 (mix_i_src_c051_2_07 0 bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_2_07 (mix_i_src_c051_2_07 mix_i_c051_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_07 (mix_q_src_c051_2_07 0 bpf_c051_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_2_07 (mix_q_src_c051_2_07 mix_q_c051_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_08 (mix_i_src_c051_2_08 0 bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_2_08 (mix_i_src_c051_2_08 mix_i_c051_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_08 (mix_q_src_c051_2_08 0 bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_2_08 (mix_q_src_c051_2_08 mix_q_c051_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_09 (mix_i_src_c051_2_09 0 bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_2_09 (mix_i_src_c051_2_09 mix_i_c051_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_09 (mix_q_src_c051_2_09 0 bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_2_09 (mix_q_src_c051_2_09 mix_q_c051_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_10 (mix_i_src_c051_2_10 0 bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_2_10 (mix_i_src_c051_2_10 mix_i_c051_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_10 (mix_q_src_c051_2_10 0 bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_2_10 (mix_q_src_c051_2_10 mix_q_c051_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_11 (mix_i_src_c051_2_11 0 bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_2_11 (mix_i_src_c051_2_11 mix_i_c051_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_11 (mix_q_src_c051_2_11 0 bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_2_11 (mix_q_src_c051_2_11 mix_q_c051_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_12 (mix_i_src_c051_2_12 0 bpf_c051_2 0) vcvs gain=1.950903220161e-01
SMIXI_c051_2_12 (mix_i_src_c051_2_12 mix_i_c051_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_12 (mix_q_src_c051_2_12 0 bpf_c051_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_2_12 (mix_q_src_c051_2_12 mix_q_c051_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_13 (mix_i_src_c051_2_13 0 bpf_c051_2 0) vcvs gain=5.555702330196e-01
SMIXI_c051_2_13 (mix_i_src_c051_2_13 mix_i_c051_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_13 (mix_q_src_c051_2_13 0 bpf_c051_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_2_13 (mix_q_src_c051_2_13 mix_q_c051_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_14 (mix_i_src_c051_2_14 0 bpf_c051_2 0) vcvs gain=8.314696123025e-01
SMIXI_c051_2_14 (mix_i_src_c051_2_14 mix_i_c051_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_14 (mix_q_src_c051_2_14 0 bpf_c051_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_2_14 (mix_q_src_c051_2_14 mix_q_c051_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_2_15 (mix_i_src_c051_2_15 0 bpf_c051_2 0) vcvs gain=9.807852804032e-01
SMIXI_c051_2_15 (mix_i_src_c051_2_15 mix_i_c051_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_2_15 (mix_q_src_c051_2_15 0 bpf_c051_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_2_15 (mix_q_src_c051_2_15 mix_q_c051_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c051_2 (mix_i_c051_2 0) resistor r=1G
RMIXQ_c051_2 (mix_q_c051_2 0) resistor r=1G
RINTI_c051_2 (mix_i_c051_2 Icar_c051_2) resistor r=1k
CINTI_c051_2 (Icar_c051_2 0) capacitor c=80p
RINTQ_c051_2 (mix_q_c051_2 Qcar_c051_2) resistor r=1k
CINTQ_c051_2 (Qcar_c051_2 0) capacitor c=80p

// bl051, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c051_3 (bl051 n_cbpf_c051_3) capacitor c=2.533029591058e-14
LBPF_c051_3 (n_cbpf_c051_3 bpf_c051_3) inductor l=1.000000000000e-06
RBPF_c051_3 (bpf_c051_3 0) resistor r=3.141592653590e+02
EMIXI_c051_3_00 (mix_i_src_c051_3_00 0 bpf_c051_3 0) vcvs gain=9.807852804032e-01
SMIXI_c051_3_00 (mix_i_src_c051_3_00 mix_i_c051_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_00 (mix_q_src_c051_3_00 0 bpf_c051_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_3_00 (mix_q_src_c051_3_00 mix_q_c051_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_01 (mix_i_src_c051_3_01 0 bpf_c051_3 0) vcvs gain=8.314696123025e-01
SMIXI_c051_3_01 (mix_i_src_c051_3_01 mix_i_c051_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_01 (mix_q_src_c051_3_01 0 bpf_c051_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_3_01 (mix_q_src_c051_3_01 mix_q_c051_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_02 (mix_i_src_c051_3_02 0 bpf_c051_3 0) vcvs gain=5.555702330196e-01
SMIXI_c051_3_02 (mix_i_src_c051_3_02 mix_i_c051_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_02 (mix_q_src_c051_3_02 0 bpf_c051_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_3_02 (mix_q_src_c051_3_02 mix_q_c051_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_03 (mix_i_src_c051_3_03 0 bpf_c051_3 0) vcvs gain=1.950903220161e-01
SMIXI_c051_3_03 (mix_i_src_c051_3_03 mix_i_c051_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_03 (mix_q_src_c051_3_03 0 bpf_c051_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_3_03 (mix_q_src_c051_3_03 mix_q_c051_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_04 (mix_i_src_c051_3_04 0 bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_3_04 (mix_i_src_c051_3_04 mix_i_c051_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_04 (mix_q_src_c051_3_04 0 bpf_c051_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c051_3_04 (mix_q_src_c051_3_04 mix_q_c051_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_05 (mix_i_src_c051_3_05 0 bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_3_05 (mix_i_src_c051_3_05 mix_i_c051_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_05 (mix_q_src_c051_3_05 0 bpf_c051_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c051_3_05 (mix_q_src_c051_3_05 mix_q_c051_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_06 (mix_i_src_c051_3_06 0 bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_3_06 (mix_i_src_c051_3_06 mix_i_c051_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_06 (mix_q_src_c051_3_06 0 bpf_c051_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c051_3_06 (mix_q_src_c051_3_06 mix_q_c051_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_07 (mix_i_src_c051_3_07 0 bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_3_07 (mix_i_src_c051_3_07 mix_i_c051_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_07 (mix_q_src_c051_3_07 0 bpf_c051_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c051_3_07 (mix_q_src_c051_3_07 mix_q_c051_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_08 (mix_i_src_c051_3_08 0 bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c051_3_08 (mix_i_src_c051_3_08 mix_i_c051_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_08 (mix_q_src_c051_3_08 0 bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_3_08 (mix_q_src_c051_3_08 mix_q_c051_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_09 (mix_i_src_c051_3_09 0 bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c051_3_09 (mix_i_src_c051_3_09 mix_i_c051_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_09 (mix_q_src_c051_3_09 0 bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_3_09 (mix_q_src_c051_3_09 mix_q_c051_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_10 (mix_i_src_c051_3_10 0 bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c051_3_10 (mix_i_src_c051_3_10 mix_i_c051_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_10 (mix_q_src_c051_3_10 0 bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_3_10 (mix_q_src_c051_3_10 mix_q_c051_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_11 (mix_i_src_c051_3_11 0 bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c051_3_11 (mix_i_src_c051_3_11 mix_i_c051_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_11 (mix_q_src_c051_3_11 0 bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_3_11 (mix_q_src_c051_3_11 mix_q_c051_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_12 (mix_i_src_c051_3_12 0 bpf_c051_3 0) vcvs gain=1.950903220161e-01
SMIXI_c051_3_12 (mix_i_src_c051_3_12 mix_i_c051_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_12 (mix_q_src_c051_3_12 0 bpf_c051_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c051_3_12 (mix_q_src_c051_3_12 mix_q_c051_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_13 (mix_i_src_c051_3_13 0 bpf_c051_3 0) vcvs gain=5.555702330196e-01
SMIXI_c051_3_13 (mix_i_src_c051_3_13 mix_i_c051_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_13 (mix_q_src_c051_3_13 0 bpf_c051_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c051_3_13 (mix_q_src_c051_3_13 mix_q_c051_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_14 (mix_i_src_c051_3_14 0 bpf_c051_3 0) vcvs gain=8.314696123025e-01
SMIXI_c051_3_14 (mix_i_src_c051_3_14 mix_i_c051_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_14 (mix_q_src_c051_3_14 0 bpf_c051_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c051_3_14 (mix_q_src_c051_3_14 mix_q_c051_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c051_3_15 (mix_i_src_c051_3_15 0 bpf_c051_3 0) vcvs gain=9.807852804032e-01
SMIXI_c051_3_15 (mix_i_src_c051_3_15 mix_i_c051_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c051_3_15 (mix_q_src_c051_3_15 0 bpf_c051_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c051_3_15 (mix_q_src_c051_3_15 mix_q_c051_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c051_3 (mix_i_c051_3 0) resistor r=1G
RMIXQ_c051_3 (mix_q_c051_3 0) resistor r=1G
RINTI_c051_3 (mix_i_c051_3 Icar_c051_3) resistor r=1k
CINTI_c051_3 (Icar_c051_3 0) capacitor c=80p
RINTQ_c051_3 (mix_q_c051_3 Qcar_c051_3) resistor r=1k
CINTQ_c051_3 (Qcar_c051_3 0) capacitor c=80p

// bl052, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c052_0 (bl052 n_cbpf_c052_0) capacitor c=4.052847345694e-13
LBPF_c052_0 (n_cbpf_c052_0 bpf_c052_0) inductor l=1.000000000000e-06
RBPF_c052_0 (bpf_c052_0 0) resistor r=7.853981633974e+01
EMIXI_c052_0_00 (mix_i_src_c052_0_00 0 bpf_c052_0 0) vcvs gain=9.807852804032e-01
SMIXI_c052_0_00 (mix_i_src_c052_0_00 mix_i_c052_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_00 (mix_q_src_c052_0_00 0 bpf_c052_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_0_00 (mix_q_src_c052_0_00 mix_q_c052_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_01 (mix_i_src_c052_0_01 0 bpf_c052_0 0) vcvs gain=8.314696123025e-01
SMIXI_c052_0_01 (mix_i_src_c052_0_01 mix_i_c052_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_01 (mix_q_src_c052_0_01 0 bpf_c052_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_0_01 (mix_q_src_c052_0_01 mix_q_c052_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_02 (mix_i_src_c052_0_02 0 bpf_c052_0 0) vcvs gain=5.555702330196e-01
SMIXI_c052_0_02 (mix_i_src_c052_0_02 mix_i_c052_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_02 (mix_q_src_c052_0_02 0 bpf_c052_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_0_02 (mix_q_src_c052_0_02 mix_q_c052_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_03 (mix_i_src_c052_0_03 0 bpf_c052_0 0) vcvs gain=1.950903220161e-01
SMIXI_c052_0_03 (mix_i_src_c052_0_03 mix_i_c052_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_03 (mix_q_src_c052_0_03 0 bpf_c052_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_0_03 (mix_q_src_c052_0_03 mix_q_c052_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_04 (mix_i_src_c052_0_04 0 bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_0_04 (mix_i_src_c052_0_04 mix_i_c052_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_04 (mix_q_src_c052_0_04 0 bpf_c052_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_0_04 (mix_q_src_c052_0_04 mix_q_c052_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_05 (mix_i_src_c052_0_05 0 bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_0_05 (mix_i_src_c052_0_05 mix_i_c052_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_05 (mix_q_src_c052_0_05 0 bpf_c052_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_0_05 (mix_q_src_c052_0_05 mix_q_c052_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_06 (mix_i_src_c052_0_06 0 bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_0_06 (mix_i_src_c052_0_06 mix_i_c052_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_06 (mix_q_src_c052_0_06 0 bpf_c052_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_0_06 (mix_q_src_c052_0_06 mix_q_c052_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_07 (mix_i_src_c052_0_07 0 bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_0_07 (mix_i_src_c052_0_07 mix_i_c052_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_07 (mix_q_src_c052_0_07 0 bpf_c052_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_0_07 (mix_q_src_c052_0_07 mix_q_c052_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_08 (mix_i_src_c052_0_08 0 bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_0_08 (mix_i_src_c052_0_08 mix_i_c052_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_08 (mix_q_src_c052_0_08 0 bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_0_08 (mix_q_src_c052_0_08 mix_q_c052_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_09 (mix_i_src_c052_0_09 0 bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_0_09 (mix_i_src_c052_0_09 mix_i_c052_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_09 (mix_q_src_c052_0_09 0 bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_0_09 (mix_q_src_c052_0_09 mix_q_c052_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_10 (mix_i_src_c052_0_10 0 bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_0_10 (mix_i_src_c052_0_10 mix_i_c052_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_10 (mix_q_src_c052_0_10 0 bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_0_10 (mix_q_src_c052_0_10 mix_q_c052_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_11 (mix_i_src_c052_0_11 0 bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_0_11 (mix_i_src_c052_0_11 mix_i_c052_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_11 (mix_q_src_c052_0_11 0 bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_0_11 (mix_q_src_c052_0_11 mix_q_c052_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_12 (mix_i_src_c052_0_12 0 bpf_c052_0 0) vcvs gain=1.950903220161e-01
SMIXI_c052_0_12 (mix_i_src_c052_0_12 mix_i_c052_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_12 (mix_q_src_c052_0_12 0 bpf_c052_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_0_12 (mix_q_src_c052_0_12 mix_q_c052_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_13 (mix_i_src_c052_0_13 0 bpf_c052_0 0) vcvs gain=5.555702330196e-01
SMIXI_c052_0_13 (mix_i_src_c052_0_13 mix_i_c052_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_13 (mix_q_src_c052_0_13 0 bpf_c052_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_0_13 (mix_q_src_c052_0_13 mix_q_c052_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_14 (mix_i_src_c052_0_14 0 bpf_c052_0 0) vcvs gain=8.314696123025e-01
SMIXI_c052_0_14 (mix_i_src_c052_0_14 mix_i_c052_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_14 (mix_q_src_c052_0_14 0 bpf_c052_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_0_14 (mix_q_src_c052_0_14 mix_q_c052_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_0_15 (mix_i_src_c052_0_15 0 bpf_c052_0 0) vcvs gain=9.807852804032e-01
SMIXI_c052_0_15 (mix_i_src_c052_0_15 mix_i_c052_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_0_15 (mix_q_src_c052_0_15 0 bpf_c052_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_0_15 (mix_q_src_c052_0_15 mix_q_c052_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c052_0 (mix_i_c052_0 0) resistor r=1G
RMIXQ_c052_0 (mix_q_c052_0 0) resistor r=1G
RINTI_c052_0 (mix_i_c052_0 Icar_c052_0) resistor r=1k
CINTI_c052_0 (Icar_c052_0 0) capacitor c=80p
RINTQ_c052_0 (mix_q_c052_0 Qcar_c052_0) resistor r=1k
CINTQ_c052_0 (Qcar_c052_0 0) capacitor c=80p

// bl052, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c052_1 (bl052 n_cbpf_c052_1) capacitor c=1.013211836423e-13
LBPF_c052_1 (n_cbpf_c052_1 bpf_c052_1) inductor l=1.000000000000e-06
RBPF_c052_1 (bpf_c052_1 0) resistor r=1.570796326795e+02
EMIXI_c052_1_00 (mix_i_src_c052_1_00 0 bpf_c052_1 0) vcvs gain=9.807852804032e-01
SMIXI_c052_1_00 (mix_i_src_c052_1_00 mix_i_c052_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_00 (mix_q_src_c052_1_00 0 bpf_c052_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_1_00 (mix_q_src_c052_1_00 mix_q_c052_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_01 (mix_i_src_c052_1_01 0 bpf_c052_1 0) vcvs gain=8.314696123025e-01
SMIXI_c052_1_01 (mix_i_src_c052_1_01 mix_i_c052_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_01 (mix_q_src_c052_1_01 0 bpf_c052_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_1_01 (mix_q_src_c052_1_01 mix_q_c052_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_02 (mix_i_src_c052_1_02 0 bpf_c052_1 0) vcvs gain=5.555702330196e-01
SMIXI_c052_1_02 (mix_i_src_c052_1_02 mix_i_c052_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_02 (mix_q_src_c052_1_02 0 bpf_c052_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_1_02 (mix_q_src_c052_1_02 mix_q_c052_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_03 (mix_i_src_c052_1_03 0 bpf_c052_1 0) vcvs gain=1.950903220161e-01
SMIXI_c052_1_03 (mix_i_src_c052_1_03 mix_i_c052_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_03 (mix_q_src_c052_1_03 0 bpf_c052_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_1_03 (mix_q_src_c052_1_03 mix_q_c052_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_04 (mix_i_src_c052_1_04 0 bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_1_04 (mix_i_src_c052_1_04 mix_i_c052_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_04 (mix_q_src_c052_1_04 0 bpf_c052_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_1_04 (mix_q_src_c052_1_04 mix_q_c052_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_05 (mix_i_src_c052_1_05 0 bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_1_05 (mix_i_src_c052_1_05 mix_i_c052_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_05 (mix_q_src_c052_1_05 0 bpf_c052_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_1_05 (mix_q_src_c052_1_05 mix_q_c052_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_06 (mix_i_src_c052_1_06 0 bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_1_06 (mix_i_src_c052_1_06 mix_i_c052_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_06 (mix_q_src_c052_1_06 0 bpf_c052_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_1_06 (mix_q_src_c052_1_06 mix_q_c052_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_07 (mix_i_src_c052_1_07 0 bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_1_07 (mix_i_src_c052_1_07 mix_i_c052_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_07 (mix_q_src_c052_1_07 0 bpf_c052_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_1_07 (mix_q_src_c052_1_07 mix_q_c052_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_08 (mix_i_src_c052_1_08 0 bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_1_08 (mix_i_src_c052_1_08 mix_i_c052_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_08 (mix_q_src_c052_1_08 0 bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_1_08 (mix_q_src_c052_1_08 mix_q_c052_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_09 (mix_i_src_c052_1_09 0 bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_1_09 (mix_i_src_c052_1_09 mix_i_c052_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_09 (mix_q_src_c052_1_09 0 bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_1_09 (mix_q_src_c052_1_09 mix_q_c052_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_10 (mix_i_src_c052_1_10 0 bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_1_10 (mix_i_src_c052_1_10 mix_i_c052_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_10 (mix_q_src_c052_1_10 0 bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_1_10 (mix_q_src_c052_1_10 mix_q_c052_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_11 (mix_i_src_c052_1_11 0 bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_1_11 (mix_i_src_c052_1_11 mix_i_c052_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_11 (mix_q_src_c052_1_11 0 bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_1_11 (mix_q_src_c052_1_11 mix_q_c052_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_12 (mix_i_src_c052_1_12 0 bpf_c052_1 0) vcvs gain=1.950903220161e-01
SMIXI_c052_1_12 (mix_i_src_c052_1_12 mix_i_c052_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_12 (mix_q_src_c052_1_12 0 bpf_c052_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_1_12 (mix_q_src_c052_1_12 mix_q_c052_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_13 (mix_i_src_c052_1_13 0 bpf_c052_1 0) vcvs gain=5.555702330196e-01
SMIXI_c052_1_13 (mix_i_src_c052_1_13 mix_i_c052_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_13 (mix_q_src_c052_1_13 0 bpf_c052_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_1_13 (mix_q_src_c052_1_13 mix_q_c052_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_14 (mix_i_src_c052_1_14 0 bpf_c052_1 0) vcvs gain=8.314696123025e-01
SMIXI_c052_1_14 (mix_i_src_c052_1_14 mix_i_c052_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_14 (mix_q_src_c052_1_14 0 bpf_c052_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_1_14 (mix_q_src_c052_1_14 mix_q_c052_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_1_15 (mix_i_src_c052_1_15 0 bpf_c052_1 0) vcvs gain=9.807852804032e-01
SMIXI_c052_1_15 (mix_i_src_c052_1_15 mix_i_c052_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_1_15 (mix_q_src_c052_1_15 0 bpf_c052_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_1_15 (mix_q_src_c052_1_15 mix_q_c052_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c052_1 (mix_i_c052_1 0) resistor r=1G
RMIXQ_c052_1 (mix_q_c052_1 0) resistor r=1G
RINTI_c052_1 (mix_i_c052_1 Icar_c052_1) resistor r=1k
CINTI_c052_1 (Icar_c052_1 0) capacitor c=80p
RINTQ_c052_1 (mix_q_c052_1 Qcar_c052_1) resistor r=1k
CINTQ_c052_1 (Qcar_c052_1 0) capacitor c=80p

// bl052, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c052_2 (bl052 n_cbpf_c052_2) capacitor c=4.503163717437e-14
LBPF_c052_2 (n_cbpf_c052_2 bpf_c052_2) inductor l=1.000000000000e-06
RBPF_c052_2 (bpf_c052_2 0) resistor r=2.356194490192e+02
EMIXI_c052_2_00 (mix_i_src_c052_2_00 0 bpf_c052_2 0) vcvs gain=9.807852804032e-01
SMIXI_c052_2_00 (mix_i_src_c052_2_00 mix_i_c052_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_00 (mix_q_src_c052_2_00 0 bpf_c052_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_2_00 (mix_q_src_c052_2_00 mix_q_c052_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_01 (mix_i_src_c052_2_01 0 bpf_c052_2 0) vcvs gain=8.314696123025e-01
SMIXI_c052_2_01 (mix_i_src_c052_2_01 mix_i_c052_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_01 (mix_q_src_c052_2_01 0 bpf_c052_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_2_01 (mix_q_src_c052_2_01 mix_q_c052_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_02 (mix_i_src_c052_2_02 0 bpf_c052_2 0) vcvs gain=5.555702330196e-01
SMIXI_c052_2_02 (mix_i_src_c052_2_02 mix_i_c052_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_02 (mix_q_src_c052_2_02 0 bpf_c052_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_2_02 (mix_q_src_c052_2_02 mix_q_c052_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_03 (mix_i_src_c052_2_03 0 bpf_c052_2 0) vcvs gain=1.950903220161e-01
SMIXI_c052_2_03 (mix_i_src_c052_2_03 mix_i_c052_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_03 (mix_q_src_c052_2_03 0 bpf_c052_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_2_03 (mix_q_src_c052_2_03 mix_q_c052_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_04 (mix_i_src_c052_2_04 0 bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_2_04 (mix_i_src_c052_2_04 mix_i_c052_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_04 (mix_q_src_c052_2_04 0 bpf_c052_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_2_04 (mix_q_src_c052_2_04 mix_q_c052_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_05 (mix_i_src_c052_2_05 0 bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_2_05 (mix_i_src_c052_2_05 mix_i_c052_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_05 (mix_q_src_c052_2_05 0 bpf_c052_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_2_05 (mix_q_src_c052_2_05 mix_q_c052_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_06 (mix_i_src_c052_2_06 0 bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_2_06 (mix_i_src_c052_2_06 mix_i_c052_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_06 (mix_q_src_c052_2_06 0 bpf_c052_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_2_06 (mix_q_src_c052_2_06 mix_q_c052_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_07 (mix_i_src_c052_2_07 0 bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_2_07 (mix_i_src_c052_2_07 mix_i_c052_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_07 (mix_q_src_c052_2_07 0 bpf_c052_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_2_07 (mix_q_src_c052_2_07 mix_q_c052_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_08 (mix_i_src_c052_2_08 0 bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_2_08 (mix_i_src_c052_2_08 mix_i_c052_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_08 (mix_q_src_c052_2_08 0 bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_2_08 (mix_q_src_c052_2_08 mix_q_c052_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_09 (mix_i_src_c052_2_09 0 bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_2_09 (mix_i_src_c052_2_09 mix_i_c052_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_09 (mix_q_src_c052_2_09 0 bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_2_09 (mix_q_src_c052_2_09 mix_q_c052_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_10 (mix_i_src_c052_2_10 0 bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_2_10 (mix_i_src_c052_2_10 mix_i_c052_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_10 (mix_q_src_c052_2_10 0 bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_2_10 (mix_q_src_c052_2_10 mix_q_c052_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_11 (mix_i_src_c052_2_11 0 bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_2_11 (mix_i_src_c052_2_11 mix_i_c052_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_11 (mix_q_src_c052_2_11 0 bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_2_11 (mix_q_src_c052_2_11 mix_q_c052_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_12 (mix_i_src_c052_2_12 0 bpf_c052_2 0) vcvs gain=1.950903220161e-01
SMIXI_c052_2_12 (mix_i_src_c052_2_12 mix_i_c052_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_12 (mix_q_src_c052_2_12 0 bpf_c052_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_2_12 (mix_q_src_c052_2_12 mix_q_c052_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_13 (mix_i_src_c052_2_13 0 bpf_c052_2 0) vcvs gain=5.555702330196e-01
SMIXI_c052_2_13 (mix_i_src_c052_2_13 mix_i_c052_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_13 (mix_q_src_c052_2_13 0 bpf_c052_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_2_13 (mix_q_src_c052_2_13 mix_q_c052_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_14 (mix_i_src_c052_2_14 0 bpf_c052_2 0) vcvs gain=8.314696123025e-01
SMIXI_c052_2_14 (mix_i_src_c052_2_14 mix_i_c052_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_14 (mix_q_src_c052_2_14 0 bpf_c052_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_2_14 (mix_q_src_c052_2_14 mix_q_c052_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_2_15 (mix_i_src_c052_2_15 0 bpf_c052_2 0) vcvs gain=9.807852804032e-01
SMIXI_c052_2_15 (mix_i_src_c052_2_15 mix_i_c052_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_2_15 (mix_q_src_c052_2_15 0 bpf_c052_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_2_15 (mix_q_src_c052_2_15 mix_q_c052_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c052_2 (mix_i_c052_2 0) resistor r=1G
RMIXQ_c052_2 (mix_q_c052_2 0) resistor r=1G
RINTI_c052_2 (mix_i_c052_2 Icar_c052_2) resistor r=1k
CINTI_c052_2 (Icar_c052_2 0) capacitor c=80p
RINTQ_c052_2 (mix_q_c052_2 Qcar_c052_2) resistor r=1k
CINTQ_c052_2 (Qcar_c052_2 0) capacitor c=80p

// bl052, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c052_3 (bl052 n_cbpf_c052_3) capacitor c=2.533029591058e-14
LBPF_c052_3 (n_cbpf_c052_3 bpf_c052_3) inductor l=1.000000000000e-06
RBPF_c052_3 (bpf_c052_3 0) resistor r=3.141592653590e+02
EMIXI_c052_3_00 (mix_i_src_c052_3_00 0 bpf_c052_3 0) vcvs gain=9.807852804032e-01
SMIXI_c052_3_00 (mix_i_src_c052_3_00 mix_i_c052_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_00 (mix_q_src_c052_3_00 0 bpf_c052_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_3_00 (mix_q_src_c052_3_00 mix_q_c052_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_01 (mix_i_src_c052_3_01 0 bpf_c052_3 0) vcvs gain=8.314696123025e-01
SMIXI_c052_3_01 (mix_i_src_c052_3_01 mix_i_c052_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_01 (mix_q_src_c052_3_01 0 bpf_c052_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_3_01 (mix_q_src_c052_3_01 mix_q_c052_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_02 (mix_i_src_c052_3_02 0 bpf_c052_3 0) vcvs gain=5.555702330196e-01
SMIXI_c052_3_02 (mix_i_src_c052_3_02 mix_i_c052_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_02 (mix_q_src_c052_3_02 0 bpf_c052_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_3_02 (mix_q_src_c052_3_02 mix_q_c052_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_03 (mix_i_src_c052_3_03 0 bpf_c052_3 0) vcvs gain=1.950903220161e-01
SMIXI_c052_3_03 (mix_i_src_c052_3_03 mix_i_c052_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_03 (mix_q_src_c052_3_03 0 bpf_c052_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_3_03 (mix_q_src_c052_3_03 mix_q_c052_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_04 (mix_i_src_c052_3_04 0 bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_3_04 (mix_i_src_c052_3_04 mix_i_c052_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_04 (mix_q_src_c052_3_04 0 bpf_c052_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c052_3_04 (mix_q_src_c052_3_04 mix_q_c052_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_05 (mix_i_src_c052_3_05 0 bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_3_05 (mix_i_src_c052_3_05 mix_i_c052_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_05 (mix_q_src_c052_3_05 0 bpf_c052_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c052_3_05 (mix_q_src_c052_3_05 mix_q_c052_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_06 (mix_i_src_c052_3_06 0 bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_3_06 (mix_i_src_c052_3_06 mix_i_c052_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_06 (mix_q_src_c052_3_06 0 bpf_c052_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c052_3_06 (mix_q_src_c052_3_06 mix_q_c052_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_07 (mix_i_src_c052_3_07 0 bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_3_07 (mix_i_src_c052_3_07 mix_i_c052_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_07 (mix_q_src_c052_3_07 0 bpf_c052_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c052_3_07 (mix_q_src_c052_3_07 mix_q_c052_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_08 (mix_i_src_c052_3_08 0 bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c052_3_08 (mix_i_src_c052_3_08 mix_i_c052_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_08 (mix_q_src_c052_3_08 0 bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_3_08 (mix_q_src_c052_3_08 mix_q_c052_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_09 (mix_i_src_c052_3_09 0 bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c052_3_09 (mix_i_src_c052_3_09 mix_i_c052_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_09 (mix_q_src_c052_3_09 0 bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_3_09 (mix_q_src_c052_3_09 mix_q_c052_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_10 (mix_i_src_c052_3_10 0 bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c052_3_10 (mix_i_src_c052_3_10 mix_i_c052_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_10 (mix_q_src_c052_3_10 0 bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_3_10 (mix_q_src_c052_3_10 mix_q_c052_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_11 (mix_i_src_c052_3_11 0 bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c052_3_11 (mix_i_src_c052_3_11 mix_i_c052_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_11 (mix_q_src_c052_3_11 0 bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_3_11 (mix_q_src_c052_3_11 mix_q_c052_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_12 (mix_i_src_c052_3_12 0 bpf_c052_3 0) vcvs gain=1.950903220161e-01
SMIXI_c052_3_12 (mix_i_src_c052_3_12 mix_i_c052_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_12 (mix_q_src_c052_3_12 0 bpf_c052_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c052_3_12 (mix_q_src_c052_3_12 mix_q_c052_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_13 (mix_i_src_c052_3_13 0 bpf_c052_3 0) vcvs gain=5.555702330196e-01
SMIXI_c052_3_13 (mix_i_src_c052_3_13 mix_i_c052_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_13 (mix_q_src_c052_3_13 0 bpf_c052_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c052_3_13 (mix_q_src_c052_3_13 mix_q_c052_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_14 (mix_i_src_c052_3_14 0 bpf_c052_3 0) vcvs gain=8.314696123025e-01
SMIXI_c052_3_14 (mix_i_src_c052_3_14 mix_i_c052_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_14 (mix_q_src_c052_3_14 0 bpf_c052_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c052_3_14 (mix_q_src_c052_3_14 mix_q_c052_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c052_3_15 (mix_i_src_c052_3_15 0 bpf_c052_3 0) vcvs gain=9.807852804032e-01
SMIXI_c052_3_15 (mix_i_src_c052_3_15 mix_i_c052_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c052_3_15 (mix_q_src_c052_3_15 0 bpf_c052_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c052_3_15 (mix_q_src_c052_3_15 mix_q_c052_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c052_3 (mix_i_c052_3 0) resistor r=1G
RMIXQ_c052_3 (mix_q_c052_3 0) resistor r=1G
RINTI_c052_3 (mix_i_c052_3 Icar_c052_3) resistor r=1k
CINTI_c052_3 (Icar_c052_3 0) capacitor c=80p
RINTQ_c052_3 (mix_q_c052_3 Qcar_c052_3) resistor r=1k
CINTQ_c052_3 (Qcar_c052_3 0) capacitor c=80p

// bl053, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c053_0 (bl053 n_cbpf_c053_0) capacitor c=4.052847345694e-13
LBPF_c053_0 (n_cbpf_c053_0 bpf_c053_0) inductor l=1.000000000000e-06
RBPF_c053_0 (bpf_c053_0 0) resistor r=7.853981633974e+01
EMIXI_c053_0_00 (mix_i_src_c053_0_00 0 bpf_c053_0 0) vcvs gain=9.807852804032e-01
SMIXI_c053_0_00 (mix_i_src_c053_0_00 mix_i_c053_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_00 (mix_q_src_c053_0_00 0 bpf_c053_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_0_00 (mix_q_src_c053_0_00 mix_q_c053_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_01 (mix_i_src_c053_0_01 0 bpf_c053_0 0) vcvs gain=8.314696123025e-01
SMIXI_c053_0_01 (mix_i_src_c053_0_01 mix_i_c053_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_01 (mix_q_src_c053_0_01 0 bpf_c053_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_0_01 (mix_q_src_c053_0_01 mix_q_c053_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_02 (mix_i_src_c053_0_02 0 bpf_c053_0 0) vcvs gain=5.555702330196e-01
SMIXI_c053_0_02 (mix_i_src_c053_0_02 mix_i_c053_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_02 (mix_q_src_c053_0_02 0 bpf_c053_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_0_02 (mix_q_src_c053_0_02 mix_q_c053_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_03 (mix_i_src_c053_0_03 0 bpf_c053_0 0) vcvs gain=1.950903220161e-01
SMIXI_c053_0_03 (mix_i_src_c053_0_03 mix_i_c053_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_03 (mix_q_src_c053_0_03 0 bpf_c053_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_0_03 (mix_q_src_c053_0_03 mix_q_c053_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_04 (mix_i_src_c053_0_04 0 bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_0_04 (mix_i_src_c053_0_04 mix_i_c053_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_04 (mix_q_src_c053_0_04 0 bpf_c053_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_0_04 (mix_q_src_c053_0_04 mix_q_c053_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_05 (mix_i_src_c053_0_05 0 bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_0_05 (mix_i_src_c053_0_05 mix_i_c053_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_05 (mix_q_src_c053_0_05 0 bpf_c053_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_0_05 (mix_q_src_c053_0_05 mix_q_c053_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_06 (mix_i_src_c053_0_06 0 bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_0_06 (mix_i_src_c053_0_06 mix_i_c053_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_06 (mix_q_src_c053_0_06 0 bpf_c053_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_0_06 (mix_q_src_c053_0_06 mix_q_c053_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_07 (mix_i_src_c053_0_07 0 bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_0_07 (mix_i_src_c053_0_07 mix_i_c053_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_07 (mix_q_src_c053_0_07 0 bpf_c053_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_0_07 (mix_q_src_c053_0_07 mix_q_c053_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_08 (mix_i_src_c053_0_08 0 bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_0_08 (mix_i_src_c053_0_08 mix_i_c053_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_08 (mix_q_src_c053_0_08 0 bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_0_08 (mix_q_src_c053_0_08 mix_q_c053_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_09 (mix_i_src_c053_0_09 0 bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_0_09 (mix_i_src_c053_0_09 mix_i_c053_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_09 (mix_q_src_c053_0_09 0 bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_0_09 (mix_q_src_c053_0_09 mix_q_c053_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_10 (mix_i_src_c053_0_10 0 bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_0_10 (mix_i_src_c053_0_10 mix_i_c053_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_10 (mix_q_src_c053_0_10 0 bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_0_10 (mix_q_src_c053_0_10 mix_q_c053_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_11 (mix_i_src_c053_0_11 0 bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_0_11 (mix_i_src_c053_0_11 mix_i_c053_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_11 (mix_q_src_c053_0_11 0 bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_0_11 (mix_q_src_c053_0_11 mix_q_c053_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_12 (mix_i_src_c053_0_12 0 bpf_c053_0 0) vcvs gain=1.950903220161e-01
SMIXI_c053_0_12 (mix_i_src_c053_0_12 mix_i_c053_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_12 (mix_q_src_c053_0_12 0 bpf_c053_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_0_12 (mix_q_src_c053_0_12 mix_q_c053_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_13 (mix_i_src_c053_0_13 0 bpf_c053_0 0) vcvs gain=5.555702330196e-01
SMIXI_c053_0_13 (mix_i_src_c053_0_13 mix_i_c053_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_13 (mix_q_src_c053_0_13 0 bpf_c053_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_0_13 (mix_q_src_c053_0_13 mix_q_c053_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_14 (mix_i_src_c053_0_14 0 bpf_c053_0 0) vcvs gain=8.314696123025e-01
SMIXI_c053_0_14 (mix_i_src_c053_0_14 mix_i_c053_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_14 (mix_q_src_c053_0_14 0 bpf_c053_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_0_14 (mix_q_src_c053_0_14 mix_q_c053_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_0_15 (mix_i_src_c053_0_15 0 bpf_c053_0 0) vcvs gain=9.807852804032e-01
SMIXI_c053_0_15 (mix_i_src_c053_0_15 mix_i_c053_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_0_15 (mix_q_src_c053_0_15 0 bpf_c053_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_0_15 (mix_q_src_c053_0_15 mix_q_c053_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c053_0 (mix_i_c053_0 0) resistor r=1G
RMIXQ_c053_0 (mix_q_c053_0 0) resistor r=1G
RINTI_c053_0 (mix_i_c053_0 Icar_c053_0) resistor r=1k
CINTI_c053_0 (Icar_c053_0 0) capacitor c=80p
RINTQ_c053_0 (mix_q_c053_0 Qcar_c053_0) resistor r=1k
CINTQ_c053_0 (Qcar_c053_0 0) capacitor c=80p

// bl053, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c053_1 (bl053 n_cbpf_c053_1) capacitor c=1.013211836423e-13
LBPF_c053_1 (n_cbpf_c053_1 bpf_c053_1) inductor l=1.000000000000e-06
RBPF_c053_1 (bpf_c053_1 0) resistor r=1.570796326795e+02
EMIXI_c053_1_00 (mix_i_src_c053_1_00 0 bpf_c053_1 0) vcvs gain=9.807852804032e-01
SMIXI_c053_1_00 (mix_i_src_c053_1_00 mix_i_c053_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_00 (mix_q_src_c053_1_00 0 bpf_c053_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_1_00 (mix_q_src_c053_1_00 mix_q_c053_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_01 (mix_i_src_c053_1_01 0 bpf_c053_1 0) vcvs gain=8.314696123025e-01
SMIXI_c053_1_01 (mix_i_src_c053_1_01 mix_i_c053_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_01 (mix_q_src_c053_1_01 0 bpf_c053_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_1_01 (mix_q_src_c053_1_01 mix_q_c053_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_02 (mix_i_src_c053_1_02 0 bpf_c053_1 0) vcvs gain=5.555702330196e-01
SMIXI_c053_1_02 (mix_i_src_c053_1_02 mix_i_c053_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_02 (mix_q_src_c053_1_02 0 bpf_c053_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_1_02 (mix_q_src_c053_1_02 mix_q_c053_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_03 (mix_i_src_c053_1_03 0 bpf_c053_1 0) vcvs gain=1.950903220161e-01
SMIXI_c053_1_03 (mix_i_src_c053_1_03 mix_i_c053_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_03 (mix_q_src_c053_1_03 0 bpf_c053_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_1_03 (mix_q_src_c053_1_03 mix_q_c053_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_04 (mix_i_src_c053_1_04 0 bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_1_04 (mix_i_src_c053_1_04 mix_i_c053_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_04 (mix_q_src_c053_1_04 0 bpf_c053_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_1_04 (mix_q_src_c053_1_04 mix_q_c053_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_05 (mix_i_src_c053_1_05 0 bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_1_05 (mix_i_src_c053_1_05 mix_i_c053_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_05 (mix_q_src_c053_1_05 0 bpf_c053_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_1_05 (mix_q_src_c053_1_05 mix_q_c053_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_06 (mix_i_src_c053_1_06 0 bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_1_06 (mix_i_src_c053_1_06 mix_i_c053_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_06 (mix_q_src_c053_1_06 0 bpf_c053_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_1_06 (mix_q_src_c053_1_06 mix_q_c053_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_07 (mix_i_src_c053_1_07 0 bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_1_07 (mix_i_src_c053_1_07 mix_i_c053_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_07 (mix_q_src_c053_1_07 0 bpf_c053_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_1_07 (mix_q_src_c053_1_07 mix_q_c053_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_08 (mix_i_src_c053_1_08 0 bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_1_08 (mix_i_src_c053_1_08 mix_i_c053_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_08 (mix_q_src_c053_1_08 0 bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_1_08 (mix_q_src_c053_1_08 mix_q_c053_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_09 (mix_i_src_c053_1_09 0 bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_1_09 (mix_i_src_c053_1_09 mix_i_c053_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_09 (mix_q_src_c053_1_09 0 bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_1_09 (mix_q_src_c053_1_09 mix_q_c053_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_10 (mix_i_src_c053_1_10 0 bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_1_10 (mix_i_src_c053_1_10 mix_i_c053_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_10 (mix_q_src_c053_1_10 0 bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_1_10 (mix_q_src_c053_1_10 mix_q_c053_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_11 (mix_i_src_c053_1_11 0 bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_1_11 (mix_i_src_c053_1_11 mix_i_c053_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_11 (mix_q_src_c053_1_11 0 bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_1_11 (mix_q_src_c053_1_11 mix_q_c053_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_12 (mix_i_src_c053_1_12 0 bpf_c053_1 0) vcvs gain=1.950903220161e-01
SMIXI_c053_1_12 (mix_i_src_c053_1_12 mix_i_c053_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_12 (mix_q_src_c053_1_12 0 bpf_c053_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_1_12 (mix_q_src_c053_1_12 mix_q_c053_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_13 (mix_i_src_c053_1_13 0 bpf_c053_1 0) vcvs gain=5.555702330196e-01
SMIXI_c053_1_13 (mix_i_src_c053_1_13 mix_i_c053_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_13 (mix_q_src_c053_1_13 0 bpf_c053_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_1_13 (mix_q_src_c053_1_13 mix_q_c053_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_14 (mix_i_src_c053_1_14 0 bpf_c053_1 0) vcvs gain=8.314696123025e-01
SMIXI_c053_1_14 (mix_i_src_c053_1_14 mix_i_c053_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_14 (mix_q_src_c053_1_14 0 bpf_c053_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_1_14 (mix_q_src_c053_1_14 mix_q_c053_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_1_15 (mix_i_src_c053_1_15 0 bpf_c053_1 0) vcvs gain=9.807852804032e-01
SMIXI_c053_1_15 (mix_i_src_c053_1_15 mix_i_c053_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_1_15 (mix_q_src_c053_1_15 0 bpf_c053_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_1_15 (mix_q_src_c053_1_15 mix_q_c053_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c053_1 (mix_i_c053_1 0) resistor r=1G
RMIXQ_c053_1 (mix_q_c053_1 0) resistor r=1G
RINTI_c053_1 (mix_i_c053_1 Icar_c053_1) resistor r=1k
CINTI_c053_1 (Icar_c053_1 0) capacitor c=80p
RINTQ_c053_1 (mix_q_c053_1 Qcar_c053_1) resistor r=1k
CINTQ_c053_1 (Qcar_c053_1 0) capacitor c=80p

// bl053, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c053_2 (bl053 n_cbpf_c053_2) capacitor c=4.503163717437e-14
LBPF_c053_2 (n_cbpf_c053_2 bpf_c053_2) inductor l=1.000000000000e-06
RBPF_c053_2 (bpf_c053_2 0) resistor r=2.356194490192e+02
EMIXI_c053_2_00 (mix_i_src_c053_2_00 0 bpf_c053_2 0) vcvs gain=9.807852804032e-01
SMIXI_c053_2_00 (mix_i_src_c053_2_00 mix_i_c053_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_00 (mix_q_src_c053_2_00 0 bpf_c053_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_2_00 (mix_q_src_c053_2_00 mix_q_c053_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_01 (mix_i_src_c053_2_01 0 bpf_c053_2 0) vcvs gain=8.314696123025e-01
SMIXI_c053_2_01 (mix_i_src_c053_2_01 mix_i_c053_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_01 (mix_q_src_c053_2_01 0 bpf_c053_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_2_01 (mix_q_src_c053_2_01 mix_q_c053_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_02 (mix_i_src_c053_2_02 0 bpf_c053_2 0) vcvs gain=5.555702330196e-01
SMIXI_c053_2_02 (mix_i_src_c053_2_02 mix_i_c053_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_02 (mix_q_src_c053_2_02 0 bpf_c053_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_2_02 (mix_q_src_c053_2_02 mix_q_c053_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_03 (mix_i_src_c053_2_03 0 bpf_c053_2 0) vcvs gain=1.950903220161e-01
SMIXI_c053_2_03 (mix_i_src_c053_2_03 mix_i_c053_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_03 (mix_q_src_c053_2_03 0 bpf_c053_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_2_03 (mix_q_src_c053_2_03 mix_q_c053_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_04 (mix_i_src_c053_2_04 0 bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_2_04 (mix_i_src_c053_2_04 mix_i_c053_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_04 (mix_q_src_c053_2_04 0 bpf_c053_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_2_04 (mix_q_src_c053_2_04 mix_q_c053_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_05 (mix_i_src_c053_2_05 0 bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_2_05 (mix_i_src_c053_2_05 mix_i_c053_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_05 (mix_q_src_c053_2_05 0 bpf_c053_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_2_05 (mix_q_src_c053_2_05 mix_q_c053_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_06 (mix_i_src_c053_2_06 0 bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_2_06 (mix_i_src_c053_2_06 mix_i_c053_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_06 (mix_q_src_c053_2_06 0 bpf_c053_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_2_06 (mix_q_src_c053_2_06 mix_q_c053_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_07 (mix_i_src_c053_2_07 0 bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_2_07 (mix_i_src_c053_2_07 mix_i_c053_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_07 (mix_q_src_c053_2_07 0 bpf_c053_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_2_07 (mix_q_src_c053_2_07 mix_q_c053_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_08 (mix_i_src_c053_2_08 0 bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_2_08 (mix_i_src_c053_2_08 mix_i_c053_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_08 (mix_q_src_c053_2_08 0 bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_2_08 (mix_q_src_c053_2_08 mix_q_c053_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_09 (mix_i_src_c053_2_09 0 bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_2_09 (mix_i_src_c053_2_09 mix_i_c053_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_09 (mix_q_src_c053_2_09 0 bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_2_09 (mix_q_src_c053_2_09 mix_q_c053_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_10 (mix_i_src_c053_2_10 0 bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_2_10 (mix_i_src_c053_2_10 mix_i_c053_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_10 (mix_q_src_c053_2_10 0 bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_2_10 (mix_q_src_c053_2_10 mix_q_c053_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_11 (mix_i_src_c053_2_11 0 bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_2_11 (mix_i_src_c053_2_11 mix_i_c053_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_11 (mix_q_src_c053_2_11 0 bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_2_11 (mix_q_src_c053_2_11 mix_q_c053_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_12 (mix_i_src_c053_2_12 0 bpf_c053_2 0) vcvs gain=1.950903220161e-01
SMIXI_c053_2_12 (mix_i_src_c053_2_12 mix_i_c053_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_12 (mix_q_src_c053_2_12 0 bpf_c053_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_2_12 (mix_q_src_c053_2_12 mix_q_c053_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_13 (mix_i_src_c053_2_13 0 bpf_c053_2 0) vcvs gain=5.555702330196e-01
SMIXI_c053_2_13 (mix_i_src_c053_2_13 mix_i_c053_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_13 (mix_q_src_c053_2_13 0 bpf_c053_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_2_13 (mix_q_src_c053_2_13 mix_q_c053_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_14 (mix_i_src_c053_2_14 0 bpf_c053_2 0) vcvs gain=8.314696123025e-01
SMIXI_c053_2_14 (mix_i_src_c053_2_14 mix_i_c053_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_14 (mix_q_src_c053_2_14 0 bpf_c053_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_2_14 (mix_q_src_c053_2_14 mix_q_c053_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_2_15 (mix_i_src_c053_2_15 0 bpf_c053_2 0) vcvs gain=9.807852804032e-01
SMIXI_c053_2_15 (mix_i_src_c053_2_15 mix_i_c053_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_2_15 (mix_q_src_c053_2_15 0 bpf_c053_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_2_15 (mix_q_src_c053_2_15 mix_q_c053_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c053_2 (mix_i_c053_2 0) resistor r=1G
RMIXQ_c053_2 (mix_q_c053_2 0) resistor r=1G
RINTI_c053_2 (mix_i_c053_2 Icar_c053_2) resistor r=1k
CINTI_c053_2 (Icar_c053_2 0) capacitor c=80p
RINTQ_c053_2 (mix_q_c053_2 Qcar_c053_2) resistor r=1k
CINTQ_c053_2 (Qcar_c053_2 0) capacitor c=80p

// bl053, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c053_3 (bl053 n_cbpf_c053_3) capacitor c=2.533029591058e-14
LBPF_c053_3 (n_cbpf_c053_3 bpf_c053_3) inductor l=1.000000000000e-06
RBPF_c053_3 (bpf_c053_3 0) resistor r=3.141592653590e+02
EMIXI_c053_3_00 (mix_i_src_c053_3_00 0 bpf_c053_3 0) vcvs gain=9.807852804032e-01
SMIXI_c053_3_00 (mix_i_src_c053_3_00 mix_i_c053_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_00 (mix_q_src_c053_3_00 0 bpf_c053_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_3_00 (mix_q_src_c053_3_00 mix_q_c053_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_01 (mix_i_src_c053_3_01 0 bpf_c053_3 0) vcvs gain=8.314696123025e-01
SMIXI_c053_3_01 (mix_i_src_c053_3_01 mix_i_c053_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_01 (mix_q_src_c053_3_01 0 bpf_c053_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_3_01 (mix_q_src_c053_3_01 mix_q_c053_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_02 (mix_i_src_c053_3_02 0 bpf_c053_3 0) vcvs gain=5.555702330196e-01
SMIXI_c053_3_02 (mix_i_src_c053_3_02 mix_i_c053_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_02 (mix_q_src_c053_3_02 0 bpf_c053_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_3_02 (mix_q_src_c053_3_02 mix_q_c053_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_03 (mix_i_src_c053_3_03 0 bpf_c053_3 0) vcvs gain=1.950903220161e-01
SMIXI_c053_3_03 (mix_i_src_c053_3_03 mix_i_c053_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_03 (mix_q_src_c053_3_03 0 bpf_c053_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_3_03 (mix_q_src_c053_3_03 mix_q_c053_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_04 (mix_i_src_c053_3_04 0 bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_3_04 (mix_i_src_c053_3_04 mix_i_c053_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_04 (mix_q_src_c053_3_04 0 bpf_c053_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c053_3_04 (mix_q_src_c053_3_04 mix_q_c053_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_05 (mix_i_src_c053_3_05 0 bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_3_05 (mix_i_src_c053_3_05 mix_i_c053_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_05 (mix_q_src_c053_3_05 0 bpf_c053_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c053_3_05 (mix_q_src_c053_3_05 mix_q_c053_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_06 (mix_i_src_c053_3_06 0 bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_3_06 (mix_i_src_c053_3_06 mix_i_c053_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_06 (mix_q_src_c053_3_06 0 bpf_c053_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c053_3_06 (mix_q_src_c053_3_06 mix_q_c053_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_07 (mix_i_src_c053_3_07 0 bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_3_07 (mix_i_src_c053_3_07 mix_i_c053_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_07 (mix_q_src_c053_3_07 0 bpf_c053_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c053_3_07 (mix_q_src_c053_3_07 mix_q_c053_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_08 (mix_i_src_c053_3_08 0 bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c053_3_08 (mix_i_src_c053_3_08 mix_i_c053_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_08 (mix_q_src_c053_3_08 0 bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_3_08 (mix_q_src_c053_3_08 mix_q_c053_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_09 (mix_i_src_c053_3_09 0 bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c053_3_09 (mix_i_src_c053_3_09 mix_i_c053_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_09 (mix_q_src_c053_3_09 0 bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_3_09 (mix_q_src_c053_3_09 mix_q_c053_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_10 (mix_i_src_c053_3_10 0 bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c053_3_10 (mix_i_src_c053_3_10 mix_i_c053_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_10 (mix_q_src_c053_3_10 0 bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_3_10 (mix_q_src_c053_3_10 mix_q_c053_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_11 (mix_i_src_c053_3_11 0 bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c053_3_11 (mix_i_src_c053_3_11 mix_i_c053_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_11 (mix_q_src_c053_3_11 0 bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_3_11 (mix_q_src_c053_3_11 mix_q_c053_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_12 (mix_i_src_c053_3_12 0 bpf_c053_3 0) vcvs gain=1.950903220161e-01
SMIXI_c053_3_12 (mix_i_src_c053_3_12 mix_i_c053_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_12 (mix_q_src_c053_3_12 0 bpf_c053_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c053_3_12 (mix_q_src_c053_3_12 mix_q_c053_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_13 (mix_i_src_c053_3_13 0 bpf_c053_3 0) vcvs gain=5.555702330196e-01
SMIXI_c053_3_13 (mix_i_src_c053_3_13 mix_i_c053_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_13 (mix_q_src_c053_3_13 0 bpf_c053_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c053_3_13 (mix_q_src_c053_3_13 mix_q_c053_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_14 (mix_i_src_c053_3_14 0 bpf_c053_3 0) vcvs gain=8.314696123025e-01
SMIXI_c053_3_14 (mix_i_src_c053_3_14 mix_i_c053_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_14 (mix_q_src_c053_3_14 0 bpf_c053_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c053_3_14 (mix_q_src_c053_3_14 mix_q_c053_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c053_3_15 (mix_i_src_c053_3_15 0 bpf_c053_3 0) vcvs gain=9.807852804032e-01
SMIXI_c053_3_15 (mix_i_src_c053_3_15 mix_i_c053_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c053_3_15 (mix_q_src_c053_3_15 0 bpf_c053_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c053_3_15 (mix_q_src_c053_3_15 mix_q_c053_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c053_3 (mix_i_c053_3 0) resistor r=1G
RMIXQ_c053_3 (mix_q_c053_3 0) resistor r=1G
RINTI_c053_3 (mix_i_c053_3 Icar_c053_3) resistor r=1k
CINTI_c053_3 (Icar_c053_3 0) capacitor c=80p
RINTQ_c053_3 (mix_q_c053_3 Qcar_c053_3) resistor r=1k
CINTQ_c053_3 (Qcar_c053_3 0) capacitor c=80p

// bl054, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c054_0 (bl054 n_cbpf_c054_0) capacitor c=4.052847345694e-13
LBPF_c054_0 (n_cbpf_c054_0 bpf_c054_0) inductor l=1.000000000000e-06
RBPF_c054_0 (bpf_c054_0 0) resistor r=7.853981633974e+01
EMIXI_c054_0_00 (mix_i_src_c054_0_00 0 bpf_c054_0 0) vcvs gain=9.807852804032e-01
SMIXI_c054_0_00 (mix_i_src_c054_0_00 mix_i_c054_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_00 (mix_q_src_c054_0_00 0 bpf_c054_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_0_00 (mix_q_src_c054_0_00 mix_q_c054_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_01 (mix_i_src_c054_0_01 0 bpf_c054_0 0) vcvs gain=8.314696123025e-01
SMIXI_c054_0_01 (mix_i_src_c054_0_01 mix_i_c054_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_01 (mix_q_src_c054_0_01 0 bpf_c054_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_0_01 (mix_q_src_c054_0_01 mix_q_c054_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_02 (mix_i_src_c054_0_02 0 bpf_c054_0 0) vcvs gain=5.555702330196e-01
SMIXI_c054_0_02 (mix_i_src_c054_0_02 mix_i_c054_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_02 (mix_q_src_c054_0_02 0 bpf_c054_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_0_02 (mix_q_src_c054_0_02 mix_q_c054_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_03 (mix_i_src_c054_0_03 0 bpf_c054_0 0) vcvs gain=1.950903220161e-01
SMIXI_c054_0_03 (mix_i_src_c054_0_03 mix_i_c054_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_03 (mix_q_src_c054_0_03 0 bpf_c054_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_0_03 (mix_q_src_c054_0_03 mix_q_c054_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_04 (mix_i_src_c054_0_04 0 bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_0_04 (mix_i_src_c054_0_04 mix_i_c054_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_04 (mix_q_src_c054_0_04 0 bpf_c054_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_0_04 (mix_q_src_c054_0_04 mix_q_c054_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_05 (mix_i_src_c054_0_05 0 bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_0_05 (mix_i_src_c054_0_05 mix_i_c054_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_05 (mix_q_src_c054_0_05 0 bpf_c054_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_0_05 (mix_q_src_c054_0_05 mix_q_c054_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_06 (mix_i_src_c054_0_06 0 bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_0_06 (mix_i_src_c054_0_06 mix_i_c054_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_06 (mix_q_src_c054_0_06 0 bpf_c054_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_0_06 (mix_q_src_c054_0_06 mix_q_c054_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_07 (mix_i_src_c054_0_07 0 bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_0_07 (mix_i_src_c054_0_07 mix_i_c054_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_07 (mix_q_src_c054_0_07 0 bpf_c054_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_0_07 (mix_q_src_c054_0_07 mix_q_c054_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_08 (mix_i_src_c054_0_08 0 bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_0_08 (mix_i_src_c054_0_08 mix_i_c054_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_08 (mix_q_src_c054_0_08 0 bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_0_08 (mix_q_src_c054_0_08 mix_q_c054_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_09 (mix_i_src_c054_0_09 0 bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_0_09 (mix_i_src_c054_0_09 mix_i_c054_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_09 (mix_q_src_c054_0_09 0 bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_0_09 (mix_q_src_c054_0_09 mix_q_c054_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_10 (mix_i_src_c054_0_10 0 bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_0_10 (mix_i_src_c054_0_10 mix_i_c054_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_10 (mix_q_src_c054_0_10 0 bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_0_10 (mix_q_src_c054_0_10 mix_q_c054_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_11 (mix_i_src_c054_0_11 0 bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_0_11 (mix_i_src_c054_0_11 mix_i_c054_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_11 (mix_q_src_c054_0_11 0 bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_0_11 (mix_q_src_c054_0_11 mix_q_c054_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_12 (mix_i_src_c054_0_12 0 bpf_c054_0 0) vcvs gain=1.950903220161e-01
SMIXI_c054_0_12 (mix_i_src_c054_0_12 mix_i_c054_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_12 (mix_q_src_c054_0_12 0 bpf_c054_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_0_12 (mix_q_src_c054_0_12 mix_q_c054_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_13 (mix_i_src_c054_0_13 0 bpf_c054_0 0) vcvs gain=5.555702330196e-01
SMIXI_c054_0_13 (mix_i_src_c054_0_13 mix_i_c054_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_13 (mix_q_src_c054_0_13 0 bpf_c054_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_0_13 (mix_q_src_c054_0_13 mix_q_c054_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_14 (mix_i_src_c054_0_14 0 bpf_c054_0 0) vcvs gain=8.314696123025e-01
SMIXI_c054_0_14 (mix_i_src_c054_0_14 mix_i_c054_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_14 (mix_q_src_c054_0_14 0 bpf_c054_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_0_14 (mix_q_src_c054_0_14 mix_q_c054_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_0_15 (mix_i_src_c054_0_15 0 bpf_c054_0 0) vcvs gain=9.807852804032e-01
SMIXI_c054_0_15 (mix_i_src_c054_0_15 mix_i_c054_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_0_15 (mix_q_src_c054_0_15 0 bpf_c054_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_0_15 (mix_q_src_c054_0_15 mix_q_c054_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c054_0 (mix_i_c054_0 0) resistor r=1G
RMIXQ_c054_0 (mix_q_c054_0 0) resistor r=1G
RINTI_c054_0 (mix_i_c054_0 Icar_c054_0) resistor r=1k
CINTI_c054_0 (Icar_c054_0 0) capacitor c=80p
RINTQ_c054_0 (mix_q_c054_0 Qcar_c054_0) resistor r=1k
CINTQ_c054_0 (Qcar_c054_0 0) capacitor c=80p

// bl054, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c054_1 (bl054 n_cbpf_c054_1) capacitor c=1.013211836423e-13
LBPF_c054_1 (n_cbpf_c054_1 bpf_c054_1) inductor l=1.000000000000e-06
RBPF_c054_1 (bpf_c054_1 0) resistor r=1.570796326795e+02
EMIXI_c054_1_00 (mix_i_src_c054_1_00 0 bpf_c054_1 0) vcvs gain=9.807852804032e-01
SMIXI_c054_1_00 (mix_i_src_c054_1_00 mix_i_c054_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_00 (mix_q_src_c054_1_00 0 bpf_c054_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_1_00 (mix_q_src_c054_1_00 mix_q_c054_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_01 (mix_i_src_c054_1_01 0 bpf_c054_1 0) vcvs gain=8.314696123025e-01
SMIXI_c054_1_01 (mix_i_src_c054_1_01 mix_i_c054_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_01 (mix_q_src_c054_1_01 0 bpf_c054_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_1_01 (mix_q_src_c054_1_01 mix_q_c054_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_02 (mix_i_src_c054_1_02 0 bpf_c054_1 0) vcvs gain=5.555702330196e-01
SMIXI_c054_1_02 (mix_i_src_c054_1_02 mix_i_c054_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_02 (mix_q_src_c054_1_02 0 bpf_c054_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_1_02 (mix_q_src_c054_1_02 mix_q_c054_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_03 (mix_i_src_c054_1_03 0 bpf_c054_1 0) vcvs gain=1.950903220161e-01
SMIXI_c054_1_03 (mix_i_src_c054_1_03 mix_i_c054_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_03 (mix_q_src_c054_1_03 0 bpf_c054_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_1_03 (mix_q_src_c054_1_03 mix_q_c054_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_04 (mix_i_src_c054_1_04 0 bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_1_04 (mix_i_src_c054_1_04 mix_i_c054_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_04 (mix_q_src_c054_1_04 0 bpf_c054_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_1_04 (mix_q_src_c054_1_04 mix_q_c054_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_05 (mix_i_src_c054_1_05 0 bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_1_05 (mix_i_src_c054_1_05 mix_i_c054_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_05 (mix_q_src_c054_1_05 0 bpf_c054_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_1_05 (mix_q_src_c054_1_05 mix_q_c054_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_06 (mix_i_src_c054_1_06 0 bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_1_06 (mix_i_src_c054_1_06 mix_i_c054_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_06 (mix_q_src_c054_1_06 0 bpf_c054_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_1_06 (mix_q_src_c054_1_06 mix_q_c054_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_07 (mix_i_src_c054_1_07 0 bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_1_07 (mix_i_src_c054_1_07 mix_i_c054_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_07 (mix_q_src_c054_1_07 0 bpf_c054_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_1_07 (mix_q_src_c054_1_07 mix_q_c054_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_08 (mix_i_src_c054_1_08 0 bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_1_08 (mix_i_src_c054_1_08 mix_i_c054_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_08 (mix_q_src_c054_1_08 0 bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_1_08 (mix_q_src_c054_1_08 mix_q_c054_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_09 (mix_i_src_c054_1_09 0 bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_1_09 (mix_i_src_c054_1_09 mix_i_c054_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_09 (mix_q_src_c054_1_09 0 bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_1_09 (mix_q_src_c054_1_09 mix_q_c054_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_10 (mix_i_src_c054_1_10 0 bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_1_10 (mix_i_src_c054_1_10 mix_i_c054_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_10 (mix_q_src_c054_1_10 0 bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_1_10 (mix_q_src_c054_1_10 mix_q_c054_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_11 (mix_i_src_c054_1_11 0 bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_1_11 (mix_i_src_c054_1_11 mix_i_c054_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_11 (mix_q_src_c054_1_11 0 bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_1_11 (mix_q_src_c054_1_11 mix_q_c054_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_12 (mix_i_src_c054_1_12 0 bpf_c054_1 0) vcvs gain=1.950903220161e-01
SMIXI_c054_1_12 (mix_i_src_c054_1_12 mix_i_c054_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_12 (mix_q_src_c054_1_12 0 bpf_c054_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_1_12 (mix_q_src_c054_1_12 mix_q_c054_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_13 (mix_i_src_c054_1_13 0 bpf_c054_1 0) vcvs gain=5.555702330196e-01
SMIXI_c054_1_13 (mix_i_src_c054_1_13 mix_i_c054_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_13 (mix_q_src_c054_1_13 0 bpf_c054_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_1_13 (mix_q_src_c054_1_13 mix_q_c054_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_14 (mix_i_src_c054_1_14 0 bpf_c054_1 0) vcvs gain=8.314696123025e-01
SMIXI_c054_1_14 (mix_i_src_c054_1_14 mix_i_c054_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_14 (mix_q_src_c054_1_14 0 bpf_c054_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_1_14 (mix_q_src_c054_1_14 mix_q_c054_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_1_15 (mix_i_src_c054_1_15 0 bpf_c054_1 0) vcvs gain=9.807852804032e-01
SMIXI_c054_1_15 (mix_i_src_c054_1_15 mix_i_c054_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_1_15 (mix_q_src_c054_1_15 0 bpf_c054_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_1_15 (mix_q_src_c054_1_15 mix_q_c054_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c054_1 (mix_i_c054_1 0) resistor r=1G
RMIXQ_c054_1 (mix_q_c054_1 0) resistor r=1G
RINTI_c054_1 (mix_i_c054_1 Icar_c054_1) resistor r=1k
CINTI_c054_1 (Icar_c054_1 0) capacitor c=80p
RINTQ_c054_1 (mix_q_c054_1 Qcar_c054_1) resistor r=1k
CINTQ_c054_1 (Qcar_c054_1 0) capacitor c=80p

// bl054, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c054_2 (bl054 n_cbpf_c054_2) capacitor c=4.503163717437e-14
LBPF_c054_2 (n_cbpf_c054_2 bpf_c054_2) inductor l=1.000000000000e-06
RBPF_c054_2 (bpf_c054_2 0) resistor r=2.356194490192e+02
EMIXI_c054_2_00 (mix_i_src_c054_2_00 0 bpf_c054_2 0) vcvs gain=9.807852804032e-01
SMIXI_c054_2_00 (mix_i_src_c054_2_00 mix_i_c054_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_00 (mix_q_src_c054_2_00 0 bpf_c054_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_2_00 (mix_q_src_c054_2_00 mix_q_c054_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_01 (mix_i_src_c054_2_01 0 bpf_c054_2 0) vcvs gain=8.314696123025e-01
SMIXI_c054_2_01 (mix_i_src_c054_2_01 mix_i_c054_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_01 (mix_q_src_c054_2_01 0 bpf_c054_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_2_01 (mix_q_src_c054_2_01 mix_q_c054_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_02 (mix_i_src_c054_2_02 0 bpf_c054_2 0) vcvs gain=5.555702330196e-01
SMIXI_c054_2_02 (mix_i_src_c054_2_02 mix_i_c054_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_02 (mix_q_src_c054_2_02 0 bpf_c054_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_2_02 (mix_q_src_c054_2_02 mix_q_c054_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_03 (mix_i_src_c054_2_03 0 bpf_c054_2 0) vcvs gain=1.950903220161e-01
SMIXI_c054_2_03 (mix_i_src_c054_2_03 mix_i_c054_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_03 (mix_q_src_c054_2_03 0 bpf_c054_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_2_03 (mix_q_src_c054_2_03 mix_q_c054_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_04 (mix_i_src_c054_2_04 0 bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_2_04 (mix_i_src_c054_2_04 mix_i_c054_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_04 (mix_q_src_c054_2_04 0 bpf_c054_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_2_04 (mix_q_src_c054_2_04 mix_q_c054_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_05 (mix_i_src_c054_2_05 0 bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_2_05 (mix_i_src_c054_2_05 mix_i_c054_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_05 (mix_q_src_c054_2_05 0 bpf_c054_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_2_05 (mix_q_src_c054_2_05 mix_q_c054_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_06 (mix_i_src_c054_2_06 0 bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_2_06 (mix_i_src_c054_2_06 mix_i_c054_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_06 (mix_q_src_c054_2_06 0 bpf_c054_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_2_06 (mix_q_src_c054_2_06 mix_q_c054_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_07 (mix_i_src_c054_2_07 0 bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_2_07 (mix_i_src_c054_2_07 mix_i_c054_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_07 (mix_q_src_c054_2_07 0 bpf_c054_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_2_07 (mix_q_src_c054_2_07 mix_q_c054_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_08 (mix_i_src_c054_2_08 0 bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_2_08 (mix_i_src_c054_2_08 mix_i_c054_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_08 (mix_q_src_c054_2_08 0 bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_2_08 (mix_q_src_c054_2_08 mix_q_c054_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_09 (mix_i_src_c054_2_09 0 bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_2_09 (mix_i_src_c054_2_09 mix_i_c054_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_09 (mix_q_src_c054_2_09 0 bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_2_09 (mix_q_src_c054_2_09 mix_q_c054_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_10 (mix_i_src_c054_2_10 0 bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_2_10 (mix_i_src_c054_2_10 mix_i_c054_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_10 (mix_q_src_c054_2_10 0 bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_2_10 (mix_q_src_c054_2_10 mix_q_c054_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_11 (mix_i_src_c054_2_11 0 bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_2_11 (mix_i_src_c054_2_11 mix_i_c054_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_11 (mix_q_src_c054_2_11 0 bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_2_11 (mix_q_src_c054_2_11 mix_q_c054_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_12 (mix_i_src_c054_2_12 0 bpf_c054_2 0) vcvs gain=1.950903220161e-01
SMIXI_c054_2_12 (mix_i_src_c054_2_12 mix_i_c054_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_12 (mix_q_src_c054_2_12 0 bpf_c054_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_2_12 (mix_q_src_c054_2_12 mix_q_c054_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_13 (mix_i_src_c054_2_13 0 bpf_c054_2 0) vcvs gain=5.555702330196e-01
SMIXI_c054_2_13 (mix_i_src_c054_2_13 mix_i_c054_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_13 (mix_q_src_c054_2_13 0 bpf_c054_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_2_13 (mix_q_src_c054_2_13 mix_q_c054_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_14 (mix_i_src_c054_2_14 0 bpf_c054_2 0) vcvs gain=8.314696123025e-01
SMIXI_c054_2_14 (mix_i_src_c054_2_14 mix_i_c054_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_14 (mix_q_src_c054_2_14 0 bpf_c054_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_2_14 (mix_q_src_c054_2_14 mix_q_c054_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_2_15 (mix_i_src_c054_2_15 0 bpf_c054_2 0) vcvs gain=9.807852804032e-01
SMIXI_c054_2_15 (mix_i_src_c054_2_15 mix_i_c054_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_2_15 (mix_q_src_c054_2_15 0 bpf_c054_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_2_15 (mix_q_src_c054_2_15 mix_q_c054_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c054_2 (mix_i_c054_2 0) resistor r=1G
RMIXQ_c054_2 (mix_q_c054_2 0) resistor r=1G
RINTI_c054_2 (mix_i_c054_2 Icar_c054_2) resistor r=1k
CINTI_c054_2 (Icar_c054_2 0) capacitor c=80p
RINTQ_c054_2 (mix_q_c054_2 Qcar_c054_2) resistor r=1k
CINTQ_c054_2 (Qcar_c054_2 0) capacitor c=80p

// bl054, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c054_3 (bl054 n_cbpf_c054_3) capacitor c=2.533029591058e-14
LBPF_c054_3 (n_cbpf_c054_3 bpf_c054_3) inductor l=1.000000000000e-06
RBPF_c054_3 (bpf_c054_3 0) resistor r=3.141592653590e+02
EMIXI_c054_3_00 (mix_i_src_c054_3_00 0 bpf_c054_3 0) vcvs gain=9.807852804032e-01
SMIXI_c054_3_00 (mix_i_src_c054_3_00 mix_i_c054_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_00 (mix_q_src_c054_3_00 0 bpf_c054_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_3_00 (mix_q_src_c054_3_00 mix_q_c054_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_01 (mix_i_src_c054_3_01 0 bpf_c054_3 0) vcvs gain=8.314696123025e-01
SMIXI_c054_3_01 (mix_i_src_c054_3_01 mix_i_c054_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_01 (mix_q_src_c054_3_01 0 bpf_c054_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_3_01 (mix_q_src_c054_3_01 mix_q_c054_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_02 (mix_i_src_c054_3_02 0 bpf_c054_3 0) vcvs gain=5.555702330196e-01
SMIXI_c054_3_02 (mix_i_src_c054_3_02 mix_i_c054_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_02 (mix_q_src_c054_3_02 0 bpf_c054_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_3_02 (mix_q_src_c054_3_02 mix_q_c054_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_03 (mix_i_src_c054_3_03 0 bpf_c054_3 0) vcvs gain=1.950903220161e-01
SMIXI_c054_3_03 (mix_i_src_c054_3_03 mix_i_c054_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_03 (mix_q_src_c054_3_03 0 bpf_c054_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_3_03 (mix_q_src_c054_3_03 mix_q_c054_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_04 (mix_i_src_c054_3_04 0 bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_3_04 (mix_i_src_c054_3_04 mix_i_c054_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_04 (mix_q_src_c054_3_04 0 bpf_c054_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c054_3_04 (mix_q_src_c054_3_04 mix_q_c054_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_05 (mix_i_src_c054_3_05 0 bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_3_05 (mix_i_src_c054_3_05 mix_i_c054_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_05 (mix_q_src_c054_3_05 0 bpf_c054_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c054_3_05 (mix_q_src_c054_3_05 mix_q_c054_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_06 (mix_i_src_c054_3_06 0 bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_3_06 (mix_i_src_c054_3_06 mix_i_c054_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_06 (mix_q_src_c054_3_06 0 bpf_c054_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c054_3_06 (mix_q_src_c054_3_06 mix_q_c054_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_07 (mix_i_src_c054_3_07 0 bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_3_07 (mix_i_src_c054_3_07 mix_i_c054_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_07 (mix_q_src_c054_3_07 0 bpf_c054_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c054_3_07 (mix_q_src_c054_3_07 mix_q_c054_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_08 (mix_i_src_c054_3_08 0 bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c054_3_08 (mix_i_src_c054_3_08 mix_i_c054_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_08 (mix_q_src_c054_3_08 0 bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_3_08 (mix_q_src_c054_3_08 mix_q_c054_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_09 (mix_i_src_c054_3_09 0 bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c054_3_09 (mix_i_src_c054_3_09 mix_i_c054_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_09 (mix_q_src_c054_3_09 0 bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_3_09 (mix_q_src_c054_3_09 mix_q_c054_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_10 (mix_i_src_c054_3_10 0 bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c054_3_10 (mix_i_src_c054_3_10 mix_i_c054_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_10 (mix_q_src_c054_3_10 0 bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_3_10 (mix_q_src_c054_3_10 mix_q_c054_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_11 (mix_i_src_c054_3_11 0 bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c054_3_11 (mix_i_src_c054_3_11 mix_i_c054_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_11 (mix_q_src_c054_3_11 0 bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_3_11 (mix_q_src_c054_3_11 mix_q_c054_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_12 (mix_i_src_c054_3_12 0 bpf_c054_3 0) vcvs gain=1.950903220161e-01
SMIXI_c054_3_12 (mix_i_src_c054_3_12 mix_i_c054_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_12 (mix_q_src_c054_3_12 0 bpf_c054_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c054_3_12 (mix_q_src_c054_3_12 mix_q_c054_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_13 (mix_i_src_c054_3_13 0 bpf_c054_3 0) vcvs gain=5.555702330196e-01
SMIXI_c054_3_13 (mix_i_src_c054_3_13 mix_i_c054_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_13 (mix_q_src_c054_3_13 0 bpf_c054_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c054_3_13 (mix_q_src_c054_3_13 mix_q_c054_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_14 (mix_i_src_c054_3_14 0 bpf_c054_3 0) vcvs gain=8.314696123025e-01
SMIXI_c054_3_14 (mix_i_src_c054_3_14 mix_i_c054_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_14 (mix_q_src_c054_3_14 0 bpf_c054_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c054_3_14 (mix_q_src_c054_3_14 mix_q_c054_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c054_3_15 (mix_i_src_c054_3_15 0 bpf_c054_3 0) vcvs gain=9.807852804032e-01
SMIXI_c054_3_15 (mix_i_src_c054_3_15 mix_i_c054_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c054_3_15 (mix_q_src_c054_3_15 0 bpf_c054_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c054_3_15 (mix_q_src_c054_3_15 mix_q_c054_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c054_3 (mix_i_c054_3 0) resistor r=1G
RMIXQ_c054_3 (mix_q_c054_3 0) resistor r=1G
RINTI_c054_3 (mix_i_c054_3 Icar_c054_3) resistor r=1k
CINTI_c054_3 (Icar_c054_3 0) capacitor c=80p
RINTQ_c054_3 (mix_q_c054_3 Qcar_c054_3) resistor r=1k
CINTQ_c054_3 (Qcar_c054_3 0) capacitor c=80p

// bl055, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c055_0 (bl055 n_cbpf_c055_0) capacitor c=4.052847345694e-13
LBPF_c055_0 (n_cbpf_c055_0 bpf_c055_0) inductor l=1.000000000000e-06
RBPF_c055_0 (bpf_c055_0 0) resistor r=7.853981633974e+01
EMIXI_c055_0_00 (mix_i_src_c055_0_00 0 bpf_c055_0 0) vcvs gain=9.807852804032e-01
SMIXI_c055_0_00 (mix_i_src_c055_0_00 mix_i_c055_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_00 (mix_q_src_c055_0_00 0 bpf_c055_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_0_00 (mix_q_src_c055_0_00 mix_q_c055_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_01 (mix_i_src_c055_0_01 0 bpf_c055_0 0) vcvs gain=8.314696123025e-01
SMIXI_c055_0_01 (mix_i_src_c055_0_01 mix_i_c055_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_01 (mix_q_src_c055_0_01 0 bpf_c055_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_0_01 (mix_q_src_c055_0_01 mix_q_c055_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_02 (mix_i_src_c055_0_02 0 bpf_c055_0 0) vcvs gain=5.555702330196e-01
SMIXI_c055_0_02 (mix_i_src_c055_0_02 mix_i_c055_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_02 (mix_q_src_c055_0_02 0 bpf_c055_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_0_02 (mix_q_src_c055_0_02 mix_q_c055_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_03 (mix_i_src_c055_0_03 0 bpf_c055_0 0) vcvs gain=1.950903220161e-01
SMIXI_c055_0_03 (mix_i_src_c055_0_03 mix_i_c055_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_03 (mix_q_src_c055_0_03 0 bpf_c055_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_0_03 (mix_q_src_c055_0_03 mix_q_c055_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_04 (mix_i_src_c055_0_04 0 bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_0_04 (mix_i_src_c055_0_04 mix_i_c055_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_04 (mix_q_src_c055_0_04 0 bpf_c055_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_0_04 (mix_q_src_c055_0_04 mix_q_c055_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_05 (mix_i_src_c055_0_05 0 bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_0_05 (mix_i_src_c055_0_05 mix_i_c055_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_05 (mix_q_src_c055_0_05 0 bpf_c055_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_0_05 (mix_q_src_c055_0_05 mix_q_c055_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_06 (mix_i_src_c055_0_06 0 bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_0_06 (mix_i_src_c055_0_06 mix_i_c055_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_06 (mix_q_src_c055_0_06 0 bpf_c055_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_0_06 (mix_q_src_c055_0_06 mix_q_c055_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_07 (mix_i_src_c055_0_07 0 bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_0_07 (mix_i_src_c055_0_07 mix_i_c055_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_07 (mix_q_src_c055_0_07 0 bpf_c055_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_0_07 (mix_q_src_c055_0_07 mix_q_c055_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_08 (mix_i_src_c055_0_08 0 bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_0_08 (mix_i_src_c055_0_08 mix_i_c055_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_08 (mix_q_src_c055_0_08 0 bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_0_08 (mix_q_src_c055_0_08 mix_q_c055_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_09 (mix_i_src_c055_0_09 0 bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_0_09 (mix_i_src_c055_0_09 mix_i_c055_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_09 (mix_q_src_c055_0_09 0 bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_0_09 (mix_q_src_c055_0_09 mix_q_c055_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_10 (mix_i_src_c055_0_10 0 bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_0_10 (mix_i_src_c055_0_10 mix_i_c055_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_10 (mix_q_src_c055_0_10 0 bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_0_10 (mix_q_src_c055_0_10 mix_q_c055_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_11 (mix_i_src_c055_0_11 0 bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_0_11 (mix_i_src_c055_0_11 mix_i_c055_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_11 (mix_q_src_c055_0_11 0 bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_0_11 (mix_q_src_c055_0_11 mix_q_c055_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_12 (mix_i_src_c055_0_12 0 bpf_c055_0 0) vcvs gain=1.950903220161e-01
SMIXI_c055_0_12 (mix_i_src_c055_0_12 mix_i_c055_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_12 (mix_q_src_c055_0_12 0 bpf_c055_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_0_12 (mix_q_src_c055_0_12 mix_q_c055_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_13 (mix_i_src_c055_0_13 0 bpf_c055_0 0) vcvs gain=5.555702330196e-01
SMIXI_c055_0_13 (mix_i_src_c055_0_13 mix_i_c055_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_13 (mix_q_src_c055_0_13 0 bpf_c055_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_0_13 (mix_q_src_c055_0_13 mix_q_c055_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_14 (mix_i_src_c055_0_14 0 bpf_c055_0 0) vcvs gain=8.314696123025e-01
SMIXI_c055_0_14 (mix_i_src_c055_0_14 mix_i_c055_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_14 (mix_q_src_c055_0_14 0 bpf_c055_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_0_14 (mix_q_src_c055_0_14 mix_q_c055_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_0_15 (mix_i_src_c055_0_15 0 bpf_c055_0 0) vcvs gain=9.807852804032e-01
SMIXI_c055_0_15 (mix_i_src_c055_0_15 mix_i_c055_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_0_15 (mix_q_src_c055_0_15 0 bpf_c055_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_0_15 (mix_q_src_c055_0_15 mix_q_c055_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c055_0 (mix_i_c055_0 0) resistor r=1G
RMIXQ_c055_0 (mix_q_c055_0 0) resistor r=1G
RINTI_c055_0 (mix_i_c055_0 Icar_c055_0) resistor r=1k
CINTI_c055_0 (Icar_c055_0 0) capacitor c=80p
RINTQ_c055_0 (mix_q_c055_0 Qcar_c055_0) resistor r=1k
CINTQ_c055_0 (Qcar_c055_0 0) capacitor c=80p

// bl055, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c055_1 (bl055 n_cbpf_c055_1) capacitor c=1.013211836423e-13
LBPF_c055_1 (n_cbpf_c055_1 bpf_c055_1) inductor l=1.000000000000e-06
RBPF_c055_1 (bpf_c055_1 0) resistor r=1.570796326795e+02
EMIXI_c055_1_00 (mix_i_src_c055_1_00 0 bpf_c055_1 0) vcvs gain=9.807852804032e-01
SMIXI_c055_1_00 (mix_i_src_c055_1_00 mix_i_c055_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_00 (mix_q_src_c055_1_00 0 bpf_c055_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_1_00 (mix_q_src_c055_1_00 mix_q_c055_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_01 (mix_i_src_c055_1_01 0 bpf_c055_1 0) vcvs gain=8.314696123025e-01
SMIXI_c055_1_01 (mix_i_src_c055_1_01 mix_i_c055_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_01 (mix_q_src_c055_1_01 0 bpf_c055_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_1_01 (mix_q_src_c055_1_01 mix_q_c055_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_02 (mix_i_src_c055_1_02 0 bpf_c055_1 0) vcvs gain=5.555702330196e-01
SMIXI_c055_1_02 (mix_i_src_c055_1_02 mix_i_c055_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_02 (mix_q_src_c055_1_02 0 bpf_c055_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_1_02 (mix_q_src_c055_1_02 mix_q_c055_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_03 (mix_i_src_c055_1_03 0 bpf_c055_1 0) vcvs gain=1.950903220161e-01
SMIXI_c055_1_03 (mix_i_src_c055_1_03 mix_i_c055_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_03 (mix_q_src_c055_1_03 0 bpf_c055_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_1_03 (mix_q_src_c055_1_03 mix_q_c055_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_04 (mix_i_src_c055_1_04 0 bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_1_04 (mix_i_src_c055_1_04 mix_i_c055_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_04 (mix_q_src_c055_1_04 0 bpf_c055_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_1_04 (mix_q_src_c055_1_04 mix_q_c055_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_05 (mix_i_src_c055_1_05 0 bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_1_05 (mix_i_src_c055_1_05 mix_i_c055_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_05 (mix_q_src_c055_1_05 0 bpf_c055_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_1_05 (mix_q_src_c055_1_05 mix_q_c055_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_06 (mix_i_src_c055_1_06 0 bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_1_06 (mix_i_src_c055_1_06 mix_i_c055_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_06 (mix_q_src_c055_1_06 0 bpf_c055_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_1_06 (mix_q_src_c055_1_06 mix_q_c055_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_07 (mix_i_src_c055_1_07 0 bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_1_07 (mix_i_src_c055_1_07 mix_i_c055_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_07 (mix_q_src_c055_1_07 0 bpf_c055_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_1_07 (mix_q_src_c055_1_07 mix_q_c055_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_08 (mix_i_src_c055_1_08 0 bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_1_08 (mix_i_src_c055_1_08 mix_i_c055_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_08 (mix_q_src_c055_1_08 0 bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_1_08 (mix_q_src_c055_1_08 mix_q_c055_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_09 (mix_i_src_c055_1_09 0 bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_1_09 (mix_i_src_c055_1_09 mix_i_c055_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_09 (mix_q_src_c055_1_09 0 bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_1_09 (mix_q_src_c055_1_09 mix_q_c055_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_10 (mix_i_src_c055_1_10 0 bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_1_10 (mix_i_src_c055_1_10 mix_i_c055_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_10 (mix_q_src_c055_1_10 0 bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_1_10 (mix_q_src_c055_1_10 mix_q_c055_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_11 (mix_i_src_c055_1_11 0 bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_1_11 (mix_i_src_c055_1_11 mix_i_c055_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_11 (mix_q_src_c055_1_11 0 bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_1_11 (mix_q_src_c055_1_11 mix_q_c055_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_12 (mix_i_src_c055_1_12 0 bpf_c055_1 0) vcvs gain=1.950903220161e-01
SMIXI_c055_1_12 (mix_i_src_c055_1_12 mix_i_c055_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_12 (mix_q_src_c055_1_12 0 bpf_c055_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_1_12 (mix_q_src_c055_1_12 mix_q_c055_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_13 (mix_i_src_c055_1_13 0 bpf_c055_1 0) vcvs gain=5.555702330196e-01
SMIXI_c055_1_13 (mix_i_src_c055_1_13 mix_i_c055_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_13 (mix_q_src_c055_1_13 0 bpf_c055_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_1_13 (mix_q_src_c055_1_13 mix_q_c055_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_14 (mix_i_src_c055_1_14 0 bpf_c055_1 0) vcvs gain=8.314696123025e-01
SMIXI_c055_1_14 (mix_i_src_c055_1_14 mix_i_c055_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_14 (mix_q_src_c055_1_14 0 bpf_c055_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_1_14 (mix_q_src_c055_1_14 mix_q_c055_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_1_15 (mix_i_src_c055_1_15 0 bpf_c055_1 0) vcvs gain=9.807852804032e-01
SMIXI_c055_1_15 (mix_i_src_c055_1_15 mix_i_c055_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_1_15 (mix_q_src_c055_1_15 0 bpf_c055_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_1_15 (mix_q_src_c055_1_15 mix_q_c055_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c055_1 (mix_i_c055_1 0) resistor r=1G
RMIXQ_c055_1 (mix_q_c055_1 0) resistor r=1G
RINTI_c055_1 (mix_i_c055_1 Icar_c055_1) resistor r=1k
CINTI_c055_1 (Icar_c055_1 0) capacitor c=80p
RINTQ_c055_1 (mix_q_c055_1 Qcar_c055_1) resistor r=1k
CINTQ_c055_1 (Qcar_c055_1 0) capacitor c=80p

// bl055, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c055_2 (bl055 n_cbpf_c055_2) capacitor c=4.503163717437e-14
LBPF_c055_2 (n_cbpf_c055_2 bpf_c055_2) inductor l=1.000000000000e-06
RBPF_c055_2 (bpf_c055_2 0) resistor r=2.356194490192e+02
EMIXI_c055_2_00 (mix_i_src_c055_2_00 0 bpf_c055_2 0) vcvs gain=9.807852804032e-01
SMIXI_c055_2_00 (mix_i_src_c055_2_00 mix_i_c055_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_00 (mix_q_src_c055_2_00 0 bpf_c055_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_2_00 (mix_q_src_c055_2_00 mix_q_c055_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_01 (mix_i_src_c055_2_01 0 bpf_c055_2 0) vcvs gain=8.314696123025e-01
SMIXI_c055_2_01 (mix_i_src_c055_2_01 mix_i_c055_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_01 (mix_q_src_c055_2_01 0 bpf_c055_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_2_01 (mix_q_src_c055_2_01 mix_q_c055_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_02 (mix_i_src_c055_2_02 0 bpf_c055_2 0) vcvs gain=5.555702330196e-01
SMIXI_c055_2_02 (mix_i_src_c055_2_02 mix_i_c055_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_02 (mix_q_src_c055_2_02 0 bpf_c055_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_2_02 (mix_q_src_c055_2_02 mix_q_c055_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_03 (mix_i_src_c055_2_03 0 bpf_c055_2 0) vcvs gain=1.950903220161e-01
SMIXI_c055_2_03 (mix_i_src_c055_2_03 mix_i_c055_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_03 (mix_q_src_c055_2_03 0 bpf_c055_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_2_03 (mix_q_src_c055_2_03 mix_q_c055_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_04 (mix_i_src_c055_2_04 0 bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_2_04 (mix_i_src_c055_2_04 mix_i_c055_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_04 (mix_q_src_c055_2_04 0 bpf_c055_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_2_04 (mix_q_src_c055_2_04 mix_q_c055_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_05 (mix_i_src_c055_2_05 0 bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_2_05 (mix_i_src_c055_2_05 mix_i_c055_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_05 (mix_q_src_c055_2_05 0 bpf_c055_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_2_05 (mix_q_src_c055_2_05 mix_q_c055_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_06 (mix_i_src_c055_2_06 0 bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_2_06 (mix_i_src_c055_2_06 mix_i_c055_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_06 (mix_q_src_c055_2_06 0 bpf_c055_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_2_06 (mix_q_src_c055_2_06 mix_q_c055_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_07 (mix_i_src_c055_2_07 0 bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_2_07 (mix_i_src_c055_2_07 mix_i_c055_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_07 (mix_q_src_c055_2_07 0 bpf_c055_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_2_07 (mix_q_src_c055_2_07 mix_q_c055_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_08 (mix_i_src_c055_2_08 0 bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_2_08 (mix_i_src_c055_2_08 mix_i_c055_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_08 (mix_q_src_c055_2_08 0 bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_2_08 (mix_q_src_c055_2_08 mix_q_c055_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_09 (mix_i_src_c055_2_09 0 bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_2_09 (mix_i_src_c055_2_09 mix_i_c055_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_09 (mix_q_src_c055_2_09 0 bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_2_09 (mix_q_src_c055_2_09 mix_q_c055_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_10 (mix_i_src_c055_2_10 0 bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_2_10 (mix_i_src_c055_2_10 mix_i_c055_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_10 (mix_q_src_c055_2_10 0 bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_2_10 (mix_q_src_c055_2_10 mix_q_c055_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_11 (mix_i_src_c055_2_11 0 bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_2_11 (mix_i_src_c055_2_11 mix_i_c055_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_11 (mix_q_src_c055_2_11 0 bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_2_11 (mix_q_src_c055_2_11 mix_q_c055_2 win_2_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_12 (mix_i_src_c055_2_12 0 bpf_c055_2 0) vcvs gain=1.950903220161e-01
SMIXI_c055_2_12 (mix_i_src_c055_2_12 mix_i_c055_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_12 (mix_q_src_c055_2_12 0 bpf_c055_2 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_2_12 (mix_q_src_c055_2_12 mix_q_c055_2 win_2_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_13 (mix_i_src_c055_2_13 0 bpf_c055_2 0) vcvs gain=5.555702330196e-01
SMIXI_c055_2_13 (mix_i_src_c055_2_13 mix_i_c055_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_13 (mix_q_src_c055_2_13 0 bpf_c055_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_2_13 (mix_q_src_c055_2_13 mix_q_c055_2 win_2_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_14 (mix_i_src_c055_2_14 0 bpf_c055_2 0) vcvs gain=8.314696123025e-01
SMIXI_c055_2_14 (mix_i_src_c055_2_14 mix_i_c055_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_14 (mix_q_src_c055_2_14 0 bpf_c055_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_2_14 (mix_q_src_c055_2_14 mix_q_c055_2 win_2_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_2_15 (mix_i_src_c055_2_15 0 bpf_c055_2 0) vcvs gain=9.807852804032e-01
SMIXI_c055_2_15 (mix_i_src_c055_2_15 mix_i_c055_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_2_15 (mix_q_src_c055_2_15 0 bpf_c055_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_2_15 (mix_q_src_c055_2_15 mix_q_c055_2 win_2_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c055_2 (mix_i_c055_2 0) resistor r=1G
RMIXQ_c055_2 (mix_q_c055_2 0) resistor r=1G
RINTI_c055_2 (mix_i_c055_2 Icar_c055_2) resistor r=1k
CINTI_c055_2 (Icar_c055_2 0) capacitor c=80p
RINTQ_c055_2 (mix_q_c055_2 Qcar_c055_2) resistor r=1k
CINTQ_c055_2 (Qcar_c055_2 0) capacitor c=80p

// bl055, carrier_3: 1000000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c055_3 (bl055 n_cbpf_c055_3) capacitor c=2.533029591058e-14
LBPF_c055_3 (n_cbpf_c055_3 bpf_c055_3) inductor l=1.000000000000e-06
RBPF_c055_3 (bpf_c055_3 0) resistor r=3.141592653590e+02
EMIXI_c055_3_00 (mix_i_src_c055_3_00 0 bpf_c055_3 0) vcvs gain=9.807852804032e-01
SMIXI_c055_3_00 (mix_i_src_c055_3_00 mix_i_c055_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_00 (mix_q_src_c055_3_00 0 bpf_c055_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_3_00 (mix_q_src_c055_3_00 mix_q_c055_3 win_3_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_01 (mix_i_src_c055_3_01 0 bpf_c055_3 0) vcvs gain=8.314696123025e-01
SMIXI_c055_3_01 (mix_i_src_c055_3_01 mix_i_c055_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_01 (mix_q_src_c055_3_01 0 bpf_c055_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_3_01 (mix_q_src_c055_3_01 mix_q_c055_3 win_3_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_02 (mix_i_src_c055_3_02 0 bpf_c055_3 0) vcvs gain=5.555702330196e-01
SMIXI_c055_3_02 (mix_i_src_c055_3_02 mix_i_c055_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_02 (mix_q_src_c055_3_02 0 bpf_c055_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_3_02 (mix_q_src_c055_3_02 mix_q_c055_3 win_3_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_03 (mix_i_src_c055_3_03 0 bpf_c055_3 0) vcvs gain=1.950903220161e-01
SMIXI_c055_3_03 (mix_i_src_c055_3_03 mix_i_c055_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_03 (mix_q_src_c055_3_03 0 bpf_c055_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_3_03 (mix_q_src_c055_3_03 mix_q_c055_3 win_3_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_04 (mix_i_src_c055_3_04 0 bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_3_04 (mix_i_src_c055_3_04 mix_i_c055_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_04 (mix_q_src_c055_3_04 0 bpf_c055_3 0) vcvs gain=9.807852804032e-01
SMIXQ_c055_3_04 (mix_q_src_c055_3_04 mix_q_c055_3 win_3_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_05 (mix_i_src_c055_3_05 0 bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_3_05 (mix_i_src_c055_3_05 mix_i_c055_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_05 (mix_q_src_c055_3_05 0 bpf_c055_3 0) vcvs gain=8.314696123025e-01
SMIXQ_c055_3_05 (mix_q_src_c055_3_05 mix_q_c055_3 win_3_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_06 (mix_i_src_c055_3_06 0 bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_3_06 (mix_i_src_c055_3_06 mix_i_c055_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_06 (mix_q_src_c055_3_06 0 bpf_c055_3 0) vcvs gain=5.555702330196e-01
SMIXQ_c055_3_06 (mix_q_src_c055_3_06 mix_q_c055_3 win_3_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_07 (mix_i_src_c055_3_07 0 bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_3_07 (mix_i_src_c055_3_07 mix_i_c055_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_07 (mix_q_src_c055_3_07 0 bpf_c055_3 0) vcvs gain=1.950903220161e-01
SMIXQ_c055_3_07 (mix_q_src_c055_3_07 mix_q_c055_3 win_3_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_08 (mix_i_src_c055_3_08 0 bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SMIXI_c055_3_08 (mix_i_src_c055_3_08 mix_i_c055_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_08 (mix_q_src_c055_3_08 0 bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_3_08 (mix_q_src_c055_3_08 mix_q_c055_3 win_3_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_09 (mix_i_src_c055_3_09 0 bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SMIXI_c055_3_09 (mix_i_src_c055_3_09 mix_i_c055_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_09 (mix_q_src_c055_3_09 0 bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_3_09 (mix_q_src_c055_3_09 mix_q_c055_3 win_3_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_10 (mix_i_src_c055_3_10 0 bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SMIXI_c055_3_10 (mix_i_src_c055_3_10 mix_i_c055_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_10 (mix_q_src_c055_3_10 0 bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_3_10 (mix_q_src_c055_3_10 mix_q_c055_3 win_3_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_11 (mix_i_src_c055_3_11 0 bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SMIXI_c055_3_11 (mix_i_src_c055_3_11 mix_i_c055_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_11 (mix_q_src_c055_3_11 0 bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_3_11 (mix_q_src_c055_3_11 mix_q_c055_3 win_3_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_12 (mix_i_src_c055_3_12 0 bpf_c055_3 0) vcvs gain=1.950903220161e-01
SMIXI_c055_3_12 (mix_i_src_c055_3_12 mix_i_c055_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_12 (mix_q_src_c055_3_12 0 bpf_c055_3 0) vcvs gain=-9.807852804032e-01
SMIXQ_c055_3_12 (mix_q_src_c055_3_12 mix_q_c055_3 win_3_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_13 (mix_i_src_c055_3_13 0 bpf_c055_3 0) vcvs gain=5.555702330196e-01
SMIXI_c055_3_13 (mix_i_src_c055_3_13 mix_i_c055_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_13 (mix_q_src_c055_3_13 0 bpf_c055_3 0) vcvs gain=-8.314696123025e-01
SMIXQ_c055_3_13 (mix_q_src_c055_3_13 mix_q_c055_3 win_3_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_14 (mix_i_src_c055_3_14 0 bpf_c055_3 0) vcvs gain=8.314696123025e-01
SMIXI_c055_3_14 (mix_i_src_c055_3_14 mix_i_c055_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_14 (mix_q_src_c055_3_14 0 bpf_c055_3 0) vcvs gain=-5.555702330196e-01
SMIXQ_c055_3_14 (mix_q_src_c055_3_14 mix_q_c055_3 win_3_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c055_3_15 (mix_i_src_c055_3_15 0 bpf_c055_3 0) vcvs gain=9.807852804032e-01
SMIXI_c055_3_15 (mix_i_src_c055_3_15 mix_i_c055_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c055_3_15 (mix_q_src_c055_3_15 0 bpf_c055_3 0) vcvs gain=-1.950903220161e-01
SMIXQ_c055_3_15 (mix_q_src_c055_3_15 mix_q_c055_3 win_3_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c055_3 (mix_i_c055_3 0) resistor r=1G
RMIXQ_c055_3 (mix_q_c055_3 0) resistor r=1G
RINTI_c055_3 (mix_i_c055_3 Icar_c055_3) resistor r=1k
CINTI_c055_3 (Icar_c055_3 0) capacitor c=80p
RINTQ_c055_3 (mix_q_c055_3 Qcar_c055_3) resistor r=1k
CINTQ_c055_3 (Qcar_c055_3 0) capacitor c=80p

// bl056, carrier_0: 250000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c056_0 (bl056 n_cbpf_c056_0) capacitor c=4.052847345694e-13
LBPF_c056_0 (n_cbpf_c056_0 bpf_c056_0) inductor l=1.000000000000e-06
RBPF_c056_0 (bpf_c056_0 0) resistor r=7.853981633974e+01
EMIXI_c056_0_00 (mix_i_src_c056_0_00 0 bpf_c056_0 0) vcvs gain=9.807852804032e-01
SMIXI_c056_0_00 (mix_i_src_c056_0_00 mix_i_c056_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_00 (mix_q_src_c056_0_00 0 bpf_c056_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_0_00 (mix_q_src_c056_0_00 mix_q_c056_0 win_0_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_01 (mix_i_src_c056_0_01 0 bpf_c056_0 0) vcvs gain=8.314696123025e-01
SMIXI_c056_0_01 (mix_i_src_c056_0_01 mix_i_c056_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_01 (mix_q_src_c056_0_01 0 bpf_c056_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_0_01 (mix_q_src_c056_0_01 mix_q_c056_0 win_0_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_02 (mix_i_src_c056_0_02 0 bpf_c056_0 0) vcvs gain=5.555702330196e-01
SMIXI_c056_0_02 (mix_i_src_c056_0_02 mix_i_c056_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_02 (mix_q_src_c056_0_02 0 bpf_c056_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_0_02 (mix_q_src_c056_0_02 mix_q_c056_0 win_0_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_03 (mix_i_src_c056_0_03 0 bpf_c056_0 0) vcvs gain=1.950903220161e-01
SMIXI_c056_0_03 (mix_i_src_c056_0_03 mix_i_c056_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_03 (mix_q_src_c056_0_03 0 bpf_c056_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_0_03 (mix_q_src_c056_0_03 mix_q_c056_0 win_0_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_04 (mix_i_src_c056_0_04 0 bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c056_0_04 (mix_i_src_c056_0_04 mix_i_c056_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_04 (mix_q_src_c056_0_04 0 bpf_c056_0 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_0_04 (mix_q_src_c056_0_04 mix_q_c056_0 win_0_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_05 (mix_i_src_c056_0_05 0 bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_0_05 (mix_i_src_c056_0_05 mix_i_c056_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_05 (mix_q_src_c056_0_05 0 bpf_c056_0 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_0_05 (mix_q_src_c056_0_05 mix_q_c056_0 win_0_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_06 (mix_i_src_c056_0_06 0 bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_0_06 (mix_i_src_c056_0_06 mix_i_c056_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_06 (mix_q_src_c056_0_06 0 bpf_c056_0 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_0_06 (mix_q_src_c056_0_06 mix_q_c056_0 win_0_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_07 (mix_i_src_c056_0_07 0 bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_0_07 (mix_i_src_c056_0_07 mix_i_c056_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_07 (mix_q_src_c056_0_07 0 bpf_c056_0 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_0_07 (mix_q_src_c056_0_07 mix_q_c056_0 win_0_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_08 (mix_i_src_c056_0_08 0 bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_0_08 (mix_i_src_c056_0_08 mix_i_c056_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_08 (mix_q_src_c056_0_08 0 bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_0_08 (mix_q_src_c056_0_08 mix_q_c056_0 win_0_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_09 (mix_i_src_c056_0_09 0 bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_0_09 (mix_i_src_c056_0_09 mix_i_c056_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_09 (mix_q_src_c056_0_09 0 bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_0_09 (mix_q_src_c056_0_09 mix_q_c056_0 win_0_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_10 (mix_i_src_c056_0_10 0 bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_0_10 (mix_i_src_c056_0_10 mix_i_c056_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_10 (mix_q_src_c056_0_10 0 bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_0_10 (mix_q_src_c056_0_10 mix_q_c056_0 win_0_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_11 (mix_i_src_c056_0_11 0 bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SMIXI_c056_0_11 (mix_i_src_c056_0_11 mix_i_c056_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_11 (mix_q_src_c056_0_11 0 bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_0_11 (mix_q_src_c056_0_11 mix_q_c056_0 win_0_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_12 (mix_i_src_c056_0_12 0 bpf_c056_0 0) vcvs gain=1.950903220161e-01
SMIXI_c056_0_12 (mix_i_src_c056_0_12 mix_i_c056_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_12 (mix_q_src_c056_0_12 0 bpf_c056_0 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_0_12 (mix_q_src_c056_0_12 mix_q_c056_0 win_0_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_13 (mix_i_src_c056_0_13 0 bpf_c056_0 0) vcvs gain=5.555702330196e-01
SMIXI_c056_0_13 (mix_i_src_c056_0_13 mix_i_c056_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_13 (mix_q_src_c056_0_13 0 bpf_c056_0 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_0_13 (mix_q_src_c056_0_13 mix_q_c056_0 win_0_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_14 (mix_i_src_c056_0_14 0 bpf_c056_0 0) vcvs gain=8.314696123025e-01
SMIXI_c056_0_14 (mix_i_src_c056_0_14 mix_i_c056_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_14 (mix_q_src_c056_0_14 0 bpf_c056_0 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_0_14 (mix_q_src_c056_0_14 mix_q_c056_0 win_0_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_0_15 (mix_i_src_c056_0_15 0 bpf_c056_0 0) vcvs gain=9.807852804032e-01
SMIXI_c056_0_15 (mix_i_src_c056_0_15 mix_i_c056_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_0_15 (mix_q_src_c056_0_15 0 bpf_c056_0 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_0_15 (mix_q_src_c056_0_15 mix_q_c056_0 win_0_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c056_0 (mix_i_c056_0 0) resistor r=1G
RMIXQ_c056_0 (mix_q_c056_0 0) resistor r=1G
RINTI_c056_0 (mix_i_c056_0 Icar_c056_0) resistor r=1k
CINTI_c056_0 (Icar_c056_0 0) capacitor c=80p
RINTQ_c056_0 (mix_q_c056_0 Qcar_c056_0) resistor r=1k
CINTQ_c056_0 (Qcar_c056_0 0) capacitor c=80p

// bl056, carrier_1: 500000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c056_1 (bl056 n_cbpf_c056_1) capacitor c=1.013211836423e-13
LBPF_c056_1 (n_cbpf_c056_1 bpf_c056_1) inductor l=1.000000000000e-06
RBPF_c056_1 (bpf_c056_1 0) resistor r=1.570796326795e+02
EMIXI_c056_1_00 (mix_i_src_c056_1_00 0 bpf_c056_1 0) vcvs gain=9.807852804032e-01
SMIXI_c056_1_00 (mix_i_src_c056_1_00 mix_i_c056_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_00 (mix_q_src_c056_1_00 0 bpf_c056_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_1_00 (mix_q_src_c056_1_00 mix_q_c056_1 win_1_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_01 (mix_i_src_c056_1_01 0 bpf_c056_1 0) vcvs gain=8.314696123025e-01
SMIXI_c056_1_01 (mix_i_src_c056_1_01 mix_i_c056_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_01 (mix_q_src_c056_1_01 0 bpf_c056_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_1_01 (mix_q_src_c056_1_01 mix_q_c056_1 win_1_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_02 (mix_i_src_c056_1_02 0 bpf_c056_1 0) vcvs gain=5.555702330196e-01
SMIXI_c056_1_02 (mix_i_src_c056_1_02 mix_i_c056_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_02 (mix_q_src_c056_1_02 0 bpf_c056_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_1_02 (mix_q_src_c056_1_02 mix_q_c056_1 win_1_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_03 (mix_i_src_c056_1_03 0 bpf_c056_1 0) vcvs gain=1.950903220161e-01
SMIXI_c056_1_03 (mix_i_src_c056_1_03 mix_i_c056_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_03 (mix_q_src_c056_1_03 0 bpf_c056_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_1_03 (mix_q_src_c056_1_03 mix_q_c056_1 win_1_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_04 (mix_i_src_c056_1_04 0 bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c056_1_04 (mix_i_src_c056_1_04 mix_i_c056_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_04 (mix_q_src_c056_1_04 0 bpf_c056_1 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_1_04 (mix_q_src_c056_1_04 mix_q_c056_1 win_1_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_05 (mix_i_src_c056_1_05 0 bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_1_05 (mix_i_src_c056_1_05 mix_i_c056_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_05 (mix_q_src_c056_1_05 0 bpf_c056_1 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_1_05 (mix_q_src_c056_1_05 mix_q_c056_1 win_1_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_06 (mix_i_src_c056_1_06 0 bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_1_06 (mix_i_src_c056_1_06 mix_i_c056_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_06 (mix_q_src_c056_1_06 0 bpf_c056_1 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_1_06 (mix_q_src_c056_1_06 mix_q_c056_1 win_1_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_07 (mix_i_src_c056_1_07 0 bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_1_07 (mix_i_src_c056_1_07 mix_i_c056_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_07 (mix_q_src_c056_1_07 0 bpf_c056_1 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_1_07 (mix_q_src_c056_1_07 mix_q_c056_1 win_1_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_08 (mix_i_src_c056_1_08 0 bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_1_08 (mix_i_src_c056_1_08 mix_i_c056_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_08 (mix_q_src_c056_1_08 0 bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_1_08 (mix_q_src_c056_1_08 mix_q_c056_1 win_1_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_09 (mix_i_src_c056_1_09 0 bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_1_09 (mix_i_src_c056_1_09 mix_i_c056_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_09 (mix_q_src_c056_1_09 0 bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_1_09 (mix_q_src_c056_1_09 mix_q_c056_1 win_1_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_10 (mix_i_src_c056_1_10 0 bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_1_10 (mix_i_src_c056_1_10 mix_i_c056_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_10 (mix_q_src_c056_1_10 0 bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_1_10 (mix_q_src_c056_1_10 mix_q_c056_1 win_1_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_11 (mix_i_src_c056_1_11 0 bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SMIXI_c056_1_11 (mix_i_src_c056_1_11 mix_i_c056_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_11 (mix_q_src_c056_1_11 0 bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_1_11 (mix_q_src_c056_1_11 mix_q_c056_1 win_1_11 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_12 (mix_i_src_c056_1_12 0 bpf_c056_1 0) vcvs gain=1.950903220161e-01
SMIXI_c056_1_12 (mix_i_src_c056_1_12 mix_i_c056_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_12 (mix_q_src_c056_1_12 0 bpf_c056_1 0) vcvs gain=-9.807852804032e-01
SMIXQ_c056_1_12 (mix_q_src_c056_1_12 mix_q_c056_1 win_1_12 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_13 (mix_i_src_c056_1_13 0 bpf_c056_1 0) vcvs gain=5.555702330196e-01
SMIXI_c056_1_13 (mix_i_src_c056_1_13 mix_i_c056_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_13 (mix_q_src_c056_1_13 0 bpf_c056_1 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_1_13 (mix_q_src_c056_1_13 mix_q_c056_1 win_1_13 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_14 (mix_i_src_c056_1_14 0 bpf_c056_1 0) vcvs gain=8.314696123025e-01
SMIXI_c056_1_14 (mix_i_src_c056_1_14 mix_i_c056_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_14 (mix_q_src_c056_1_14 0 bpf_c056_1 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_1_14 (mix_q_src_c056_1_14 mix_q_c056_1 win_1_14 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_1_15 (mix_i_src_c056_1_15 0 bpf_c056_1 0) vcvs gain=9.807852804032e-01
SMIXI_c056_1_15 (mix_i_src_c056_1_15 mix_i_c056_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_1_15 (mix_q_src_c056_1_15 0 bpf_c056_1 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_1_15 (mix_q_src_c056_1_15 mix_q_c056_1 win_1_15 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
RMIXI_c056_1 (mix_i_c056_1 0) resistor r=1G
RMIXQ_c056_1 (mix_q_c056_1 0) resistor r=1G
RINTI_c056_1 (mix_i_c056_1 Icar_c056_1) resistor r=1k
CINTI_c056_1 (Icar_c056_1 0) capacitor c=80p
RINTQ_c056_1 (mix_q_c056_1 Qcar_c056_1) resistor r=1k
CINTQ_c056_1 (Qcar_c056_1 0) capacitor c=80p

// bl056, carrier_2: 750000000 Hz coherent I/Q phase-window verification-demod path
CBPF_c056_2 (bl056 n_cbpf_c056_2) capacitor c=4.503163717437e-14
LBPF_c056_2 (n_cbpf_c056_2 bpf_c056_2) inductor l=1.000000000000e-06
RBPF_c056_2 (bpf_c056_2 0) resistor r=2.356194490192e+02
EMIXI_c056_2_00 (mix_i_src_c056_2_00 0 bpf_c056_2 0) vcvs gain=9.807852804032e-01
SMIXI_c056_2_00 (mix_i_src_c056_2_00 mix_i_c056_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_00 (mix_q_src_c056_2_00 0 bpf_c056_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_2_00 (mix_q_src_c056_2_00 mix_q_c056_2 win_2_00 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_01 (mix_i_src_c056_2_01 0 bpf_c056_2 0) vcvs gain=8.314696123025e-01
SMIXI_c056_2_01 (mix_i_src_c056_2_01 mix_i_c056_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_01 (mix_q_src_c056_2_01 0 bpf_c056_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_2_01 (mix_q_src_c056_2_01 mix_q_c056_2 win_2_01 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_02 (mix_i_src_c056_2_02 0 bpf_c056_2 0) vcvs gain=5.555702330196e-01
SMIXI_c056_2_02 (mix_i_src_c056_2_02 mix_i_c056_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_02 (mix_q_src_c056_2_02 0 bpf_c056_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_2_02 (mix_q_src_c056_2_02 mix_q_c056_2 win_2_02 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_03 (mix_i_src_c056_2_03 0 bpf_c056_2 0) vcvs gain=1.950903220161e-01
SMIXI_c056_2_03 (mix_i_src_c056_2_03 mix_i_c056_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_03 (mix_q_src_c056_2_03 0 bpf_c056_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_2_03 (mix_q_src_c056_2_03 mix_q_c056_2 win_2_03 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_04 (mix_i_src_c056_2_04 0 bpf_c056_2 0) vcvs gain=-1.950903220161e-01
SMIXI_c056_2_04 (mix_i_src_c056_2_04 mix_i_c056_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_04 (mix_q_src_c056_2_04 0 bpf_c056_2 0) vcvs gain=9.807852804032e-01
SMIXQ_c056_2_04 (mix_q_src_c056_2_04 mix_q_c056_2 win_2_04 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_05 (mix_i_src_c056_2_05 0 bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_2_05 (mix_i_src_c056_2_05 mix_i_c056_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_05 (mix_q_src_c056_2_05 0 bpf_c056_2 0) vcvs gain=8.314696123025e-01
SMIXQ_c056_2_05 (mix_q_src_c056_2_05 mix_q_c056_2 win_2_05 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_06 (mix_i_src_c056_2_06 0 bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_2_06 (mix_i_src_c056_2_06 mix_i_c056_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_06 (mix_q_src_c056_2_06 0 bpf_c056_2 0) vcvs gain=5.555702330196e-01
SMIXQ_c056_2_06 (mix_q_src_c056_2_06 mix_q_c056_2 win_2_06 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_07 (mix_i_src_c056_2_07 0 bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_2_07 (mix_i_src_c056_2_07 mix_i_c056_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_07 (mix_q_src_c056_2_07 0 bpf_c056_2 0) vcvs gain=1.950903220161e-01
SMIXQ_c056_2_07 (mix_q_src_c056_2_07 mix_q_c056_2 win_2_07 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_08 (mix_i_src_c056_2_08 0 bpf_c056_2 0) vcvs gain=-9.807852804032e-01
SMIXI_c056_2_08 (mix_i_src_c056_2_08 mix_i_c056_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_08 (mix_q_src_c056_2_08 0 bpf_c056_2 0) vcvs gain=-1.950903220161e-01
SMIXQ_c056_2_08 (mix_q_src_c056_2_08 mix_q_c056_2 win_2_08 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_09 (mix_i_src_c056_2_09 0 bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SMIXI_c056_2_09 (mix_i_src_c056_2_09 mix_i_c056_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_09 (mix_q_src_c056_2_09 0 bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SMIXQ_c056_2_09 (mix_q_src_c056_2_09 mix_q_c056_2 win_2_09 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_10 (mix_i_src_c056_2_10 0 bpf_c056_2 0) vcvs gain=-5.555702330196e-01
SMIXI_c056_2_10 (mix_i_src_c056_2_10 mix_i_c056_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXQ_c056_2_10 (mix_q_src_c056_2_10 0 bpf_c056_2 0) vcvs gain=-8.314696123025e-01
SMIXQ_c056_2_10 (mix_q_src_c056_2_10 mix_q_c056_2 win_2_10 0) relay vt1=-1m vt2=1m ropen=ropen_mix rclosed=rclosed_mix
EMIXI_c056_2_11 (mix_i_src_c056_2_11 0 bpf_c056_2 0) vcvs gain=-1.950903220161e-01
